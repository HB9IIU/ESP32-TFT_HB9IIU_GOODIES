#ifndef _ROBOTOMONO_ITALIC53PT7B_H_
#define _ROBOTOMONO_ITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x00, 0x38, 0x1D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x03, 0x9C, 0x0E, 0xF0, 0x7B, 0xC1, 0xEE,
  0x07, 0x38, 0x1C, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x3E,
  0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xE3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x01, 0x87, 0x01, 0xC0, 0xF1,
  0xC0, 0x70, 0x78, 0x70, 0x1C, 0x1E, 0x3C, 0x0F, 0x0F, 0x0F, 0x03, 0xC7,
  0x81, 0xC0, 0xE1, 0xE0, 0x78, 0x78, 0xF0, 0x1F, 0xFC, 0x78, 0x03, 0xFE,
  0x1C, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x8F, 0xC0, 0x03, 0xC7, 0xFC, 0x01, 0xE3, 0xFF, 0x00, 0x79,
  0xF1, 0xE0, 0x3C, 0x70, 0x78, 0x1E, 0x3C, 0x0E, 0x07, 0x8F, 0x03, 0x83,
  0xC3, 0x80, 0xE1, 0xE0, 0xE0, 0x38, 0x70, 0x38, 0x0E, 0x0C, 0x0E, 0x07,
  0x80, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x1E, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x1F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0xF8,
  0x0F, 0x1F, 0x8F, 0x80, 0xF1, 0xF0, 0x7C, 0x1F, 0x3E, 0x07, 0xC1, 0xE7,
  0xE0, 0x3E, 0x1E, 0x7C, 0x03, 0xF3, 0xE7, 0xC0, 0x1F, 0x7C, 0x7C, 0x00,
  0xFF, 0xC7, 0x80, 0x0F, 0xF8, 0x7C, 0x00, 0x7F, 0x07, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xF0, 0x3F, 0xCF, 0xFF, 0x01, 0xFF,
  0xFE, 0xF8, 0x0F, 0xFF, 0xCF, 0xC0, 0x3F, 0xF0, 0x7C, 0x00, 0x10, 0x00,
  0x00, 0x3C, 0xF3, 0xCF, 0x39, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x40, 0x1C, 0x02, 0x70, 0x1C, 0x0E, 0x7C, 0x3C,
  0x3E, 0xFF, 0xBD, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0x8F, 0x00, 0x0F, 0x8F, 0x80, 0x1F, 0x07, 0x80, 0x3E, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x83, 0x80, 0x80, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E,
  0x7E, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xF3, 0xE0, 0x07, 0xFC, 0xF0, 0x07,
  0xFE, 0x3C, 0x03, 0xF7, 0x9F, 0x03, 0xFB, 0xE7, 0xC1, 0xF8, 0xF9, 0xF0,
  0xFC, 0x3E, 0x7C, 0xFC, 0x0F, 0x9E, 0x7E, 0x03, 0xE7, 0xFF, 0x00, 0xF1,
  0xFF, 0x00, 0x3C, 0xFF, 0x80, 0x1F, 0x3F, 0x80, 0x07, 0xCF, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x3E, 0x78, 0x3E, 0xC0, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1F,
  0x3C, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF7, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x38,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03,
  0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x0F, 0x9F, 0xF8, 0x1E,
  0x7F, 0xF8, 0x3D, 0xFF, 0xF8, 0xFF, 0xC3, 0xF9, 0xFE, 0x03, 0xF3, 0xF8,
  0x03, 0xE7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C,
  0x7E, 0x00, 0xF8, 0x7C, 0x07, 0xE0, 0x7F, 0x3F, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFD,
  0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xE7, 0xE0, 0x3F, 0xC7, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x07, 0xFF, 0x3C, 0x07, 0xFC, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x81,
  0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x1F, 0x83, 0xF0, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE0, 0xF8, 0x04, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0x83, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x01, 0xE0, 0x70, 0x70, 0x3F, 0xC3,
  0x87, 0x83, 0xFF, 0x1C, 0x38, 0x3C, 0x38, 0xE3, 0xC3, 0xC1, 0x87, 0x1C,
  0x3C, 0x1C, 0x38, 0xE1, 0xC0, 0xE1, 0xCF, 0x1E, 0x07, 0x0E, 0x70, 0xE0,
  0x30, 0x73, 0x87, 0x03, 0x83, 0xBC, 0x38, 0x1C, 0x1D, 0xC3, 0xC0, 0xE0,
  0xEE, 0x1C, 0x07, 0x06, 0x70, 0xE0, 0x70, 0x33, 0x87, 0x03, 0x83, 0x9C,
  0x38, 0x1C, 0x18, 0xE1, 0xC1, 0xE1, 0xC7, 0x0E, 0x1F, 0x0E, 0x38, 0x7F,
  0xF8, 0xE1, 0xC3, 0xFD, 0xFE, 0x0E, 0x0F, 0xC7, 0xE0, 0x78, 0x18, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x04, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xC0, 0x03, 0xC0,
  0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E,
  0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xFC,
  0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xF0, 0x78, 0x01,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x07,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF8, 0x78, 0x00, 0x7E, 0x1F, 0x00,
  0x3F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x83, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3E, 0x07, 0xF8, 0x01, 0xF0,
  0x0F, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xFE, 0x7C, 0x03, 0xFF, 0xC7,
  0x80, 0x3F, 0xFC, 0x78, 0x03, 0xFF, 0xC7, 0x80, 0x00, 0x7C, 0x78, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00,
  0xF8, 0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x78, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x04, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x20, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x07, 0x8F, 0xC0, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xF0, 0x00, 0x0F, 0xF1, 0xF0,
  0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE,
  0x07, 0xB8, 0x0F, 0xF8, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC1, 0xFF, 0x81,
  0xEF, 0x07, 0xBE, 0x0F, 0xBC, 0x3E, 0xF0, 0x3E, 0xF0, 0xF3, 0xC0, 0xF3,
  0xC7, 0xCF, 0x03, 0xC7, 0x1E, 0x7C, 0x0F, 0x1E, 0xF9, 0xF0, 0x3C, 0x7B,
  0xC7, 0xC1, 0xF1, 0xFF, 0x1E, 0x07, 0xC7, 0xF8, 0x78, 0x1F, 0x1F, 0xE3,
  0xE0, 0x78, 0x7F, 0x0F, 0x81, 0xE0, 0xFC, 0x3E, 0x07, 0x83, 0xE0, 0xF0,
  0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xE0, 0xE0, 0x7C, 0x0F,
  0x03, 0x81, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x78,
  0x0F, 0xE0, 0x03, 0xE0, 0x7F, 0x80, 0x0F, 0x81, 0xFE, 0x00, 0x3E, 0x07,
  0xFC, 0x00, 0xF8, 0x1F, 0xF0, 0x03, 0xE0, 0x7B, 0xC0, 0x0F, 0x03, 0xEF,
  0x80, 0x7C, 0x0F, 0x9E, 0x01, 0xF0, 0x3E, 0x78, 0x07, 0xC0, 0xF9, 0xF0,
  0x1F, 0x03, 0xE3, 0xC0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x7C, 0x3E, 0x0F,
  0x81, 0xF0, 0x78, 0x3E, 0x07, 0xC1, 0xE0, 0xF8, 0x1F, 0x07, 0xC3, 0xE0,
  0x7C, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x7C, 0x0F, 0x80, 0xF9, 0xF0, 0x3E,
  0x01, 0xE7, 0xC0, 0xF8, 0x07, 0x9F, 0x03, 0xE0, 0x1F, 0x7C, 0x0F, 0x00,
  0x7D, 0xE0, 0x3C, 0x00, 0xFF, 0x81, 0xF0, 0x03, 0xFE, 0x07, 0xC0, 0x0F,
  0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0x7C, 0x00, 0x7F, 0x81, 0xE0, 0x01, 0xFC,
  0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0xF0, 0x00,
  0x0F, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0xFE, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x07,
  0xE0, 0x78, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xC0, 0x3F, 0xC0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x0F,
  0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0x80,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x07, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1F,
  0x0F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x78, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x7B, 0xE0, 0x3C, 0x07, 0xDF, 0x03, 0xE0, 0x3E, 0xF8,
  0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x0F, 0x3C, 0x0F, 0xC0, 0xF9, 0xE0, 0x7E,
  0x07, 0xCF, 0x03, 0xF0, 0x3C, 0x78, 0x3F, 0x81, 0xE3, 0xC1, 0xFC, 0x1F,
  0x1E, 0x0F, 0xE0, 0xF0, 0xF0, 0xF7, 0x07, 0x87, 0x87, 0xB8, 0x3C, 0x3C,
  0x3D, 0xC3, 0xE1, 0xE3, 0xCE, 0x1E, 0x0F, 0x1E, 0x70, 0xF0, 0x78, 0xF3,
  0x87, 0x83, 0xC7, 0x1C, 0x78, 0x1E, 0x78, 0xE3, 0xC0, 0xF3, 0xC7, 0x9E,
  0x07, 0x9C, 0x3D, 0xF0, 0x3D, 0xE1, 0xEF, 0x03, 0xCF, 0x0F, 0x78, 0x1E,
  0x70, 0x7B, 0xC0, 0xF7, 0x83, 0xFE, 0x07, 0xBC, 0x1F, 0xE0, 0x3D, 0xC0,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x07,
  0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x01, 0xE0, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F,
  0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x1F, 0x07, 0x87, 0xC0, 0xF0, 0xF0,
  0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0x80,
  0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xF0, 0x3E, 0x7F, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0x78, 0x3F, 0xFE, 0x78, 0x0F, 0xF8, 0x7C, 0x00, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x10, 0x00, 0xF8, 0xFF, 0x80, 0x7D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x79, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0xE0, 0x3F, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83,
  0xCF, 0xFF, 0x81, 0xE1, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0x9F, 0xE0, 0x7E, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0x1F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xC0, 0x7C, 0x00, 0xFF, 0xC7, 0xC0, 0x1F, 0xFE, 0x78, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x78,
  0x00, 0x7F, 0xCF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0xC0,
  0x7E, 0x01, 0xF0, 0x7E, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x1F, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x40, 0xFC, 0x00, 0x78, 0x3F,
  0x00, 0xFC, 0x1F, 0xF3, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF,
  0x1F, 0x00, 0x7F, 0xF9, 0xE0, 0x1F, 0xFF, 0xDE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80,
  0x03, 0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF9, 0xE0, 0x01, 0xFF, 0x3E, 0x00,
  0x01, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x20, 0x00,
  0x7C, 0x03, 0x00, 0x0F, 0x80, 0x78, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x18, 0x00, 0xF8, 0x7F, 0x80, 0x7C, 0xFF, 0xF0, 0x3E, 0xFF,
  0xFC, 0x1E, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0x87, 0xE0, 0x07, 0xC7, 0xE0,
  0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x78,
  0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFE,
  0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0x00,
  0xFC, 0x01, 0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x87, 0xF0, 0x01,
  0xF1, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xF7, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xEF, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x80, 0x3E,
  0xFE, 0x1F, 0x80, 0xF7, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3E, 0x0F, 0xC1, 0xE0, 0xF0, 0x3E, 0x07, 0x87, 0xC0, 0xF8,
  0x1E, 0x1F, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x07,
  0x87, 0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xC3,
  0xE0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0xF0, 0xF0,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x78, 0x7C, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x1E, 0x07, 0xC0,
  0xF8, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0x3C,
  0x3C, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x07, 0xC0, 0x00, 0x00, 0x80, 0x07,
  0xC3, 0xFC, 0x03, 0xC7, 0xFF, 0x81, 0xE7, 0xFF, 0xE0, 0xF7, 0xFF, 0xF0,
  0x7F, 0x80, 0xFC, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3E, 0x00,
  0x1F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F,
  0x00, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x00,
  0xF8, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xEF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC7, 0xF8,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x7F, 0x80, 0x0F, 0xBF, 0xFC, 0x01,
  0xEF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x01,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0xC0,
  0x7F, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0x7F, 0xFC, 0x03,
  0xE3, 0xFE, 0x00, 0x78, 0x0C, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xF1, 0xF0, 0x1F,
  0xFE, 0x78, 0x1F, 0xFF, 0xDE, 0x0F, 0xF9, 0xFF, 0x83, 0xF0, 0x0F, 0xE1,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x03,
  0xFC, 0x0F, 0xE3, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xE0, 0x07,
  0xFC, 0xF8, 0x00, 0x30, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x60, 0x1F, 0x0F, 0xFC, 0x3E, 0x7F, 0xF8, 0x79,
  0xFF, 0xE0, 0xF7, 0xFF, 0xC1, 0xFF, 0x81, 0x87, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0xE0, 0x7E, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xE3, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xE1, 0xF8, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x78, 0x0F, 0xFF, 0x3C, 0x01, 0xFE, 0x1E, 0x00,
  0x18, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF8,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE3,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07,
  0x00, 0x7F, 0x80, 0x38, 0x07, 0xFC, 0x03, 0xC0, 0x3C, 0xE0, 0x1E, 0x01,
  0xE7, 0x01, 0xF0, 0x1E, 0x38, 0x0F, 0xC0, 0xF1, 0xC0, 0xFE, 0x07, 0x8F,
  0x07, 0x70, 0x78, 0x78, 0x3B, 0x83, 0xC3, 0xC3, 0xDC, 0x1E, 0x1E, 0x1C,
  0xE1, 0xE0, 0xF1, 0xE7, 0x0F, 0x07, 0x8F, 0x38, 0x70, 0x3C, 0x71, 0xC7,
  0x81, 0xE7, 0x8E, 0x3C, 0x0F, 0x38, 0x71, 0xC0, 0x7B, 0xC3, 0x9E, 0x03,
  0xDC, 0x1C, 0xE0, 0x1F, 0xE0, 0xE7, 0x00, 0xEF, 0x07, 0x78, 0x07, 0x70,
  0x3B, 0x80, 0x3F, 0x81, 0xDC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x7B, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x07,
  0xFF, 0x00, 0x0E, 0x7F, 0xFC, 0x00, 0xF7, 0xF7, 0xF8, 0x0F, 0x3C, 0x0F,
  0xE0, 0xFB, 0xC0, 0x3F, 0xFF, 0xDE, 0x00, 0x7F, 0xFC, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x00,
};

const GFXglyph RobotoMono_Italic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 38, 31, 10, -38 },
  { 54, 14, 13, 31, 11, -40 },
  { 77, 31, 38, 31, 1, -38 },
  { 225, 26, 49, 31, 3, -44 },
  { 385, 26, 39, 31, 3, -38 },
  { 512, 28, 39, 31, 1, -38 },
  { 649, 6, 13, 31, 14, -40 },
  { 659, 18, 55, 31, 8, -43 },
  { 783, 18, 55, 31, 4, -43 },
  { 907, 24, 26, 31, 6, -38 },
  { 985, 26, 27, 31, 3, -31 },
  { 1073, 9, 15, 31, 5, -6 },
  { 1090, 20, 3, 31, 5, -18 },
  { 1098, 8, 8, 31, 10, -7 },
  { 1106, 27, 41, 31, 3, -38 },
  { 1245, 26, 39, 31, 3, -38 },
  { 1372, 16, 38, 31, 7, -38 },
  { 1448, 27, 38, 31, 0, -38 },
  { 1577, 26, 39, 31, 1, -38 },
  { 1704, 27, 38, 31, 1, -38 },
  { 1833, 26, 39, 31, 4, -38 },
  { 1960, 23, 39, 31, 3, -38 },
  { 2073, 26, 38, 31, 5, -38 },
  { 2197, 26, 39, 31, 3, -38 },
  { 2324, 23, 38, 31, 5, -38 },
  { 2434, 11, 31, 31, 12, -30 },
  { 2477, 15, 39, 31, 8, -30 },
  { 2551, 24, 24, 31, 4, -29 },
  { 2623, 25, 15, 31, 3, -24 },
  { 2670, 24, 23, 31, 3, -28 },
  { 2739, 22, 38, 31, 7, -38 },
  { 2844, 29, 38, 31, 2, -38 },
  { 2982, 28, 38, 31, -1, -38 },
  { 3115, 27, 38, 31, 2, -38 },
  { 3244, 27, 39, 31, 3, -38 },
  { 3376, 29, 38, 31, 1, -38 },
  { 3514, 29, 38, 31, 2, -38 },
  { 3652, 29, 38, 31, 2, -38 },
  { 3790, 28, 39, 31, 2, -38 },
  { 3927, 30, 38, 31, 1, -38 },
  { 4070, 28, 38, 31, 2, -38 },
  { 4203, 28, 39, 31, 2, -38 },
  { 4340, 31, 38, 31, 2, -38 },
  { 4488, 24, 38, 31, 2, -38 },
  { 4602, 30, 38, 31, 1, -38 },
  { 4745, 30, 38, 31, 1, -38 },
  { 4888, 26, 39, 31, 3, -38 },
  { 5015, 29, 38, 31, 2, -38 },
  { 5153, 28, 44, 31, 2, -38 },
  { 5307, 28, 38, 31, 2, -38 },
  { 5440, 28, 39, 31, 2, -38 },
  { 5577, 28, 38, 31, 5, -38 },
  { 5710, 28, 39, 31, 3, -38 },
  { 5847, 27, 38, 31, 5, -38 },
  { 5976, 29, 38, 31, 4, -38 },
  { 6114, 33, 38, 31, 0, -38 },
  { 6271, 28, 38, 31, 5, -38 },
  { 6404, 30, 38, 31, 0, -38 },
  { 6547, 18, 51, 31, 7, -43 },
  { 6662, 12, 41, 31, 10, -38 },
  { 6724, 18, 51, 31, 6, -43 },
  { 6839, 19, 20, 31, 6, -38 },
  { 6887, 23, 4, 31, 1, 0 },
  { 6899, 9, 7, 31, 14, -38 },
  { 6907, 24, 30, 31, 3, -29 },
  { 6997, 25, 41, 31, 2, -40 },
  { 7126, 25, 30, 31, 3, -29 },
  { 7220, 28, 41, 31, 3, -40 },
  { 7364, 25, 30, 31, 3, -29 },
  { 7458, 28, 41, 31, 5, -41 },
  { 7602, 28, 40, 31, 1, -29 },
  { 7742, 25, 40, 31, 2, -40 },
  { 7867, 24, 38, 31, 2, -38 },
  { 7981, 24, 49, 31, 1, -38 },
  { 8128, 27, 40, 31, 2, -40 },
  { 8263, 24, 40, 31, 2, -40 },
  { 8383, 30, 29, 31, 0, -29 },
  { 8492, 25, 29, 31, 2, -29 },
  { 8583, 25, 30, 31, 3, -29 },
  { 8677, 27, 40, 31, 0, -29 },
  { 8812, 26, 40, 31, 3, -29 },
  { 8942, 23, 29, 31, 6, -29 },
  { 9026, 25, 30, 31, 3, -29 },
  { 9120, 23, 36, 31, 5, -35 },
  { 9224, 25, 29, 31, 4, -28 },
  { 9315, 26, 28, 31, 4, -28 },
  { 9406, 29, 28, 31, 3, -28 },
  { 9508, 30, 28, 31, 0, -28 },
  { 9613, 32, 39, 31, -1, -28 },
  { 9769, 26, 28, 31, 2, -28 },
  { 9860, 21, 50, 31, 8, -41 },
  { 9992, 12, 48, 31, 9, -38 },
  { 10064, 20, 51, 31, 5, -41 },
  { 10192, 29, 11, 31, 1, -21 },
};

const GFXfont RobotoMono_Italic53pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic53pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOMONO_ITALIC53PT7B_H_
