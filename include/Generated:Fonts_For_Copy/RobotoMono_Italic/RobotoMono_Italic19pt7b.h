#ifndef _ROBOTOMONO_ITALIC19PT7B_H_
#define _ROBOTOMONO_ITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x66, 0x64, 0x4C, 0x00, 0x8C, 0xCE, 0xE7, 0x20, 0x02,
  0x20, 0x4C, 0x11, 0x02, 0x63, 0xFE, 0x7F, 0xC2, 0x60, 0xC8, 0x11, 0x1F,
  0xF8, 0xC8, 0x11, 0x02, 0x60, 0xC8, 0x00, 0x02, 0x01, 0x01, 0x83, 0xF3,
  0x19, 0x04, 0x82, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x2C, 0x1E, 0x19, 0x9C,
  0x7C, 0x10, 0x08, 0x00, 0x30, 0x2C, 0x32, 0x79, 0x2C, 0xA3, 0xB0, 0x10,
  0x10, 0x1B, 0x0A, 0xCB, 0x29, 0x90, 0xC8, 0x38, 0x0C, 0x0F, 0x8C, 0xC6,
  0x63, 0x31, 0xF0, 0x60, 0x70, 0x6C, 0xE6, 0xE1, 0xF0, 0xEC, 0x73, 0xEC,
  0x5F, 0x04, 0x31, 0x8C, 0x21, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x10, 0x41, 0x83, 0x00, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC1, 0x83, 0x06,
  0x0C, 0x10, 0x20, 0xC1, 0x86, 0x0C, 0x30, 0xC3, 0x00, 0x0C, 0x06, 0x02,
  0x09, 0x2F, 0xF8, 0xC0, 0xF0, 0xC8, 0xC6, 0x22, 0x00, 0x04, 0x06, 0x03,
  0x01, 0x8F, 0xF8, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x6D, 0xE8, 0xFF,
  0xFC, 0xF0, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x00, 0x0E, 0x0F, 0x8C,
  0x6C, 0x16, 0x0A, 0x1D, 0x1F, 0xBB, 0xF1, 0xF0, 0xF0, 0x58, 0x66, 0x61,
  0xE0, 0x09, 0xFF, 0x31, 0x88, 0x46, 0x31, 0x8C, 0x42, 0x30, 0x06, 0x07,
  0xE3, 0x0C, 0x83, 0x40, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x3F, 0xE0, 0x07, 0x07, 0xE3, 0x0C, 0xC3, 0x00, 0xC0, 0x60,
  0xF0, 0x3C, 0x01, 0x80, 0x6C, 0x19, 0x06, 0x63, 0x0F, 0x80, 0x00, 0xC0,
  0x70, 0x38, 0x1A, 0x05, 0x83, 0x61, 0x98, 0xC4, 0x61, 0x1F, 0xFF, 0xFC,
  0x0C, 0x03, 0x00, 0x80, 0x1F, 0xC7, 0xF1, 0x00, 0xC0, 0x30, 0x0B, 0x87,
  0xF0, 0x86, 0x01, 0x80, 0x6C, 0x1B, 0x0C, 0x67, 0x0F, 0x80, 0x01, 0x0F,
  0x18, 0x30, 0x60, 0x6E, 0x7F, 0xE3, 0xC1, 0xC1, 0xC1, 0xC3, 0x66, 0x3C,
  0xFF, 0xFF, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C,
  0x0C, 0x04, 0x06, 0x00, 0x06, 0x0F, 0xCC, 0x64, 0x12, 0x09, 0x8C, 0xFC,
  0x7E, 0x63, 0x60, 0xF0, 0x78, 0x66, 0x71, 0xF0, 0x1C, 0x7E, 0x63, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x02, 0x06, 0x0C, 0xF8, 0xE0, 0x33, 0x00,
  0x00, 0x00, 0xEE, 0x38, 0xC0, 0x00, 0x00, 0x00, 0x63, 0x18, 0x8C, 0x00,
  0x01, 0x83, 0xC7, 0x0E, 0x0E, 0x01, 0xE0, 0x3C, 0x06, 0x7F, 0xBF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF8, 0x60, 0x3C, 0x07, 0x80, 0x70, 0x78, 0xF3, 0xC1,
  0x80, 0x38, 0xFF, 0x1C, 0x10, 0x60, 0xC3, 0x0C, 0x30, 0xC0, 0x00, 0x06,
  0x0C, 0x00, 0x02, 0x07, 0xE3, 0x09, 0x99, 0x4B, 0x64, 0x99, 0x26, 0x89,
  0xA6, 0xA9, 0x2B, 0xB2, 0x00, 0xC4, 0x0F, 0x00, 0x03, 0x00, 0xC0, 0x70,
  0x14, 0x0D, 0x02, 0x41, 0x98, 0x66, 0x31, 0x8F, 0xE7, 0xF9, 0x82, 0xC0,
  0xB0, 0x30, 0x3C, 0x0F, 0xE2, 0x19, 0x83, 0x60, 0x98, 0x67, 0xF1, 0xFC,
  0x41, 0xB0, 0x6C, 0x1B, 0x0C, 0xC7, 0x3F, 0x00, 0x0E, 0x07, 0xE3, 0x19,
  0x83, 0x40, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0x0C, 0x67,
  0x0F, 0x00, 0x1C, 0x03, 0xF0, 0xC3, 0x18, 0x63, 0x04, 0x60, 0xC8, 0x19,
  0x02, 0x60, 0x4C, 0x19, 0x82, 0x30, 0xC4, 0x71, 0xF8, 0x00, 0x3F, 0xCF,
  0xF2, 0x01, 0x80, 0x60, 0x18, 0x07, 0xF1, 0xFC, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x3F, 0xC0, 0x3F, 0xCF, 0xF2, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xFC, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x07,
  0xE3, 0x19, 0x83, 0x40, 0x30, 0x0C, 0x03, 0x1E, 0xC7, 0xB0, 0x6C, 0x1B,
  0x06, 0x63, 0x0F, 0x80, 0x10, 0x26, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x40,
  0x8F, 0xF3, 0xFE, 0x60, 0xCC, 0x19, 0x02, 0x20, 0x44, 0x19, 0x83, 0x00,
  0x3F, 0xCF, 0xF0, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x3F, 0xC0, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x48, 0x33, 0x0C, 0xC6, 0x1F, 0x00,
  0x30, 0x64, 0x18, 0x86, 0x31, 0x86, 0x60, 0xD8, 0x1E, 0x03, 0xE0, 0x6C,
  0x18, 0xC3, 0x18, 0x61, 0x0C, 0x31, 0x03, 0x00, 0x30, 0x30, 0x20, 0x20,
  0x60, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xFF, 0x18, 0x63,
  0x0C, 0xE3, 0x9C, 0x73, 0x9E, 0x52, 0x8B, 0xD3, 0x76, 0x66, 0xCC, 0x99,
  0x83, 0x20, 0x44, 0x09, 0x83, 0x00, 0x10, 0x67, 0x0C, 0xE1, 0x9C, 0x33,
  0xC4, 0x78, 0x89, 0x33, 0x36, 0x66, 0xCC, 0x59, 0x8E, 0x21, 0xC4, 0x19,
  0x83, 0x00, 0x0E, 0x07, 0xC3, 0x19, 0x82, 0x40, 0xB0, 0x3C, 0x0B, 0x02,
  0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0x66, 0x0F, 0x00, 0x3C, 0x0F, 0xE2, 0x0C,
  0x83, 0x60, 0xD8, 0x36, 0x19, 0xFC, 0x7C, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x00, 0x0E, 0x07, 0xC3, 0x19, 0x82, 0x40, 0xF0, 0x3C, 0x0F, 0x02,
  0xC0, 0xB0, 0x6C, 0x1B, 0x0C, 0x66, 0x0F, 0x80, 0x70, 0x0C, 0x3C, 0x0F,
  0xE2, 0x19, 0x83, 0x60, 0xD8, 0x26, 0x19, 0xFC, 0x46, 0x31, 0x8C, 0x23,
  0x0C, 0xC3, 0x20, 0xC0, 0x0E, 0x0F, 0xE3, 0x19, 0x83, 0x60, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x6C, 0x1B, 0x06, 0x67, 0x0F, 0x80, 0xFF, 0xFF,
  0xF0, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x08, 0x00, 0x20, 0x58, 0x36, 0x0D, 0x83, 0x60, 0x90, 0x24,
  0x0B, 0x06, 0xC1, 0xB0, 0x6C, 0x13, 0x0C, 0x66, 0x0F, 0x00, 0xC0, 0xF0,
  0x6C, 0x1B, 0x0C, 0x43, 0x10, 0x84, 0x61, 0x90, 0x6C, 0x1A, 0x07, 0x80,
  0xE0, 0x30, 0x0C, 0x00, 0x46, 0x68, 0xCD, 0x39, 0x27, 0x24, 0xEC, 0x9D,
  0x97, 0xA2, 0xBC, 0x57, 0x8E, 0xE1, 0x9C, 0x73, 0x8E, 0x71, 0x8C, 0x00,
  0x30, 0x31, 0x06, 0x18, 0xC1, 0x8C, 0x0D, 0x80, 0xF0, 0x06, 0x00, 0x60,
  0x0E, 0x01, 0xB0, 0x33, 0x03, 0x18, 0x61, 0x8C, 0x0C, 0xC0, 0xF0, 0x64,
  0x31, 0x8C, 0x66, 0x09, 0x02, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x08, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xFF, 0x00, 0x1E,
  0x30, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18,
  0x20, 0x71, 0xE0, 0xC2, 0x10, 0xC6, 0x30, 0x84, 0x31, 0x8C, 0x21, 0x0C,
  0x60, 0x1E, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x10, 0x60, 0xC1,
  0x83, 0x04, 0x08, 0x71, 0xE0, 0x08, 0x18, 0x70, 0xA3, 0x4C, 0xD1, 0xE1,
  0xFF, 0x80, 0xCC, 0x80, 0x3E, 0x39, 0x98, 0x60, 0x33, 0xF3, 0x0B, 0x0D,
  0x86, 0xCF, 0x3D, 0x80, 0x30, 0x10, 0x08, 0x0C, 0x07, 0xF3, 0x99, 0x86,
  0x83, 0x41, 0xE0, 0xF0, 0x58, 0x6E, 0x65, 0xE0, 0x1F, 0x19, 0x98, 0x68,
  0x0C, 0x06, 0x03, 0x01, 0x86, 0x67, 0x1E, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x3F, 0x9C, 0xE6, 0x1B, 0x06, 0xC1, 0x30, 0x4C, 0x33, 0x0C, 0x67,
  0x1F, 0xC0, 0x1E, 0x19, 0x98, 0x78, 0x3F, 0xFE, 0x03, 0x01, 0x82, 0x63,
  0x1F, 0x00, 0x03, 0x83, 0xF1, 0x80, 0x60, 0x18, 0x3F, 0xC1, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x00, 0x1F, 0x4E, 0x73,
  0x0D, 0x83, 0x60, 0x98, 0x26, 0x19, 0x86, 0x33, 0x8F, 0xE0, 0x11, 0x0C,
  0xE6, 0x0F, 0x00, 0x30, 0x10, 0x08, 0x0C, 0x06, 0xF3, 0x99, 0x86, 0x83,
  0x41, 0xE0, 0xB0, 0x58, 0x6C, 0x34, 0x18, 0x02, 0x06, 0x00, 0x00, 0x7E,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0xFF, 0x01, 0x80, 0xC0,
  0x00, 0x01, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x18, 0x9C, 0x7C, 0x00, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x1B,
  0x39, 0xB8, 0xB0, 0x78, 0x7C, 0x33, 0x18, 0xCC, 0x64, 0x18, 0x3E, 0x06,
  0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0xFF,
  0x3D, 0xCC, 0xCD, 0x99, 0xB2, 0x24, 0x44, 0x89, 0xB3, 0x36, 0x66, 0xCC,
  0xD9, 0x10, 0x6F, 0x39, 0x98, 0x68, 0x34, 0x1E, 0x0B, 0x05, 0x86, 0xC3,
  0x41, 0x80, 0x1E, 0x39, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x86, 0x66,
  0x1E, 0x00, 0x3F, 0x8E, 0x63, 0x0C, 0x83, 0x20, 0xD8, 0x36, 0x09, 0x86,
  0x73, 0x17, 0x84, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x3E, 0xB9, 0xD8, 0x78,
  0x3C, 0x16, 0x0B, 0x0D, 0x86, 0x67, 0x3F, 0x80, 0x80, 0x40, 0x60, 0x30,
  0x2F, 0x7D, 0x70, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x1F, 0x19,
  0xD8, 0x6C, 0x03, 0xC0, 0x78, 0x0D, 0x82, 0x63, 0x1F, 0x00, 0x18, 0x10,
  0xFF, 0x30, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x32, 0x3E, 0x60, 0xB0,
  0xD8, 0x68, 0x34, 0x16, 0x0B, 0x0D, 0x86, 0x67, 0x3D, 0x80, 0x81, 0xE1,
  0xB0, 0x98, 0xC4, 0x42, 0x61, 0xA0, 0xF0, 0x30, 0x18, 0x00, 0xC4, 0x79,
  0x9B, 0x33, 0x6E, 0x4D, 0x59, 0xEA, 0x39, 0x47, 0x38, 0x66, 0x08, 0xC0,
  0x30, 0xE2, 0x18, 0x66, 0x07, 0x80, 0xE0, 0x1C, 0x06, 0x81, 0x98, 0x61,
  0x1C, 0x30, 0x60, 0x66, 0x18, 0xC3, 0x18, 0xC1, 0x18, 0x36, 0x06, 0x80,
  0xF0, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x07, 0x01, 0xC0, 0x00, 0x7F, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0x80, 0x02, 0x18,
  0x20, 0xC1, 0x83, 0x06, 0x18, 0x61, 0x81, 0x81, 0x83, 0x04, 0x08, 0x10,
  0x30, 0x30, 0x11, 0x11, 0x33, 0x32, 0x22, 0x26, 0x64, 0x44, 0x4C, 0x30,
  0x30, 0x20, 0x40, 0x83, 0x06, 0x0C, 0x0C, 0x1C, 0x60, 0x83, 0x06, 0x0C,
  0x10, 0x61, 0x80, 0x7C, 0x69, 0xCB, 0x0F, 0x00,
};

const GFXglyph RobotoMono_Italic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 14, 11, 4, -14 },
  { 8, 5, 4, 11, 4, -14 },
  { 11, 11, 14, 11, 0, -14 },
  { 31, 9, 18, 11, 1, -16 },
  { 52, 9, 14, 11, 1, -14 },
  { 68, 9, 14, 11, 1, -14 },
  { 84, 2, 4, 11, 5, -14 },
  { 85, 6, 19, 11, 3, -15 },
  { 100, 7, 19, 11, 1, -15 },
  { 117, 9, 10, 11, 2, -14 },
  { 129, 9, 10, 11, 1, -11 },
  { 141, 3, 5, 11, 2, -2 },
  { 143, 7, 2, 11, 2, -7 },
  { 145, 2, 2, 11, 4, -2 },
  { 146, 10, 15, 11, 1, -14 },
  { 165, 9, 14, 11, 1, -14 },
  { 181, 5, 14, 11, 3, -14 },
  { 190, 10, 14, 11, 0, -14 },
  { 208, 10, 14, 11, 0, -14 },
  { 226, 10, 14, 11, 0, -14 },
  { 244, 10, 14, 11, 1, -14 },
  { 262, 8, 14, 11, 1, -14 },
  { 276, 9, 14, 11, 2, -14 },
  { 292, 9, 14, 11, 1, -14 },
  { 308, 8, 14, 11, 2, -14 },
  { 322, 4, 10, 11, 4, -10 },
  { 327, 5, 13, 11, 3, -10 },
  { 336, 9, 8, 11, 1, -10 },
  { 345, 9, 6, 11, 1, -9 },
  { 352, 9, 8, 11, 1, -10 },
  { 361, 7, 14, 11, 3, -14 },
  { 374, 10, 14, 11, 1, -14 },
  { 392, 10, 14, 11, 0, -14 },
  { 410, 10, 14, 11, 1, -14 },
  { 428, 10, 14, 11, 1, -14 },
  { 446, 11, 14, 11, 0, -14 },
  { 466, 10, 14, 11, 1, -14 },
  { 484, 10, 14, 11, 1, -14 },
  { 502, 10, 14, 11, 1, -14 },
  { 520, 11, 14, 11, 0, -14 },
  { 540, 10, 14, 11, 1, -14 },
  { 558, 10, 14, 11, 1, -14 },
  { 576, 11, 14, 11, 1, -14 },
  { 596, 8, 14, 11, 1, -14 },
  { 610, 11, 14, 11, 0, -14 },
  { 630, 11, 14, 11, 0, -14 },
  { 650, 10, 14, 11, 1, -14 },
  { 668, 10, 14, 11, 1, -14 },
  { 686, 10, 16, 11, 1, -14 },
  { 706, 10, 14, 11, 1, -14 },
  { 724, 10, 14, 11, 1, -14 },
  { 742, 10, 14, 11, 2, -14 },
  { 760, 10, 14, 11, 1, -14 },
  { 778, 10, 14, 11, 2, -14 },
  { 796, 11, 14, 11, 1, -14 },
  { 816, 12, 14, 11, 0, -14 },
  { 837, 10, 14, 11, 2, -14 },
  { 855, 11, 14, 11, 0, -14 },
  { 875, 7, 18, 11, 2, -15 },
  { 891, 5, 15, 11, 3, -14 },
  { 901, 7, 18, 11, 2, -15 },
  { 917, 7, 8, 11, 2, -14 },
  { 924, 9, 1, 11, 0, 0 },
  { 926, 3, 3, 11, 5, -14 },
  { 928, 9, 10, 11, 1, -10 },
  { 940, 9, 14, 11, 1, -14 },
  { 956, 9, 10, 11, 1, -10 },
  { 968, 10, 14, 11, 1, -14 },
  { 986, 9, 10, 11, 1, -10 },
  { 998, 10, 15, 11, 2, -15 },
  { 1017, 10, 14, 11, 0, -10 },
  { 1035, 9, 14, 11, 1, -14 },
  { 1051, 8, 14, 11, 1, -14 },
  { 1065, 9, 18, 11, 0, -14 },
  { 1086, 9, 14, 11, 1, -14 },
  { 1102, 8, 14, 11, 1, -14 },
  { 1116, 11, 10, 11, 0, -10 },
  { 1130, 9, 10, 11, 1, -10 },
  { 1142, 9, 10, 11, 1, -10 },
  { 1154, 10, 14, 11, 0, -10 },
  { 1172, 9, 14, 11, 1, -10 },
  { 1188, 8, 10, 11, 2, -10 },
  { 1198, 9, 10, 11, 1, -10 },
  { 1210, 8, 12, 11, 2, -12 },
  { 1222, 9, 10, 11, 1, -10 },
  { 1234, 9, 10, 11, 2, -10 },
  { 1246, 11, 10, 11, 1, -10 },
  { 1260, 11, 10, 11, 0, -10 },
  { 1274, 11, 14, 11, 0, -10 },
  { 1294, 9, 10, 11, 1, -10 },
  { 1306, 7, 18, 11, 3, -15 },
  { 1322, 4, 18, 11, 3, -14 },
  { 1331, 7, 18, 11, 2, -15 },
  { 1347, 11, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_Italic19pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic19pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOMONO_ITALIC19PT7B_H_
