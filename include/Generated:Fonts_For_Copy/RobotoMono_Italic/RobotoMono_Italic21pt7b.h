#ifndef _ROBOTOMONO_ITALIC21PT7B_H_
#define _ROBOTOMONO_ITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x32, 0x66, 0x66, 0x00, 0x0C, 0xC0, 0x65, 0x34, 0xD2,
  0xC8, 0x03, 0x30, 0x11, 0x80, 0x88, 0x0C, 0xC3, 0xFF, 0x9F, 0xF8, 0x33,
  0x01, 0x10, 0x19, 0x87, 0xFF, 0x3F, 0xF8, 0x66, 0x02, 0x30, 0x11, 0x01,
  0x98, 0x00, 0x03, 0x00, 0x60, 0x3E, 0x0F, 0xE3, 0x0C, 0x60, 0x8C, 0x11,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xC0, 0x0D, 0x81, 0x18, 0x63, 0xBC,
  0x3E, 0x01, 0x00, 0x60, 0x00, 0x38, 0x13, 0x0C, 0xCF, 0x36, 0xCD, 0x1E,
  0xC0, 0x60, 0x10, 0x08, 0x06, 0xF1, 0x64, 0x91, 0x64, 0x41, 0x30, 0x78,
  0x0F, 0x03, 0x70, 0xC6, 0x18, 0xC3, 0x30, 0x6C, 0x07, 0x01, 0xC0, 0x7C,
  0x78, 0xCB, 0x1B, 0x61, 0xCC, 0x39, 0xCF, 0x1F, 0x70, 0xFE, 0x80, 0x02,
  0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30,
  0x20, 0x40, 0xC1, 0x81, 0x03, 0x02, 0x00, 0x10, 0x30, 0x20, 0x60, 0xC0,
  0x81, 0x03, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x60, 0xC3,
  0x0C, 0x10, 0x00, 0x06, 0x01, 0x00, 0x41, 0x13, 0xFF, 0xC7, 0x81, 0xC0,
  0xD8, 0x63, 0x10, 0x80, 0x06, 0x01, 0x80, 0x60, 0x10, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x36, 0x66, 0xC0, 0xFF, 0x5F, 0x80,
  0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x0F, 0x87,
  0x73, 0x0C, 0x81, 0x60, 0x58, 0x76, 0x3D, 0xBB, 0x58, 0xFC, 0x3C, 0x0F,
  0x06, 0x41, 0x99, 0xC3, 0xE0, 0x04, 0xFF, 0xE3, 0x08, 0x61, 0x86, 0x18,
  0x61, 0x0C, 0x30, 0xC3, 0x00, 0x0F, 0x83, 0xB8, 0xC1, 0x98, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xFF,
  0xBF, 0xF0, 0x0F, 0x83, 0xB8, 0xC1, 0x98, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x78, 0x01, 0x80, 0x18, 0x03, 0x20, 0x66, 0x18, 0xE7, 0x0F, 0x80, 0x00,
  0xE0, 0x18, 0x07, 0x01, 0xE0, 0x6C, 0x19, 0x82, 0x30, 0xC4, 0x31, 0x8C,
  0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x02, 0x00, 0xC0, 0x0F, 0xE3, 0xFC, 0x60,
  0x08, 0x03, 0x00, 0x6C, 0x0F, 0xE1, 0x8C, 0x00, 0xC0, 0x18, 0x03, 0x60,
  0x46, 0x18, 0xE6, 0x0F, 0x80, 0x03, 0x87, 0xC7, 0x06, 0x03, 0x03, 0x71,
  0xFC, 0xC3, 0xC1, 0xE0, 0x70, 0x78, 0x36, 0x1B, 0xB8, 0xF8, 0xFF, 0xFF,
  0xF0, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0F, 0x83, 0xB8, 0xC3, 0x18, 0x33, 0x04,
  0x61, 0x86, 0xE0, 0xF8, 0x31, 0x8C, 0x13, 0x03, 0x60, 0x64, 0x18, 0xE7,
  0x0F, 0x80, 0x1E, 0x19, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x7F,
  0x9E, 0x80, 0xC0, 0xC0, 0xE3, 0xE1, 0xC0, 0x27, 0x70, 0x00, 0x00, 0x0C,
  0xEC, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x71, 0x8C,
  0x00, 0x01, 0x83, 0xCF, 0x9E, 0x0C, 0x03, 0x80, 0x78, 0x0E, 0x01, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x20, 0x1E, 0x01, 0xE0,
  0x0E, 0x01, 0xC3, 0xE3, 0xC3, 0xC0, 0x80, 0x00, 0x3E, 0x7F, 0xC3, 0xC3,
  0x03, 0x03, 0x06, 0x1C, 0x18, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0x07,
  0x83, 0x98, 0xC1, 0xB3, 0x94, 0xD2, 0xB2, 0x64, 0x4C, 0x99, 0x92, 0x76,
  0x4A, 0x7B, 0x4C, 0xCC, 0x00, 0xC4, 0x0F, 0x80, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x19, 0x03, 0x20, 0xC6, 0x18, 0xC7, 0xF8, 0xFF, 0x30,
  0x66, 0x0D, 0x80, 0xB0, 0x18, 0x3F, 0x07, 0xF8, 0xC3, 0x10, 0x36, 0x06,
  0xC1, 0x9F, 0xE3, 0xF8, 0x61, 0x88, 0x1B, 0x03, 0x60, 0x6C, 0x19, 0xFE,
  0x3F, 0x80, 0x0F, 0x83, 0xB8, 0xC3, 0x30, 0x36, 0x06, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x01, 0x60, 0x44, 0x18, 0xE6, 0x0F, 0x80, 0x1F,
  0x01, 0xFC, 0x18, 0x63, 0x06, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x20,
  0x26, 0x06, 0x60, 0x66, 0x0C, 0x61, 0xC7, 0xF0, 0xFE, 0x00, 0x3F, 0xE7,
  0xFC, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x1F, 0xE3, 0xFC, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0xFC, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x0F, 0x83, 0xB8, 0xC3, 0x30, 0x36, 0x00, 0x80,
  0x30, 0x06, 0x00, 0xC7, 0xD8, 0x1B, 0x03, 0x60, 0x66, 0x0C, 0xE7, 0x0F,
  0xC0, 0x18, 0x11, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x02, 0x3F, 0xE3,
  0xFE, 0x60, 0x66, 0x06, 0x60, 0x66, 0x04, 0x60, 0xC4, 0x0C, 0xC0, 0xC0,
  0x3F, 0xE7, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x81, 0xFF, 0x3F, 0xE0, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x60, 0xCC, 0x31, 0xCE, 0x1F, 0x00, 0x30, 0x73, 0x0E, 0x31, 0xC3, 0x38,
  0x67, 0x06, 0x60, 0x6C, 0x07, 0xC0, 0x76, 0x06, 0x60, 0xC3, 0x0C, 0x30,
  0xC3, 0x8C, 0x18, 0xC1, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x07, 0xFF, 0xFE, 0x18, 0x31,
  0x87, 0x1C, 0x73, 0xCF, 0x3C, 0xF3, 0x5B, 0x35, 0xA2, 0x76, 0x27, 0x66,
  0x66, 0x66, 0x66, 0x04, 0x60, 0x44, 0x0C, 0xC0, 0xC0, 0x18, 0x31, 0x83,
  0x1C, 0x33, 0xC3, 0x3C, 0x33, 0x66, 0x36, 0x63, 0x66, 0x63, 0x66, 0x36,
  0x63, 0x66, 0x1C, 0x61, 0xC4, 0x1C, 0xC0, 0xC0, 0x0F, 0x83, 0xF8, 0xC3,
  0x30, 0x26, 0x06, 0xC0, 0xF0, 0x1E, 0x02, 0xC0, 0xD8, 0x1B, 0x03, 0x60,
  0xC4, 0x18, 0xEE, 0x0F, 0x80, 0x3F, 0x87, 0xF8, 0xC1, 0x98, 0x32, 0x06,
  0xC0, 0xD8, 0x33, 0xFE, 0x7F, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x0F, 0x83, 0xF8, 0xC3, 0x30, 0x36, 0x06, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x58, 0x1B, 0x03, 0x60, 0xCC, 0x18, 0xEE, 0x0F, 0x80, 0x18,
  0x01, 0x80, 0x20, 0x3F, 0x07, 0xF8, 0xC3, 0x18, 0x32, 0x06, 0xC0, 0xD8,
  0x33, 0xFC, 0x7E, 0x0C, 0x61, 0x0C, 0x61, 0x8C, 0x19, 0x83, 0x30, 0x60,
  0x0F, 0x87, 0xB8, 0xC3, 0xB0, 0x36, 0x00, 0x60, 0x0F, 0x00, 0xF8, 0x03,
  0x80, 0x38, 0x03, 0x60, 0x6C, 0x1C, 0xE7, 0x0F, 0xC0, 0xFF, 0xFF, 0xFC,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x64, 0x0C, 0x81, 0xB0, 0x36,
  0x06, 0xC0, 0x98, 0x32, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xCC, 0x18,
  0xEE, 0x0F, 0x80, 0xC0, 0x78, 0x1B, 0x03, 0x20, 0xC6, 0x18, 0xC6, 0x18,
  0xC3, 0x10, 0x66, 0x04, 0x80, 0xB0, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x00,
  0xC4, 0x79, 0x8F, 0x31, 0x66, 0x6D, 0xCD, 0xB9, 0xA5, 0x25, 0xBC, 0xB7,
  0x94, 0xF3, 0x9C, 0x73, 0x8C, 0x71, 0x8C, 0x31, 0x80, 0x38, 0x38, 0xC1,
  0x86, 0x18, 0x19, 0x80, 0xCC, 0x02, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x06, 0x60, 0x73, 0x03, 0x0C, 0x30, 0x63, 0x03, 0x80, 0xC0, 0xEC,
  0x19, 0x86, 0x30, 0xC2, 0x30, 0x6C, 0x0D, 0x81, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0F, 0xFC, 0xFF, 0xC0, 0x1E, 0x3C, 0x41, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x83, 0x07, 0x80,
  0xC6, 0x30, 0x84, 0x31, 0x8C, 0x21, 0x0C, 0x63, 0x08, 0x43, 0x1E, 0x78,
  0x10, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x08,
  0x30, 0x60, 0xC7, 0x80, 0x04, 0x0E, 0x0E, 0x1E, 0x32, 0x32, 0x63, 0xE3,
  0xFF, 0xFF, 0xE0, 0xCC, 0x80, 0x1F, 0x0C, 0x66, 0x0C, 0x03, 0x1F, 0x9F,
  0xEE, 0x1B, 0x06, 0xC3, 0xBB, 0xE7, 0xD8, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x1B, 0xC7, 0x99, 0x83, 0x60, 0xD8, 0x34, 0x0F, 0x03, 0xC1, 0xB0,
  0x6F, 0x73, 0xF8, 0x1F, 0x0E, 0x66, 0x0D, 0x83, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x41, 0x9C, 0xC3, 0xE0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x3F, 0x8E, 0x73, 0x06, 0x60, 0xD8, 0x1B, 0x02, 0x60, 0xCC, 0x18, 0x83,
  0x1D, 0xE1, 0xE8, 0x1F, 0x0E, 0x66, 0x0D, 0x83, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x61, 0x1C, 0xE3, 0xE0, 0x03, 0xE1, 0xCC, 0x30, 0x04, 0x01, 0x81,
  0xFF, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x0F, 0xE3, 0x9C, 0xC1, 0x98, 0x36, 0x06, 0xC0, 0x98,
  0x33, 0x06, 0x20, 0xC7, 0x78, 0x7B, 0x00, 0xC4, 0x19, 0xC6, 0x0F, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x1B, 0xE7, 0x99, 0x83, 0x60, 0xD8,
  0x34, 0x0B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0x03, 0x01, 0x80, 0x00,
  0x03, 0xE1, 0xF0, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC7, 0xFF,
  0xFE, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x8F,
  0xC0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x02, 0x43, 0x98, 0xE3,
  0x38, 0x6E, 0x0F, 0x01, 0xF0, 0x76, 0x0C, 0x61, 0x8E, 0x30, 0xC6, 0x0C,
  0x1F, 0x1F, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x63, 0xFF, 0xFF, 0x2E, 0xE3, 0x73, 0x62, 0x36, 0x63,
  0x66, 0x26, 0x66, 0x46, 0x6C, 0x66, 0xC4, 0x6C, 0xC6, 0xCC, 0xC0, 0x6F,
  0x9E, 0x66, 0x0D, 0x83, 0x60, 0xD0, 0x2C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C,
  0x18, 0x1F, 0x0C, 0x66, 0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x06, 0xC1,
  0x99, 0xC3, 0xE0, 0x37, 0x87, 0x98, 0xC1, 0x98, 0x33, 0x06, 0x40, 0xD8,
  0x1B, 0x06, 0x60, 0xCE, 0x71, 0xFC, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x00,
  0x1F, 0xCE, 0x76, 0x0D, 0x83, 0xC0, 0xF0, 0x2C, 0x1B, 0x06, 0x41, 0x9D,
  0xE3, 0xD0, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x37, 0xCF, 0xE3, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x00, 0x1F, 0x8E, 0x66,
  0x0D, 0x80, 0x38, 0x07, 0xC0, 0x38, 0x06, 0xC1, 0x9C, 0xE3, 0xF0, 0x08,
  0x0C, 0x06, 0x1F, 0xF1, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0xB0, 0xF8, 0x30, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x24, 0x1B,
  0x06, 0x41, 0x99, 0xE3, 0xD8, 0xC0, 0xF0, 0x6C, 0x19, 0x0C, 0x62, 0x19,
  0x86, 0x40, 0xB0, 0x28, 0x0E, 0x03, 0x00, 0xC6, 0x3C, 0x62, 0xCE, 0x6C,
  0xA4, 0x5A, 0xC5, 0x2C, 0x52, 0x87, 0x38, 0x63, 0x06, 0x30, 0x43, 0x00,
  0x30, 0x71, 0x8E, 0x08, 0xC0, 0xD8, 0x07, 0x00, 0x60, 0x0F, 0x01, 0xB0,
  0x39, 0x87, 0x18, 0xE0, 0xC0, 0x30, 0x33, 0x06, 0x30, 0x61, 0x0C, 0x18,
  0xC1, 0x98, 0x19, 0x00, 0xB0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x18,
  0x03, 0x00, 0xE0, 0x08, 0x00, 0x7F, 0xC0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x3F, 0xEF, 0xF8, 0x03, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x30, 0xE0, 0x70, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x1C, 0x08, 0x11, 0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0xCC, 0xCC,
  0x80, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x07, 0x0E,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xE0, 0x80, 0x3C, 0x16, 0xE3,
  0xC3, 0xE0, 0x1C,
};

const GFXglyph RobotoMono_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 5, 12, 4, -16 },
  { 13, 13, 15, 12, 0, -15 },
  { 38, 11, 19, 12, 1, -17 },
  { 65, 10, 15, 12, 1, -15 },
  { 84, 11, 15, 12, 1, -15 },
  { 105, 2, 5, 12, 6, -16 },
  { 107, 7, 22, 12, 3, -17 },
  { 127, 7, 22, 12, 2, -17 },
  { 147, 10, 10, 12, 2, -15 },
  { 160, 10, 11, 12, 1, -12 },
  { 174, 4, 5, 12, 2, -2 },
  { 177, 8, 1, 12, 2, -7 },
  { 178, 3, 3, 12, 4, -3 },
  { 180, 11, 16, 12, 1, -15 },
  { 202, 10, 15, 12, 1, -15 },
  { 221, 6, 15, 12, 3, -15 },
  { 233, 11, 15, 12, 0, -15 },
  { 254, 11, 15, 12, 0, -15 },
  { 275, 11, 15, 12, 0, -15 },
  { 296, 11, 15, 12, 1, -15 },
  { 317, 9, 15, 12, 1, -15 },
  { 334, 10, 15, 12, 2, -15 },
  { 353, 11, 15, 12, 1, -15 },
  { 374, 9, 15, 12, 2, -15 },
  { 391, 4, 12, 12, 5, -12 },
  { 397, 6, 15, 12, 3, -12 },
  { 409, 9, 9, 12, 2, -11 },
  { 420, 10, 6, 12, 1, -10 },
  { 428, 10, 9, 12, 1, -11 },
  { 440, 8, 15, 12, 3, -15 },
  { 455, 11, 15, 12, 1, -15 },
  { 476, 11, 15, 12, 0, -15 },
  { 497, 11, 15, 12, 1, -15 },
  { 518, 11, 15, 12, 1, -15 },
  { 539, 12, 15, 12, 0, -15 },
  { 562, 11, 15, 12, 1, -15 },
  { 583, 11, 15, 12, 1, -15 },
  { 604, 11, 15, 12, 1, -15 },
  { 625, 12, 15, 12, 0, -15 },
  { 648, 11, 15, 12, 1, -15 },
  { 669, 11, 15, 12, 1, -15 },
  { 690, 12, 15, 12, 1, -15 },
  { 713, 9, 15, 12, 1, -15 },
  { 730, 12, 15, 12, 0, -15 },
  { 753, 12, 15, 12, 0, -15 },
  { 776, 11, 15, 12, 1, -15 },
  { 797, 11, 15, 12, 1, -15 },
  { 818, 11, 18, 12, 1, -15 },
  { 843, 11, 15, 12, 1, -15 },
  { 864, 11, 15, 12, 1, -15 },
  { 885, 11, 15, 12, 2, -15 },
  { 906, 11, 15, 12, 1, -15 },
  { 927, 11, 15, 12, 2, -15 },
  { 948, 11, 15, 12, 2, -15 },
  { 969, 13, 15, 12, 0, -15 },
  { 994, 11, 15, 12, 2, -15 },
  { 1015, 12, 15, 12, 0, -15 },
  { 1038, 7, 20, 12, 3, -17 },
  { 1056, 5, 16, 12, 4, -15 },
  { 1066, 7, 20, 12, 3, -17 },
  { 1084, 8, 8, 12, 2, -15 },
  { 1092, 10, 2, 12, 0, 0 },
  { 1095, 3, 3, 12, 6, -15 },
  { 1097, 10, 11, 12, 1, -11 },
  { 1111, 10, 16, 12, 1, -16 },
  { 1131, 10, 11, 12, 1, -11 },
  { 1145, 11, 16, 12, 1, -16 },
  { 1167, 10, 11, 12, 1, -11 },
  { 1181, 11, 16, 12, 2, -16 },
  { 1203, 11, 15, 12, 0, -11 },
  { 1224, 10, 16, 12, 1, -16 },
  { 1244, 9, 15, 12, 1, -15 },
  { 1261, 10, 20, 12, 0, -15 },
  { 1286, 11, 16, 12, 1, -16 },
  { 1308, 9, 16, 12, 1, -16 },
  { 1326, 12, 11, 12, 0, -11 },
  { 1343, 10, 11, 12, 1, -11 },
  { 1357, 10, 11, 12, 1, -11 },
  { 1371, 11, 15, 12, 0, -11 },
  { 1392, 10, 15, 12, 1, -11 },
  { 1411, 10, 11, 12, 2, -11 },
  { 1425, 10, 11, 12, 1, -11 },
  { 1439, 9, 14, 12, 2, -14 },
  { 1455, 10, 11, 12, 1, -11 },
  { 1469, 10, 11, 12, 2, -11 },
  { 1483, 12, 11, 12, 1, -11 },
  { 1500, 12, 11, 12, 0, -11 },
  { 1517, 12, 16, 12, 0, -11 },
  { 1541, 10, 11, 12, 1, -11 },
  { 1555, 8, 20, 12, 3, -16 },
  { 1575, 4, 19, 12, 4, -15 },
  { 1585, 8, 20, 12, 2, -16 },
  { 1605, 12, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_Italic21pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic21pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOMONO_ITALIC21PT7B_H_
