#ifndef _ROBOTOMONO_ITALIC48PT7B_H_
#define _ROBOTOMONO_ITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x00, 0x78, 0x3B, 0xC3, 0xDE,
  0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0xC1, 0xDE, 0x1E, 0xE0, 0xE7, 0x07,
  0x38, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0,
  0xE1, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0xC0, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x00, 0xF0, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF9,
  0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xF0, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xE7, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0F, 0x02, 0x3C, 0x1E, 0x0F, 0x78, 0x3C, 0x3C, 0xE0, 0x70,
  0x71, 0xC0, 0xE1, 0xC3, 0x81, 0xC7, 0x87, 0x87, 0x9E, 0x07, 0xBE, 0x38,
  0x0F, 0xF8, 0xF0, 0x0F, 0xE3, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x04, 0x00,
  0x3C, 0x7F, 0x00, 0x73, 0xFF, 0x01, 0xC7, 0x9E, 0x07, 0x9E, 0x1E, 0x0E,
  0x38, 0x3C, 0x38, 0x70, 0x38, 0xF1, 0xE0, 0x73, 0xC3, 0xC1, 0xE3, 0x07,
  0x83, 0x82, 0x0F, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x87, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x71, 0xF9, 0xE0,
  0x79, 0xF8, 0xF8, 0x3C, 0xF8, 0x3C, 0x1E, 0xF8, 0x1F, 0x1E, 0x7C, 0x07,
  0xCF, 0x3C, 0x01, 0xEF, 0x9E, 0x00, 0xFF, 0x8F, 0x00, 0x3F, 0x87, 0x80,
  0x1F, 0xC3, 0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0xE0, 0x7C, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0x9F, 0x01, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3B, 0xDE, 0xF7, 0xB9, 0xDE, 0xF7, 0x38, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x02, 0x03, 0x80, 0x5E, 0x0E,
  0x0E, 0x7E, 0x38, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x00, 0x07,
  0x9E, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x07,
  0xC0, 0x60, 0x1C, 0x00, 0x80, 0x20, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7E, 0x0F, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xF3, 0xC0, 0x07, 0xE7, 0x80, 0x3F, 0xDF, 0x00, 0xFF, 0xBC, 0x07, 0xFF,
  0x78, 0x1F, 0xBE, 0xF0, 0xFC, 0x79, 0xE3, 0xF0, 0xF3, 0xCF, 0x81, 0xEF,
  0xFE, 0x03, 0xDF, 0xF0, 0x0F, 0xBF, 0xC0, 0x1F, 0x7F, 0x00, 0x3C, 0xF8,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x1F, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xC7, 0xB8, 0x1E,
  0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78,
  0x03, 0xC0, 0xF8, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x3E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x01, 0xF8, 0x01,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC7, 0xF0, 0x1E, 0xFF, 0xE1, 0xEF, 0xFF, 0x8F,
  0xF8, 0xFC, 0x7F, 0x01, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xC7, 0x80, 0x3E,
  0x3E, 0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07,
  0xC0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1,
  0xF0, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xF9, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7E, 0x3F, 0x01, 0xF0, 0x1F, 0x07, 0x80,
  0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E,
  0x1F, 0x00, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x87, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x3F, 0x78, 0x07, 0xF7, 0xE1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xDE, 0x0F, 0xF3, 0xC0, 0x18, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC1,
  0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC1, 0xF0, 0x00,
  0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF0, 0xFC, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x38, 0x3F, 0x0E, 0x1C, 0x1F, 0xE1,
  0x87, 0x0F, 0xFC, 0x63, 0x87, 0x86, 0x18, 0xE3, 0xC3, 0x86, 0x70, 0xE0,
  0xE1, 0x9C, 0x38, 0x38, 0x67, 0x1C, 0x0C, 0x1B, 0x87, 0x07, 0x06, 0xE1,
  0xC1, 0xC1, 0xB8, 0xE0, 0x70, 0xEE, 0x38, 0x18, 0x3B, 0x8E, 0x0E, 0x0C,
  0xC3, 0x83, 0x83, 0x30, 0xE0, 0xE1, 0xCC, 0x38, 0x78, 0x63, 0x0F, 0xFE,
  0x30, 0xE1, 0xFB, 0xFC, 0x38, 0x7C, 0x7E, 0x0E, 0x04, 0x04, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x30, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0,
  0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xC0,
  0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x3E,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xE0, 0x0F, 0xC0, 0x78,
  0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7F, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0x0F, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xE0, 0x07,
  0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x83, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0x78, 0x01, 0xF8, 0x1E, 0x01, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0x87, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x3C,
  0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xE7, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xFF, 0xCF, 0x00, 0xFF, 0xEF, 0x80, 0x7F, 0xE7, 0xC0, 0x7F, 0xF3, 0xE0,
  0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E,
  0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF8, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x01, 0xF8,
  0x00, 0xF0, 0x1F, 0x80, 0x07, 0x81, 0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x01,
  0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0x9F,
  0x80, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xC0, 0x00, 0x3F, 0x9F, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0x70, 0x1F, 0xC0, 0x77, 0x03,
  0xFC, 0x0F, 0x70, 0x3F, 0xC0, 0xF7, 0x07, 0xBC, 0x0F, 0x70, 0x7B, 0xC0,
  0xF7, 0x8F, 0x38, 0x0F, 0x78, 0xF7, 0x81, 0xE7, 0x9E, 0x78, 0x1E, 0x39,
  0xE7, 0x81, 0xE3, 0xBC, 0x78, 0x1E, 0x3B, 0xC7, 0x81, 0xE3, 0xF8, 0xF0,
  0x1E, 0x3F, 0x8F, 0x03, 0xE3, 0xF0, 0xF0, 0x3C, 0x3F, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1C, 0x1F, 0x03, 0xC1, 0xC1, 0xE0, 0x3C, 0x18, 0x1E,
  0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0xF8, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00,
  0x3C, 0x0F, 0xE0, 0x07, 0x81, 0xFC, 0x00, 0xF0, 0x7F, 0x80, 0x1E, 0x0F,
  0xF8, 0x07, 0xC1, 0xEF, 0x00, 0xF8, 0x3D, 0xE0, 0x1E, 0x07, 0x9E, 0x03,
  0xC0, 0xF3, 0xC0, 0x78, 0x3E, 0x78, 0x0F, 0x07, 0xC7, 0x83, 0xE0, 0xF0,
  0xF0, 0x78, 0x1E, 0x1E, 0x0F, 0x03, 0xC1, 0xE1, 0xE0, 0xF8, 0x3C, 0x3C,
  0x1F, 0x07, 0x8F, 0x83, 0xC0, 0x79, 0xF0, 0x78, 0x0F, 0x3C, 0x0F, 0x01,
  0xE7, 0x81, 0xE0, 0x1E, 0xF0, 0x7C, 0x03, 0xDE, 0x0F, 0x80, 0x7F, 0xC1,
  0xE0, 0x07, 0xF8, 0x3C, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0xC0, 0xF0, 0x01,
  0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0xF0, 0x00, 0x7C, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x8F, 0xC0, 0x3F, 0x01, 0xF0, 0x1E, 0x00,
  0x78, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0,
  0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF3,
  0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0x1F,
  0x81, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xFC,
  0x1E, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0x8F, 0xE0, 0x3F, 0x01, 0xF0, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0xC0, 0x78, 0x03, 0xF0,
  0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1E, 0x07,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x1F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x87, 0xE0, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x8F,
  0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xFC,
  0x03, 0xF0, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x01, 0xE7, 0x81, 0xE0, 0x3C, 0xF0, 0x3C, 0x0F, 0x1E, 0x0F, 0x81,
  0xE3, 0xC1, 0xF0, 0x3C, 0x70, 0x3E, 0x07, 0x8E, 0x0F, 0xC1, 0xE1, 0xC1,
  0xF8, 0x3C, 0x78, 0x3F, 0x07, 0x8F, 0x0F, 0xE0, 0xE1, 0xE1, 0xDC, 0x3C,
  0x3C, 0x3B, 0x87, 0x87, 0x8F, 0x70, 0xF0, 0xF1, 0xEE, 0x3C, 0x1E, 0x39,
  0xC7, 0x83, 0xCF, 0x38, 0xF0, 0x79, 0xE7, 0x1E, 0x0F, 0x38, 0xE7, 0x81,
  0xEF, 0x1E, 0xF0, 0x3D, 0xE3, 0xDE, 0x07, 0xB8, 0x7B, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xB8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x78,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0,
  0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x1E, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E,
  0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x1C,
  0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x0E, 0x7C, 0x03, 0xFE,
  0x00, 0xF0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x7C, 0x01,
  0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xF0,
  0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xF1, 0xF0, 0x1F, 0xC7, 0xF1, 0xFF, 0x0F,
  0xFF, 0xBC, 0x1F, 0xFC, 0xF0, 0x3F, 0xC3, 0xC0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x79, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0xCF,
  0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x3F, 0x00,
  0x7C, 0x7F, 0x01, 0xF8, 0xFF, 0x0F, 0xE1, 0xEF, 0xFF, 0x83, 0xCF, 0xFE,
  0x07, 0x8F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xE3,
  0xE0, 0x07, 0xCF, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x3E,
  0x00, 0x3C, 0x78, 0x01, 0xF1, 0xF0, 0x0F, 0x83, 0xE0, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x7F, 0xE7, 0xC0,
  0x7F, 0xFB, 0xE0, 0x7F, 0xFF, 0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x01, 0xF8,
  0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x78, 0x01,
  0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x7C, 0x01, 0xE3, 0xE0,
  0x07, 0x8F, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x7E, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE3, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7F, 0x1F, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x78, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x0F, 0x81, 0xC0, 0x0F,
  0x81, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xE0, 0x07, 0x8F, 0xF8, 0x07, 0xBF, 0xFC, 0x0F, 0x7F, 0xFE, 0x0F,
  0xF0, 0x7E, 0x0F, 0xC0, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F,
  0x03, 0xF0, 0x1E, 0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x1E,
  0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x0F, 0x01, 0xEF, 0xE7, 0xF0, 0x3B,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xF0, 0xFC, 0x3E, 0x3C, 0x0F, 0x03,
  0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x1E, 0x0F, 0x83, 0xC3, 0xC1,
  0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x3C,
  0x78, 0x1E, 0x07, 0x8F, 0x07, 0xC1, 0xE3, 0xE0, 0xF0, 0x3C, 0x78, 0x1E,
  0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC7,
  0x83, 0xE0, 0xF1, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x03, 0xC7, 0x81, 0xE0,
  0x78, 0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0x07,
  0x9F, 0xF8, 0x07, 0x3F, 0xFC, 0x0F, 0x7F, 0xFC, 0x0F, 0xF0, 0x7E, 0x0F,
  0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8,
  0x00, 0x78, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x1F, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xC7,
  0xC0, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xE7, 0xFC, 0x00, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xE0,
  0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00,
  0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC3, 0xE0,
  0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3D,
  0xFF, 0xE0, 0x1E, 0x3F, 0xC0, 0x1F, 0x01, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x3C, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xF8, 0x1F, 0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0x80,
  0x1E, 0x0F, 0x80, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFD,
  0xE0, 0x1F, 0xE3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0,
  0x78, 0xFF, 0xC3, 0xCF, 0xFE, 0x1E, 0xFF, 0xF0, 0xFF, 0xE7, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0x80, 0xF8, 0x7C, 0x01, 0xF1, 0xE0,
  0x07, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xF8, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC3, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x7C, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1F,
  0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE3,
  0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0xC3, 0xFC, 0x0F,
  0xFF, 0x78, 0x0F, 0xFC, 0xF0, 0x0F, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x03,
  0xE0, 0x78, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x1C, 0x03, 0xFC, 0x07, 0x80, 0xEF, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E,
  0xF0, 0x3E, 0x07, 0x3C, 0x1F, 0x83, 0xCF, 0x07, 0xE0, 0xF3, 0xC3, 0xB8,
  0x38, 0xF0, 0xEE, 0x1E, 0x3C, 0x7B, 0x87, 0x0F, 0x1C, 0xE1, 0xC3, 0xC7,
  0x38, 0xF0, 0x73, 0xCE, 0x38, 0x1C, 0xE3, 0x8E, 0x07, 0x78, 0xE7, 0x01,
  0xDC, 0x39, 0xC0, 0x77, 0x06, 0xF0, 0x1F, 0x81, 0xB8, 0x07, 0xE0, 0x6E,
  0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F,
  0x80, 0x00, 0x3D, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x1E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0x3C, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x07, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0D, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x63, 0xFF, 0x80,
  0x1D, 0xFF, 0xF0, 0x0F, 0x78, 0x7E, 0x03, 0xBC, 0x07, 0xE3, 0xEE, 0x00,
  0xFF, 0xF3, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0C, 0x00,
};

const GFXglyph RobotoMono_Italic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 34, 28, 9, -34 },
  { 44, 13, 11, 28, 10, -36 },
  { 62, 28, 34, 28, 1, -34 },
  { 181, 23, 45, 28, 3, -40 },
  { 311, 23, 36, 28, 3, -35 },
  { 415, 25, 36, 28, 1, -35 },
  { 528, 5, 11, 28, 13, -36 },
  { 535, 16, 50, 28, 8, -39 },
  { 635, 16, 50, 28, 4, -39 },
  { 735, 22, 23, 28, 5, -34 },
  { 799, 23, 25, 28, 3, -28 },
  { 871, 8, 13, 28, 5, -5 },
  { 884, 18, 4, 28, 5, -17 },
  { 893, 7, 6, 28, 9, -6 },
  { 899, 24, 37, 28, 3, -34 },
  { 1010, 23, 36, 28, 3, -35 },
  { 1114, 14, 34, 28, 7, -34 },
  { 1174, 25, 35, 28, 0, -35 },
  { 1284, 24, 36, 28, 1, -35 },
  { 1392, 24, 34, 28, 1, -34 },
  { 1494, 25, 35, 28, 3, -34 },
  { 1604, 21, 35, 28, 3, -34 },
  { 1696, 24, 34, 28, 4, -34 },
  { 1798, 23, 36, 28, 3, -35 },
  { 1902, 20, 35, 28, 5, -35 },
  { 1990, 11, 27, 28, 10, -27 },
  { 2028, 12, 35, 28, 8, -27 },
  { 2081, 21, 21, 28, 4, -26 },
  { 2137, 23, 13, 28, 3, -22 },
  { 2175, 23, 22, 28, 2, -26 },
  { 2239, 19, 35, 28, 7, -35 },
  { 2323, 26, 34, 28, 2, -34 },
  { 2434, 25, 34, 28, -1, -34 },
  { 2541, 26, 34, 28, 1, -34 },
  { 2652, 25, 36, 28, 2, -35 },
  { 2765, 26, 34, 28, 1, -34 },
  { 2876, 26, 34, 28, 2, -34 },
  { 2987, 26, 34, 28, 2, -34 },
  { 3098, 25, 36, 28, 2, -35 },
  { 3211, 27, 34, 28, 1, -34 },
  { 3326, 26, 34, 28, 1, -34 },
  { 3437, 26, 35, 28, 1, -34 },
  { 3551, 29, 34, 28, 1, -34 },
  { 3675, 21, 34, 28, 2, -34 },
  { 3765, 28, 34, 28, 1, -34 },
  { 3884, 27, 34, 28, 1, -34 },
  { 3999, 25, 36, 28, 2, -35 },
  { 4112, 26, 34, 28, 2, -34 },
  { 4223, 25, 41, 28, 2, -35 },
  { 4352, 25, 34, 28, 2, -34 },
  { 4459, 25, 36, 28, 2, -35 },
  { 4572, 25, 34, 28, 5, -34 },
  { 4679, 26, 35, 28, 2, -34 },
  { 4793, 24, 34, 28, 5, -34 },
  { 4895, 27, 34, 28, 3, -34 },
  { 5010, 30, 34, 28, 0, -34 },
  { 5138, 25, 34, 28, 5, -34 },
  { 5245, 27, 34, 28, 0, -34 },
  { 5360, 17, 46, 28, 6, -39 },
  { 5458, 11, 37, 28, 9, -34 },
  { 5509, 16, 46, 28, 6, -39 },
  { 5601, 18, 18, 28, 5, -34 },
  { 5642, 22, 4, 28, 0, 0 },
  { 5653, 8, 7, 28, 13, -35 },
  { 5660, 22, 26, 28, 2, -26 },
  { 5732, 23, 37, 28, 2, -36 },
  { 5839, 22, 27, 28, 3, -26 },
  { 5914, 25, 37, 28, 3, -36 },
  { 6030, 22, 27, 28, 3, -26 },
  { 6105, 24, 37, 28, 5, -37 },
  { 6216, 25, 36, 28, 1, -26 },
  { 6329, 24, 36, 28, 1, -36 },
  { 6437, 21, 35, 28, 2, -35 },
  { 6529, 22, 45, 28, 1, -35 },
  { 6653, 24, 36, 28, 2, -36 },
  { 6761, 21, 36, 28, 2, -36 },
  { 6856, 27, 26, 28, 0, -26 },
  { 6944, 24, 26, 28, 1, -26 },
  { 7022, 23, 27, 28, 2, -26 },
  { 7100, 25, 36, 28, 0, -26 },
  { 7213, 23, 36, 28, 3, -26 },
  { 7317, 21, 26, 28, 5, -26 },
  { 7386, 22, 27, 28, 3, -26 },
  { 7461, 20, 33, 28, 5, -32 },
  { 7544, 23, 26, 28, 3, -25 },
  { 7619, 23, 25, 28, 4, -25 },
  { 7691, 26, 25, 28, 3, -25 },
  { 7773, 28, 25, 28, 0, -25 },
  { 7861, 29, 35, 28, -1, -25 },
  { 7988, 25, 25, 28, 1, -25 },
  { 8067, 19, 47, 28, 7, -38 },
  { 8179, 10, 43, 28, 9, -34 },
  { 8233, 19, 46, 28, 4, -37 },
  { 8343, 26, 10, 28, 1, -19 },
};

const GFXfont RobotoMono_Italic48pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic48pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOMONO_ITALIC48PT7B_H_
