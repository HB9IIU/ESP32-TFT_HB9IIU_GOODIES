#ifndef _ROBOTOMONO_ITALIC70PT7B_H_
#define _ROBOTOMONO_ITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0x1F,
  0x01, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x20, 0x7C, 0x03,
  0xE0, 0x1E, 0x1F, 0x00, 0xF8, 0x0F, 0xC7, 0x80, 0x3E, 0x03, 0xE1, 0xE0,
  0x0F, 0x81, 0xF0, 0x78, 0x03, 0xC0, 0xFC, 0x1E, 0x00, 0xF0, 0x3E, 0x07,
  0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0x83, 0xE0,
  0x1F, 0x87, 0xE1, 0xF0, 0x03, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xFC, 0x7E,
  0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x01, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x80,
  0x00, 0x7C, 0x3F, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x00, 0x0F, 0x8F, 0xFF,
  0xC0, 0x07, 0xC7, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x3E, 0x01, 0xF8, 0xF8,
  0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x7C, 0x01, 0xE1, 0xF0,
  0x1F, 0x00, 0x78, 0x1C, 0x07, 0xC0, 0x3E, 0x02, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xF0, 0x7F, 0x9F, 0xC0, 0x1F, 0x0F, 0xF1, 0xFC, 0x03,
  0xF1, 0xFE, 0x0F, 0xE0, 0x3F, 0x3F, 0xC0, 0x7E, 0x03, 0xF3, 0xF8, 0x07,
  0xF0, 0x3E, 0x7F, 0x00, 0x3F, 0x87, 0xE7, 0xF0, 0x03, 0xF8, 0x7E, 0x7E,
  0x00, 0x1F, 0xCF, 0xCF, 0xE0, 0x01, 0xFD, 0xFC, 0xFE, 0x00, 0x0F, 0xFF,
  0x8F, 0xC0, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7E, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF,
  0xC3, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18,
  0x01, 0xF0, 0x06, 0x3E, 0x01, 0xE0, 0x1F, 0x3F, 0xC1, 0xE0, 0xFF, 0x7F,
  0xF1, 0xE3, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x03, 0x80, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xFC, 0x7E, 0x00,
  0x07, 0xFF, 0x3F, 0x80, 0x07, 0xFF, 0xCF, 0xC0, 0x03, 0xFF, 0xF3, 0xF0,
  0x03, 0xFF, 0xF8, 0xFC, 0x01, 0xFE, 0x7E, 0x3F, 0x00, 0xFF, 0x1F, 0x8F,
  0xC0, 0xFF, 0x87, 0xE3, 0xF0, 0x7F, 0x81, 0xF9, 0xFC, 0x7F, 0xC0, 0xFE,
  0x7E, 0x3F, 0xC0, 0x3F, 0x1F, 0xBF, 0xE0, 0x0F, 0xC7, 0xFF, 0xE0, 0x03,
  0xF1, 0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0x3F, 0xF8, 0x00,
  0x1F, 0xCF, 0xFC, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFE, 0x3F, 0x3F, 0xC1, 0xF9, 0xF0,
  0x0F, 0xCC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00, 0x7E, 0x1F,
  0xFC, 0x00, 0xFC, 0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xFE, 0x07, 0xEF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x03,
  0xF8, 0xFF, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x01, 0xFF, 0x8F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0x3F, 0x01,
  0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x81, 0xFE, 0x01, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0,
  0x06, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x3F, 0xE7, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x30, 0x07, 0x80,
  0xF8, 0x07, 0xF8, 0x1E, 0x03, 0xC0, 0x7F, 0xF8, 0x3C, 0x1F, 0x03, 0xFF,
  0xF0, 0xF0, 0x78, 0x1F, 0xFF, 0x83, 0xC3, 0xE0, 0xFC, 0x1E, 0x0F, 0x0F,
  0x03, 0xE0, 0x78, 0x3C, 0x7C, 0x1F, 0x01, 0xE0, 0xF1, 0xE0, 0x78, 0x07,
  0x03, 0xC7, 0x83, 0xE0, 0x3C, 0x0F, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0xF0,
  0x7C, 0x03, 0xC0, 0xF3, 0xC1, 0xE0, 0x0E, 0x03, 0xDF, 0x07, 0x80, 0x78,
  0x0F, 0x78, 0x1E, 0x01, 0xE0, 0x39, 0xE0, 0xF8, 0x07, 0x80, 0xE7, 0x83,
  0xC0, 0x1C, 0x07, 0x9E, 0x0F, 0x00, 0xF0, 0x1E, 0x78, 0x3C, 0x03, 0xC0,
  0x73, 0xE0, 0xF0, 0x0F, 0x01, 0xCF, 0x03, 0xC0, 0x3C, 0x0F, 0x3C, 0x0F,
  0x01, 0xE0, 0x38, 0xF0, 0x3C, 0x0F, 0x81, 0xE3, 0xC0, 0xF0, 0x7E, 0x07,
  0x0F, 0x03, 0xFF, 0xFC, 0x3C, 0x3E, 0x0F, 0xFE, 0xFF, 0xE0, 0x78, 0x1F,
  0xF3, 0xFF, 0x01, 0xE0, 0x7F, 0x87, 0xF8, 0x07, 0x80, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0x00, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F,
  0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7E,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x0F, 0xFF, 0x80, 0x07,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xFF, 0x87, 0xE0,
  0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0xFF,
  0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80,
  0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x0F, 0xBE, 0x01,
  0xFB, 0xE0, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x07, 0xE7, 0xC0, 0xFD, 0xF8,
  0x03, 0xF3, 0xE0, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x3F, 0x3F, 0x00, 0x7E, 0x3E, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xDF, 0x87, 0xE0,
  0x0F, 0xC3, 0xEF, 0xC3, 0xF0, 0x07, 0xE1, 0xFF, 0xC3, 0xF0, 0x03, 0xE0,
  0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0xE0,
  0x7E, 0x00, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x01,
  0xF8, 0x03, 0xF0, 0x1E, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x01,
  0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x01, 0xFC, 0x03, 0xF3,
  0xF0, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x0F,
  0xCF, 0xC0, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x07, 0xFF, 0xC0,
  0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x79, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0x07, 0xE3, 0xF0, 0x0F, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0xC0, 0x1F, 0x0F,
  0x80, 0x3F, 0x80, 0x7E, 0x1F, 0x00, 0xFF, 0x00, 0xFC, 0x3E, 0x01, 0xFE,
  0x01, 0xF8, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xF8, 0x0F, 0xC1,
  0xF0, 0x1F, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0xE0, 0x3E, 0x0F, 0xC0, 0xFB,
  0xC0, 0xFC, 0x1F, 0x81, 0xF7, 0x81, 0xF8, 0x3F, 0x03, 0xEF, 0x03, 0xF0,
  0x7E, 0x0F, 0x9E, 0x07, 0xC0, 0xFC, 0x1F, 0x3C, 0x1F, 0x81, 0xF8, 0x3E,
  0x78, 0x3F, 0x03, 0xF0, 0xF8, 0xF0, 0x7E, 0x07, 0xE1, 0xF1, 0xE0, 0xF8,
  0x0F, 0xC3, 0xE3, 0xC3, 0xF0, 0x1F, 0x8F, 0x87, 0x87, 0xE0, 0x3F, 0x1F,
  0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x1E, 0x1F, 0x00, 0xF8, 0xF8, 0x3C, 0x7E,
  0x01, 0xF1, 0xF0, 0x78, 0xFC, 0x03, 0xE3, 0xE0, 0xF1, 0xF0, 0x07, 0xCF,
  0x81, 0xE3, 0xE0, 0x0F, 0x9F, 0x03, 0xCF, 0xC0, 0x1F, 0x3E, 0x07, 0x9F,
  0x80, 0x3E, 0xF8, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC7,
  0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0x3F, 0x00, 0xFF,
  0xFF, 0x1F, 0x80, 0x1F, 0xFE, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x01, 0xF8, 0x7F, 0xE0, 0x00,
  0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x07, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0xF8, 0x07, 0xE7, 0xFF, 0xFC, 0x03,
  0xF0, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0xF9, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x1F, 0xC0, 0x07,
  0xFF, 0xF1, 0xFC, 0x00, 0xFF, 0xFF, 0xDF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFB, 0xF0, 0x00, 0x7F, 0xFF, 0x3F, 0x00,
  0x01, 0xFF, 0xC3, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x7F, 0x00, 0x00,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x3E,
  0x00, 0x03, 0xFC, 0x00, 0x20, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x1F, 0xFF,
  0xC3, 0xF0, 0x03, 0xFF, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xC0, 0x01, 0xFF, 0xFC, 0xFC, 0x00, 0x07,
  0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x10, 0x00, 0x03,
  0xF0, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x3F, 0xF0, 0x00,
  0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x03,
  0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x70, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x7E, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0xFF, 0x80, 0x00, 0x7E, 0x1F, 0xF0, 0x00, 0x07, 0xE3, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x00, 0xFD,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFC,
  0x00, 0x01, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0,
  0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x07, 0xC7, 0xF8,
  0x3F, 0xE0, 0x0F, 0x9F, 0xFC, 0xFF, 0xE0, 0x3F, 0x7F, 0xFB, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x0F,
  0xF8, 0x3F, 0x83, 0xF0, 0x1F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x1F,
  0x83, 0xE0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0xFC, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0x80,
  0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x0F, 0xFC, 0x00, 0x3F, 0x0F, 0xFF, 0xC0, 0x0F,
  0xCF, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xFF, 0x00, 0xFB, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x1F,
  0x81, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC3, 0xFF, 0x80, 0x00,
  0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xDF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xF9, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0x9F, 0xFF, 0xE0,
  0x03, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x83, 0xF0, 0x07, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xFF,
  0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xEF, 0xC0, 0x07, 0xFF, 0xF3, 0xF0, 0x00, 0x7F, 0xF0,
  0xF8, 0x00, 0x03, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF,
  0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xE0, 0x1F, 0xFF, 0xFB, 0xF0, 0x07, 0xFF,
  0xF9, 0xF8, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0x80, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xEF,
  0x80, 0x3F, 0x80, 0x3F, 0x7C, 0x01, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xE0,
  0x0F, 0x9F, 0x00, 0xFF, 0x00, 0xFC, 0xF8, 0x07, 0xF8, 0x07, 0xC7, 0xC0,
  0x7F, 0xC0, 0x3E, 0x3E, 0x03, 0xDE, 0x03, 0xE1, 0xF0, 0x1E, 0xF0, 0x1F,
  0x0F, 0x81, 0xF7, 0x80, 0xF8, 0x7C, 0x0F, 0x3C, 0x0F, 0x83, 0xE0, 0xF9,
  0xE0, 0x7C, 0x1F, 0x07, 0xCF, 0x03, 0xE0, 0xF8, 0x7C, 0x78, 0x3E, 0x07,
  0xC3, 0xE3, 0xE1, 0xF0, 0x3E, 0x1E, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0xF8,
  0xF8, 0x0F, 0x8F, 0x87, 0xC7, 0xC0, 0x7C, 0xF8, 0x3E, 0x7C, 0x03, 0xE7,
  0xC1, 0xF3, 0xE0, 0x1F, 0x3C, 0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x3D, 0xF0,
  0x07, 0xDE, 0x01, 0xEF, 0x80, 0x3E, 0xF0, 0x0F, 0x78, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xE7,
  0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x74, 0x3F, 0xFF, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0x80,
  0x01, 0xE3, 0xFF, 0xFF, 0x80, 0x07, 0xC7, 0xF0, 0xFF, 0xC0, 0x1F, 0x9F,
  0x80, 0x7F, 0xC0, 0x7E, 0x3E, 0x00, 0x7F, 0xE3, 0xFC, 0xFC, 0x00, 0x7F,
  0xFF, 0xF1, 0xF0, 0x00, 0x3F, 0xFF, 0xE3, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph RobotoMono_Italic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 15, 50, 41, 13, -50 },
  { 95, 20, 17, 41, 14, -53 },
  { 138, 41, 50, 41, 1, -50 },
  { 395, 34, 65, 41, 4, -58 },
  { 672, 34, 52, 41, 4, -51 },
  { 893, 36, 52, 41, 2, -51 },
  { 1127, 8, 17, 41, 19, -53 },
  { 1144, 23, 72, 41, 11, -56 },
  { 1351, 24, 72, 41, 5, -56 },
  { 1567, 32, 34, 41, 7, -50 },
  { 1703, 34, 36, 41, 4, -41 },
  { 1856, 12, 18, 41, 7, -7 },
  { 1883, 26, 5, 41, 7, -24 },
  { 1900, 9, 10, 41, 14, -9 },
  { 1912, 35, 54, 41, 4, -50 },
  { 2149, 34, 52, 41, 4, -51 },
  { 2370, 21, 50, 41, 10, -50 },
  { 2502, 35, 51, 41, 1, -51 },
  { 2726, 34, 52, 41, 2, -51 },
  { 2947, 36, 50, 41, 1, -50 },
  { 3172, 35, 51, 41, 5, -50 },
  { 3396, 31, 51, 41, 4, -50 },
  { 3594, 34, 50, 41, 7, -50 },
  { 3807, 35, 52, 41, 4, -51 },
  { 4035, 30, 50, 41, 7, -50 },
  { 4223, 15, 40, 41, 15, -39 },
  { 4298, 19, 50, 41, 11, -39 },
  { 4417, 32, 31, 41, 5, -38 },
  { 4541, 33, 20, 41, 4, -32 },
  { 4624, 33, 30, 41, 3, -37 },
  { 4748, 28, 51, 41, 10, -51 },
  { 4927, 38, 50, 41, 2, -50 },
  { 5165, 36, 50, 41, -1, -50 },
  { 5390, 37, 50, 41, 2, -50 },
  { 5622, 37, 52, 41, 3, -51 },
  { 5863, 37, 50, 41, 2, -50 },
  { 6095, 39, 50, 41, 2, -50 },
  { 6339, 38, 50, 41, 3, -50 },
  { 6577, 37, 52, 41, 3, -51 },
  { 6818, 40, 50, 41, 1, -50 },
  { 7068, 38, 50, 41, 2, -50 },
  { 7306, 38, 51, 41, 2, -50 },
  { 7549, 42, 50, 41, 2, -50 },
  { 7812, 31, 50, 41, 3, -50 },
  { 8006, 41, 50, 41, 1, -50 },
  { 8263, 40, 50, 41, 1, -50 },
  { 8513, 36, 52, 41, 3, -51 },
  { 8747, 38, 50, 41, 3, -50 },
  { 8985, 36, 59, 41, 3, -51 },
  { 9251, 37, 50, 41, 2, -50 },
  { 9483, 37, 52, 41, 3, -51 },
  { 9724, 36, 50, 41, 7, -50 },
  { 9949, 37, 51, 41, 4, -50 },
  { 10185, 36, 50, 41, 7, -50 },
  { 10410, 39, 50, 41, 5, -50 },
  { 10654, 44, 50, 41, -1, -50 },
  { 10929, 36, 50, 41, 7, -50 },
  { 11154, 38, 50, 41, 1, -50 },
  { 11392, 24, 68, 41, 9, -57 },
  { 11596, 16, 54, 41, 13, -50 },
  { 11704, 23, 68, 41, 9, -57 },
  { 11900, 25, 27, 41, 8, -50 },
  { 11985, 31, 5, 41, 1, 0 },
  { 12005, 11, 9, 41, 19, -51 },
  { 12018, 33, 39, 41, 3, -38 },
  { 12179, 34, 54, 41, 2, -53 },
  { 12409, 33, 39, 41, 4, -38 },
  { 12570, 36, 54, 41, 4, -53 },
  { 12813, 32, 39, 41, 4, -38 },
  { 12969, 36, 54, 41, 7, -54 },
  { 13212, 36, 53, 41, 2, -38 },
  { 13451, 34, 53, 41, 2, -53 },
  { 13677, 31, 51, 41, 3, -51 },
  { 13875, 32, 66, 41, 1, -51 },
  { 14139, 36, 53, 41, 2, -53 },
  { 14378, 31, 53, 41, 3, -53 },
  { 14584, 39, 38, 41, 0, -38 },
  { 14770, 34, 38, 41, 2, -38 },
  { 14932, 34, 39, 41, 3, -38 },
  { 15098, 36, 52, 41, 0, -38 },
  { 15332, 34, 52, 41, 4, -38 },
  { 15553, 31, 38, 41, 7, -38 },
  { 15701, 32, 39, 41, 4, -38 },
  { 15857, 30, 47, 41, 7, -46 },
  { 16034, 33, 38, 41, 5, -37 },
  { 16191, 34, 37, 41, 6, -37 },
  { 16349, 37, 37, 41, 5, -37 },
  { 16521, 40, 37, 41, 0, -37 },
  { 16706, 42, 52, 41, -1, -37 },
  { 16979, 35, 37, 41, 2, -37 },
  { 17141, 27, 67, 41, 11, -55 },
  { 17368, 14, 64, 41, 13, -50 },
  { 17480, 28, 68, 41, 6, -55 },
  { 17718, 39, 13, 41, 1, -27 },
};

const GFXfont RobotoMono_Italic70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic70pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_ITALIC70PT7B_H_
