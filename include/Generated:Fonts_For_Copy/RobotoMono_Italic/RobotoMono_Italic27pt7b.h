#ifndef _ROBOTOMONO_ITALIC27PT7B_H_
#define _ROBOTOMONO_ITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x1C, 0x70, 0x00,
  0x00, 0x43, 0x8E, 0x00, 0x63, 0x63, 0x62, 0x66, 0x46, 0xC6, 0x00, 0xC6,
  0x00, 0xC6, 0x01, 0x84, 0x01, 0x8C, 0x01, 0x8C, 0x1F, 0xFF, 0x3F, 0xFF,
  0x02, 0x18, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x7F, 0xFC,
  0xFF, 0xFC, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x80, 0x31, 0x80, 0x71, 0x80,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x1F, 0xC1, 0xFF, 0x1C, 0x18, 0xE0, 0xE6,
  0x07, 0x30, 0x39, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0x80, 0x0C, 0xC0, 0x76, 0x03, 0x30, 0x19, 0xC1, 0xC7, 0xFC, 0x1F, 0x80,
  0x30, 0x01, 0x80, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x3B, 0x81, 0x8C, 0x4C,
  0x67, 0x63, 0x33, 0x33, 0x1F, 0xB0, 0x79, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x00, 0xDE, 0x0D, 0xD8, 0xCC, 0x46, 0x43, 0x66, 0x11, 0x31, 0x80, 0xCC,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x07, 0x1C, 0x1C, 0x70, 0x61,
  0xC1, 0x8E, 0x07, 0x70, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xC3, 0x73,
  0x9F, 0x86, 0x6C, 0x1D, 0xB0, 0x3C, 0xC0, 0xF3, 0x83, 0xC7, 0xFF, 0x0F,
  0xCE, 0x6D, 0xB5, 0x80, 0x00, 0x80, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00,
  0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x00, 0x03, 0x00, 0x30, 0x03,
  0x08, 0x61, 0xE6, 0x7F, 0xFF, 0x1F, 0xC0, 0xE0, 0x1B, 0x03, 0xB8, 0x71,
  0x8E, 0x1C, 0x21, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x07, 0xFF, 0xDF, 0xFE, 0x83, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x33, 0x77, 0x6E, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF7, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x70, 0x63, 0x03, 0x38,
  0x1D, 0x80, 0xEC, 0x0F, 0xE1, 0xFF, 0x1D, 0xBB, 0xCD, 0xB8, 0x6F, 0x87,
  0x70, 0x3B, 0x01, 0x98, 0x0C, 0xC0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7E, 0x00,
  0x03, 0x1F, 0xFE, 0xF6, 0x86, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x07, 0xF0, 0x3F, 0xE1, 0xC1,
  0x8E, 0x07, 0x38, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x8E, 0x0E, 0x60, 0x77,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x0F, 0xE0, 0x7E, 0x00, 0x78, 0x00,
  0xC0, 0x07, 0x00, 0x3B, 0x01, 0x98, 0x0C, 0xE0, 0xE3, 0xFE, 0x0F, 0xC0,
  0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xD8, 0x06, 0xE0, 0x33,
  0x81, 0x8C, 0x0E, 0x30, 0x70, 0xC1, 0x83, 0x0C, 0x1C, 0x60, 0x71, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0xFC,
  0x7F, 0xE1, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x10, 0x0F, 0xF0,
  0x3F, 0xE1, 0xC1, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xCC, 0x06,
  0x30, 0x38, 0xE0, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x78,
  0x0E, 0x03, 0x80, 0xE0, 0x18, 0x83, 0x7E, 0xFF, 0xFE, 0x1F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0xE1, 0xCF, 0xF0, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x00, 0x0F, 0xE0, 0xFF, 0x8E, 0x0E, 0x70,
  0x73, 0x03, 0x98, 0x1C, 0xC0, 0xC7, 0x0E, 0x1F, 0xC0, 0xFE, 0x1E, 0x38,
  0xC0, 0xCE, 0x07, 0x60, 0x3B, 0x01, 0x98, 0x0C, 0xE0, 0xE3, 0xFE, 0x0F,
  0xC0, 0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xFC, 0x3F, 0xDF, 0xBF, 0x60, 0x8C, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x1F, 0x83, 0xC0, 0x00, 0x00, 0xE3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x8F, 0x38, 0x00, 0x0E, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x30, 0x70, 0x60, 0xE0,
  0x00, 0x10, 0x03, 0x01, 0xF0, 0x7E, 0x1F, 0x0F, 0x80, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x0C, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x30, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1C, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xC0, 0x38, 0x00, 0x3F,
  0x8F, 0xFB, 0x83, 0x60, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x01,
  0xC0, 0x00, 0x03, 0xF0, 0x1E, 0xF0, 0x70, 0x30, 0xC0, 0x63, 0x3E, 0x4C,
  0xE4, 0x99, 0x99, 0x26, 0x32, 0xCC, 0x45, 0x90, 0x8B, 0x23, 0x14, 0xC6,
  0x68, 0x9C, 0x99, 0xFE, 0x33, 0x98, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x00,
  0x7C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x0C,
  0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x07, 0x0E, 0x1F,
  0xF8, 0xFF, 0xE3, 0x01, 0x9C, 0x06, 0x60, 0x1B, 0x80, 0x6C, 0x01, 0xC0,
  0x1F, 0xE0, 0x7F, 0xE1, 0x81, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x01,
  0x8C, 0x1E, 0x3F, 0xE1, 0xFF, 0x87, 0x07, 0x1C, 0x0E, 0x60, 0x39, 0x80,
  0xE6, 0x03, 0xB8, 0x1C, 0xE0, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xC1, 0xCE, 0x07, 0x30, 0x0C, 0xC0, 0x37, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xE6, 0x03,
  0x18, 0x1C, 0x70, 0xE0, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xC3,
  0x87, 0x8E, 0x06, 0x38, 0x1C, 0xC0, 0x73, 0x00, 0xCC, 0x03, 0x70, 0x0D,
  0xC0, 0x77, 0x01, 0xD8, 0x06, 0x60, 0x19, 0x80, 0xEE, 0x07, 0x38, 0x38,
  0xC1, 0xE3, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x7F,
  0xE1, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xC1, 0xCE,
  0x07, 0x30, 0x0D, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x87, 0xFE,
  0x1F, 0xB8, 0x7E, 0xE0, 0x1B, 0x80, 0x66, 0x03, 0x98, 0x0E, 0x70, 0x70,
  0xFF, 0x81, 0xFC, 0x00, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xFC,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x18, 0x60, 0x18, 0xE0, 0x38, 0x1F, 0xFC, 0x7F, 0xF0, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x33, 0x00, 0xCC, 0x07, 0x38, 0x18, 0x60, 0xE1, 0xFF, 0x03,
  0xF0, 0x00, 0x1C, 0x0F, 0x18, 0x1C, 0x18, 0x38, 0x18, 0x70, 0x38, 0xE0,
  0x39, 0xC0, 0x33, 0x80, 0x37, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x79, 0x80, 0x61, 0xC0, 0x61, 0xC0, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0xE0, 0x70, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x38,
  0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xC3, 0xC6, 0xCD, 0x8D, 0x9B, 0x1B, 0x6E,
  0x76, 0xDC, 0xCF, 0x31, 0x9E, 0x63, 0x38, 0xC6, 0x31, 0x9C, 0x47, 0x38,
  0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xC0, 0x0C, 0x07, 0x1E,
  0x07, 0x1E, 0x06, 0x1E, 0x06, 0x1F, 0x06, 0x1B, 0x0E, 0x1B, 0x0E, 0x3B,
  0x8E, 0x39, 0x8C, 0x39, 0x8C, 0x31, 0xCC, 0x30, 0xDC, 0x30, 0xDC, 0x70,
  0xF8, 0x70, 0x78, 0x60, 0x78, 0x60, 0x78, 0x60, 0x38, 0xE0, 0x38, 0x07,
  0xF0, 0x3F, 0xE1, 0xC3, 0x8E, 0x06, 0x30, 0x1C, 0xC0, 0x37, 0x00, 0xD8,
  0x03, 0x60, 0x1D, 0x80, 0x7E, 0x01, 0xB8, 0x06, 0xE0, 0x1B, 0x80, 0xE6,
  0x03, 0x18, 0x1C, 0x70, 0xE0, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x60, 0x70, 0xC0, 0x61, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x18, 0x0E,
  0x30, 0x3C, 0x7F, 0xF0, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x3F,
  0xE1, 0xC3, 0x8E, 0x07, 0x30, 0x0D, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0x60,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0x18,
  0x1C, 0x70, 0xE0, 0xFF, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0x80,
  0x1F, 0xE0, 0x7F, 0xE1, 0x81, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x33, 0x01,
  0xCC, 0x06, 0x30, 0x38, 0xFF, 0xC7, 0xFC, 0x1C, 0x30, 0x60, 0xC1, 0x83,
  0x86, 0x0E, 0x18, 0x18, 0xE0, 0x73, 0x81, 0xCC, 0x03, 0x00, 0x07, 0xF0,
  0x3F, 0xE1, 0xC1, 0xCE, 0x07, 0x38, 0x0C, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x0E, 0x70, 0x70, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x00, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x31,
  0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x9C, 0x07, 0x38, 0x0C, 0x30, 0x38,
  0x70, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0xC0, 0x1F, 0x00, 0xEE, 0x03, 0x38,
  0x1C, 0xE0, 0x61, 0x83, 0x86, 0x0C, 0x18, 0x70, 0x61, 0xC1, 0x86, 0x07,
  0x38, 0x1C, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x01, 0x80, 0x00, 0x63, 0x8E, 0xC7, 0x19, 0x8E, 0x33, 0x1C, 0x66,
  0x79, 0xDC, 0xF3, 0x39, 0x66, 0x76, 0xCC, 0xCD, 0xB9, 0x9B, 0x63, 0x66,
  0xC6, 0xCD, 0x8D, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xE1, 0xC1,
  0xC3, 0x83, 0x87, 0x00, 0x1C, 0x07, 0x86, 0x03, 0x03, 0x83, 0x80, 0xC3,
  0x80, 0x63, 0x80, 0x39, 0xC0, 0x0D, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x71, 0xC0,
  0x70, 0x60, 0x38, 0x38, 0x38, 0x1C, 0x38, 0x07, 0x00, 0xE0, 0x3F, 0x80,
  0xE6, 0x07, 0x18, 0x18, 0x70, 0xE0, 0xC7, 0x03, 0x18, 0x0C, 0xE0, 0x3F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0x8F, 0x87, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xF8, 0x7C,
  0x00, 0xC3, 0x0E, 0x18, 0x61, 0x86, 0x1C, 0x30, 0xC3, 0x0C, 0x38, 0x61,
  0x86, 0x18, 0x70, 0xC3, 0x0C, 0x0F, 0x87, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x7C, 0x7C, 0x00, 0x03,
  0x01, 0xC0, 0xF0, 0x3C, 0x1D, 0x86, 0x63, 0x18, 0xC6, 0x61, 0xF8, 0x30,
  0x7F, 0xFF, 0xFF, 0xE3, 0x0C, 0x70, 0x01, 0x00, 0x7F, 0x07, 0xBC, 0x70,
  0x63, 0x03, 0x80, 0x1C, 0x1F, 0xC3, 0xFE, 0x78, 0x33, 0x01, 0xB8, 0x1D,
  0xC0, 0xEE, 0x0E, 0x3F, 0xF0, 0xFD, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x40, 0xDF, 0x87, 0xFE, 0x38, 0x31, 0x81, 0xCC,
  0x0E, 0xE0, 0x37, 0x03, 0xB0, 0x1D, 0x80, 0xCC, 0x06, 0xE0, 0x77, 0x87,
  0x3F, 0xF1, 0x9F, 0x00, 0x02, 0x01, 0xFC, 0x3D, 0xE7, 0x07, 0x60, 0x3E,
  0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7C, 0x0E, 0xE0, 0xC7,
  0xFC, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x18, 0xE1, 0xFB, 0x0F, 0xFC, 0x70, 0x71, 0x80, 0xCE, 0x07, 0x30, 0x1C,
  0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x38, 0xC0, 0xE3, 0x87, 0x87, 0xFC,
  0x0F, 0xB0, 0x01, 0x00, 0x7F, 0x07, 0xBC, 0x70, 0x63, 0x01, 0xB8, 0x0D,
  0x80, 0x6F, 0xFF, 0x7F, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x47, 0x07, 0x1F,
  0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x78, 0x81, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC1, 0x3F, 0xF8, 0xFF, 0xE0, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x00, 0x01, 0x04, 0x3F, 0x61, 0xFF, 0x8E, 0x0E, 0x30,
  0x39, 0xC0, 0xE6, 0x03, 0x98, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18,
  0x1C, 0x70, 0xF0, 0xFF, 0x81, 0xF6, 0x00, 0x18, 0x00, 0xE3, 0x07, 0x0E,
  0x3C, 0x1F, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x40, 0xCF, 0xC6, 0xFE, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0,
  0x77, 0x03, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x37, 0x03, 0xB8, 0x1D,
  0x80, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0xF8, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x13, 0x83,
  0x8C, 0x1C, 0x30, 0xE0, 0xCF, 0x03, 0x78, 0x1F, 0x80, 0x7E, 0x01, 0xFC,
  0x07, 0x38, 0x18, 0xE0, 0xE1, 0xC3, 0x83, 0x8E, 0x0E, 0x30, 0x1C, 0x0F,
  0xE1, 0xFE, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x01, 0x08, 0x6F, 0x78, 0xFF, 0xF9, 0x8E,
  0x33, 0x18, 0x6E, 0x30, 0xDC, 0x63, 0xB0, 0xC6, 0x63, 0x8C, 0xC7, 0x19,
  0x8C, 0x37, 0x18, 0x6E, 0x31, 0xD8, 0x63, 0x31, 0xC6, 0x00, 0x00, 0x81,
  0x9F, 0x8F, 0xFC, 0x70, 0x73, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x60,
  0x33, 0x01, 0x98, 0x0D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x01, 0x80, 0x01,
  0x00, 0x7F, 0x07, 0xBC, 0x70, 0x67, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0C, 0xC0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7E, 0x00,
  0x00, 0x40, 0x6F, 0xC1, 0xFF, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x30, 0x1C, 0xC0, 0x63, 0x01, 0x9C, 0x0E, 0x78, 0x71, 0xFF,
  0x86, 0x7C, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x02,
  0x08, 0xFD, 0x8F, 0x7C, 0xE0, 0xE6, 0x03, 0x70, 0x3B, 0x01, 0xD8, 0x0C,
  0xC0, 0x66, 0x03, 0x30, 0x39, 0x81, 0xCE, 0x1E, 0x3F, 0xE0, 0xFB, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x08, 0x43, 0x3F, 0x37,
  0xE3, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x02, 0x01, 0xFC, 0x3F, 0xE7,
  0x07, 0x60, 0x37, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x6C,
  0x06, 0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x0F,
  0xFF, 0xFF, 0xC6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x3F, 0x83, 0xF0, 0x70, 0x3B, 0x01, 0x98, 0x0C,
  0xC0, 0x66, 0x07, 0x70, 0x3B, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x07, 0x30,
  0x39, 0xC3, 0xC7, 0xFC, 0x3F, 0x60, 0xE0, 0x1B, 0x01, 0x98, 0x1C, 0xC0,
  0xC7, 0x0E, 0x18, 0x60, 0xC7, 0x06, 0x30, 0x33, 0x80, 0xD8, 0x07, 0xC0,
  0x3C, 0x01, 0xC0, 0x06, 0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x71, 0xB1, 0xC6,
  0xCF, 0x1B, 0x3C, 0xCD, 0x93, 0x36, 0x48, 0xD1, 0x63, 0xC5, 0x8F, 0x14,
  0x38, 0x70, 0xE1, 0xC3, 0x06, 0x00, 0x1C, 0x0F, 0x0C, 0x1C, 0x0E, 0x38,
  0x06, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x0E, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x30, 0xE0, 0x38, 0x38, 0x07,
  0x38, 0x0E, 0x18, 0x0C, 0x18, 0x1C, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x70,
  0x0C, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0xE0, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x1C, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x61, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x86, 0x18, 0xC3, 0x0C, 0x30, 0x0C, 0x01, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x1E, 0x03, 0xC1, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0xF0, 0x18, 0x00, 0x08, 0x00, 0x7E, 0x05, 0xFE,
  0x1B, 0x0F, 0xFC, 0x0F, 0xC0, 0x06, 0x00,
};

const GFXglyph RobotoMono_Italic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 8, 6, 16, 5, -20 },
  { 22, 16, 19, 16, 0, -19 },
  { 60, 13, 25, 16, 2, -22 },
  { 101, 13, 20, 16, 2, -20 },
  { 134, 14, 20, 16, 1, -20 },
  { 169, 3, 6, 16, 7, -20 },
  { 172, 9, 28, 16, 4, -22 },
  { 204, 9, 28, 16, 2, -22 },
  { 236, 12, 13, 16, 3, -19 },
  { 256, 14, 14, 16, 1, -16 },
  { 281, 4, 7, 16, 3, -3 },
  { 285, 10, 2, 16, 3, -9 },
  { 288, 4, 4, 16, 5, -4 },
  { 290, 14, 21, 16, 1, -19 },
  { 327, 13, 20, 16, 2, -20 },
  { 360, 8, 19, 16, 4, -19 },
  { 379, 14, 19, 16, 0, -19 },
  { 413, 13, 19, 16, 1, -19 },
  { 444, 14, 19, 16, 0, -19 },
  { 478, 14, 19, 16, 2, -19 },
  { 512, 11, 19, 16, 2, -19 },
  { 539, 13, 19, 16, 3, -19 },
  { 570, 13, 19, 16, 2, -19 },
  { 601, 11, 19, 16, 3, -19 },
  { 628, 6, 16, 16, 6, -16 },
  { 640, 8, 20, 16, 4, -16 },
  { 660, 12, 12, 16, 2, -15 },
  { 678, 12, 7, 16, 2, -12 },
  { 689, 13, 11, 16, 1, -14 },
  { 707, 11, 19, 16, 4, -19 },
  { 734, 15, 19, 16, 1, -19 },
  { 770, 14, 19, 16, 0, -19 },
  { 804, 14, 19, 16, 1, -19 },
  { 838, 14, 19, 16, 1, -19 },
  { 872, 14, 19, 16, 1, -19 },
  { 906, 15, 19, 16, 1, -19 },
  { 942, 15, 19, 16, 1, -19 },
  { 978, 14, 19, 16, 1, -19 },
  { 1012, 16, 19, 16, 0, -19 },
  { 1050, 14, 19, 16, 1, -19 },
  { 1084, 14, 19, 16, 1, -19 },
  { 1118, 16, 19, 16, 1, -19 },
  { 1156, 12, 19, 16, 1, -19 },
  { 1185, 15, 19, 16, 1, -19 },
  { 1221, 16, 19, 16, 0, -19 },
  { 1259, 14, 19, 16, 1, -19 },
  { 1293, 15, 19, 16, 1, -19 },
  { 1329, 14, 22, 16, 1, -19 },
  { 1368, 14, 19, 16, 1, -19 },
  { 1402, 14, 19, 16, 1, -19 },
  { 1436, 14, 19, 16, 3, -19 },
  { 1470, 15, 19, 16, 1, -19 },
  { 1506, 14, 19, 16, 3, -19 },
  { 1540, 15, 19, 16, 2, -19 },
  { 1576, 17, 19, 16, 0, -19 },
  { 1617, 14, 19, 16, 3, -19 },
  { 1651, 15, 19, 16, 0, -19 },
  { 1687, 9, 26, 16, 4, -22 },
  { 1717, 6, 21, 16, 5, -19 },
  { 1733, 9, 26, 16, 3, -22 },
  { 1763, 10, 10, 16, 3, -19 },
  { 1776, 12, 2, 16, 0, 0 },
  { 1779, 5, 4, 16, 7, -20 },
  { 1782, 13, 15, 16, 1, -15 },
  { 1807, 13, 20, 16, 1, -20 },
  { 1840, 12, 15, 16, 2, -15 },
  { 1863, 14, 20, 16, 2, -20 },
  { 1898, 13, 15, 16, 1, -15 },
  { 1923, 14, 21, 16, 3, -21 },
  { 1960, 14, 21, 16, 1, -15 },
  { 1997, 13, 20, 16, 1, -20 },
  { 2030, 12, 19, 16, 1, -19 },
  { 2059, 13, 25, 16, 0, -19 },
  { 2100, 14, 20, 16, 1, -20 },
  { 2135, 12, 20, 16, 1, -20 },
  { 2165, 15, 15, 16, 0, -15 },
  { 2194, 13, 15, 16, 1, -15 },
  { 2219, 13, 15, 16, 1, -15 },
  { 2244, 14, 20, 16, 0, -15 },
  { 2279, 13, 20, 16, 2, -15 },
  { 2312, 12, 15, 16, 3, -15 },
  { 2335, 12, 15, 16, 2, -15 },
  { 2358, 11, 18, 16, 3, -18 },
  { 2383, 13, 14, 16, 2, -14 },
  { 2406, 13, 14, 16, 2, -14 },
  { 2429, 14, 14, 16, 2, -14 },
  { 2454, 16, 14, 16, 0, -14 },
  { 2482, 16, 20, 16, 0, -14 },
  { 2522, 13, 14, 16, 1, -14 },
  { 2545, 11, 26, 16, 4, -21 },
  { 2581, 6, 24, 16, 5, -19 },
  { 2599, 11, 26, 16, 2, -21 },
  { 2635, 15, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_Italic27pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic27pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOMONO_ITALIC27PT7B_H_
