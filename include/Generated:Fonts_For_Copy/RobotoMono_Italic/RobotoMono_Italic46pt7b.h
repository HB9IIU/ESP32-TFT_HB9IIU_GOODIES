#ifndef _ROBOTOMONO_ITALIC46PT7B_H_
#define _ROBOTOMONO_ITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x83, 0xE1,
  0xF0, 0xF0, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xF7, 0x87, 0x38,
  0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x38, 0x38, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00,
  0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFB, 0xF8, 0x1F, 0x03,
  0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x7C, 0xF8, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0x70, 0x23, 0x81, 0xC1,
  0xEE, 0x07, 0x0F, 0x38, 0x1C, 0x38, 0xE0, 0x71, 0xC3, 0x83, 0x8F, 0x0F,
  0x0E, 0x38, 0x1E, 0xF1, 0xC0, 0x7F, 0xCF, 0x00, 0xFC, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0xF8, 0x01, 0xCF, 0xF0, 0x0E, 0x7F, 0xE0, 0x79, 0xC3, 0x81,
  0xCF, 0x0F, 0x0E, 0x38, 0x1C, 0x70, 0xE0, 0x73, 0xC3, 0x81, 0xCE, 0x0E,
  0x0E, 0x08, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC7, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xF8, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x78,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xF0,
  0x03, 0xC3, 0xE0, 0x03, 0xC7, 0xC0, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xBC, 0x07, 0x1F, 0x3E, 0x0F, 0x3E, 0x1E, 0x0F, 0x7C, 0x0F, 0x0F,
  0x78, 0x0F, 0x9E, 0x78, 0x07, 0x9E, 0x78, 0x07, 0xFC, 0xF8, 0x03, 0xFC,
  0x78, 0x03, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x0F, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0x7C, 0x07, 0xFC, 0x3E, 0x3C, 0xE3, 0x8E,
  0x79, 0xE7, 0x1C, 0x71, 0xCF, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x01, 0x01, 0xE0, 0x2E, 0x0E, 0x06, 0x7C, 0x71, 0xF7,
  0xFB, 0xBF, 0xDF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x80, 0x0F, 0x1C, 0x00, 0xF0, 0xF0, 0x0F,
  0x83, 0xC0, 0xF8, 0x1E, 0x03, 0x80, 0xF8, 0x08, 0x03, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78,
  0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF8, 0x7C, 0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xDF, 0x00, 0x3F,
  0x78, 0x03, 0xFD, 0xE0, 0x1F, 0xF7, 0x81, 0xFB, 0xDE, 0x0F, 0xDE, 0x78,
  0x7C, 0x79, 0xE7, 0xE1, 0xEF, 0x3E, 0x07, 0xBF, 0xF0, 0x1E, 0xFF, 0x00,
  0x7B, 0xF8, 0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0,
  0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x3F, 0xF9, 0xFF, 0xE7,
  0xE7, 0x9C, 0x1E, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF8, 0xFC, 0x07,
  0xC0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80,
  0x1F, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x07, 0x80,
  0x3E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3C, 0x01,
  0xE0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0,
  0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xEF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC3, 0xC0, 0x0F, 0x07,
  0xC0, 0x3E, 0x07, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0xFF, 0x07, 0xBF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF8, 0x7E, 0x7E, 0x03, 0xEF,
  0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03,
  0xE7, 0x80, 0x3C, 0x7C, 0x07, 0xC3, 0xE1, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFC, 0x7E, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xF0, 0x03, 0xC3,
  0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x7F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78,
  0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0x78, 0x78, 0x03,
  0xE1, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFC,
  0x7E, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xF7, 0xC0, 0x7E,
  0x3F, 0x1F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFD, 0xE0, 0x7F, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x03, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x00, 0x00,
  0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01,
  0xF0, 0x1F, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x18, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xCF, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xDE, 0x00, 0x7F,
  0x80, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xE0, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00,
  0x38, 0x1C, 0x1F, 0x0E, 0x0E, 0x1F, 0xE1, 0x87, 0x0F, 0xFC, 0x61, 0xC3,
  0x86, 0x18, 0x61, 0xC1, 0x86, 0x38, 0x70, 0xE1, 0x8E, 0x38, 0x38, 0x63,
  0x0E, 0x0C, 0x19, 0xC7, 0x03, 0x06, 0x71, 0xC1, 0xC3, 0x9C, 0x70, 0x70,
  0xE6, 0x1C, 0x1C, 0x31, 0x86, 0x06, 0x0C, 0x61, 0x83, 0x87, 0x38, 0x71,
  0xE1, 0x86, 0x1C, 0xF8, 0xE1, 0x87, 0xF7, 0xF0, 0x61, 0xF9, 0xF8, 0x1C,
  0x1C, 0x3C, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x78, 0x03, 0xF0, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x78, 0x03,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0x83,
  0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF0,
  0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xF0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0xC0, 0x3C,
  0x01, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x7C, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x07, 0x80,
  0x7E, 0x03, 0xC3, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF9, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x0F,
  0xFE, 0xF0, 0x0F, 0xFC, 0xF0, 0x0F, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x1F, 0x03,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0,
  0x3C, 0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0x3C, 0x01, 0xF8, 0x07, 0x80,
  0x3F, 0x00, 0x78, 0x07, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x0F, 0x80,
  0x07, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x7C, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xDF, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE0,
  0xF7, 0x0F, 0x78, 0x39, 0xC7, 0x9C, 0x1E, 0x71, 0xEF, 0x07, 0x9C, 0xF3,
  0xC1, 0xE7, 0xBC, 0xF0, 0x79, 0xFE, 0x3C, 0x1E, 0x7F, 0x8F, 0x07, 0x0F,
  0xC7, 0x83, 0xC3, 0xF1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1F, 0x80, 0x1E, 0x07, 0xE0, 0x07, 0x81, 0xF8, 0x01, 0xE0, 0xFF,
  0x00, 0x78, 0x3F, 0xC0, 0x1E, 0x0F, 0xF0, 0x0F, 0x83, 0xDE, 0x03, 0xC0,
  0xF7, 0x80, 0xF0, 0x3D, 0xE0, 0x3C, 0x1E, 0x38, 0x0F, 0x07, 0x8F, 0x03,
  0xC1, 0xE3, 0xC1, 0xF0, 0x78, 0x70, 0x78, 0x1E, 0x1E, 0x1E, 0x0F, 0x87,
  0x87, 0x83, 0xC0, 0xE1, 0xE0, 0xF0, 0x3C, 0x78, 0x3C, 0x0F, 0x3E, 0x0F,
  0x01, 0xCF, 0x03, 0xC0, 0x7B, 0xC1, 0xF0, 0x1E, 0xF0, 0x78, 0x03, 0xBC,
  0x1E, 0x00, 0xFF, 0x07, 0x80, 0x3F, 0x81, 0xE0, 0x07, 0xE0, 0x78, 0x01,
  0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x03,
  0xC0, 0x3E, 0x07, 0xE1, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF8,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0x80,
  0x7E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x1E, 0x01, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3C, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF9,
  0xFC, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xF8, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80,
  0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x01,
  0xC3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x0E, 0x03, 0xCE, 0x07, 0x80, 0xE3, 0x81, 0xE0, 0x79, 0xE0,
  0x78, 0x1E, 0x78, 0x1E, 0x07, 0x9E, 0x0F, 0xC1, 0xC7, 0x83, 0xF0, 0xF1,
  0xE0, 0xFC, 0x3C, 0x78, 0x7F, 0x0F, 0x1E, 0x1F, 0xC3, 0x87, 0x87, 0xF1,
  0xE1, 0xE3, 0xDC, 0x78, 0x78, 0xE7, 0x1C, 0x1E, 0x39, 0xCF, 0x07, 0x9E,
  0x73, 0xC1, 0xE7, 0x1C, 0xF0, 0x79, 0xC7, 0x38, 0x1C, 0xF1, 0xDE, 0x07,
  0x38, 0x77, 0x81, 0xCE, 0x1D, 0xE0, 0x77, 0x87, 0x70, 0x1D, 0xC1, 0xFC,
  0x07, 0x70, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0,
  0x1E, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF0,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00,
  0x3C, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F,
  0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x00, 0xE1, 0xE0, 0x01, 0xE7,
  0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0x70, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xC7, 0x03, 0xC3,
  0x81, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x1C, 0x70, 0x0E, 0x78,
  0x07, 0xF8, 0x03, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF8, 0x3C, 0x3C, 0x1E, 0x0E, 0x07, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC0, 0x78, 0xF8, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0x3F, 0x0F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xBC, 0x0F, 0xF1, 0xE0,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x39, 0xFF, 0x00, 0xF7,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F,
  0x80, 0x1F, 0x1F, 0x80, 0x7C, 0x3F, 0xC3, 0xF0, 0x7F, 0xFF, 0xC0, 0xF7,
  0xFF, 0x03, 0xC7, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x00, 0x78,
  0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xF0, 0x03,
  0xC7, 0x80, 0x3C, 0x3F, 0x07, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x3C, 0x03, 0xFE, 0x7C, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0x83, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0x78,
  0x07, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFB, 0xC0, 0x0F,
  0xF3, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xC0, 0xF8, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x0F,
  0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x10, 0x3E, 0x00, 0xF0,
  0xFC, 0x0F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x07, 0xE0, 0x40, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0x8F, 0x01, 0xFF, 0xEF, 0x03, 0xFF, 0xFE, 0x07, 0xE0,
  0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x3E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x1E, 0x01,
  0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFE, 0xF0, 0x03, 0xFC,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x20, 0x03,
  0xE0, 0x70, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x1F, 0x00, 0x38, 0xFF, 0x80, 0xF3, 0xFF, 0x81, 0xEF, 0xFF, 0x83,
  0xF8, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x3F, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0x01,
  0xF0, 0x0F, 0x07, 0xE0, 0x0F, 0x0F, 0xC0, 0x0F, 0x1F, 0x80, 0x1E, 0x3F,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x1E, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x3C, 0x1E, 0x03, 0xBF, 0x9F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0x0F, 0x87, 0x87, 0x83, 0xE0,
  0xF1, 0xE0, 0xF0, 0x3C, 0x78, 0x3C, 0x0E, 0x1C, 0x0F, 0x07, 0x8F, 0x03,
  0xC1, 0xE3, 0xC0, 0xE0, 0x78, 0xF0, 0x78, 0x1E, 0x3C, 0x1E, 0x07, 0x8F,
  0x07, 0x81, 0xC3, 0x81, 0xE0, 0xF1, 0xE0, 0x78, 0x3C, 0x78, 0x1C, 0x0F,
  0x1E, 0x0F, 0x03, 0xC7, 0x83, 0xC0, 0xF1, 0xE0, 0xF0, 0x38, 0xF0, 0x3C,
  0x1E, 0x3C, 0x0F, 0x07, 0x8F, 0x03, 0x81, 0xE3, 0xC1, 0xE0, 0x78, 0xF0,
  0x78, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x0E, 0x3F, 0xE0, 0x3C, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFE, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F,
  0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF8, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x00,
  0x1F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0,
  0x00, 0x79, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x7C, 0x03,
  0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0x9F, 0xF0, 0x07, 0xBF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x1E,
  0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C,
  0x3E, 0x00, 0x78, 0x3F, 0x00, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0xFF, 0xE0,
  0x3D, 0xFF, 0xC0, 0x3C, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xFC, 0xF0, 0x7F, 0xFB, 0x83, 0xFF, 0xFE, 0x1F, 0x81, 0xF8, 0xF8,
  0x03, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3E, 0x00, 0xF8, 0x78, 0x07, 0xC1, 0xF0, 0x7F, 0x03, 0xFF, 0xFC,
  0x07, 0xFE, 0xF0, 0x0F, 0xF3, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0xF1, 0xFF,
  0x0F, 0x7F, 0xF0, 0xEF, 0xFE, 0x1F, 0xF8, 0x61, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x0F,
  0x00, 0x7C, 0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE4, 0x00, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x3E, 0x03, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC1, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1E, 0x00,
  0x3C, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x07,
  0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x80, 0x3E, 0x1E, 0x01, 0xF0, 0x7C, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xBC, 0x07, 0xF8, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xE7, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x83,
  0x80, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0xF0, 0x07, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0,
  0x03, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x1C, 0x07, 0xF0, 0x1E, 0x03, 0xB8, 0x0F, 0x03, 0xDE, 0x0F,
  0x81, 0xCF, 0x07, 0xC0, 0xE7, 0x83, 0xE0, 0xF3, 0xC3, 0xF0, 0x71, 0xE1,
  0xF8, 0x38, 0xF1, 0xDC, 0x3C, 0x78, 0xEE, 0x1C, 0x3C, 0x77, 0x0E, 0x1E,
  0x71, 0x8E, 0x0F, 0x38, 0xE7, 0x07, 0xB8, 0x77, 0x83, 0xDC, 0x3B, 0x81,
  0xFE, 0x1D, 0xC0, 0x6E, 0x0F, 0xE0, 0x37, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x8F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0xF8, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xF8, 0x01, 0xCF, 0xFE, 0x00, 0xEF, 0xFF, 0x80, 0xFF, 0x07, 0xE0, 0xF7,
  0x00, 0xFF, 0xFB, 0x80, 0x3F, 0xF8, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xF0,
  0x00,
};

const GFXglyph RobotoMono_Italic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 9, 33, 27, 9, -33 },
  { 39, 13, 11, 27, 9, -35 },
  { 57, 26, 33, 27, 1, -33 },
  { 165, 22, 43, 27, 3, -38 },
  { 284, 22, 34, 27, 3, -33 },
  { 378, 24, 33, 27, 1, -33 },
  { 477, 6, 11, 27, 12, -35 },
  { 486, 16, 48, 27, 7, -37 },
  { 582, 15, 48, 27, 4, -37 },
  { 672, 21, 22, 27, 5, -33 },
  { 730, 22, 24, 27, 3, -27 },
  { 796, 9, 13, 27, 4, -5 },
  { 811, 17, 3, 27, 5, -16 },
  { 818, 6, 6, 27, 9, -6 },
  { 823, 23, 36, 27, 3, -33 },
  { 927, 22, 34, 27, 3, -33 },
  { 1021, 14, 33, 27, 6, -33 },
  { 1079, 24, 33, 27, 0, -33 },
  { 1178, 23, 34, 27, 1, -33 },
  { 1276, 23, 33, 27, 1, -33 },
  { 1371, 23, 34, 27, 3, -33 },
  { 1469, 20, 34, 27, 3, -33 },
  { 1554, 23, 33, 27, 4, -33 },
  { 1649, 22, 34, 27, 3, -33 },
  { 1743, 20, 33, 27, 4, -33 },
  { 1826, 10, 26, 27, 10, -26 },
  { 1859, 13, 34, 27, 7, -26 },
  { 1915, 20, 20, 27, 4, -25 },
  { 1965, 22, 13, 27, 3, -21 },
  { 2001, 22, 21, 27, 2, -25 },
  { 2059, 19, 33, 27, 6, -33 },
  { 2138, 26, 33, 27, 1, -33 },
  { 2246, 24, 33, 27, -1, -33 },
  { 2345, 25, 33, 27, 1, -33 },
  { 2449, 24, 34, 27, 2, -33 },
  { 2551, 25, 33, 27, 1, -33 },
  { 2655, 25, 33, 27, 2, -33 },
  { 2759, 25, 33, 27, 2, -33 },
  { 2863, 24, 34, 27, 2, -33 },
  { 2965, 26, 33, 27, 1, -33 },
  { 3073, 25, 33, 27, 1, -33 },
  { 3177, 25, 34, 27, 1, -33 },
  { 3284, 28, 33, 27, 1, -33 },
  { 3400, 20, 33, 27, 2, -33 },
  { 3483, 26, 33, 27, 1, -33 },
  { 3591, 26, 33, 27, 1, -33 },
  { 3699, 23, 34, 27, 2, -33 },
  { 3797, 25, 33, 27, 2, -33 },
  { 3901, 24, 39, 27, 2, -33 },
  { 4018, 24, 33, 27, 2, -33 },
  { 4117, 24, 34, 27, 2, -33 },
  { 4219, 25, 33, 27, 4, -33 },
  { 4323, 25, 34, 27, 2, -33 },
  { 4430, 23, 33, 27, 5, -33 },
  { 4525, 26, 33, 27, 3, -33 },
  { 4633, 28, 33, 27, 0, -33 },
  { 4749, 23, 33, 27, 5, -33 },
  { 4844, 26, 33, 27, 0, -33 },
  { 4952, 16, 44, 27, 6, -37 },
  { 5040, 11, 36, 27, 8, -33 },
  { 5090, 15, 44, 27, 6, -37 },
  { 5173, 17, 18, 27, 5, -33 },
  { 5212, 21, 3, 27, 0, 0 },
  { 5220, 8, 6, 27, 12, -33 },
  { 5226, 21, 25, 27, 2, -25 },
  { 5292, 23, 36, 27, 1, -35 },
  { 5396, 21, 26, 27, 3, -25 },
  { 5465, 24, 35, 27, 3, -35 },
  { 5570, 22, 26, 27, 2, -25 },
  { 5642, 23, 36, 27, 5, -36 },
  { 5746, 24, 35, 27, 1, -25 },
  { 5851, 23, 35, 27, 1, -35 },
  { 5952, 20, 33, 27, 2, -33 },
  { 6035, 21, 43, 27, 1, -33 },
  { 6148, 24, 35, 27, 1, -35 },
  { 6253, 20, 35, 27, 2, -35 },
  { 6341, 26, 25, 27, 0, -25 },
  { 6423, 23, 25, 27, 1, -25 },
  { 6495, 22, 26, 27, 2, -25 },
  { 6567, 24, 34, 27, 0, -25 },
  { 6669, 22, 34, 27, 3, -25 },
  { 6763, 20, 25, 27, 5, -25 },
  { 6826, 21, 26, 27, 3, -25 },
  { 6895, 20, 30, 27, 4, -30 },
  { 6970, 22, 25, 27, 3, -24 },
  { 7039, 22, 24, 27, 4, -24 },
  { 7105, 25, 24, 27, 3, -24 },
  { 7180, 26, 24, 27, 0, -24 },
  { 7258, 28, 34, 27, -1, -24 },
  { 7377, 24, 24, 27, 1, -24 },
  { 7449, 18, 44, 27, 7, -36 },
  { 7548, 10, 42, 27, 8, -33 },
  { 7601, 18, 44, 27, 4, -36 },
  { 7700, 25, 9, 27, 1, -18 },
};

const GFXfont RobotoMono_Italic46pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic46pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOMONO_ITALIC46PT7B_H_
