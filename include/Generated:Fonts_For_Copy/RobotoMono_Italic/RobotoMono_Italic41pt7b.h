#ifndef _ROBOTOMONO_ITALIC41PT7B_H_
#define _ROBOTOMONO_ITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x38, 0x73, 0x87, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xC6, 0x0C, 0xE1, 0xCE, 0x1C, 0x00, 0x1E, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x07, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0E,
  0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x07, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x83,
  0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x80,
  0x3C, 0x3C, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x38, 0xE0, 0x0E, 0x1C,
  0x11, 0xC1, 0x83, 0xB8, 0x30, 0xE6, 0x0E, 0x1C, 0xC1, 0xC7, 0x1C, 0x39,
  0xC3, 0x8E, 0x70, 0x3F, 0x8E, 0x03, 0xE3, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x7E, 0x03, 0x9F,
  0xE0, 0xE7, 0x9E, 0x1C, 0xE1, 0xC7, 0x18, 0x39, 0xC7, 0x07, 0x78, 0xE0,
  0xE6, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x38, 0xE0, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0,
  0x03, 0xC3, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x70, 0x07,
  0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x04,
  0x7D, 0xE0, 0xE3, 0xE3, 0x83, 0x9F, 0x0F, 0x0E, 0x78, 0x1E, 0x79, 0xC0,
  0x79, 0xCF, 0x00, 0xFF, 0x3C, 0x03, 0xF8, 0xF0, 0x07, 0xC1, 0xC0, 0x1F,
  0x07, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFD, 0xE0, 0x3F, 0xC3, 0xC0,
  0x7B, 0x9C, 0xE7, 0x39, 0x9C, 0xE7, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x30, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x40, 0xE0, 0x5E, 0x18, 0x3B, 0xF3,
  0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0xF1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03,
  0xC0, 0x60, 0x30, 0x00, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x71, 0xC0, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0xF7, 0xE0, 0xF0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x39,
  0xE0, 0x07, 0x38, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x0F, 0xBC, 0x03, 0xF7,
  0x01, 0xFE, 0xE0, 0x7F, 0xFC, 0x3E, 0x7F, 0x8F, 0x8F, 0xF3, 0xC1, 0xDF,
  0xF0, 0x3B, 0xFC, 0x0F, 0x7E, 0x01, 0xEF, 0x80, 0x3D, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x1E, 0x01, 0xE1, 0xE0, 0x78, 0x3F,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x30, 0x1F, 0x0F, 0xE3,
  0xFE, 0xFF, 0xEF, 0x9E, 0xE1, 0xE8, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xEF, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x18,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0x7E, 0x0F, 0x81, 0xE0, 0xF0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0x8F, 0x00, 0x78, 0x78, 0x0F, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00, 0x79,
  0xC0, 0x07, 0x8E, 0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x03,
  0xC1, 0xE0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x3C,
  0x1E, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x3F, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x8F, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x70, 0x01, 0xE3, 0x80, 0x0E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x03,
  0xC0, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xCF, 0xC0,
  0xEF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC3, 0xE7, 0xC0, 0x3D, 0xE0, 0x0F, 0x78,
  0x03, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDC, 0x00,
  0xF7, 0x00, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x8F, 0x07, 0xC3, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x1E, 0x00, 0xE1,
  0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1, 0xE0, 0x3C,
  0x0F, 0x07, 0xC0, 0xFD, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0x03, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF8,
  0x1F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x8F, 0x01, 0xE7, 0x80,
  0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x79, 0xE0, 0x3E, 0x7C, 0x1F, 0x8F,
  0xFF, 0xE3, 0xFF, 0x70, 0x3F, 0x9C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x1F, 0x0F, 0xC7, 0xC1, 0xE0, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC0, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xC0, 0x07, 0xE3, 0xC0, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xC0,
  0x03, 0x83, 0x87, 0xC3, 0x0E, 0x1F, 0xC6, 0x18, 0x79, 0x8C, 0x71, 0xC3,
  0x18, 0xC3, 0x06, 0x31, 0x8E, 0x1C, 0x67, 0x18, 0x30, 0xCC, 0x70, 0x61,
  0x98, 0xE0, 0xC3, 0x31, 0xC3, 0x86, 0xE3, 0x06, 0x19, 0xC6, 0x0C, 0x33,
  0x8C, 0x38, 0x67, 0x1C, 0xF1, 0x8E, 0x3F, 0xFF, 0x0C, 0x3E, 0xFC, 0x18,
  0x20, 0x60, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x08, 0x00, 0x7C,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x1E,
  0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x9E, 0x00,
  0x0E, 0xF0, 0x00, 0x3C, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xC0, 0x3E, 0x07, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0x80,
  0x7C, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0x01, 0xF8,
  0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x03,
  0xE1, 0xC0, 0x3F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xEF, 0xC0, 0x78,
  0x0F, 0x07, 0x80, 0x78, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x01, 0xCE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0xC0, 0x3C, 0x0F, 0x03, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x03,
  0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x8E,
  0x00, 0x1C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0xF0, 0x70, 0x0F, 0x81, 0xC0, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0x78, 0x1F,
  0x07, 0x80, 0x78, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x03, 0xFE, 0xF0, 0x1F, 0xF7, 0x80, 0xFF, 0xBC, 0x0F,
  0xFD, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x8E,
  0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x01, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xF0,
  0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80,
  0x1F, 0x83, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x00, 0xE0, 0x1F, 0x00, 0x70,
  0x1F, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xBC, 0x00, 0x1F, 0x9E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x03, 0x80, 0xF0, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0E, 0x00,
  0x3C, 0x0F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xEE, 0x1E, 0xC3,
  0xDC, 0x39, 0xC7, 0x78, 0x73, 0x9E, 0xF0, 0xE7, 0x39, 0xC1, 0xCE, 0xF3,
  0x87, 0x9D, 0xC7, 0x0F, 0x3F, 0x9E, 0x1E, 0x7E, 0x3C, 0x38, 0x7C, 0x70,
  0x70, 0xF0, 0xE0, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x87, 0x0F, 0x0F,
  0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7E, 0x00, 0xE0, 0xFC,
  0x01, 0xC1, 0xF8, 0x07, 0x83, 0xF8, 0x0F, 0x0F, 0xF0, 0x1E, 0x1E, 0xE0,
  0x3C, 0x3D, 0xE0, 0x70, 0x7B, 0xC0, 0xE0, 0xE3, 0x83, 0xC1, 0xC7, 0x87,
  0x87, 0x8F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x38, 0x3C, 0x3C, 0xF0,
  0x70, 0x39, 0xE0, 0xE0, 0x7B, 0xC3, 0xC0, 0xF7, 0x87, 0x80, 0xEE, 0x0F,
  0x01, 0xDC, 0x1C, 0x03, 0xF8, 0x38, 0x03, 0xF0, 0xF0, 0x07, 0xE1, 0xE0,
  0x0F, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x78, 0x1E,
  0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0,
  0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xB8, 0x00, 0x3D,
  0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x1E,
  0x00, 0x78, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x0F, 0x07, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xC0, 0x3E, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xC0, 0x07,
  0x87, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xF8, 0x1E, 0x07, 0x80, 0x78, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x3C,
  0x00, 0x79, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x00, 0x07,
  0xB8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80,
  0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x78, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x0F, 0x07,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xC0, 0x3E, 0x07, 0x00, 0x78,
  0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x38,
  0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x0F,
  0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0x80,
  0x78, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0x7C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF3, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7,
  0xC0, 0x1E, 0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x1C, 0x00, 0xF0,
  0x78, 0x07, 0x81, 0xF0, 0x7C, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBC, 0x00, 0x3C, 0xE0, 0x01,
  0xC7, 0x00, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x07, 0x81, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xE0,
  0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x07, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xE3,
  0xC0, 0x07, 0x1C, 0x00, 0x39, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x1E, 0xE0, 0x70,
  0x39, 0xC1, 0xE0, 0x73, 0x83, 0xC1, 0xE7, 0x07, 0xC3, 0x8E, 0x1F, 0x87,
  0x1C, 0x3F, 0x1E, 0x38, 0x7E, 0x3C, 0x71, 0xDC, 0x70, 0xE3, 0xB8, 0xE1,
  0xC7, 0x73, 0xC3, 0x9C, 0xE7, 0x07, 0x39, 0xCE, 0x0E, 0x73, 0x9C, 0x1D,
  0xC7, 0x78, 0x7B, 0x8E, 0xE0, 0xF7, 0x1D, 0xC1, 0xFC, 0x3B, 0x83, 0xF8,
  0x7F, 0x07, 0x70, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x83, 0xC0,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x1C, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00,
  0x39, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x03, 0x80, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x80, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF0, 0x03,
  0xC3, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x03, 0x81, 0xE0, 0x1C,
  0x0F, 0x00, 0xF0, 0xF0, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xF7, 0x80,
  0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xDE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x70, 0xF0, 0xE1, 0xC1, 0xE7,
  0x81, 0xCE, 0x03, 0xBC, 0x07, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x00, 0xF0, 0xF0, 0xE1, 0xE1, 0xC1, 0xC0, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0x1F, 0xF1,
  0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x07,
  0x9E, 0x01, 0xF3, 0xE0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0x78, 0x3F, 0x8F,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF3, 0xF0, 0x0E, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xC3, 0xE1, 0xF0, 0x1E,
  0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x3C, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xF3, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3C, 0x7C, 0x03, 0xC7, 0xE0, 0xF8, 0x7F,
  0xFF, 0x87, 0x7F, 0xF0, 0xF3, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xC1, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x3B,
  0xC0, 0x07, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF0, 0xF0, 0x3E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x07, 0xE3, 0xC0, 0x7F, 0xEF, 0x03, 0xFF, 0xFC, 0x1F, 0x87, 0xF0,
  0x78, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x1F, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFE,
  0x70, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1,
  0xE0, 0x1C, 0x78, 0x03, 0xCF, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x01, 0x0F, 0x00, 0x70, 0xF0, 0x1F, 0x1F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x38, 0x1F, 0xFB,
  0xC1, 0xFF, 0xFE, 0x1F, 0x87, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x38,
  0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x00,
  0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xF9, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x83, 0x00, 0x78, 0x3C, 0x07, 0xC1, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF1, 0xF8, 0x0E, 0x7F, 0xC0, 0xEF, 0xFE, 0x1F,
  0xC3, 0xE1, 0xF8, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00, 0xF1,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xE3, 0xC0, 0x0E,
  0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xC7, 0x80, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xC0, 0x00,
  0x04, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x02, 0x1F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0xF0, 0x1F, 0x03, 0x80, 0xF8, 0x0E, 0x07, 0xC0, 0x78,
  0x3E, 0x01, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1C, 0x78, 0x00, 0x73, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFD, 0xE0, 0x03,
  0xE7, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x0F, 0x0F, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0xF8, 0xF8, 0x3B, 0xFB, 0xF8, 0x7F, 0xFF, 0xF0, 0xF1, 0xF8, 0xF1, 0xC1,
  0xE1, 0xE3, 0x83, 0x83, 0xCF, 0x07, 0x07, 0x9E, 0x0E, 0x0E, 0x38, 0x3C,
  0x1C, 0x70, 0x78, 0x38, 0xE0, 0xF0, 0x71, 0xC1, 0xC1, 0xE7, 0x83, 0x83,
  0xCF, 0x07, 0x07, 0x1C, 0x1E, 0x0E, 0x38, 0x3C, 0x1C, 0x70, 0x78, 0x39,
  0xE0, 0xE0, 0xF3, 0xC1, 0xC1, 0xE7, 0x83, 0x83, 0x8E, 0x0F, 0x07, 0x1C,
  0x1E, 0x0E, 0x00, 0x0E, 0x1F, 0x80, 0xE7, 0xFC, 0x0E, 0xFF, 0xE1, 0xFC,
  0x3E, 0x1F, 0x80, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3,
  0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C,
  0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE1, 0xE0, 0x3C, 0x78, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E,
  0x70, 0x03, 0xCF, 0x00, 0xF1, 0xF0, 0x3C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x07, 0x1F, 0x80, 0x3B, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xC3, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F,
  0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1,
  0xE0, 0x0F, 0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0x83, 0xBF, 0xF8, 0x3C, 0xFF,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8,
  0x70, 0x7F, 0xEF, 0x0F, 0xFF, 0xF1, 0xF8, 0x7F, 0x1E, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x1E, 0x70,
  0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xC7,
  0x00, 0x38, 0x78, 0x03, 0x87, 0x80, 0x78, 0x7C, 0x1F, 0x83, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFE, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x0E, 0x1F, 0xC3, 0x9F, 0xF0, 0xEF, 0xFC, 0x7F, 0xFF, 0x1F, 0xC0,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07, 0xC1,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF7, 0x80, 0x1E, 0x70, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1E,
  0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0xE0, 0x07, 0x9C, 0x00, 0xF7, 0x80, 0x1C, 0xF0, 0x03, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x7B, 0xC0, 0x0E, 0x78,
  0x01, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x00, 0x3C, 0xF0,
  0x0F, 0x1E, 0x03, 0xE3, 0xE0, 0xFC, 0x3F, 0xFB, 0x83, 0xFE, 0xF0, 0x3F,
  0x9E, 0x00, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x0F,
  0x01, 0xC0, 0xE0, 0x1C, 0x1E, 0x01, 0xC1, 0xC0, 0x1E, 0x3C, 0x00, 0xE3,
  0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x1F,
  0x81, 0xC0, 0xEE, 0x07, 0x03, 0xB8, 0x3C, 0x0E, 0xE0, 0xF0, 0x73, 0x87,
  0xC1, 0xCE, 0x1F, 0x0F, 0x38, 0x6C, 0x38, 0xE3, 0xB0, 0xE3, 0x8C, 0xC7,
  0x0E, 0x73, 0x9C, 0x39, 0xCE, 0x70, 0xEE, 0x3B, 0x83, 0xB8, 0xEE, 0x0E,
  0xC3, 0xB0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x0F, 0x00,
  0x1F, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0xC1,
  0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xC7, 0x00, 0x07, 0x87,
  0x80, 0x0F, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x7C, 0x01,
  0xE0, 0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC1, 0xC0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00,
  0x70, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x0B, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xC0, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0E, 0x00, 0x03, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x80, 0x37, 0xFF, 0x01, 0xFE, 0x7E, 0x0F, 0xE0, 0x7E, 0x7B, 0x80,
  0xFF, 0xEC, 0x01, 0xFF, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoMono_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 8, 29, 24, 8, -29 },
  { 30, 12, 10, 24, 8, -31 },
  { 45, 23, 29, 24, 1, -29 },
  { 129, 21, 38, 24, 2, -34 },
  { 229, 19, 30, 24, 3, -30 },
  { 301, 22, 30, 24, 1, -30 },
  { 384, 5, 10, 24, 11, -31 },
  { 391, 13, 42, 24, 7, -33 },
  { 460, 14, 42, 24, 3, -33 },
  { 534, 19, 20, 24, 4, -29 },
  { 582, 20, 21, 24, 2, -24 },
  { 635, 7, 11, 24, 4, -4 },
  { 645, 16, 3, 24, 4, -14 },
  { 651, 6, 5, 24, 8, -5 },
  { 655, 21, 32, 24, 2, -29 },
  { 739, 19, 30, 24, 3, -30 },
  { 811, 12, 29, 24, 6, -29 },
  { 855, 21, 30, 24, 0, -30 },
  { 934, 20, 30, 24, 1, -30 },
  { 1009, 21, 29, 24, 1, -29 },
  { 1086, 21, 29, 24, 3, -29 },
  { 1163, 18, 29, 24, 2, -29 },
  { 1229, 20, 29, 24, 4, -29 },
  { 1302, 20, 30, 24, 3, -30 },
  { 1377, 18, 30, 24, 4, -30 },
  { 1445, 9, 23, 24, 9, -23 },
  { 1471, 11, 30, 24, 6, -23 },
  { 1513, 19, 18, 24, 3, -22 },
  { 1556, 19, 12, 24, 3, -19 },
  { 1585, 19, 18, 24, 2, -22 },
  { 1628, 16, 30, 24, 6, -30 },
  { 1688, 23, 29, 24, 1, -29 },
  { 1772, 22, 29, 24, -1, -29 },
  { 1852, 22, 29, 24, 1, -29 },
  { 1932, 21, 30, 24, 2, -30 },
  { 2011, 22, 29, 24, 1, -29 },
  { 2091, 23, 29, 24, 1, -29 },
  { 2175, 22, 29, 24, 2, -29 },
  { 2255, 21, 30, 24, 2, -30 },
  { 2334, 23, 29, 24, 1, -29 },
  { 2418, 22, 29, 24, 1, -29 },
  { 2498, 22, 29, 24, 1, -29 },
  { 2578, 25, 29, 24, 1, -29 },
  { 2669, 18, 29, 24, 2, -29 },
  { 2735, 23, 29, 24, 1, -29 },
  { 2819, 23, 29, 24, 1, -29 },
  { 2903, 21, 30, 24, 2, -30 },
  { 2982, 22, 29, 24, 2, -29 },
  { 3062, 21, 35, 24, 2, -30 },
  { 3154, 22, 29, 24, 1, -29 },
  { 3234, 21, 30, 24, 2, -30 },
  { 3313, 21, 29, 24, 4, -29 },
  { 3390, 22, 29, 24, 2, -29 },
  { 3470, 21, 29, 24, 4, -29 },
  { 3547, 23, 29, 24, 3, -29 },
  { 3631, 25, 29, 24, 0, -29 },
  { 3722, 21, 29, 24, 4, -29 },
  { 3799, 23, 29, 24, 0, -29 },
  { 3883, 14, 39, 24, 5, -33 },
  { 3952, 9, 32, 24, 8, -29 },
  { 3988, 14, 39, 24, 5, -33 },
  { 4057, 15, 15, 24, 5, -29 },
  { 4086, 19, 3, 24, 0, 0 },
  { 4094, 7, 6, 24, 11, -30 },
  { 4100, 19, 22, 24, 2, -22 },
  { 4153, 20, 31, 24, 1, -31 },
  { 4231, 19, 22, 24, 2, -22 },
  { 4284, 22, 31, 24, 2, -31 },
  { 4370, 19, 22, 24, 2, -22 },
  { 4423, 21, 32, 24, 4, -32 },
  { 4507, 21, 31, 24, 1, -22 },
  { 4589, 20, 31, 24, 1, -31 },
  { 4667, 18, 30, 24, 2, -30 },
  { 4735, 18, 39, 24, 1, -30 },
  { 4823, 22, 31, 24, 1, -31 },
  { 4909, 18, 31, 24, 2, -31 },
  { 4979, 23, 22, 24, 0, -22 },
  { 5043, 20, 22, 24, 1, -22 },
  { 5098, 19, 22, 24, 2, -22 },
  { 5151, 21, 30, 24, 0, -22 },
  { 5230, 20, 30, 24, 2, -22 },
  { 5305, 18, 22, 24, 4, -22 },
  { 5355, 19, 22, 24, 2, -22 },
  { 5408, 18, 27, 24, 4, -27 },
  { 5469, 19, 22, 24, 3, -22 },
  { 5522, 20, 22, 24, 3, -22 },
  { 5577, 22, 22, 24, 3, -22 },
  { 5638, 24, 22, 24, 0, -22 },
  { 5704, 25, 31, 24, -1, -22 },
  { 5801, 21, 22, 24, 1, -22 },
  { 5859, 16, 39, 24, 6, -32 },
  { 5937, 9, 37, 24, 7, -29 },
  { 5979, 16, 39, 24, 4, -32 },
  { 6057, 22, 8, 24, 1, -16 },
};

const GFXfont RobotoMono_Italic41pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic41pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOMONO_ITALIC41PT7B_H_
