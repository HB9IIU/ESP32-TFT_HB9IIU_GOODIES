#ifndef _ROBOTOMONO_ITALIC38PT7B_H_
#define _ROBOTOMONO_ITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xF0, 0xF0, 0x70, 0x70, 0xDC, 0x77, 0x1D, 0x87, 0xE1, 0xF8, 0x6E,
  0x1B, 0x0E, 0xC3, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70,
  0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x70, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x43, 0x87, 0x00,
  0x06, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0x80, 0x03, 0x07, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x84, 0x30,
  0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0C,
  0x00, 0x1C, 0x38, 0x00, 0x30, 0x70, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xF0, 0x7C, 0x1E, 0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0xF1,
  0xC0, 0x1C, 0x3C, 0x0F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0x1C, 0x01, 0xC3, 0x04, 0x60, 0xC1, 0x98, 0x30, 0xEE,
  0x0C, 0x73, 0x87, 0x38, 0x71, 0xCC, 0x1F, 0xE7, 0x03, 0xF3, 0x80, 0x30,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x10, 0x03, 0x9F,
  0x81, 0xCF, 0xF0, 0x67, 0x1C, 0x39, 0xC3, 0x1C, 0x60, 0xC6, 0x18, 0x33,
  0x86, 0x0C, 0x41, 0x87, 0x00, 0x71, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x78, 0x78, 0x07, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x07, 0x80, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x7B, 0xE0,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0,
  0x03, 0xEF, 0x07, 0x3C, 0x70, 0xF7, 0x87, 0x8E, 0x70, 0x3C, 0xEF, 0x01,
  0xDC, 0xF0, 0x1F, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x07, 0x81, 0xF8, 0x7E,
  0xFF, 0x83, 0xFF, 0xBC, 0x0F, 0xE1, 0xE0, 0x37, 0x77, 0x77, 0x66, 0xE0,
  0x00, 0x08, 0x01, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x02, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x06, 0x05, 0xE3, 0x1F,
  0xFD, 0xBF, 0x7F, 0xFF, 0x83, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xE7,
  0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x08, 0x08, 0x00,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0xF3,
  0xCF, 0x3C, 0xE7, 0x9C, 0xE3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x39, 0xEF, 0xFF, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x3E, 0x07, 0x81, 0xE1, 0xE0,
  0x1C, 0x38, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00,
  0xFD, 0xE0, 0x3F, 0x3C, 0x1F, 0xE7, 0x87, 0x9C, 0xE3, 0xE3, 0x9C, 0xF0,
  0xF3, 0xFC, 0x1E, 0x7F, 0x03, 0xDF, 0x80, 0x73, 0xE0, 0x0E, 0x78, 0x01,
  0xCF, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x3E, 0x7C,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x30, 0x1E, 0x0F, 0xE3, 0xFE,
  0x7F, 0xE7, 0x9E, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0xC0, 0xF0, 0xF0, 0x0E, 0x3C,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0x3E, 0x07,
  0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x03, 0xC3, 0xC0,
  0xF0, 0x7E, 0x7C, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x71, 0xC0, 0x0F, 0x3C, 0x01, 0xE3,
  0xC0, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x70, 0x38, 0x0F, 0x03, 0x81, 0xE0,
  0x78, 0x1C, 0x07, 0x83, 0x80, 0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x9C, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xF7, 0xE0,
  0x70, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x07, 0x87,
  0x81, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x78, 0x0E, 0xFF, 0x0F, 0xFF, 0xC7,
  0xF1, 0xF3, 0xE0, 0x79, 0xE0, 0x1C, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x73, 0x80, 0x79, 0xE0, 0x38, 0xF0,
  0x3C, 0x3E, 0x7C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xBF, 0x07, 0xC1, 0xE0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC1, 0xC0, 0x78, 0x3C, 0x0E, 0x03,
  0xC7, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xE0, 0x78, 0x38,
  0x07, 0x8F, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x38, 0xE0,
  0x0F, 0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x3F, 0x7E, 0x03, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0x7E, 0x3C, 0x1E, 0x78, 0x0E,
  0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0x78, 0x7E, 0x7F, 0xFE, 0x3F, 0xEE,
  0x0F, 0x9C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xF0,
  0x07, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x0E, 0x1F, 0x1F, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x78, 0xFC, 0xF8, 0x78, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF0, 0x00,
  0x18, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0,
  0x18, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0x78, 0x78, 0x0F, 0x00, 0xC0, 0x70, 0x03, 0x07, 0x00, 0x18, 0x70, 0xF8,
  0xC3, 0x0F, 0xE3, 0x38, 0xE3, 0x19, 0x8E, 0x18, 0xDC, 0x61, 0x86, 0xC7,
  0x0C, 0x36, 0x30, 0x61, 0x31, 0x83, 0x1B, 0x8C, 0x30, 0xDC, 0xE1, 0x86,
  0xE7, 0x0C, 0x26, 0x38, 0xE3, 0x39, 0xFF, 0x39, 0xC7, 0xDF, 0x86, 0x3C,
  0x78, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x38, 0x00,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xB8, 0x00, 0x79, 0xC0, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x01,
  0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0E, 0x00, 0xE1, 0xE0, 0x0E,
  0x1C, 0x00, 0xE3, 0xC0, 0x0F, 0x38, 0x00, 0x77, 0x80, 0x07, 0xF0, 0x00,
  0x70, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xF0, 0x1E, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x1E, 0x1C, 0x03, 0xC1, 0xC1, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x3C, 0x0F, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xE7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0x70, 0x07, 0xC7, 0x00,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0x3F, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xCF,
  0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xE0,
  0x0F, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x3E, 0x7E, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xE0, 0x7C,
  0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x3C, 0x00, 0x73, 0xC0,
  0x07, 0x38, 0x00, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78,
  0x01, 0xE7, 0x80, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x78, 0x70, 0x0F, 0x0F,
  0x03, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xCF, 0x00,
  0x39, 0xC0, 0x07, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0xF7, 0x01, 0xFE, 0xE0, 0x41,
  0xDC, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x39, 0xE0, 0x07,
  0x1E, 0x00, 0xE3, 0xC0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71,
  0xE0, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE3, 0xC0,
  0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE0,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC1, 0xC0, 0x3C, 0x0F,
  0x03, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0x00,
  0x3E, 0x0E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x3C,
  0x01, 0xC0, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0x0F, 0x80, 0x1E, 0x3E, 0x00,
  0x3C, 0xF8, 0x00, 0x73, 0xE0, 0x00, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xBC, 0x00, 0x3E, 0x38, 0x00, 0x78,
  0x78, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x81, 0xE0, 0x07,
  0x83, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8,
  0x76, 0x0F, 0xE1, 0xD8, 0x3F, 0x07, 0x71, 0xFC, 0x1D, 0xC7, 0x70, 0x77,
  0x3D, 0xC1, 0xDC, 0xE7, 0x0F, 0x77, 0xBC, 0x38, 0xDC, 0xE0, 0xE3, 0xE3,
  0x83, 0x8F, 0x8E, 0x0E, 0x3C, 0x38, 0x38, 0xF1, 0xE1, 0xE3, 0x87, 0x87,
  0x0E, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0x8F, 0xC0, 0x38, 0x7F, 0x01, 0xC3, 0xB8, 0x0E, 0x1D, 0xC0,
  0xF0, 0xE7, 0x07, 0x8F, 0x38, 0x3C, 0x79, 0xC1, 0xC3, 0xC7, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC7, 0x87, 0x07, 0x3C, 0x78, 0x39, 0xC3, 0xC1, 0xCE,
  0x1E, 0x07, 0x70, 0xE0, 0x3F, 0x87, 0x01, 0xFC, 0x38, 0x0F, 0xE3, 0xC0,
  0x3E, 0x1E, 0x01, 0xF0, 0xE0, 0x0F, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0, 0x1C,
  0x38, 0x03, 0x8F, 0x00, 0x79, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x79, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x3C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01,
  0xE1, 0xC0, 0x1E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x78,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x0F, 0x70, 0x01, 0xCE, 0x00, 0x79, 0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0,
  0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x10, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xC0, 0x1E, 0x1C, 0x07, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x38, 0x1C, 0x03, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00,
  0x38, 0xF0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0,
  0xF0, 0x3E, 0x1E, 0x01, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0xF0,
  0x07, 0x87, 0x80, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0E, 0x38,
  0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07,
  0x8F, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x81, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70,
  0x0E, 0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0x83, 0x80, 0x70,
  0x70, 0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x9C, 0x00, 0x77,
  0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x70, 0x7B,
  0x83, 0x83, 0x9C, 0x3C, 0x1C, 0xE1, 0xE0, 0xE7, 0x0F, 0x0F, 0x38, 0xF8,
  0x71, 0xC7, 0xC3, 0x8E, 0x3E, 0x1C, 0xF3, 0xB1, 0xC7, 0x1D, 0x8E, 0x38,
  0xEC, 0x71, 0xC6, 0x63, 0x8E, 0x73, 0x38, 0x73, 0x99, 0xC3, 0x98, 0xCE,
  0x1D, 0xC6, 0x70, 0xEE, 0x37, 0x07, 0x61, 0xB8, 0x3F, 0x0D, 0xC1, 0xF8,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x38,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0xE7, 0x80, 0x01, 0xEF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x9C, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x03, 0xC3, 0xC0,
  0x07, 0x80, 0xF0, 0x01, 0xFE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0x70, 0x1E, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x1C, 0x3C, 0x03,
  0x87, 0x00, 0x71, 0xE0, 0x0F, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x00, 0xE0, 0x70, 0x38, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x38, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x03, 0xCE, 0x0E, 0x38, 0x70, 0xE1, 0xC3,
  0x8E, 0x06, 0x78, 0x1F, 0xC0, 0x70, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0xE3, 0x87, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xC7, 0xC7, 0x80,
  0xF3, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x07, 0xFF, 0x8F,
  0xFF, 0xCF, 0x81, 0xCF, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3D,
  0xC0, 0x3E, 0xF0, 0x3E, 0x7F, 0xFF, 0x1F, 0xFB, 0x83, 0xF9, 0xE0, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xDF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xF0, 0x3C, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x8F, 0x81,
  0xE1, 0xFF, 0xF8, 0x7B, 0xFF, 0x0E, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x3E, 0x7E, 0x1E, 0x07, 0x8F, 0x00, 0xE3, 0x80, 0x3D,
  0xE0, 0x07, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x70, 0x0F, 0x1E, 0x07,
  0x83, 0xE7, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x3F, 0x9C, 0x0F, 0xFD, 0xC1,
  0xF9, 0xFC, 0x1E, 0x07, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x38,
  0x70, 0x03, 0x87, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07,
  0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x81,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xCE, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0xF9, 0xF0, 0x78, 0x1E, 0x3C, 0x03, 0x8E, 0x00, 0xE7, 0x80,
  0x3D, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x08, 0x78, 0x0F, 0x0F,
  0xDF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x1F, 0xCE, 0x07, 0xFE, 0xE0, 0xFC,
  0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x1E, 0x1C, 0x01, 0xE3, 0xC0, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x38, 0x78, 0x03, 0x87, 0x80, 0x38, 0x38, 0x07, 0x83, 0xC0, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x04, 0x00, 0xE0, 0x60, 0x1E, 0x0F, 0x07, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xCF, 0xE0, 0x7B, 0xFE, 0x0E, 0xFF, 0xE1, 0xF0, 0x3C, 0x3C,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0,
  0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x1F, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x1F, 0x01, 0xC3,
  0xE0, 0x1C, 0x7C, 0x01, 0xCF, 0x80, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07,
  0x83, 0xC0, 0x70, 0x1E, 0x07, 0x01, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1D, 0xFB, 0xF0, 0xFF, 0xFF, 0xC7, 0xDF,
  0xFE, 0x38, 0x78, 0x73, 0xC3, 0x83, 0x9C, 0x1C, 0x1C, 0xE0, 0xE0, 0xE7,
  0x07, 0x0F, 0x38, 0x78, 0x71, 0xC3, 0xC3, 0x9E, 0x1C, 0x1C, 0xE0, 0xE0,
  0xE7, 0x07, 0x07, 0x38, 0x38, 0x79, 0xC3, 0xC3, 0x8E, 0x1E, 0x1C, 0xF0,
  0xE0, 0xE7, 0x07, 0x07, 0x38, 0x38, 0x39, 0xC1, 0xC3, 0xC0, 0x0E, 0x7F,
  0x03, 0x9F, 0xF0, 0x77, 0xBF, 0x0F, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F,
  0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7E, 0x7C, 0x3E, 0x07, 0x8F, 0x00, 0xE7,
  0x80, 0x39, 0xC0, 0x0F, 0x70, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B, 0xC0, 0x1C, 0x70, 0x0F,
  0x1E, 0x07, 0x83, 0xE7, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0x7F,
  0x00, 0xEF, 0xFC, 0x0F, 0xFF, 0xC0, 0xF8, 0x1E, 0x0F, 0x01, 0xE0, 0xE0,
  0x0E, 0x0E, 0x00, 0xE1, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xC3,
  0xC0, 0x3C, 0x3E, 0x07, 0x83, 0xF9, 0xF0, 0x7F, 0xFE, 0x07, 0x9F, 0xC0,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF9, 0xE1, 0xFF,
  0xB8, 0x7E, 0x7F, 0x0F, 0x03, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x9E, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0x8F, 0x00, 0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xC3, 0x80, 0x78, 0x78, 0x1F,
  0x07, 0xCF, 0xC0, 0xFF, 0xF8, 0x07, 0xE7, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x1E, 0x7F, 0x8E, 0x7F, 0x87, 0x7F, 0xC3, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0xF9, 0xF8, 0x78, 0x1E, 0x1C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x1C, 0x78, 0x0F,
  0x1F, 0xDF, 0x83, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x38, 0x03, 0xCE,
  0x00, 0xE7, 0x80, 0x39, 0xE0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x00,
  0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x3C,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xF0, 0x3E, 0x3F,
  0xFF, 0x87, 0xFD, 0xC0, 0xFE, 0x70, 0xF0, 0x01, 0xEE, 0x00, 0x79, 0xC0,
  0x0E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x19, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x3F, 0x03, 0x83, 0x98,
  0x3C, 0x1C, 0xC1, 0xE0, 0xE6, 0x0F, 0x0E, 0x30, 0xF8, 0x71, 0x86, 0xC3,
  0x8C, 0x76, 0x38, 0x63, 0xB1, 0xC3, 0x19, 0x8C, 0x19, 0xCC, 0xE0, 0xCC,
  0x77, 0x06, 0xE3, 0xB0, 0x36, 0x1F, 0x81, 0xB0, 0xFC, 0x0F, 0x87, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x00, 0x0F,
  0x00, 0x7C, 0x1C, 0x03, 0xC0, 0x78, 0x1F, 0x00, 0xE0, 0x78, 0x03, 0xC3,
  0xC0, 0x07, 0x1E, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0x78, 0x00, 0x78, 0xE0, 0x03, 0xC1, 0xC0, 0x1E, 0x07, 0x80, 0xF0, 0x0E,
  0x07, 0xC0, 0x3C, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x00,
  0xE0, 0x3C, 0x01, 0xC0, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x08,
  0x00, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x02,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x03,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFC, 0x03, 0x7F, 0xE0, 0x3F, 0x1F, 0x07, 0xE0, 0xFD, 0xEC, 0x03, 0xFE,
  0x40, 0x1F, 0xC0, 0x00, 0x20,
};

const GFXglyph RobotoMono_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 27, 22, 7, -27 },
  { 28, 10, 9, 22, 8, -29 },
  { 40, 23, 27, 22, 0, -27 },
  { 118, 19, 35, 22, 2, -31 },
  { 202, 18, 27, 22, 2, -27 },
  { 263, 20, 27, 22, 1, -27 },
  { 331, 4, 9, 22, 10, -29 },
  { 336, 13, 40, 22, 6, -31 },
  { 401, 13, 39, 22, 3, -30 },
  { 465, 17, 18, 22, 4, -27 },
  { 504, 19, 19, 22, 2, -22 },
  { 550, 6, 10, 22, 4, -4 },
  { 558, 14, 3, 22, 4, -13 },
  { 564, 6, 5, 22, 7, -5 },
  { 568, 19, 29, 22, 2, -27 },
  { 637, 19, 27, 22, 2, -27 },
  { 702, 12, 27, 22, 5, -27 },
  { 743, 19, 27, 22, 0, -27 },
  { 808, 19, 27, 22, 1, -27 },
  { 873, 20, 27, 22, 0, -27 },
  { 941, 19, 27, 22, 3, -27 },
  { 1006, 17, 27, 22, 2, -27 },
  { 1064, 18, 27, 22, 4, -27 },
  { 1125, 19, 27, 22, 2, -27 },
  { 1190, 16, 27, 22, 4, -27 },
  { 1244, 8, 21, 22, 8, -21 },
  { 1265, 10, 27, 22, 6, -21 },
  { 1299, 17, 16, 22, 3, -20 },
  { 1333, 18, 10, 22, 2, -17 },
  { 1356, 18, 16, 22, 2, -20 },
  { 1392, 16, 27, 22, 5, -27 },
  { 1446, 21, 27, 22, 1, -27 },
  { 1517, 20, 27, 22, -1, -27 },
  { 1585, 20, 27, 22, 1, -27 },
  { 1653, 19, 27, 22, 2, -27 },
  { 1718, 20, 27, 22, 1, -27 },
  { 1786, 21, 27, 22, 1, -27 },
  { 1857, 21, 27, 22, 1, -27 },
  { 1928, 19, 27, 22, 2, -27 },
  { 1993, 21, 27, 22, 1, -27 },
  { 2064, 21, 27, 22, 1, -27 },
  { 2135, 21, 27, 22, 1, -27 },
  { 2206, 23, 27, 22, 1, -27 },
  { 2284, 16, 27, 22, 2, -27 },
  { 2338, 22, 27, 22, 1, -27 },
  { 2413, 21, 27, 22, 1, -27 },
  { 2484, 19, 27, 22, 2, -27 },
  { 2549, 21, 27, 22, 1, -27 },
  { 2620, 19, 32, 22, 2, -27 },
  { 2696, 20, 27, 22, 1, -27 },
  { 2764, 20, 27, 22, 2, -27 },
  { 2832, 20, 27, 22, 4, -27 },
  { 2900, 20, 27, 22, 2, -27 },
  { 2968, 19, 27, 22, 4, -27 },
  { 3033, 21, 27, 22, 3, -27 },
  { 3104, 23, 27, 22, 0, -27 },
  { 3182, 19, 27, 22, 4, -27 },
  { 3247, 21, 27, 22, 0, -27 },
  { 3318, 13, 37, 22, 5, -31 },
  { 3379, 9, 29, 22, 7, -27 },
  { 3412, 13, 37, 22, 5, -31 },
  { 3473, 14, 14, 22, 4, -27 },
  { 3498, 17, 3, 22, 0, 0 },
  { 3505, 6, 4, 22, 10, -27 },
  { 3508, 17, 20, 22, 2, -20 },
  { 3551, 19, 29, 22, 1, -29 },
  { 3620, 18, 21, 22, 2, -21 },
  { 3668, 20, 29, 22, 2, -29 },
  { 3741, 18, 20, 22, 2, -20 },
  { 3786, 19, 29, 22, 4, -29 },
  { 3855, 20, 29, 22, 1, -21 },
  { 3928, 19, 29, 22, 1, -29 },
  { 3997, 17, 27, 22, 2, -27 },
  { 4055, 17, 35, 22, 1, -27 },
  { 4130, 20, 29, 22, 1, -29 },
  { 4203, 17, 29, 22, 2, -29 },
  { 4265, 21, 20, 22, 0, -20 },
  { 4318, 19, 20, 22, 1, -20 },
  { 4366, 18, 21, 22, 2, -21 },
  { 4414, 20, 28, 22, 0, -20 },
  { 4484, 19, 28, 22, 2, -20 },
  { 4551, 17, 20, 22, 4, -20 },
  { 4594, 18, 20, 22, 2, -20 },
  { 4639, 16, 25, 22, 4, -25 },
  { 4689, 18, 20, 22, 3, -20 },
  { 4734, 19, 20, 22, 3, -20 },
  { 4782, 21, 20, 22, 2, -20 },
  { 4835, 22, 20, 22, 0, -20 },
  { 4890, 23, 28, 22, -1, -20 },
  { 4971, 19, 20, 22, 1, -20 },
  { 5019, 15, 37, 22, 6, -30 },
  { 5089, 8, 34, 22, 7, -27 },
  { 5123, 15, 37, 22, 3, -30 },
  { 5193, 20, 8, 22, 1, -15 },
};

const GFXfont RobotoMono_Italic38pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic38pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOMONO_ITALIC38PT7B_H_
