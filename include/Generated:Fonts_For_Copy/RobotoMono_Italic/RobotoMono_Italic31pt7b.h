#ifndef _ROBOTOMONO_ITALIC31PT7B_H_
#define _ROBOTOMONO_ITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7,
  0x00, 0x00, 0x00, 0x38, 0xE3, 0x80, 0x71, 0xB1, 0xD8, 0xCC, 0x66, 0x33,
  0x1B, 0x0C, 0x00, 0x71, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x03, 0x8C, 0x00,
  0xC3, 0x00, 0x30, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0x8E, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x86, 0x07, 0xFF, 0xF3,
  0xFF, 0xFC, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x63, 0x80, 0x30,
  0xC0, 0x0C, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x3F, 0x81, 0xFF, 0x87, 0x87, 0x0E, 0x07, 0x18, 0x0E, 0x70, 0x1C, 0xE0,
  0x39, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0xE7, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x38,
  0x78, 0x7F, 0xE0, 0x3F, 0x80, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x3E,
  0x00, 0xEE, 0x03, 0x8C, 0x06, 0x18, 0x6C, 0x31, 0x98, 0x66, 0x31, 0xDC,
  0x7F, 0x30, 0x7C, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xDF, 0x83, 0x3F, 0x0C, 0xC7, 0x39, 0x86, 0x63, 0x1D, 0x86, 0x30, 0x0C,
  0x60, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0x18, 0x0E,
  0x1C, 0x0C, 0x1C, 0x0C, 0x18, 0x0C, 0x38, 0x0E, 0x70, 0x0F, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x3D, 0x87, 0x71, 0xC7, 0x70, 0xE6, 0xE0,
  0xEE, 0xE0, 0x7E, 0xE0, 0x7C, 0xE0, 0x38, 0x70, 0xFC, 0x7F, 0xFC, 0x1F,
  0x8E, 0x77, 0x66, 0x66, 0xE0, 0x00, 0x40, 0x30, 0x3C, 0x0C, 0x07, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x20, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x02, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x41, 0x85, 0xE6, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0x80, 0x3E, 0x01, 0xDC,
  0x0E, 0x30, 0x78, 0xE0, 0xC1, 0xC2, 0x04, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x39, 0xCE, 0x77, 0x3B, 0x88, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07,
  0xF0, 0x1F, 0xF0, 0x78, 0x71, 0xC0, 0x63, 0x80, 0xE6, 0x01, 0xDC, 0x03,
  0xB8, 0x0F, 0x70, 0x7E, 0xC1, 0xDD, 0x8F, 0x37, 0x3C, 0xEF, 0xE1, 0xDF,
  0x83, 0xBC, 0x07, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC3, 0x87,
  0x83, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xC1, 0xE3, 0xF9, 0xFE, 0xF3, 0xA0,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x03, 0xF8, 0x07,
  0xFC, 0x0E, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x78, 0x71, 0xE0,
  0x73, 0x80, 0xE7, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x01, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0xE0,
  0x19, 0xC0, 0x73, 0x80, 0xE3, 0x87, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xEE, 0x00,
  0xCE, 0x01, 0xCE, 0x03, 0x8C, 0x07, 0x1C, 0x0E, 0x1C, 0x0C, 0x1C, 0x1C,
  0x1C, 0x38, 0x18, 0x70, 0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x3F,
  0xE0, 0x3F, 0xF8, 0x3C, 0x78, 0x08, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x60, 0x38, 0x70, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1E, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x77, 0xE3, 0xFF, 0xBE, 0x1F, 0xE0, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1C, 0xE1, 0xC3,
  0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xF8, 0x78, 0x70, 0xE0, 0x71, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x06,
  0x1C, 0x1C, 0x3E, 0xF0, 0x3F, 0x80, 0xFF, 0x83, 0x83, 0x8E, 0x03, 0x38,
  0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80, 0xE3, 0x87, 0x87, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x8E, 0x1C, 0xE0, 0x77, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0E, 0xE1, 0xF7, 0xFF,
  0x9F, 0xD8, 0x39, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x7F, 0x07,
  0xE0, 0x3C, 0x00, 0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x8F, 0x3C, 0xF0, 0x07, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70,
  0xE0, 0x40, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x07, 0xC0, 0x1C, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x70, 0x00, 0x40, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x40, 0x00, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x0F, 0x01, 0xF8, 0x3F, 0x83,
  0xF0, 0x3F, 0x00, 0xE0, 0x02, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x9E, 0x1C,
  0xE0, 0x7E, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0xC1, 0x81, 0x80, 0x61, 0x82, 0x11, 0x8F, 0xCC, 0xCE, 0x66, 0xC6, 0x33,
  0x66, 0x11, 0xB3, 0x18, 0xF1, 0x8C, 0x59, 0x86, 0x2C, 0xC2, 0x36, 0x63,
  0x1B, 0x33, 0x89, 0x9F, 0xFC, 0xC7, 0x3C, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x08, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xD8, 0x01, 0xD8, 0x01, 0x9C, 0x03, 0x9C,
  0x03, 0x1C, 0x07, 0x1C, 0x06, 0x0C, 0x0E, 0x0C, 0x0C, 0x0C, 0x1F, 0xFE,
  0x1F, 0xFE, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x06,
  0xE0, 0x07, 0x0F, 0xF8, 0x1F, 0xFC, 0x1C, 0x1E, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xFC, 0x30, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x60, 0x1C, 0x60, 0x3C, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x03, 0xF0,
  0x0F, 0xFC, 0x1E, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x06, 0x70, 0x07,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x1C, 0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0x38,
  0x70, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x1C, 0x7C,
  0x1C, 0x0E, 0x1C, 0x0E, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x03,
  0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E,
  0x70, 0x0E, 0x60, 0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xE1, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xC7, 0xFF,
  0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC3, 0x83, 0xC0, 0xE1, 0xC0, 0x71, 0xC0,
  0x18, 0xE0, 0x02, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x0F, 0xE6, 0x0F, 0xE7, 0x00, 0x33, 0x80, 0x38, 0xC0, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x87, 0x87, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x0E,
  0x00, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x30, 0x07, 0x0C, 0x01, 0x87, 0x00,
  0x61, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x87, 0xFF, 0xE3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70,
  0x06, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x38, 0x03,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x84, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0xE0, 0x1C,
  0x70, 0x1C, 0x38, 0x0E, 0x0F, 0x1E, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x0E,
  0x03, 0xC7, 0x01, 0xE1, 0xC0, 0xF0, 0x70, 0x78, 0x1C, 0x3C, 0x07, 0x0E,
  0x01, 0x87, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3D, 0xC0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x70,
  0x70, 0x1C, 0x0E, 0x06, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xF1, 0xE0, 0xF9, 0xF8, 0xF8, 0xFC, 0x6C, 0x76, 0x76, 0x33, 0x37, 0x19,
  0xBB, 0x8C, 0xD9, 0xCE, 0x7C, 0xC7, 0x3C, 0x63, 0x9E, 0x71, 0xC6, 0x38,
  0xC3, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x03, 0x1C, 0x03, 0x8E, 0x01,
  0xC6, 0x00, 0xE0, 0x1C, 0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x71,
  0xF0, 0x31, 0xF8, 0x38, 0xEC, 0x1C, 0x77, 0x0E, 0x3B, 0x87, 0x18, 0xC3,
  0x8C, 0x71, 0x8E, 0x39, 0xC7, 0x0C, 0xE3, 0x87, 0x71, 0xC3, 0xB8, 0xC0,
  0xDC, 0xE0, 0x7C, 0x70, 0x3E, 0x38, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC6,
  0x00, 0xC0, 0x07, 0xF0, 0x1F, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0x80, 0xEE,
  0x01, 0xDC, 0x03, 0xB0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xB0, 0x07, 0x60, 0x0E, 0xC0, 0x19, 0xC0, 0x73,
  0x81, 0xC3, 0xC7, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFF,
  0x03, 0x03, 0xC3, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x30,
  0x07, 0x18, 0x07, 0x1C, 0x03, 0x8E, 0x07, 0x87, 0xFF, 0x83, 0xFF, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F,
  0x1E, 0x1C, 0x06, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x03, 0x70, 0x03, 0x70,
  0x03, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x06, 0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x70, 0x38, 0x38, 0x70, 0x1F,
  0xE0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x08, 0x0F,
  0xF8, 0x0F, 0xFC, 0x1C, 0x1E, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x18,
  0x03, 0x18, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x3C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x70, 0x38, 0x60,
  0x38, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x03, 0xF8, 0x03, 0xFF, 0x03,
  0xC3, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x1C, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x07, 0x0F,
  0x07, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x07, 0x30, 0x06,
  0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0x60, 0x0E, 0xE0, 0x0C,
  0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x38,
  0xE0, 0x38, 0xE0, 0x70, 0x70, 0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x1C, 0x70, 0x1C, 0x70, 0x18, 0x70, 0x38,
  0x70, 0x38, 0x70, 0x70, 0x30, 0x70, 0x30, 0xE0, 0x30, 0xE0, 0x39, 0xC0,
  0x39, 0xC0, 0x39, 0x80, 0x3B, 0x80, 0x1B, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x70, 0xC1, 0xB8, 0x61, 0xDC, 0x70,
  0xEC, 0x38, 0x66, 0x1C, 0x33, 0x1F, 0x39, 0x8F, 0x9C, 0xC7, 0xCC, 0x66,
  0xE6, 0x33, 0x77, 0x19, 0xBB, 0x8D, 0xDD, 0x86, 0xCE, 0xC3, 0x67, 0xE1,
  0xF3, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E,
  0x0F, 0x07, 0x07, 0x03, 0x80, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x1C, 0x0E,
  0x03, 0x83, 0xC0, 0x70, 0x70, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x0C, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E, 0x18, 0x03, 0x83, 0x80,
  0xF0, 0x70, 0x1C, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x1E, 0x00, 0xE0, 0x07,
  0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x30, 0x38, 0x38, 0x78, 0x38, 0x70,
  0x18, 0xE0, 0x18, 0xE0, 0x1D, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC4, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x07, 0xE0, 0xF8, 0x38, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0xC1,
  0x83, 0x87, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x87, 0x06,
  0x0C, 0x18, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x87, 0x0F, 0xC3, 0xF0, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x03, 0x00,
  0xF0, 0x1E, 0x07, 0xC0, 0xD8, 0x3B, 0x06, 0x71, 0xCE, 0x70, 0xCC, 0x1B,
  0x83, 0xE0, 0x70, 0x7F, 0xFF, 0xFF, 0xF0, 0xF1, 0x8E, 0x30, 0x01, 0xC0,
  0x0F, 0xF0, 0x7F, 0xF0, 0xE0, 0xE3, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x03,
  0xFE, 0x1F, 0xFC, 0x78, 0x39, 0xC0, 0x73, 0x00, 0xE6, 0x01, 0x8E, 0x07,
  0x1C, 0x3E, 0x3F, 0xFC, 0x1F, 0xB8, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x38, 0x0D, 0xFC, 0x1F, 0xFC, 0x78,
  0x38, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0xDC, 0x03, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xCF, 0x87, 0x9F, 0xFE, 0x3B,
  0xF8, 0x00, 0x03, 0x80, 0x3F, 0xC1, 0xFF, 0x8E, 0x0F, 0x70, 0x1D, 0xC0,
  0x7E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x3B, 0x80, 0xE7, 0x0F, 0x0F, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0x8E, 0x0F, 0xEE,
  0x1F, 0xFC, 0x38, 0x3C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70,
  0x70, 0xF0, 0x7F, 0xB0, 0x3F, 0x70, 0x03, 0xC0, 0x3F, 0xC1, 0xFF, 0x8E,
  0x0E, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xC7, 0x87, 0x8F, 0xFC, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0xFF, 0x01, 0xF7, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0xFF, 0xF8, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x07, 0xF7, 0x0F, 0xFE, 0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x3C, 0x38, 0x78, 0x3F, 0xD8, 0x1F, 0xB8, 0x00, 0x38,
  0x00, 0x38, 0x40, 0x70, 0xE0, 0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x1C, 0x0C, 0xFC, 0x3B, 0xFC, 0x7C, 0x3C, 0xE0, 0x39, 0xC0, 0x73, 0x80,
  0xE6, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0x80, 0x73,
  0x00, 0xEE, 0x01, 0xDC, 0x03, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x0F, 0xF0, 0x3F, 0x80,
  0xF0, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x01, 0x18, 0x1E, 0x18, 0x3C, 0x38, 0x78, 0x38, 0xF0,
  0x39, 0xE0, 0x3B, 0x80, 0x37, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x79, 0xC0,
  0x71, 0xE0, 0x70, 0xE0, 0x60, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x3C,
  0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x86, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0x1C, 0x73, 0x8E, 0x19, 0x87, 0x1C, 0xC3, 0x8E, 0xE1, 0x87, 0x70, 0xC3,
  0xB8, 0xE1, 0x9C, 0x70, 0xCC, 0x38, 0xE6, 0x1C, 0x77, 0x0C, 0x3B, 0x86,
  0x1D, 0xC7, 0x0C, 0xC3, 0x86, 0x00, 0x00, 0x70, 0x33, 0xF0, 0xFF, 0xF1,
  0xF0, 0xF3, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x98, 0x07, 0x70, 0x0C, 0xE0,
  0x19, 0xC0, 0x73, 0x80, 0xE6, 0x01, 0xCC, 0x03, 0xB8, 0x06, 0x70, 0x0C,
  0xE0, 0x38, 0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0xE3, 0x80, 0xE6,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0x60, 0x0E, 0xC0, 0x1D, 0x80, 0x3B, 0x00,
  0x67, 0x01, 0xCE, 0x07, 0x0E, 0x1E, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x70,
  0x0D, 0xFC, 0x1F, 0xFE, 0x1E, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x30, 0x0E,
  0x38, 0x1C, 0x7C, 0x3C, 0x7F, 0xF8, 0x77, 0xF0, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1F, 0xDC,
  0xFF, 0xF1, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x19, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x1C, 0x3C,
  0x3F, 0xF8, 0x3F, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x00, 0x78, 0x77, 0xF1, 0xBF, 0xC7, 0xC0, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x3F, 0xC1, 0xFF, 0x8E, 0x07, 0x30, 0x1C, 0xC0, 0x03, 0x80, 0x0F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x0E, 0xE0, 0x3B, 0x80, 0xE7, 0x07,
  0x1F, 0xFC, 0x1F, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFC, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE1, 0x07, 0xF8, 0x1F,
  0xC0, 0x38, 0x0E, 0x60, 0x19, 0xC0, 0x33, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x9C, 0x07, 0x30, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE,
  0x07, 0x8E, 0x1E, 0x1F, 0xEC, 0x1F, 0xB8, 0xC0, 0x1F, 0xC0, 0x3B, 0x80,
  0xE3, 0x01, 0xC6, 0x07, 0x0E, 0x0C, 0x1C, 0x38, 0x18, 0x60, 0x31, 0xC0,
  0x63, 0x00, 0xEE, 0x01, 0xD8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0xC1, 0x83, 0xE0, 0xC1, 0xB0, 0xE1, 0xD8, 0x70, 0xCC, 0x6C, 0x66,
  0x36, 0x73, 0x1B, 0x31, 0x99, 0x98, 0xCC, 0xD8, 0x6C, 0x6C, 0x36, 0x36,
  0x1B, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x83, 0x80, 0xC1, 0xC0, 0x1C,
  0x03, 0xC3, 0x81, 0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x77, 0x00,
  0x38, 0xE0, 0x1E, 0x38, 0x0F, 0x07, 0x07, 0x81, 0xC3, 0xC0, 0x38, 0x38,
  0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x0C, 0x0E, 0x03, 0x83,
  0x80, 0xE1, 0xC0, 0x38, 0x70, 0x06, 0x38, 0x01, 0xCC, 0x00, 0x77, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x70, 0x0F, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x10, 0x0C, 0x30, 0xC7, 0x18,
  0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x61,
  0x8E, 0x30, 0xC3, 0x0C, 0x30, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x1F, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x08, 0x00, 0x1F, 0x00, 0x4F, 0xE0, 0x67, 0x3C, 0x19, 0x83, 0xFE, 0xE0,
  0x7F, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoMono_Italic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 22, 18, 6, -22 },
  { 18, 9, 7, 18, 6, -23 },
  { 26, 18, 22, 18, 0, -22 },
  { 76, 15, 29, 18, 2, -26 },
  { 131, 15, 22, 18, 2, -22 },
  { 173, 16, 22, 18, 1, -22 },
  { 217, 4, 7, 18, 8, -23 },
  { 221, 10, 32, 18, 5, -25 },
  { 261, 11, 32, 18, 2, -25 },
  { 305, 14, 15, 18, 3, -22 },
  { 332, 15, 16, 18, 2, -18 },
  { 362, 5, 8, 18, 3, -3 },
  { 367, 12, 3, 18, 3, -11 },
  { 372, 4, 4, 18, 6, -4 },
  { 374, 15, 24, 18, 2, -22 },
  { 419, 15, 22, 18, 2, -22 },
  { 461, 10, 22, 18, 4, -22 },
  { 489, 16, 22, 18, 0, -22 },
  { 533, 15, 22, 18, 1, -22 },
  { 575, 16, 22, 18, 0, -22 },
  { 619, 16, 22, 18, 2, -22 },
  { 663, 13, 22, 18, 2, -22 },
  { 699, 15, 22, 18, 3, -22 },
  { 741, 15, 22, 18, 2, -22 },
  { 783, 13, 22, 18, 3, -22 },
  { 819, 6, 17, 18, 7, -17 },
  { 832, 8, 22, 18, 5, -17 },
  { 854, 14, 14, 18, 2, -17 },
  { 879, 15, 8, 18, 2, -14 },
  { 894, 14, 14, 18, 2, -17 },
  { 919, 13, 22, 18, 4, -22 },
  { 955, 17, 22, 18, 1, -22 },
  { 1002, 16, 22, 18, 0, -22 },
  { 1046, 16, 22, 18, 1, -22 },
  { 1090, 16, 22, 18, 2, -22 },
  { 1134, 16, 22, 18, 1, -22 },
  { 1178, 17, 22, 18, 1, -22 },
  { 1225, 17, 22, 18, 1, -22 },
  { 1272, 17, 22, 18, 1, -22 },
  { 1319, 18, 22, 18, 0, -22 },
  { 1369, 17, 22, 18, 1, -22 },
  { 1416, 17, 22, 18, 1, -22 },
  { 1463, 18, 22, 18, 1, -22 },
  { 1513, 14, 22, 18, 1, -22 },
  { 1552, 17, 22, 18, 1, -22 },
  { 1599, 17, 22, 18, 1, -22 },
  { 1646, 15, 22, 18, 2, -22 },
  { 1688, 17, 22, 18, 1, -22 },
  { 1735, 16, 26, 18, 1, -22 },
  { 1787, 16, 22, 18, 1, -22 },
  { 1831, 17, 22, 18, 1, -22 },
  { 1878, 16, 22, 18, 3, -22 },
  { 1922, 16, 22, 18, 2, -22 },
  { 1966, 16, 22, 18, 3, -22 },
  { 2010, 17, 22, 18, 2, -22 },
  { 2057, 19, 22, 18, 0, -22 },
  { 2110, 16, 22, 18, 3, -22 },
  { 2154, 17, 22, 18, 0, -22 },
  { 2201, 11, 30, 18, 4, -25 },
  { 2243, 7, 24, 18, 6, -22 },
  { 2264, 10, 30, 18, 4, -25 },
  { 2302, 11, 12, 18, 4, -22 },
  { 2319, 14, 2, 18, 0, 0 },
  { 2323, 5, 4, 18, 8, -22 },
  { 2326, 15, 17, 18, 1, -17 },
  { 2358, 15, 23, 18, 1, -23 },
  { 2402, 14, 17, 18, 2, -17 },
  { 2432, 16, 23, 18, 2, -23 },
  { 2478, 14, 17, 18, 2, -17 },
  { 2508, 16, 24, 18, 3, -24 },
  { 2556, 16, 24, 18, 1, -17 },
  { 2604, 15, 23, 18, 1, -23 },
  { 2648, 14, 22, 18, 1, -22 },
  { 2687, 14, 29, 18, 1, -22 },
  { 2738, 16, 23, 18, 1, -23 },
  { 2784, 14, 23, 18, 1, -23 },
  { 2825, 17, 17, 18, 0, -17 },
  { 2862, 15, 17, 18, 1, -17 },
  { 2894, 15, 17, 18, 1, -17 },
  { 2926, 16, 23, 18, 0, -17 },
  { 2972, 15, 23, 18, 2, -17 },
  { 3016, 14, 17, 18, 3, -17 },
  { 3046, 14, 17, 18, 2, -17 },
  { 3076, 13, 20, 18, 3, -20 },
  { 3109, 15, 16, 18, 2, -16 },
  { 3139, 15, 16, 18, 3, -16 },
  { 3169, 17, 16, 18, 2, -16 },
  { 3203, 18, 16, 18, 0, -16 },
  { 3239, 18, 23, 18, 0, -16 },
  { 3291, 16, 16, 18, 1, -16 },
  { 3323, 12, 30, 18, 5, -24 },
  { 3368, 6, 28, 18, 6, -22 },
  { 3389, 12, 30, 18, 3, -24 },
  { 3434, 18, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_Italic31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic31pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_ITALIC31PT7B_H_
