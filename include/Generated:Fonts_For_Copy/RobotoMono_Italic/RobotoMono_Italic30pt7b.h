#ifndef _ROBOTOMONO_ITALIC30PT7B_H_
#define _ROBOTOMONO_ITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x30, 0xC7, 0x1C, 0x71, 0xC0,
  0x00, 0x00, 0x0E, 0x38, 0xE0, 0x63, 0x63, 0x63, 0x63, 0x63, 0xC6, 0xC6,
  0xC6, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC6,
  0x00, 0x61, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x03, 0x0C, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x38, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x31,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x31, 0xC0,
  0x00, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x07, 0xF8, 0x3F, 0xE1,
  0xC1, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x33, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xB8, 0x0E,
  0xE0, 0x3B, 0x81, 0xE7, 0x0F, 0x1F, 0xF8, 0x3F, 0x80, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x01, 0xF8, 0x06, 0x60, 0x30, 0xC4, 0xC3, 0x1B, 0x0C,
  0xCC, 0x67, 0x31, 0x98, 0x7C, 0xC0, 0xE7, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x19, 0xE0, 0xDF, 0xC6, 0x63, 0x39, 0x8C, 0xCC, 0x36, 0x30, 0xC0,
  0xC3, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x0E,
  0x38, 0x0C, 0x18, 0x0C, 0x38, 0x1C, 0x38, 0x0C, 0x70, 0x0F, 0xE0, 0x0F,
  0xC0, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x87, 0x79, 0xC6, 0x71, 0xCE, 0xE0,
  0xEE, 0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0x78, 0xF0, 0xF8, 0x7F, 0xFC, 0x3F,
  0x9E, 0x6D, 0xB7, 0xB6, 0x00, 0x80, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01,
  0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x80, 0x04, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x04, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x63, 0x1F, 0xED, 0xF7, 0xFF, 0x81, 0xE0,
  0x0F, 0x80, 0x76, 0x01, 0x9C, 0x0E, 0x30, 0x70, 0xE0, 0x81, 0x00, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x39, 0xCE, 0x67, 0x3B, 0x88, 0xFF, 0xFF, 0xFC, 0x6F,
  0xFF, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x1F,
  0xC0, 0xFF, 0x87, 0x07, 0x38, 0x1C, 0xC0, 0x37, 0x00, 0xDC, 0x07, 0x60,
  0x7D, 0x83, 0xF6, 0x1D, 0xF9, 0xE7, 0xEE, 0x1F, 0xF0, 0x6F, 0x01, 0xB8,
  0x0E, 0xC0, 0x3B, 0x80, 0xCE, 0x07, 0x1C, 0x38, 0x7F, 0xC0, 0x7E, 0x00,
  0x01, 0x87, 0xDF, 0xFF, 0x6C, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0x00, 0xC0, 0x07, 0xF0, 0x3F, 0xF0, 0xF0, 0x71, 0xC0, 0xE3, 0x00, 0xCE,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0x80, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x87,
  0x07, 0x38, 0x0C, 0xE0, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x7E, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0xC0, 0x3B,
  0x00, 0xEE, 0x07, 0x3C, 0x3C, 0x7F, 0xE0, 0xFE, 0x00, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x6C, 0x00, 0xCC, 0x01, 0xCC, 0x03,
  0x9C, 0x07, 0x1C, 0x06, 0x1C, 0x0C, 0x18, 0x1C, 0x18, 0x38, 0x38, 0x70,
  0x38, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x0F, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1D, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x40, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0xE1, 0xC3, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x83, 0xE0,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0xF8, 0x6F, 0xE7, 0xE7, 0xBC,
  0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03,
  0x9C, 0x38, 0x7F, 0x81, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0xE1, 0xC0, 0xC7, 0x01, 0x8E, 0x03, 0x1C,
  0x0E, 0x38, 0x1C, 0x38, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0x87, 0x0E, 0x07,
  0x38, 0x0E, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xC3, 0x87, 0x87,
  0xFE, 0x03, 0xF0, 0x00, 0x03, 0x00, 0xFF, 0x0F, 0xFC, 0xF0, 0xE7, 0x03,
  0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xE7,
  0x9F, 0x1F, 0xF8, 0x79, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x3E,
  0x07, 0xE0, 0x3C, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x8F, 0x3C, 0xE0, 0x0E, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0x40, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x06, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C,
  0x00, 0x30, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x10, 0x00, 0x70, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x1F, 0x03, 0xF0, 0x7F, 0x07,
  0xE0, 0x1E, 0x00, 0xC0, 0x00, 0x07, 0x01, 0xFC, 0x7F, 0xE7, 0x07, 0xE0,
  0x7E, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x06, 0x18, 0x03, 0x18, 0xF3,
  0x31, 0xFB, 0x23, 0x13, 0x66, 0x31, 0x66, 0x33, 0xC4, 0x33, 0xCC, 0x23,
  0xCC, 0x63, 0xCC, 0x62, 0xCC, 0xE6, 0xCF, 0xEC, 0xC7, 0x78, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x40, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x66, 0x01, 0xCC, 0x03,
  0x18, 0x0E, 0x38, 0x18, 0x70, 0x70, 0xE0, 0xC1, 0xC3, 0xFF, 0x87, 0xFF,
  0x1C, 0x06, 0x30, 0x0C, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1C, 0x0E, 0x1C, 0x06, 0x18, 0x07, 0x18, 0x07,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x3C, 0x3F, 0xF0, 0x3F, 0xF8, 0x30, 0x3C,
  0x70, 0x1C, 0x70, 0x0C, 0x70, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x3C,
  0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xFC,
  0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x38, 0x07, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x1C, 0x60, 0x1C, 0x70, 0x38, 0x38, 0x78, 0x3F, 0xF0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1C, 0x3C, 0x18, 0x0E, 0x18, 0x0E,
  0x38, 0x06, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x06,
  0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0xE0, 0x38,
  0xE0, 0x78, 0xE1, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0xFE, 0x60,
  0xFE, 0xE0, 0xFE, 0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x0C, 0x70,
  0x1C, 0x38, 0x3C, 0x1F, 0xF8, 0x0F, 0xE0, 0x0E, 0x01, 0xC3, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x1C, 0x30, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x86,
  0x00, 0xC1, 0x80, 0x30, 0xE0, 0x1C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0,
  0x70, 0x70, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x1C, 0x07, 0xC7, 0x01, 0xC1,
  0xC0, 0xE0, 0x70, 0x70, 0x18, 0x38, 0x06, 0x1C, 0x03, 0x8E, 0x00, 0xE7,
  0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xF7, 0x00, 0x79, 0xC0,
  0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x60, 0x70, 0x18, 0x0E, 0x0E,
  0x03, 0x83, 0x80, 0x70, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xC3, 0xC3, 0xE3, 0xE1, 0xB1, 0xF1, 0xF8, 0xF8, 0xDC, 0x6E, 0xEC, 0x33,
  0x66, 0x19, 0xF3, 0x1C, 0xF3, 0x8E, 0x79, 0xC7, 0x38, 0xE3, 0x1C, 0x61,
  0x8C, 0x30, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03,
  0x0C, 0x01, 0x80, 0x0E, 0x01, 0xC3, 0x80, 0x60, 0xF0, 0x38, 0x3C, 0x0E,
  0x1F, 0x03, 0x87, 0xE0, 0xE1, 0xD8, 0x30, 0x76, 0x0C, 0x19, 0xC7, 0x0E,
  0x71, 0xC3, 0x8C, 0x70, 0xE3, 0x9C, 0x38, 0xE6, 0x0C, 0x19, 0x83, 0x07,
  0xE1, 0xC1, 0xF8, 0x70, 0x3E, 0x1C, 0x0F, 0x87, 0x03, 0xC1, 0x80, 0x70,
  0xE0, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x0E, 0x1E, 0x1C,
  0x0E, 0x38, 0x06, 0x38, 0x06, 0x30, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0xE0, 0x0E, 0x60, 0x0C, 0x60,
  0x1C, 0x70, 0x18, 0x70, 0x38, 0x38, 0x70, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x1C, 0x0F, 0x1C, 0x07, 0x1C, 0x03, 0x1C, 0x03, 0x18,
  0x03, 0x18, 0x07, 0x38, 0x07, 0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x0E,
  0x0E, 0x1C, 0x0E, 0x38, 0x06, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x60, 0x07, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x70, 0x38, 0x38, 0x70, 0x3F, 0xE0, 0x0F,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x10, 0x0F, 0xF8, 0x1F,
  0xFC, 0x1C, 0x0E, 0x1C, 0x06, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07, 0x38,
  0x06, 0x38, 0x0E, 0x38, 0x3C, 0x3F, 0xF8, 0x3F, 0xE0, 0x30, 0xE0, 0x70,
  0x60, 0x70, 0x70, 0x70, 0x70, 0x60, 0x30, 0x60, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x1C, 0x00, 0xE0, 0x03, 0xF8, 0x0F, 0xFE, 0x1E, 0x0E, 0x1C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0x70, 0x1C, 0x78, 0x78, 0x3F, 0xF0, 0x0F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0,
  0x38, 0xC0, 0x30, 0xE0, 0x70, 0x70, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x73, 0x00, 0xE6, 0x03, 0x8E, 0x07, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0x60, 0xE1, 0xC0, 0xC3, 0x01, 0x8E, 0x03, 0x18, 0x07,
  0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x71, 0xC3, 0xB0, 0xE1, 0x98, 0x70, 0xCC, 0x78, 0xE6,
  0x3C, 0x63, 0x1E, 0x31, 0x9F, 0x38, 0xCD, 0x9C, 0x66, 0xCC, 0x37, 0x66,
  0x1B, 0x37, 0x0D, 0x9B, 0x86, 0xCD, 0x87, 0xC6, 0xC3, 0xE3, 0xE1, 0xF1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x00,
  0x1E, 0x01, 0xC3, 0x80, 0xE0, 0x60, 0x70, 0x1C, 0x1C, 0x07, 0x0E, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x06, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0x73, 0x00, 0x38, 0xE0,
  0x1C, 0x38, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x38, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x60, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x30, 0x70, 0x38, 0x70,
  0x38, 0xE0, 0x18, 0xC0, 0x19, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0F,
  0xC3, 0xF0, 0xFC, 0x00, 0xC3, 0x0C, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xC3,
  0x0C, 0x30, 0xE3, 0x86, 0x18, 0x61, 0xC7, 0x0C, 0x30, 0xC0, 0x0F, 0xC3,
  0xF0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xE0, 0xEC, 0x19, 0x87, 0x31, 0xC7, 0x30, 0xEE,
  0x0F, 0x81, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0xE3, 0x8C, 0x70, 0x07, 0xF0,
  0x3F, 0xE1, 0xC3, 0xCE, 0x07, 0x38, 0x1C, 0x00, 0x70, 0x3F, 0xC7, 0xFF,
  0x3E, 0x1D, 0xC0, 0x66, 0x01, 0xB8, 0x0E, 0xE0, 0x79, 0xC3, 0xE7, 0xFF,
  0x8F, 0xCE, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x7C, 0x3F, 0xF8, 0xF8, 0xF3, 0xC1, 0xCE, 0x03, 0x30,
  0x0C, 0xC0, 0x37, 0x00, 0xDC, 0x03, 0x70, 0x1D, 0xC0, 0x76, 0x01, 0x9C,
  0x0E, 0xF8, 0x73, 0xFF, 0xCE, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xC7,
  0x9C, 0x06, 0x70, 0x1F, 0x80, 0x7E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x0E, 0xE0, 0x71, 0xC3, 0xC7, 0xFE, 0x07, 0xE0, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x07, 0xEE, 0x1F, 0xFC, 0x78, 0xF9, 0xC0, 0xF3, 0x80, 0xCE, 0x01, 0x9C,
  0x07, 0x38, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x63, 0x80, 0xC7, 0x03,
  0x87, 0x0F, 0x0F, 0xFE, 0x0F, 0xDC, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xC7,
  0x9E, 0x0E, 0x70, 0x1B, 0x80, 0x6E, 0x01, 0xFF, 0xFE, 0xFF, 0xFB, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x21, 0xC1, 0xC3, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xFC, 0x0F, 0x08, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xE6, 0x1F, 0xFC, 0x78,
  0xF9, 0xC0, 0xF3, 0x80, 0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x1C,
  0xC0, 0x39, 0x80, 0x63, 0x80, 0xC7, 0x03, 0x87, 0x0F, 0x0F, 0xFE, 0x0F,
  0xDC, 0x00, 0x30, 0x00, 0xE1, 0x01, 0xC7, 0x0F, 0x07, 0xFC, 0x07, 0xF0,
  0x00, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x7C, 0x3B, 0xF8, 0xF8, 0xF3, 0xC1, 0xCE, 0x03, 0x30, 0x0C,
  0xC0, 0x37, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x76, 0x01, 0x98, 0x06,
  0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x80, 0x00, 0x20, 0x01, 0xC0, 0x07, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x01,
  0xC0, 0x0E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x3F, 0xC1, 0xF8, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x07, 0x38, 0x3C,
  0x70, 0xF0, 0xE3, 0xC1, 0xCF, 0x03, 0x3C, 0x06, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7B, 0xC0, 0xE3, 0x81, 0x83, 0x83, 0x07, 0x0E, 0x07, 0x1C, 0x0F,
  0x38, 0x0E, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x3B, 0xCF, 0x1F, 0xFF,
  0x8E, 0x3C, 0xE6, 0x1C, 0x73, 0x0C, 0x39, 0x86, 0x19, 0xC3, 0x0C, 0xE3,
  0x86, 0x71, 0xC7, 0x30, 0xE3, 0x98, 0x61, 0xCC, 0x30, 0xCE, 0x18, 0x67,
  0x1C, 0x33, 0x8E, 0x39, 0x87, 0x1C, 0x19, 0xF0, 0xEF, 0xE3, 0xE3, 0xCF,
  0x07, 0x38, 0x0C, 0xC0, 0x33, 0x00, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77,
  0x01, 0xD8, 0x06, 0x60, 0x1B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0x03, 0xE0,
  0x1F, 0xF0, 0x78, 0xF1, 0xC0, 0xE3, 0x80, 0xCE, 0x01, 0xDC, 0x03, 0xB0,
  0x07, 0x60, 0x0F, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xE7, 0x03, 0x87, 0x0E,
  0x0F, 0xF8, 0x0F, 0xE0, 0x0C, 0xF8, 0x3F, 0xF8, 0x7C, 0x78, 0xE0, 0x71,
  0xC0, 0xE3, 0x00, 0xC6, 0x01, 0x9C, 0x03, 0x38, 0x06, 0x70, 0x1C, 0xE0,
  0x39, 0x80, 0x63, 0x81, 0xCF, 0x07, 0x1F, 0xFE, 0x3B, 0xF0, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xCC,
  0x7F, 0xF3, 0xC7, 0xDC, 0x0F, 0x70, 0x1B, 0x80, 0x6E, 0x03, 0xB8, 0x0E,
  0xC0, 0x3B, 0x00, 0xEC, 0x03, 0x38, 0x0C, 0xE0, 0x71, 0xC3, 0xC7, 0xFF,
  0x0F, 0xDC, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0xF8, 0xDF, 0xCF, 0xFE, 0x7C, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xC3, 0x8C, 0x06, 0x70, 0x1D,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xB8, 0x0E,
  0xE0, 0x33, 0xC1, 0xC7, 0xFE, 0x07, 0xF0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x0F, 0xFF, 0xFF, 0xFC, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x30, 0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70,
  0x19, 0xC0, 0x66, 0x03, 0x98, 0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0x38,
  0x0C, 0xE0, 0x71, 0xC7, 0xC7, 0xFF, 0x0F, 0x9C, 0xC0, 0x1F, 0x00, 0x6E,
  0x03, 0xB8, 0x0C, 0x60, 0x71, 0x81, 0x86, 0x0E, 0x1C, 0x30, 0x31, 0xC0,
  0xC6, 0x03, 0x30, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0xC1, 0x83, 0xC1, 0x87, 0xC3, 0x86, 0xC3, 0x86, 0xC7, 0x8E, 0xC7, 0x8C,
  0xCF, 0x8C, 0xCD, 0x98, 0xCC, 0x98, 0xD8, 0x98, 0xD8, 0xF0, 0xF0, 0xF0,
  0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0x1C, 0x03, 0x87, 0x03,
  0x83, 0x83, 0x80, 0xE3, 0x80, 0x73, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xDC, 0x01, 0xCE, 0x01, 0xC3, 0x81,
  0xE1, 0xC1, 0xE0, 0x71, 0xE0, 0x1C, 0x38, 0x03, 0xC6, 0x00, 0xE1, 0xC0,
  0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x60,
  0x0E, 0x38, 0x01, 0x9C, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0E,
  0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C,
  0x18, 0x30, 0x60, 0xC3, 0x80, 0x0C, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x3C, 0x03,
  0xC0, 0x78, 0x3C, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0x1F, 0xC0,
  0xDF, 0xF0, 0x6C, 0x3C, 0xEE, 0x0F, 0xF0, 0x01, 0xE0,
};

const GFXglyph RobotoMono_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 21, 18, 6, -21 },
  { 17, 8, 8, 18, 6, -23 },
  { 25, 18, 21, 18, 0, -21 },
  { 73, 14, 28, 18, 2, -25 },
  { 122, 14, 22, 18, 2, -22 },
  { 161, 16, 22, 18, 1, -22 },
  { 205, 3, 8, 18, 8, -23 },
  { 208, 10, 31, 18, 5, -24 },
  { 247, 10, 31, 18, 2, -24 },
  { 286, 14, 14, 18, 3, -21 },
  { 311, 14, 16, 18, 2, -18 },
  { 339, 5, 8, 18, 3, -3 },
  { 344, 11, 2, 18, 3, -10 },
  { 347, 4, 4, 18, 6, -4 },
  { 349, 15, 23, 18, 2, -21 },
  { 393, 14, 22, 18, 2, -22 },
  { 432, 9, 21, 18, 4, -21 },
  { 456, 15, 22, 18, 0, -22 },
  { 498, 14, 22, 18, 1, -22 },
  { 537, 16, 21, 18, 0, -21 },
  { 579, 15, 21, 18, 2, -21 },
  { 619, 13, 21, 18, 2, -21 },
  { 654, 15, 21, 18, 3, -21 },
  { 694, 15, 22, 18, 2, -22 },
  { 736, 13, 22, 18, 3, -22 },
  { 772, 6, 17, 18, 7, -17 },
  { 785, 8, 22, 18, 5, -17 },
  { 807, 14, 13, 18, 2, -16 },
  { 830, 14, 9, 18, 2, -14 },
  { 846, 14, 13, 18, 1, -16 },
  { 869, 12, 22, 18, 4, -22 },
  { 902, 16, 21, 18, 1, -21 },
  { 944, 15, 21, 18, 0, -21 },
  { 984, 16, 21, 18, 1, -21 },
  { 1026, 16, 22, 18, 1, -22 },
  { 1070, 16, 21, 18, 1, -21 },
  { 1112, 16, 21, 18, 1, -21 },
  { 1154, 17, 21, 18, 1, -21 },
  { 1199, 16, 22, 18, 1, -22 },
  { 1243, 18, 21, 18, 0, -21 },
  { 1291, 16, 21, 18, 1, -21 },
  { 1333, 16, 21, 18, 1, -21 },
  { 1375, 18, 21, 18, 1, -21 },
  { 1423, 13, 21, 18, 1, -21 },
  { 1458, 17, 21, 18, 1, -21 },
  { 1503, 18, 21, 18, 0, -21 },
  { 1551, 16, 22, 18, 1, -22 },
  { 1595, 16, 21, 18, 1, -21 },
  { 1637, 16, 26, 18, 1, -22 },
  { 1689, 16, 21, 18, 1, -21 },
  { 1731, 16, 22, 18, 1, -22 },
  { 1775, 16, 21, 18, 3, -21 },
  { 1817, 16, 21, 18, 2, -21 },
  { 1859, 15, 21, 18, 3, -21 },
  { 1899, 17, 21, 18, 2, -21 },
  { 1944, 18, 21, 18, 0, -21 },
  { 1992, 16, 21, 18, 3, -21 },
  { 2034, 17, 21, 18, 0, -21 },
  { 2079, 10, 29, 18, 4, -24 },
  { 2116, 6, 23, 18, 6, -21 },
  { 2134, 10, 29, 18, 4, -24 },
  { 2171, 11, 11, 18, 3, -21 },
  { 2187, 14, 2, 18, 0, 0 },
  { 2191, 5, 4, 18, 8, -22 },
  { 2194, 14, 16, 18, 1, -16 },
  { 2222, 14, 23, 18, 1, -23 },
  { 2263, 14, 16, 18, 2, -16 },
  { 2291, 15, 23, 18, 2, -23 },
  { 2335, 14, 16, 18, 2, -16 },
  { 2363, 15, 23, 18, 3, -23 },
  { 2407, 15, 22, 18, 1, -16 },
  { 2449, 14, 23, 18, 1, -23 },
  { 2490, 14, 22, 18, 1, -22 },
  { 2529, 13, 28, 18, 1, -22 },
  { 2575, 15, 23, 18, 1, -23 },
  { 2619, 14, 23, 18, 1, -23 },
  { 2660, 17, 16, 18, 0, -16 },
  { 2694, 14, 16, 18, 1, -16 },
  { 2722, 15, 16, 18, 1, -16 },
  { 2752, 15, 22, 18, 0, -16 },
  { 2794, 14, 22, 18, 2, -16 },
  { 2833, 13, 16, 18, 3, -16 },
  { 2859, 14, 16, 18, 2, -16 },
  { 2887, 13, 20, 18, 3, -20 },
  { 2920, 14, 16, 18, 2, -16 },
  { 2948, 14, 16, 18, 3, -16 },
  { 2976, 16, 16, 18, 2, -16 },
  { 3008, 17, 16, 18, 0, -16 },
  { 3042, 18, 22, 18, 0, -16 },
  { 3092, 15, 16, 18, 1, -16 },
  { 3122, 11, 28, 18, 5, -23 },
  { 3161, 7, 27, 18, 5, -21 },
  { 3185, 11, 28, 18, 3, -23 },
  { 3224, 17, 6, 18, 0, -12 },
};

const GFXfont RobotoMono_Italic30pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic30pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOMONO_ITALIC30PT7B_H_
