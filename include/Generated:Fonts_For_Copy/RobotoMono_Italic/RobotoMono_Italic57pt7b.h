#ifndef _ROBOTOMONO_ITALIC57PT7B_H_
#define _ROBOTOMONO_ITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x78, 0x00, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81,
  0xEF, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7,
  0x81, 0xCE, 0x07, 0x9C, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x04, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x3F,
  0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x04, 0x3C, 0x07,
  0x01, 0xC7, 0x80, 0xF0, 0x3C, 0xF0, 0x1C, 0x0F, 0x1E, 0x03, 0x83, 0xC3,
  0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0xF1,
  0xF0, 0x1F, 0xFE, 0x3C, 0x03, 0xFF, 0x8F, 0x00, 0x3F, 0xE3, 0xC0, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x7E, 0x00, 0x1E, 0x3F, 0xF0, 0x07, 0x8F, 0xFE, 0x00, 0xF3, 0xE3,
  0xE0, 0x3C, 0x78, 0x3C, 0x0F, 0x1E, 0x03, 0xC3, 0xE3, 0xC0, 0x78, 0x78,
  0x78, 0x0F, 0x1E, 0x0F, 0x01, 0xE7, 0x81, 0xE0, 0x38, 0x70, 0x3C, 0x0F,
  0x04, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x01, 0xE3,
  0xF9, 0xF0, 0x0F, 0x3F, 0x8F, 0xC0, 0xF9, 0xF8, 0x3E, 0x07, 0xDF, 0x81,
  0xF8, 0x3E, 0xF8, 0x07, 0xE3, 0xEF, 0xC0, 0x1F, 0x1F, 0x7C, 0x00, 0xFD,
  0xF3, 0xE0, 0x03, 0xEF, 0x9F, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x7F, 0x87,
  0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x01, 0xFE, 0x07, 0xE0,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xBF, 0x01, 0xFF, 0xF8,
  0xFC, 0x07, 0xFF, 0x03, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x7C, 0xF1,
  0xE3, 0xC7, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x0F, 0x00, 0x8E, 0x03, 0xC0,
  0xE7, 0xF0, 0xE1, 0xFD, 0xFF, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xC7, 0xC0,
  0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0x80, 0x7C, 0x00, 0xC0, 0x0E, 0x00, 0x10, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F,
  0x07, 0xC1, 0xF0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0xCF, 0x80, 0x07, 0xFB, 0xE0, 0x01, 0xFF, 0x7C, 0x00,
  0xFF, 0xEF, 0x80, 0x3F, 0xFD, 0xF0, 0x1F, 0xDF, 0x3E, 0x07, 0xF3, 0xE7,
  0xC3, 0xF8, 0x7D, 0xF0, 0xFE, 0x0F, 0xBE, 0x7F, 0x01, 0xF7, 0xDF, 0xC0,
  0x3E, 0xFF, 0xE0, 0x0F, 0x9F, 0xF8, 0x01, 0xF3, 0xFE, 0x00, 0x3E, 0x7F,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xBE, 0xFE, 0x1F, 0x78, 0x1F, 0x30,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF7, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x01,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00,
  0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x0E, 0x00, 0x3E, 0x3F, 0xE0, 0x3E, 0x7F, 0xF8, 0x1F, 0x7F, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xE7, 0xF8, 0x03, 0xF3, 0xF8, 0x00,
  0xFD, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x07, 0xEF, 0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF1, 0xF0, 0x07, 0xF8, 0xFE,
  0x07, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xDE, 0x07, 0xFF, 0xDF, 0x00,
  0xFF, 0x8F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x80,
  0xF8, 0x03, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x08, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE,
  0x7F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x03, 0xF8, 0x38,
  0x3C, 0x0F, 0xF8, 0x70, 0x70, 0x7F, 0xF8, 0xE1, 0xE0, 0xF8, 0xE1, 0xC3,
  0x83, 0xC1, 0xC3, 0xCF, 0x0F, 0x03, 0x83, 0x9C, 0x1E, 0x07, 0x07, 0x38,
  0x78, 0x1C, 0x1E, 0xF0, 0xF0, 0x38, 0x39, 0xC1, 0xC0, 0x70, 0x73, 0x87,
  0x80, 0xE0, 0xE7, 0x0F, 0x03, 0xC1, 0xDE, 0x1C, 0x07, 0x03, 0xBC, 0x38,
  0x0E, 0x07, 0x78, 0x70, 0x1C, 0x1C, 0xE0, 0xE0, 0x78, 0x39, 0xC3, 0xC0,
  0xE0, 0x73, 0x83, 0x83, 0xC1, 0xC7, 0x07, 0x0F, 0x83, 0x8E, 0x0F, 0xFF,
  0x8E, 0x1C, 0x1F, 0xFF, 0xF8, 0x3C, 0x1F, 0x8F, 0xE0, 0x78, 0x3E, 0x0F,
  0x80, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x3E, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x0F, 0xE0, 0x3E, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xF0, 0x03, 0xF8,
  0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x0F,
  0xE0, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x07, 0xF8,
  0x07, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFB, 0xE0, 0x07,
  0xFF, 0x9F, 0x00, 0x7F, 0xFC, 0xF8, 0x03, 0xFF, 0xE7, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x7C,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0xE0,
  0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x7C, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00,
  0x1F, 0xC3, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xEF, 0x01, 0xF7, 0x81, 0xF7, 0x80, 0xFB, 0xC0, 0xF7, 0xC0,
  0x7D, 0xE0, 0xFB, 0xE0, 0x3C, 0xF0, 0x79, 0xF0, 0x1E, 0x78, 0x7C, 0xF0,
  0x0F, 0x3C, 0x3C, 0x78, 0x0F, 0x9F, 0x3E, 0x7C, 0x07, 0xC7, 0x9E, 0x3E,
  0x03, 0xE3, 0xDF, 0x1F, 0x01, 0xF1, 0xEF, 0x0F, 0x80, 0xF0, 0xFF, 0x87,
  0x80, 0xF8, 0x7F, 0x87, 0xC0, 0x7C, 0x3F, 0xC3, 0xE0, 0x3E, 0x1F, 0xC1,
  0xF0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0x81, 0xF0,
  0x7C, 0x07, 0xC0, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xF0, 0x38,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F,
  0x03, 0xF8, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x1F,
  0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3E,
  0x07, 0xFE, 0x00, 0x3E, 0x07, 0xFE, 0x00, 0x3E, 0x07, 0xDF, 0x00, 0x7E,
  0x07, 0xDF, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x07, 0xCF, 0x80, 0x7C,
  0x0F, 0xCF, 0x80, 0x7C, 0x0F, 0x8F, 0x80, 0x7C, 0x0F, 0x87, 0xC0, 0xFC,
  0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x00, 0xF9, 0xF0,
  0x3E, 0x00, 0xF9, 0xF0, 0x3E, 0x00, 0xFB, 0xF0, 0x3E, 0x00, 0x7F, 0xE0,
  0x3E, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0x7F, 0xE0, 0x7E, 0x00, 0x3F, 0xE0,
  0x7C, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x3F, 0xE0, 0x7C, 0x00, 0x1F, 0xC0,
  0x7C, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0x80, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x80, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x8F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x1F,
  0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x7F, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3E, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x7E, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x3E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x1F, 0x3C, 0x03, 0xE0, 0x1E, 0x3C, 0x03, 0xE0, 0x3E,
  0x3C, 0x07, 0xE0, 0x3E, 0x3C, 0x07, 0xE0, 0x3E, 0x3C, 0x07, 0xE0, 0x3C,
  0x7C, 0x0F, 0xE0, 0x7C, 0x7C, 0x0F, 0xE0, 0x7C, 0x7C, 0x0F, 0xE0, 0x7C,
  0x7C, 0x1F, 0xE0, 0x78, 0x7C, 0x1F, 0xE0, 0xF8, 0x7C, 0x1F, 0xE0, 0xF8,
  0x7C, 0x3F, 0xE0, 0xF0, 0x7C, 0x3D, 0xE1, 0xF0, 0x7C, 0x3D, 0xE1, 0xF0,
  0x7C, 0x7D, 0xE1, 0xF0, 0x7C, 0x79, 0xE1, 0xE0, 0x7C, 0x79, 0xE3, 0xE0,
  0x78, 0x79, 0xE3, 0xE0, 0x78, 0xF1, 0xE3, 0xC0, 0x78, 0xF1, 0xE3, 0xC0,
  0x78, 0xF1, 0xE7, 0xC0, 0x79, 0xE1, 0xE7, 0xC0, 0x79, 0xE1, 0xE7, 0x80,
  0x79, 0xE1, 0xE7, 0x80, 0x7B, 0xC1, 0xEF, 0x80, 0x7B, 0xC1, 0xEF, 0x80,
  0x7B, 0xC1, 0xEF, 0x00, 0x7F, 0x81, 0xEF, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x7C, 0xF8,
  0x03, 0xC7, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0,
  0x3E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xF7,
  0xC0, 0x0F, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFD, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0xF8,
  0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0x8F, 0xE0,
  0x03, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x7F, 0x8F, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xBE, 0x07, 0xFF, 0xCF, 0x80, 0xFF, 0xC3, 0xE0, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x8F, 0xF8, 0x01, 0xF7,
  0xFF, 0xC0, 0x3D, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xF0, 0x3F, 0x87, 0xFF,
  0xFF, 0xE0, 0xFB, 0xFF, 0xFC, 0x1F, 0x3F, 0xFE, 0x03, 0xE1, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0xBE,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF, 0x80,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0xF8, 0x00, 0x3F, 0xE3, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x3F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x20, 0x7E, 0x00,
  0x0E, 0x07, 0xE0, 0x03, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xE1,
  0xF0, 0x07, 0xFF, 0xE7, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBE, 0x00, 0x0F, 0xF8,
  0xF8, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x87, 0xFC, 0x01, 0xF3,
  0xFF, 0xE0, 0x3C, 0xFF, 0xFC, 0x0F, 0xBF, 0xFF, 0xC1, 0xFF, 0x01, 0xF8,
  0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x80, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x80,
  0x1F, 0x03, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0x07, 0xC3, 0xF8, 0x00, 0x7C,
  0x3F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x9F,
  0xE3, 0xF8, 0x07, 0xBF, 0xE7, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0x81, 0xF8, 0x1F, 0x0F, 0x01,
  0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1E, 0x1F, 0x01,
  0xF0, 0x1E, 0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x1E, 0x03,
  0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3C, 0x3E, 0x03,
  0xE0, 0x3C, 0x3E, 0x03, 0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0x7C, 0x3C, 0x07,
  0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x78, 0x7C, 0x07,
  0xC0, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x0F, 0x80, 0xF8, 0x78, 0x0F,
  0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x81, 0xF0, 0xF8, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x40,
  0xF0, 0x00, 0xF0, 0xFF, 0xC0, 0x1E, 0x3F, 0xFE, 0x03, 0xCF, 0xFF, 0xC0,
  0xFB, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x9F, 0xF8, 0x00, 0x79, 0xFF, 0xF0, 0x03, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xFE,
  0x03, 0xEF, 0xFF, 0xE0, 0x1F, 0x3F, 0xFE, 0x00, 0xF8, 0x7F, 0xE0, 0x07,
  0xC0, 0x30, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xFE, 0x1F, 0x01, 0xFF, 0xF9, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFB, 0xE0, 0x03, 0xFE, 0x3E, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xE1, 0xFF, 0xC1, 0xF1, 0xFF, 0xE0,
  0xFB, 0xFF, 0xF0, 0x7B, 0xFF, 0xF0, 0x7F, 0xFC, 0x78, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0x83,
  0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x08, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xF0, 0x7C,
  0x01, 0xFE, 0x0F, 0xC0, 0xFF, 0x81, 0xFF, 0xFE, 0xF0, 0x1F, 0xFF, 0xBE,
  0x01, 0xFF, 0xE7, 0xC0, 0x1F, 0xF0, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x03,
  0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xE0, 0x0F, 0x00, 0xFB, 0xC0, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x03, 0xCF,
  0x01, 0xF8, 0x0F, 0x9E, 0x03, 0xF0, 0x1E, 0x3C, 0x07, 0xE0, 0x3C, 0x78,
  0x1F, 0xC0, 0xF8, 0xF0, 0x3B, 0x81, 0xE1, 0xE0, 0xF7, 0x03, 0xC3, 0xC1,
  0xEE, 0x0F, 0x87, 0x83, 0x9C, 0x1E, 0x0F, 0x0F, 0x38, 0x3C, 0x1E, 0x1E,
  0x78, 0xF0, 0x3C, 0x78, 0xF1, 0xE0, 0x78, 0xF1, 0xE3, 0xC0, 0xF3, 0xC3,
  0xCF, 0x01, 0xE7, 0x87, 0x9E, 0x03, 0xCE, 0x0F, 0x3C, 0x07, 0xBC, 0x1E,
  0xF0, 0x0F, 0x78, 0x3D, 0xE0, 0x1E, 0xE0, 0x3B, 0x80, 0x3F, 0xC0, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x04, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x1C, 0xFF, 0xFC, 0x00, 0x79, 0xFF, 0xFC, 0x00, 0xF7, 0xE3, 0xFC, 0x03,
  0xEF, 0x01, 0xFE, 0x0F, 0xBE, 0x00, 0xFF, 0xFF, 0x78, 0x00, 0xFF, 0xFC,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoMono_Italic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 12, 41, 33, 11, -41 },
  { 63, 15, 14, 33, 12, -43 },
  { 90, 33, 41, 33, 1, -41 },
  { 260, 28, 53, 33, 3, -47 },
  { 446, 27, 42, 33, 4, -41 },
  { 588, 29, 42, 33, 2, -41 },
  { 741, 7, 14, 33, 15, -43 },
  { 754, 19, 59, 33, 9, -46 },
  { 895, 19, 59, 33, 4, -46 },
  { 1036, 26, 28, 33, 6, -41 },
  { 1127, 28, 30, 33, 3, -34 },
  { 1232, 11, 15, 33, 5, -6 },
  { 1253, 21, 4, 33, 6, -20 },
  { 1264, 8, 8, 33, 11, -7 },
  { 1272, 29, 44, 33, 3, -41 },
  { 1432, 27, 42, 33, 4, -41 },
  { 1574, 17, 41, 33, 8, -41 },
  { 1662, 29, 41, 33, 0, -41 },
  { 1811, 28, 42, 33, 1, -41 },
  { 1958, 29, 41, 33, 1, -41 },
  { 2107, 29, 42, 33, 4, -41 },
  { 2260, 25, 42, 33, 3, -41 },
  { 2392, 28, 41, 33, 5, -41 },
  { 2536, 27, 42, 33, 4, -41 },
  { 2678, 25, 41, 33, 5, -41 },
  { 2807, 13, 32, 33, 12, -31 },
  { 2859, 15, 40, 33, 9, -31 },
  { 2934, 26, 25, 33, 4, -31 },
  { 3016, 27, 16, 33, 3, -26 },
  { 3070, 26, 26, 33, 3, -31 },
  { 3155, 23, 41, 33, 8, -41 },
  { 3273, 31, 41, 33, 2, -41 },
  { 3432, 30, 41, 33, -1, -41 },
  { 3586, 30, 41, 33, 2, -41 },
  { 3740, 29, 42, 33, 3, -41 },
  { 3893, 31, 41, 33, 1, -41 },
  { 4052, 31, 41, 33, 2, -41 },
  { 4211, 31, 41, 33, 2, -41 },
  { 4370, 29, 42, 33, 3, -41 },
  { 4523, 33, 41, 33, 1, -41 },
  { 4693, 31, 41, 33, 2, -41 },
  { 4852, 30, 42, 33, 2, -41 },
  { 5010, 34, 41, 33, 2, -41 },
  { 5185, 25, 41, 33, 2, -41 },
  { 5314, 33, 41, 33, 1, -41 },
  { 5484, 32, 41, 33, 1, -41 },
  { 5648, 29, 42, 33, 3, -41 },
  { 5801, 31, 41, 33, 2, -41 },
  { 5960, 29, 48, 33, 3, -41 },
  { 6134, 30, 41, 33, 2, -41 },
  { 6288, 30, 42, 33, 2, -41 },
  { 6446, 30, 41, 33, 5, -41 },
  { 6600, 31, 42, 33, 3, -41 },
  { 6763, 29, 41, 33, 6, -41 },
  { 6912, 32, 41, 33, 4, -41 },
  { 7076, 35, 41, 33, 0, -41 },
  { 7256, 29, 41, 33, 6, -41 },
  { 7405, 31, 41, 33, 1, -41 },
  { 7564, 19, 55, 33, 8, -46 },
  { 7695, 14, 44, 33, 10, -41 },
  { 7772, 19, 55, 33, 7, -46 },
  { 7903, 21, 22, 33, 6, -41 },
  { 7961, 25, 4, 33, 1, 0 },
  { 7974, 10, 7, 33, 15, -41 },
  { 7983, 26, 32, 33, 3, -31 },
  { 8087, 27, 44, 33, 2, -43 },
  { 8236, 27, 32, 33, 3, -31 },
  { 8344, 30, 44, 33, 3, -43 },
  { 8509, 27, 32, 33, 3, -31 },
  { 8617, 29, 44, 33, 6, -44 },
  { 8777, 30, 43, 33, 1, -31 },
  { 8939, 27, 43, 33, 2, -43 },
  { 9085, 25, 41, 33, 3, -41 },
  { 9214, 26, 53, 33, 1, -41 },
  { 9387, 29, 43, 33, 2, -43 },
  { 9543, 25, 43, 33, 3, -43 },
  { 9678, 32, 31, 33, 0, -31 },
  { 9802, 27, 31, 33, 2, -31 },
  { 9907, 27, 32, 33, 3, -31 },
  { 10015, 29, 43, 33, 0, -31 },
  { 10171, 28, 43, 33, 3, -31 },
  { 10322, 25, 31, 33, 6, -31 },
  { 10419, 27, 32, 33, 3, -31 },
  { 10527, 25, 38, 33, 5, -37 },
  { 10646, 27, 31, 33, 4, -30 },
  { 10751, 28, 30, 33, 5, -30 },
  { 10856, 31, 30, 33, 4, -30 },
  { 10973, 33, 30, 33, 0, -30 },
  { 11097, 35, 42, 33, -1, -30 },
  { 11281, 28, 30, 33, 2, -30 },
  { 11386, 22, 55, 33, 9, -45 },
  { 11538, 12, 52, 33, 10, -41 },
  { 11616, 22, 54, 33, 5, -44 },
  { 11765, 31, 11, 33, 1, -22 },
};

const GFXfont RobotoMono_Italic57pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic57pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOMONO_ITALIC57PT7B_H_
