#ifndef _ROBOTOMONO_ITALIC47PT7B_H_
#define _ROBOTOMONO_ITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0xE0, 0xE3, 0x83,
  0x8E, 0x0E, 0x78, 0x79, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1,
  0xCE, 0x0E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x01, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xC1, 0xF8,
  0x1F, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x83,
  0xF0, 0x7F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1E, 0x3C,
  0x00, 0x70, 0x70, 0x23, 0xC1, 0xC0, 0xCE, 0x07, 0x07, 0xB8, 0x1C, 0x1C,
  0xE0, 0x70, 0xE3, 0x81, 0xC7, 0x8E, 0x0F, 0x3C, 0x3C, 0x78, 0xE0, 0x7F,
  0xC7, 0x00, 0xFE, 0x3C, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xF0,
  0x07, 0x3F, 0xE0, 0x38, 0xFF, 0xC1, 0xE7, 0x87, 0x07, 0x1C, 0x1C, 0x38,
  0xE0, 0x71, 0xE3, 0x81, 0xCF, 0x0E, 0x07, 0x38, 0x38, 0x1C, 0x20, 0xE0,
  0x70, 0x03, 0xC3, 0x80, 0x07, 0x9E, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0xF0,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xF7, 0xC0, 0xF1, 0xF1, 0xE0, 0x79, 0xF0, 0xF8, 0x79,
  0xF0, 0x3E, 0x3C, 0xF0, 0x0F, 0x1E, 0x78, 0x07, 0xDE, 0x3C, 0x01, 0xFF,
  0x1E, 0x00, 0xFF, 0x0F, 0x00, 0x3F, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x1F,
  0xC0, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x3C, 0x03, 0xFE,
  0x1F, 0x00, 0x7B, 0xDC, 0xE7, 0x7B, 0xDC, 0xE7, 0x38, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0x80,
  0xE0, 0x6F, 0x07, 0x0F, 0x7F, 0x33, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xF3,
  0x80, 0x0F, 0x1E, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1F, 0x03,
  0x80, 0x70, 0x04, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8,
  0x78, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x78, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00,
  0xF9, 0xE0, 0x03, 0xF7, 0xC0, 0x1F, 0xCF, 0x80, 0x7F, 0x9E, 0x01, 0xFF,
  0x3C, 0x0F, 0xDE, 0x78, 0x3E, 0x3C, 0xF1, 0xF8, 0x79, 0xE7, 0xC1, 0xF7,
  0xFF, 0x03, 0xCF, 0xFC, 0x07, 0x9F, 0xE0, 0x0F, 0x3F, 0x80, 0x1E, 0x7C,
  0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0xF8, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0x1E, 0x30,
  0x3C, 0x80, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xC0, 0xF0, 0x07, 0xC3,
  0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7,
  0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x3C, 0x00,
  0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x01, 0xF0, 0x3C,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0x83, 0xF0, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC7, 0xE0, 0x3D, 0xFF, 0x87, 0xBF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0x3E,
  0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1E, 0xF8, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xC3, 0xE1, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7E, 0x07, 0xC0, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0,
  0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x0F,
  0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79,
  0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x80, 0x1F, 0x0F,
  0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3E, 0x0F, 0x00, 0xF8, 0xF8, 0x03, 0xC7,
  0x80, 0x1E, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x78,
  0x01, 0xF3, 0xE0, 0x1F, 0x8F, 0x81, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xEE,
  0x07, 0xFC, 0xF0, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xE7, 0xC0,
  0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xDF, 0x80,
  0x3E, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x1C, 0x06, 0x06,
  0x1E, 0x1F, 0xC3, 0x8E, 0x1F, 0xF1, 0xCE, 0x1F, 0x38, 0xE7, 0x0E, 0x1C,
  0x77, 0x0E, 0x0C, 0x3B, 0x87, 0x06, 0x1D, 0xC7, 0x07, 0x0F, 0xC3, 0x83,
  0x87, 0xE3, 0x81, 0xC3, 0x71, 0xC0, 0xC1, 0xB8, 0xE0, 0xE0, 0xD8, 0x70,
  0x70, 0xEC, 0x38, 0x38, 0x76, 0x1C, 0x38, 0x33, 0x0E, 0x1C, 0x39, 0x87,
  0xBF, 0x38, 0xC3, 0xFB, 0xF8, 0x70, 0xF9, 0xF8, 0x38, 0x30, 0x38, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x18, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x78, 0x0F, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x78,
  0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0x00, 0xFC, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xE1,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x1F,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x7C,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xE7, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80,
  0xFC, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0xF0, 0x3F, 0x80, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1E,
  0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0xC7, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x3E, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x7E, 0x03, 0xC7,
  0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x27, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x03, 0xFF, 0x1E, 0x01, 0xFF, 0x9F, 0x01, 0xFF, 0xCF, 0x00,
  0xFF, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x83,
  0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x0F, 0xC3, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x7C,
  0x03, 0xC0, 0x0F, 0xC0, 0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x78,
  0x07, 0xE0, 0x07, 0x80, 0xFC, 0x00, 0x78, 0x1F, 0x80, 0x07, 0x83, 0xF0,
  0x00, 0x78, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xCF, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xDE, 0x0F, 0x70, 0x7B, 0x81, 0xEE,
  0x0E, 0xF0, 0x3D, 0xC3, 0xDE, 0x07, 0x38, 0x73, 0xC1, 0xE7, 0x9E, 0x78,
  0x3C, 0xF7, 0x8F, 0x07, 0x9E, 0xF3, 0xC0, 0xF1, 0xFC, 0x78, 0x1E, 0x3F,
  0x8F, 0x03, 0xC7, 0xE1, 0xE0, 0xF0, 0xFC, 0x3C, 0x1E, 0x1F, 0x0F, 0x03,
  0xC3, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x0F, 0x07, 0x07, 0x81, 0xE0, 0xC0,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x78, 0x1F, 0x80, 0x0F, 0x03, 0xF0, 0x01, 0xE0, 0x7E, 0x00,
  0x3C, 0x0F, 0xE0, 0x0F, 0x83, 0xFC, 0x01, 0xE0, 0x7F, 0x80, 0x3C, 0x0F,
  0x78, 0x07, 0x81, 0xEF, 0x00, 0xF0, 0x3D, 0xE0, 0x3E, 0x07, 0x9E, 0x07,
  0xC1, 0xF3, 0xC0, 0xF0, 0x3C, 0x78, 0x1E, 0x07, 0x87, 0x83, 0xC0, 0xF0,
  0xF0, 0x78, 0x1E, 0x1E, 0x1F, 0x07, 0xC1, 0xE3, 0xC0, 0xF8, 0x3C, 0x78,
  0x1E, 0x07, 0x8F, 0x03, 0xC0, 0x79, 0xE0, 0x78, 0x0F, 0x3C, 0x0F, 0x01,
  0xEF, 0x83, 0xE0, 0x1F, 0xE0, 0x78, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0x81,
  0xE0, 0x07, 0xF0, 0x3C, 0x00, 0xFE, 0x07, 0x80, 0x1F, 0xC1, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E,
  0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x7C, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xF0, 0x07, 0xE0, 0x78, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x01, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3F,
  0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x07, 0x80, 0x7E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E,
  0x00, 0x7C, 0x1E, 0x01, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x01, 0xF0, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00,
  0x3C, 0x1F, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x03, 0xCE, 0x03, 0xC0, 0xF3, 0x81, 0xF0, 0x3C, 0xE0, 0x7C,
  0x1E, 0x38, 0x1F, 0x07, 0x9E, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x79, 0xE0,
  0xFC, 0x3C, 0x78, 0x7F, 0x0F, 0x1E, 0x1D, 0xC3, 0xC7, 0x87, 0x70, 0xE1,
  0xE3, 0xDC, 0x78, 0x78, 0xE7, 0x1E, 0x1E, 0x39, 0xC7, 0x87, 0x9E, 0x71,
  0xC1, 0xE7, 0x1C, 0xF0, 0x79, 0xC7, 0x3C, 0x1E, 0xF1, 0xCF, 0x07, 0xB8,
  0x73, 0x81, 0xEE, 0x1D, 0xE0, 0x77, 0x87, 0x78, 0x1D, 0xC1, 0xDC, 0x07,
  0x70, 0x77, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x3C, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x1E,
  0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x1E, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0x9C, 0x07, 0x8E, 0x03, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xE1, 0xE0, 0x70, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x03,
  0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xF0, 0xF1,
  0xE1, 0xE1, 0xC1, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xF0, 0x7E, 0x0F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x01, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8,
  0x07, 0xF1, 0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0x7C, 0x0F, 0xF1,
  0xF0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x7F, 0x80, 0x3D, 0xFF, 0x80,
  0xF7, 0xFF, 0x81, 0xFF, 0x3F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07,
  0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x3F, 0xC3, 0xF8, 0x7F, 0xFF, 0xE0,
  0xF7, 0xFF, 0x83, 0xC3, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0xF8, 0xF8,
  0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xCF, 0x00,
  0x1F, 0x1E, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0xF8, 0x3F, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x01, 0xFE, 0x3C, 0x03, 0xFF, 0xBC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xC7, 0xFC, 0x1F, 0x01, 0xFC, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF8, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFD, 0xC0, 0x0F, 0xF3, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xF8, 0x7E, 0x0F, 0x80, 0x78, 0x7C, 0x00, 0xF1, 0xE0,
  0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x18, 0x3E, 0x00, 0xF0, 0x7C, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x0E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0x01, 0xFF, 0xEF,
  0x03, 0xFF, 0xEF, 0x07, 0xF1, 0xFF, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E,
  0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x87, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFE, 0xF0, 0x03, 0xFC, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x20, 0x03, 0xE0, 0x70, 0x03, 0xE0,
  0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x3F, 0x80, 0x3C,
  0xFF, 0xC0, 0xF7, 0xFF, 0xC1, 0xFF, 0x1F, 0x83, 0xF8, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF7,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x0F, 0x00, 0x7C, 0x1F, 0x00,
  0xF8, 0x1E, 0x01, 0xF0, 0x1E, 0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x1E, 0x1F,
  0x80, 0x1E, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03,
  0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0x7E, 0x3F, 0x03, 0xBF, 0xDF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x7E, 0x7F, 0x9F, 0x1F, 0x0F, 0x83, 0xC7, 0x83, 0xE0, 0xF1, 0xE0,
  0xF0, 0x3C, 0x78, 0x3C, 0x0F, 0x1C, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF3,
  0xC0, 0xF0, 0x78, 0xF0, 0x3C, 0x1E, 0x3C, 0x1E, 0x07, 0x8F, 0x07, 0x81,
  0xE7, 0x81, 0xE0, 0x79, 0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x0F, 0x1E, 0x07,
  0x83, 0xC7, 0x83, 0xC0, 0xF1, 0xE0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x3C,
  0x0F, 0x03, 0xCF, 0x03, 0xC1, 0xE3, 0xC0, 0xF0, 0x78, 0xF0, 0x78, 0x1E,
  0x00, 0x07, 0x0F, 0xE0, 0x0E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0x7F, 0xC7,
  0xE0, 0xFE, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1,
  0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0xF8, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0x0F,
  0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E,
  0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0x83, 0xC0,
  0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xCF, 0xF0, 0x03, 0x9F, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x1E, 0x00,
  0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3D, 0xFF, 0xE0, 0x3C, 0x7F, 0x80, 0x7C, 0x08, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x3C, 0x0F, 0xFE, 0xF0, 0xFF, 0xFF, 0xC7, 0xF0, 0xFF,
  0x1F, 0x00, 0xFC, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xF3,
  0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0x78, 0x07, 0xE1, 0xF8,
  0x7F, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xF3, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x0F, 0xF8, 0x79, 0xFF, 0x83, 0xDF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0x87, 0xE1, 0xF0, 0x0F, 0x8F, 0x00, 0x3C,
  0xF8, 0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x03,
  0xEF, 0x80, 0x3E, 0x3F, 0x03, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF4, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC3, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF,
  0x80, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0xF0,
  0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x07,
  0xE1, 0xF0, 0x7F, 0x83, 0xFF, 0xDE, 0x0F, 0xFE, 0x70, 0x0F, 0xE3, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x79, 0xE0, 0x01, 0xF3,
  0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xE0,
  0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x03, 0xFC, 0x07, 0x01, 0xEF, 0x03, 0xC0,
  0x7B, 0xC0, 0xF0, 0x1C, 0xF0, 0x3C, 0x0F, 0x3C, 0x1F, 0x03, 0x8F, 0x07,
  0xC0, 0xE3, 0xC3, 0xB8, 0x78, 0xF0, 0xEE, 0x1C, 0x3C, 0x7B, 0x87, 0x0F,
  0x1C, 0xE3, 0xC3, 0xC7, 0x38, 0xE0, 0xF3, 0x8E, 0x38, 0x3C, 0xE3, 0x9C,
  0x0F, 0x78, 0xE7, 0x01, 0xDC, 0x3B, 0xC0, 0x77, 0x0E, 0xE0, 0x1F, 0x83,
  0xB8, 0x07, 0xE0, 0xFE, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x00,
  0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x01, 0xE0, 0xFC, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x78, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x04, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x01,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x77,
  0xFF, 0xC0, 0x39, 0xF3, 0xF8, 0x1E, 0xF0, 0x3F, 0x0F, 0xB8, 0x07, 0xFF,
  0xCE, 0x00, 0xFF, 0xE0, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
};

const GFXglyph RobotoMono_Italic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 10, 33, 28, 9, -33 },
  { 43, 14, 11, 28, 9, -35 },
  { 63, 27, 33, 28, 1, -33 },
  { 175, 23, 44, 28, 3, -39 },
  { 302, 22, 35, 28, 3, -34 },
  { 399, 25, 34, 28, 1, -34 },
  { 506, 5, 11, 28, 13, -35 },
  { 513, 16, 49, 28, 7, -38 },
  { 611, 15, 49, 28, 4, -38 },
  { 703, 21, 22, 28, 5, -33 },
  { 761, 23, 25, 28, 3, -28 },
  { 833, 9, 13, 28, 4, -5 },
  { 848, 17, 3, 28, 5, -16 },
  { 855, 7, 6, 28, 9, -6 },
  { 861, 23, 36, 28, 3, -33 },
  { 965, 23, 35, 28, 3, -34 },
  { 1066, 15, 33, 28, 6, -33 },
  { 1128, 24, 34, 28, 0, -34 },
  { 1230, 23, 35, 28, 1, -34 },
  { 1331, 24, 33, 28, 1, -33 },
  { 1430, 24, 34, 28, 3, -33 },
  { 1532, 20, 34, 28, 3, -33 },
  { 1617, 24, 33, 28, 4, -33 },
  { 1716, 23, 35, 28, 3, -34 },
  { 1817, 21, 34, 28, 4, -34 },
  { 1907, 10, 26, 28, 10, -26 },
  { 1940, 13, 34, 28, 7, -26 },
  { 1996, 21, 20, 28, 4, -25 },
  { 2049, 22, 14, 28, 3, -22 },
  { 2088, 22, 21, 28, 2, -25 },
  { 2146, 20, 34, 28, 6, -34 },
  { 2231, 25, 34, 28, 2, -34 },
  { 2338, 25, 33, 28, -1, -33 },
  { 2442, 25, 33, 28, 1, -33 },
  { 2546, 25, 35, 28, 2, -34 },
  { 2656, 25, 33, 28, 1, -33 },
  { 2760, 25, 33, 28, 2, -33 },
  { 2864, 26, 33, 28, 2, -33 },
  { 2972, 25, 35, 28, 2, -34 },
  { 3082, 27, 33, 28, 1, -33 },
  { 3194, 26, 33, 28, 1, -33 },
  { 3302, 26, 34, 28, 1, -33 },
  { 3413, 28, 33, 28, 1, -33 },
  { 3529, 21, 33, 28, 2, -33 },
  { 3616, 27, 33, 28, 1, -33 },
  { 3728, 27, 33, 28, 1, -33 },
  { 3840, 24, 35, 28, 2, -34 },
  { 3945, 25, 33, 28, 2, -33 },
  { 4049, 24, 40, 28, 2, -34 },
  { 4169, 24, 33, 28, 2, -33 },
  { 4268, 25, 35, 28, 2, -34 },
  { 4378, 25, 33, 28, 4, -33 },
  { 4482, 26, 34, 28, 2, -33 },
  { 4593, 24, 33, 28, 5, -33 },
  { 4692, 26, 33, 28, 3, -33 },
  { 4800, 29, 33, 28, 0, -33 },
  { 4920, 24, 33, 28, 5, -33 },
  { 5019, 26, 33, 28, 0, -33 },
  { 5127, 16, 45, 28, 6, -38 },
  { 5217, 10, 36, 28, 9, -33 },
  { 5262, 16, 45, 28, 6, -38 },
  { 5352, 17, 17, 28, 5, -33 },
  { 5389, 22, 3, 28, 0, 0 },
  { 5398, 7, 6, 28, 13, -34 },
  { 5404, 22, 25, 28, 2, -25 },
  { 5473, 23, 36, 28, 1, -35 },
  { 5577, 22, 26, 28, 3, -25 },
  { 5649, 24, 35, 28, 3, -35 },
  { 5754, 22, 26, 28, 2, -25 },
  { 5826, 24, 36, 28, 5, -36 },
  { 5934, 24, 35, 28, 1, -25 },
  { 6039, 23, 35, 28, 1, -35 },
  { 6140, 21, 34, 28, 2, -34 },
  { 6230, 21, 44, 28, 1, -34 },
  { 6346, 24, 35, 28, 2, -35 },
  { 6451, 21, 35, 28, 2, -35 },
  { 6543, 26, 25, 28, 0, -25 },
  { 6625, 23, 25, 28, 1, -25 },
  { 6697, 23, 26, 28, 2, -25 },
  { 6772, 24, 35, 28, 0, -25 },
  { 6877, 22, 35, 28, 3, -25 },
  { 6974, 21, 25, 28, 5, -25 },
  { 7040, 21, 26, 28, 3, -25 },
  { 7109, 21, 31, 28, 4, -31 },
  { 7191, 22, 26, 28, 3, -25 },
  { 7263, 23, 25, 28, 4, -25 },
  { 7335, 26, 25, 28, 3, -25 },
  { 7417, 27, 25, 28, 0, -25 },
  { 7502, 29, 35, 28, -1, -25 },
  { 7629, 24, 25, 28, 1, -25 },
  { 7704, 18, 45, 28, 7, -37 },
  { 7806, 10, 42, 28, 8, -33 },
  { 7859, 18, 45, 28, 4, -37 },
  { 7961, 26, 9, 28, 1, -18 },
};

const GFXfont RobotoMono_Italic47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic47pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_ITALIC47PT7B_H_
