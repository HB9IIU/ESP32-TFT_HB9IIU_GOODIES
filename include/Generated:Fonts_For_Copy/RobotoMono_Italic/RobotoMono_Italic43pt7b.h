#ifndef _ROBOTOMONO_ITALIC43PT7B_H_
#define _ROBOTOMONO_ITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x87, 0xC1, 0xC0,
  0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C,
  0xE1, 0xCC, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0,
  0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0xF8, 0x3E, 0x0F, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0xCE, 0x0E, 0x0E, 0xE0, 0xE1, 0xCE,
  0x0E, 0x38, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0xF3, 0xCE, 0x07, 0xF8, 0xE0,
  0x3F, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC7, 0xC0, 0x39, 0xFE, 0x07, 0x3F, 0xE0, 0xF3,
  0x87, 0x0E, 0x70, 0x71, 0xC7, 0x07, 0x3C, 0x70, 0x73, 0x87, 0x07, 0x10,
  0x70, 0x70, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0x8F, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0xF0, 0x07,
  0x81, 0xE0, 0x07, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x3C, 0xF8, 0xF0, 0x71, 0xE1, 0xE0, 0xE7, 0x81, 0xE3,
  0xCF, 0x03, 0xE7, 0x1C, 0x03, 0xDE, 0x78, 0x03, 0xF8, 0xF0, 0x07, 0xF0,
  0xE0, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xDE, 0x03, 0xFE, 0x1E, 0x00, 0x77, 0x77, 0xFE, 0xEE, 0xEC, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0x80, 0x02, 0x00, 0x01, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x10, 0x38, 0x0B,
  0x87, 0x0F, 0xFC, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0xF1, 0xC0, 0x3E, 0x3C, 0x0F,
  0x87, 0x81, 0xE0, 0x78, 0x18, 0x0E, 0x01, 0x00, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0xF0, 0x60, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x11, 0xF7, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7C, 0x3E, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x07,
  0x3C, 0x00, 0x73, 0x80, 0x07, 0x78, 0x01, 0xF7, 0x80, 0x3F, 0x78, 0x0F,
  0xF7, 0x81, 0xFF, 0x70, 0x7E, 0xFF, 0x0F, 0x8F, 0xF3, 0xF0, 0xFF, 0x7C,
  0x0E, 0xFF, 0x81, 0xEF, 0xE0, 0x1E, 0xFC, 0x01, 0xEF, 0x00, 0x1E, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x87,
  0x81, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x08,
  0x03, 0xC0, 0x7C, 0x1F, 0xE7, 0xFF, 0x7F, 0xFB, 0xF3, 0xDC, 0x1E, 0x80,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x7E,
  0x07, 0xC0, 0x78, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xC3, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x1E,
  0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00,
  0x3C, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x3C, 0x78, 0x01, 0xE1,
  0xE0, 0x0F, 0x07, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x70, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x78, 0x03, 0x87, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x9F, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x3F, 0x03, 0xDF, 0xF0,
  0x77, 0xFF, 0x0F, 0xE1, 0xF3, 0xF0, 0x1F, 0x7C, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x07, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xC7, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03,
  0xC0, 0xF0, 0x3E, 0x07, 0xE7, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x01, 0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x3E, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xC7,
  0xC3, 0xE0, 0x7C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0F, 0x70, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xBC, 0x00, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F, 0xC7, 0xEF, 0xF8, 0xFF, 0xEE,
  0x0F, 0xF9, 0xC0, 0x7C, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x02, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x01, 0xF0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0x00,
  0x80, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x18, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xCF, 0xE7, 0xE7, 0x80, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x0E,
  0x07, 0x00, 0x0E, 0x0E, 0x0F, 0x86, 0x1C, 0x3F, 0xC6, 0x1C, 0x78, 0xC6,
  0x18, 0x70, 0xC7, 0x38, 0xE1, 0xC7, 0x30, 0xC1, 0x87, 0x71, 0xC1, 0x86,
  0x71, 0xC1, 0x86, 0x61, 0x83, 0x86, 0x63, 0x83, 0x86, 0x63, 0x83, 0x06,
  0xE3, 0x83, 0x0C, 0xE3, 0x87, 0x0C, 0xE3, 0x8F, 0x1C, 0xE3, 0xFF, 0x38,
  0x61, 0xFB, 0xF0, 0x61, 0xF3, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x02, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x38, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0x1E,
  0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x01, 0xCF, 0x00, 0x03, 0xBE, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x07, 0xC0,
  0xF0, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE0, 0xE0, 0x0F, 0x83, 0xFD,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x38, 0x03,
  0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE1,
  0xE0, 0x0F, 0xC3, 0xC0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x01,
  0xF8, 0x7C, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x70, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x70, 0x1F, 0x81, 0xE0, 0x0F, 0x03, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x38, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0x78, 0x01, 0xF0, 0xF0, 0x07, 0xC1, 0xE0, 0x3F, 0x03, 0x81,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFC, 0x7E, 0x07, 0x80,
  0x78, 0x3C, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x1F, 0xFB, 0xC0, 0x7F,
  0xEF, 0x01, 0xFF, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xC0, 0x01, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x07, 0xC1,
  0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x78, 0x01,
  0xF0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0x70,
  0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x00,
  0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0E, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF,
  0x80, 0x03, 0xF1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01,
  0xF0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3B, 0x81, 0xF8, 0x1D, 0xC1, 0xFC, 0x0E,
  0xE0, 0xEE, 0x07, 0x70, 0xF7, 0x07, 0xB8, 0x77, 0x83, 0xDC, 0x7B, 0xC1,
  0xEE, 0x39, 0xC0, 0xE7, 0xBC, 0xE0, 0x71, 0xFC, 0x70, 0x38, 0xFE, 0x78,
  0x3C, 0x7E, 0x3C, 0x1E, 0x3E, 0x1E, 0x0F, 0x1F, 0x0E, 0x07, 0x8F, 0x07,
  0x03, 0x87, 0x87, 0x83, 0xC1, 0x83, 0xC1, 0xE0, 0xC1, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0xC0, 0x0F, 0x0F,
  0xC0, 0x0F, 0x0F, 0xC0, 0x0E, 0x0F, 0xE0, 0x1E, 0x0F, 0xE0, 0x1E, 0x0F,
  0xE0, 0x1E, 0x1E, 0xF0, 0x1E, 0x1E, 0xF0, 0x1E, 0x1E, 0x70, 0x3C, 0x1E,
  0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1C, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x3C, 0x1C, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x38,
  0x0E, 0x78, 0x78, 0x0F, 0x78, 0x78, 0x0F, 0x70, 0x78, 0x07, 0xF0, 0x78,
  0x07, 0xF0, 0x78, 0x07, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x03, 0xF0, 0xF0,
  0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0x80, 0xF0, 0x3C, 0x01,
  0xE1, 0xE0, 0x07, 0x87, 0x80, 0x0E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0x83,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF0, 0x07,
  0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x87, 0x00, 0x3E, 0x1E, 0x07, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFD, 0xFC, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0x70, 0x01,
  0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x78, 0x07, 0xC0, 0xF0, 0x07,
  0x81, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x87,
  0x80, 0x3E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFC, 0x7E,
  0x0F, 0x80, 0x78, 0x3C, 0x01, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xE0, 0x07,
  0xC7, 0x80, 0x3E, 0x1F, 0x81, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x0E,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00,
  0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x07, 0x81,
  0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x07, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00,
  0x78, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x07, 0x80, 0x1C,
  0x1E, 0x00, 0x70, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x1C, 0x0F, 0x78, 0x1C, 0x0F, 0x78,
  0x3C, 0x0E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78,
  0x7C, 0x1C, 0x70, 0x7C, 0x3C, 0x70, 0xFC, 0x3C, 0x70, 0xFC, 0x38, 0x70,
  0xFC, 0x38, 0x71, 0xCC, 0x78, 0x71, 0xCC, 0x78, 0x71, 0xCC, 0x70, 0x73,
  0x8C, 0x70, 0x73, 0x8C, 0xF0, 0x73, 0x8C, 0xF0, 0x77, 0x0C, 0xE0, 0x77,
  0x0C, 0xE0, 0x77, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x3E,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x38,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8, 0x0E, 0x01, 0xE0, 0x1E, 0x07,
  0x80, 0x3C, 0x1F, 0x00, 0x38, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0x80, 0x01, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x08, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x07, 0x3C,
  0x0F, 0x1C, 0x1E, 0x1C, 0x1E, 0x1C, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x0E,
  0x70, 0x0E, 0xF0, 0x0F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0xF8, 0x78, 0xF0, 0xF0, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xC0, 0xF8, 0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x0F, 0xCF, 0x81, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xBC,
  0x1F, 0xE3, 0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0xFC, 0x03, 0xDF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE,
  0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9F,
  0x00, 0x78, 0xF8, 0x07, 0xC7, 0xE0, 0x7C, 0x3F, 0xFF, 0xC1, 0xCF, 0xFC,
  0x1E, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xC3,
  0xE3, 0xE0, 0x1E, 0x78, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x1E,
  0x3E, 0x0F, 0x83, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x01, 0xF8, 0xF0, 0x0F, 0xFD, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x3F, 0x83,
  0xE0, 0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x00,
  0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x03,
  0x81, 0xE0, 0x0F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xFE, 0xF0, 0x07, 0xF9, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFC, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3,
  0xC0, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x08, 0x7C, 0x01, 0xC3, 0xE0, 0x7E, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0x83, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFE, 0x1C, 0x07, 0xFE, 0xF0, 0x3F, 0xFF, 0xC1, 0xF8, 0x7F, 0x0F, 0x80,
  0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0,
  0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x07,
  0x83, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xF7, 0x80,
  0x7F, 0x9C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x06, 0x00,
  0x78, 0x3C, 0x03, 0xE0, 0xFC, 0x3F, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0xFE, 0x03, 0xCF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE,
  0x1F, 0x07, 0xC0, 0x7C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00,
  0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x07,
  0x9E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x3C, 0x03, 0xE0,
  0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xC0, 0xF8, 0x07, 0x83, 0xE0, 0x0F,
  0x0F, 0x80, 0x1E, 0x7E, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xCF, 0x00, 0x1F, 0x1F,
  0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x7C, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF8, 0x78, 0x00, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x7C, 0x7C, 0x1F, 0xFE, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0x1F, 0x8F, 0x1E, 0x1F, 0x0F, 0x1C, 0x1E, 0x0F, 0x1C, 0x1E,
  0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0E, 0x3C, 0x1C, 0x0E, 0x38, 0x1C,
  0x0E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C,
  0x1C, 0x78, 0x38, 0x1C, 0x70, 0x38, 0x3C, 0x70, 0x78, 0x3C, 0xF0, 0x78,
  0x3C, 0xF0, 0x78, 0x3C, 0xF0, 0x78, 0x38, 0xF0, 0x70, 0x38, 0xE0, 0x70,
  0x78, 0x0F, 0x1F, 0xC0, 0x73, 0xFF, 0x03, 0xBF, 0xFC, 0x1F, 0xC3, 0xE0,
  0xF8, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF3, 0xC0,
  0x07, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x07,
  0xC1, 0xF0, 0x1E, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0x73, 0xC0, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0,
  0x1E, 0x1E, 0x01, 0xF0, 0x78, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0x9F, 0xC0, 0x1E, 0xFF, 0x80, 0x77, 0xFF, 0x01,
  0xFC, 0x7E, 0x07, 0xC0, 0x78, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0x8F, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x38, 0x1F, 0xFB,
  0xC1, 0xFF, 0xFE, 0x1F, 0x07, 0xF1, 0xF0, 0x1F, 0x1F, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38,
  0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00,
  0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0x78, 0x1F, 0x83,
  0xFF, 0xFC, 0x0F, 0xFD, 0xE0, 0x3F, 0xCE, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x1F, 0xE3, 0xCF, 0xF8,
  0x7B, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xC3, 0xE3,
  0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0xE0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x7C,
  0x07, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x81, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x00, 0x3C, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00,
  0x78, 0xF0, 0x0F, 0x87, 0x83, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0x78, 0x1F,
  0xC7, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x03,
  0xC7, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x38,
  0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x01, 0xC3, 0xC0,
  0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x77,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x3F, 0x81, 0xE0, 0x77,
  0x03, 0xC0, 0xEE, 0x0F, 0x83, 0x9C, 0x1F, 0x07, 0x38, 0x3E, 0x1E, 0x70,
  0xFC, 0x38, 0xE1, 0xF8, 0x71, 0xC7, 0x71, 0xE3, 0x8E, 0x63, 0x87, 0x38,
  0xC7, 0x0E, 0x71, 0x9C, 0x1C, 0xE3, 0x38, 0x3B, 0x87, 0x70, 0x77, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x1E,
  0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xC7, 0x80, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x3C,
  0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x7C, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xE0, 0x00, 0x10, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x0D, 0xFF, 0xC0,
  0x3B, 0xFF, 0xC0, 0x7F, 0x07, 0xC1, 0xFC, 0x07, 0xFF, 0xB8, 0x07, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0,
};

const GFXglyph RobotoMono_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 31, 25, 8, -31 },
  { 36, 12, 10, 25, 9, -32 },
  { 51, 25, 31, 25, 1, -31 },
  { 148, 22, 40, 25, 2, -36 },
  { 258, 20, 31, 25, 3, -31 },
  { 336, 23, 31, 25, 1, -31 },
  { 426, 4, 10, 25, 12, -32 },
  { 431, 14, 45, 25, 7, -35 },
  { 510, 15, 45, 25, 3, -35 },
  { 595, 19, 21, 25, 5, -31 },
  { 645, 21, 22, 25, 2, -25 },
  { 703, 8, 12, 25, 4, -5 },
  { 715, 16, 3, 25, 4, -15 },
  { 721, 6, 6, 25, 8, -6 },
  { 726, 22, 34, 25, 2, -31 },
  { 820, 20, 31, 25, 3, -31 },
  { 898, 13, 31, 25, 6, -31 },
  { 949, 22, 31, 25, 0, -31 },
  { 1035, 21, 31, 25, 1, -31 },
  { 1117, 22, 31, 25, 1, -31 },
  { 1203, 22, 31, 25, 3, -31 },
  { 1289, 19, 31, 25, 2, -31 },
  { 1363, 21, 31, 25, 4, -31 },
  { 1445, 21, 31, 25, 3, -31 },
  { 1527, 19, 31, 25, 4, -31 },
  { 1601, 10, 24, 25, 9, -24 },
  { 1631, 11, 31, 25, 7, -24 },
  { 1674, 20, 19, 25, 3, -23 },
  { 1722, 20, 12, 25, 3, -20 },
  { 1752, 20, 19, 25, 2, -23 },
  { 1800, 17, 31, 25, 6, -31 },
  { 1866, 24, 31, 25, 1, -31 },
  { 1959, 23, 31, 25, -1, -31 },
  { 2049, 23, 31, 25, 1, -31 },
  { 2139, 22, 31, 25, 2, -31 },
  { 2225, 23, 31, 25, 1, -31 },
  { 2315, 23, 31, 25, 2, -31 },
  { 2405, 23, 31, 25, 2, -31 },
  { 2495, 22, 32, 25, 2, -31 },
  { 2583, 24, 31, 25, 1, -31 },
  { 2676, 24, 31, 25, 1, -31 },
  { 2769, 23, 31, 25, 1, -31 },
  { 2859, 26, 31, 25, 1, -31 },
  { 2960, 19, 31, 25, 2, -31 },
  { 3034, 25, 31, 25, 1, -31 },
  { 3131, 24, 31, 25, 1, -31 },
  { 3224, 22, 31, 25, 2, -31 },
  { 3310, 23, 31, 25, 2, -31 },
  { 3400, 22, 36, 25, 2, -31 },
  { 3499, 23, 31, 25, 1, -31 },
  { 3589, 22, 31, 25, 2, -31 },
  { 3675, 23, 31, 25, 4, -31 },
  { 3765, 23, 31, 25, 2, -31 },
  { 3855, 22, 31, 25, 4, -31 },
  { 3941, 24, 31, 25, 3, -31 },
  { 4034, 27, 31, 25, 0, -31 },
  { 4139, 23, 31, 25, 4, -31 },
  { 4229, 24, 31, 25, 0, -31 },
  { 4322, 14, 42, 25, 6, -35 },
  { 4396, 10, 34, 25, 8, -31 },
  { 4439, 15, 42, 25, 5, -35 },
  { 4518, 16, 17, 25, 5, -31 },
  { 4552, 20, 3, 25, 0, 0 },
  { 4560, 7, 5, 25, 11, -31 },
  { 4565, 20, 23, 25, 2, -23 },
  { 4623, 21, 32, 25, 1, -32 },
  { 4707, 19, 23, 25, 3, -23 },
  { 4762, 23, 32, 25, 2, -32 },
  { 4854, 20, 23, 25, 2, -23 },
  { 4912, 22, 33, 25, 4, -33 },
  { 5003, 22, 32, 25, 1, -23 },
  { 5091, 21, 32, 25, 1, -32 },
  { 5175, 19, 31, 25, 2, -31 },
  { 5249, 19, 40, 25, 1, -31 },
  { 5344, 23, 32, 25, 1, -32 },
  { 5436, 19, 32, 25, 2, -32 },
  { 5512, 24, 23, 25, 0, -23 },
  { 5581, 21, 23, 25, 1, -23 },
  { 5642, 21, 23, 25, 2, -23 },
  { 5703, 22, 32, 25, 0, -23 },
  { 5791, 21, 32, 25, 2, -23 },
  { 5875, 19, 23, 25, 5, -23 },
  { 5930, 19, 23, 25, 3, -23 },
  { 5985, 19, 28, 25, 4, -28 },
  { 6052, 20, 23, 25, 3, -23 },
  { 6110, 21, 23, 25, 4, -23 },
  { 6171, 23, 23, 25, 3, -23 },
  { 6238, 25, 23, 25, 0, -23 },
  { 6310, 26, 32, 25, -1, -23 },
  { 6414, 22, 23, 25, 1, -23 },
  { 6478, 17, 42, 25, 6, -34 },
  { 6568, 9, 39, 25, 8, -31 },
  { 6612, 17, 41, 25, 4, -33 },
  { 6700, 23, 9, 25, 1, -17 },
};

const GFXfont RobotoMono_Italic43pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic43pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOMONO_ITALIC43PT7B_H_
