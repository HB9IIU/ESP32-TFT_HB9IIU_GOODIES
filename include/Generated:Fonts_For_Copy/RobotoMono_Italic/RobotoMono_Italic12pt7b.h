#ifndef _ROBOTOMONO_ITALIC12PT7B_H_
#define _ROBOTOMONO_ITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x80, 0xC0, 0x55, 0xA0, 0x0A, 0x24, 0x53, 0xF2, 0x85,
  0x3F, 0x28, 0x50, 0x10, 0xC4, 0x93, 0x41, 0xC1, 0xA2, 0x8B, 0xC4, 0x00,
  0x45, 0x6B, 0xA2, 0x1D, 0xB5, 0x18, 0x18, 0x48, 0x91, 0x43, 0x0A, 0x73,
  0x66, 0x74, 0x68, 0x12, 0x64, 0x48, 0x88, 0x88, 0x84, 0x40, 0x42, 0x11,
  0x11, 0x11, 0x22, 0x44, 0x80, 0x10, 0x4D, 0xCC, 0x31, 0x60, 0x30, 0x8F,
  0xFE, 0x20, 0x80, 0x58, 0xF8, 0x70, 0x04, 0x20, 0x84, 0x10, 0x84, 0x10,
  0x82, 0x00, 0x31, 0x28, 0xA3, 0xBB, 0x28, 0xA2, 0xF0, 0x3E, 0x92, 0x92,
  0x40, 0x19, 0x94, 0x41, 0x08, 0x42, 0x10, 0xFC, 0x18, 0x94, 0x41, 0x38,
  0x20, 0x62, 0x78, 0x04, 0x31, 0x45, 0x29, 0x2F, 0xC2, 0x08, 0x3D, 0xF4,
  0x1C, 0xD8, 0x20, 0xA2, 0x70, 0x09, 0x91, 0x6D, 0xC6, 0x33, 0x70, 0xFC,
  0x10, 0x86, 0x10, 0x82, 0x10, 0xC0, 0x31, 0x24, 0x52, 0x72, 0x28, 0xA2,
  0xF0, 0x32, 0x63, 0x18, 0xBC, 0x22, 0xE0, 0x70, 0x28, 0x2C, 0x00, 0x16,
  0x80, 0x1B, 0x30, 0x60, 0x80, 0xF8, 0x01, 0xF0, 0xC1, 0xC7, 0xC8, 0x00,
  0x64, 0x84, 0x22, 0x21, 0x00, 0xC0, 0x08, 0x69, 0x6B, 0x5A, 0xB5, 0x6F,
  0x20, 0x70, 0x08, 0x61, 0x86, 0x28, 0x97, 0xD1, 0x84, 0x38, 0x49, 0x8A,
  0x27, 0x88, 0x91, 0x22, 0xF8, 0x31, 0x28, 0x60, 0x82, 0x08, 0xA2, 0xF0,
  0x30, 0x59, 0x12, 0x14, 0x28, 0x91, 0x24, 0xF0, 0x3E, 0x40, 0x82, 0x07,
  0xC8, 0x10, 0x20, 0xFC, 0x3E, 0x40, 0x82, 0x07, 0xC8, 0x10, 0x20, 0xC0,
  0x31, 0x28, 0x60, 0x82, 0x68, 0xA2, 0x70, 0x22, 0x85, 0x0A, 0x17, 0xC8,
  0x91, 0x42, 0x84, 0x3E, 0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0xFC, 0x02,
  0x04, 0x10, 0x20, 0x40, 0xA1, 0x24, 0x78, 0x22, 0x4D, 0xB2, 0xC7, 0x0E,
  0x12, 0x24, 0xC4, 0x42, 0x11, 0x88, 0x42, 0x10, 0xF8, 0x22, 0x4D, 0x9B,
  0x55, 0xCA, 0x95, 0x62, 0x84, 0x22, 0x45, 0x8A, 0xB5, 0x4A, 0x93, 0x66,
  0x8C, 0x31, 0x28, 0x61, 0x8E, 0x28, 0xA6, 0xF0, 0x38, 0x4C, 0x8A, 0x14,
  0x4F, 0x10, 0x20, 0xC0, 0x31, 0x28, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x60,
  0x38, 0x48, 0x8A, 0x34, 0xCF, 0x12, 0x24, 0xC4, 0x18, 0x49, 0x8B, 0x03,
  0x81, 0xA1, 0x22, 0x78, 0xFC, 0x41, 0x08, 0x20, 0x82, 0x08, 0x40, 0x47,
  0x18, 0x61, 0x8A, 0x28, 0xA6, 0xF0, 0x86, 0x14, 0x92, 0x51, 0x45, 0x18,
  0x60, 0x97, 0x2A, 0xD5, 0xAD, 0x9B, 0x36, 0x4C, 0x90, 0x62, 0x4C, 0x90,
  0xC1, 0x07, 0x0A, 0x24, 0xC4, 0x85, 0x14, 0x94, 0x50, 0x82, 0x08, 0x40,
  0x7E, 0x0C, 0x10, 0x41, 0x04, 0x18, 0x20, 0xFC, 0x74, 0x44, 0x44, 0x88,
  0x88, 0x8C, 0x91, 0x24, 0x91, 0x24, 0x38, 0x84, 0x21, 0x08, 0x44, 0x21,
  0x09, 0xC0, 0x11, 0x8C, 0xAC, 0x80, 0xF8, 0x90, 0x7C, 0x5F, 0x19, 0xFC,
  0x20, 0x82, 0x1F, 0x45, 0x14, 0x53, 0xF8, 0x7C, 0x61, 0x08, 0xF8, 0x04,
  0x10, 0xDE, 0x8A, 0x28, 0xA6, 0xF0, 0x7C, 0x7F, 0x08, 0xB8, 0x1C, 0x82,
  0x3E, 0x20, 0x84, 0x10, 0x40, 0x3D, 0x14, 0x51, 0x4D, 0xE0, 0xB6, 0x20,
  0x20, 0x82, 0x1F, 0x45, 0x14, 0x51, 0xCC, 0x10, 0x81, 0xE2, 0x10, 0x84,
  0xF8, 0x04, 0x20, 0x0E, 0x08, 0x20, 0x84, 0x10, 0x43, 0x30, 0x20, 0x40,
  0x8A, 0x65, 0x8E, 0x14, 0x24, 0xCC, 0x70, 0x84, 0x22, 0x10, 0x84, 0xF8,
  0x7E, 0xA5, 0x54, 0xA9, 0x54, 0x80, 0x7D, 0x14, 0x51, 0x47, 0x30, 0x7C,
  0x63, 0x18, 0xF8, 0x7D, 0x14, 0x51, 0x4F, 0xE8, 0x20, 0x7C, 0x63, 0x19,
  0xF8, 0x42, 0x7D, 0x04, 0x10, 0x42, 0x00, 0x7C, 0x58, 0x38, 0xF8, 0x21,
  0x3E, 0x44, 0x21, 0x07, 0xCE, 0x28, 0xA2, 0x9B, 0xC0, 0x8E, 0x25, 0x14,
  0x61, 0x80, 0xA6, 0x9D, 0xB6, 0x92, 0x40, 0x66, 0x50, 0x41, 0x86, 0x99,
  0x80, 0x46, 0x88, 0xA1, 0x43, 0x06, 0x08, 0x20, 0x80, 0x7C, 0x21, 0x08,
  0x43, 0xF0, 0x19, 0x08, 0x44, 0x41, 0x08, 0x42, 0x18, 0x25, 0x24, 0x92,
  0x52, 0x00, 0x20, 0x8C, 0x41, 0x0C, 0x84, 0x22, 0x30, 0x61, 0x24, 0x30,
};

const GFXglyph RobotoMono_Italic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 3, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 7, 1, -10 },
  { 24, 5, 9, 7, 1, -9 },
  { 30, 7, 9, 7, 0, -9 },
  { 38, 2, 3, 7, 3, -9 },
  { 39, 4, 13, 7, 2, -10 },
  { 46, 4, 13, 7, 1, -10 },
  { 53, 6, 6, 7, 1, -9 },
  { 58, 6, 6, 7, 1, -7 },
  { 63, 2, 3, 7, 1, -1 },
  { 64, 5, 1, 7, 1, -4 },
  { 65, 2, 2, 7, 2, -2 },
  { 66, 6, 10, 7, 1, -9 },
  { 74, 6, 9, 7, 1, -9 },
  { 81, 3, 9, 7, 2, -9 },
  { 85, 6, 9, 7, 0, -9 },
  { 92, 6, 9, 7, 0, -9 },
  { 99, 6, 9, 7, 0, -9 },
  { 106, 6, 9, 7, 1, -9 },
  { 113, 5, 9, 7, 1, -9 },
  { 119, 6, 9, 7, 1, -9 },
  { 126, 6, 9, 7, 1, -9 },
  { 133, 5, 9, 7, 1, -9 },
  { 139, 2, 7, 7, 3, -7 },
  { 141, 3, 9, 7, 2, -7 },
  { 145, 5, 5, 7, 1, -6 },
  { 149, 5, 4, 7, 1, -6 },
  { 152, 5, 5, 7, 1, -6 },
  { 156, 5, 9, 7, 2, -9 },
  { 162, 7, 9, 7, 0, -9 },
  { 170, 6, 9, 7, 0, -9 },
  { 177, 7, 9, 7, 0, -9 },
  { 185, 6, 9, 7, 1, -9 },
  { 192, 7, 9, 7, 0, -9 },
  { 200, 7, 9, 7, 0, -9 },
  { 208, 7, 9, 7, 0, -9 },
  { 216, 6, 9, 7, 1, -9 },
  { 223, 7, 9, 7, 0, -9 },
  { 231, 7, 9, 7, 0, -9 },
  { 239, 7, 9, 7, 0, -9 },
  { 247, 7, 9, 7, 0, -9 },
  { 255, 5, 9, 7, 1, -9 },
  { 261, 7, 9, 7, 0, -9 },
  { 269, 7, 9, 7, 0, -9 },
  { 277, 6, 9, 7, 1, -9 },
  { 284, 7, 9, 7, 0, -9 },
  { 292, 6, 10, 7, 1, -9 },
  { 300, 7, 9, 7, 0, -9 },
  { 308, 7, 9, 7, 0, -9 },
  { 316, 6, 9, 7, 1, -9 },
  { 323, 6, 9, 7, 1, -9 },
  { 330, 6, 9, 7, 1, -9 },
  { 337, 7, 9, 7, 1, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 6, 9, 7, 1, -9 },
  { 360, 7, 9, 7, 0, -9 },
  { 368, 4, 12, 7, 2, -10 },
  { 374, 3, 10, 7, 2, -9 },
  { 378, 5, 12, 7, 1, -10 },
  { 386, 5, 5, 7, 1, -9 },
  { 390, 5, 1, 7, 0, 0 },
  { 391, 2, 2, 7, 3, -9 },
  { 392, 5, 6, 7, 1, -6 },
  { 396, 6, 9, 7, 0, -9 },
  { 403, 5, 6, 7, 1, -6 },
  { 407, 6, 9, 7, 1, -9 },
  { 414, 5, 6, 7, 1, -6 },
  { 418, 6, 9, 7, 1, -9 },
  { 425, 6, 9, 7, 0, -6 },
  { 432, 6, 9, 7, 0, -9 },
  { 439, 5, 9, 7, 1, -9 },
  { 445, 6, 12, 7, 0, -9 },
  { 454, 7, 9, 7, 0, -9 },
  { 462, 5, 9, 7, 1, -9 },
  { 468, 7, 6, 7, 0, -6 },
  { 474, 6, 6, 7, 0, -6 },
  { 479, 5, 6, 7, 1, -6 },
  { 483, 6, 8, 7, 0, -6 },
  { 489, 5, 8, 7, 1, -6 },
  { 494, 6, 6, 7, 1, -6 },
  { 499, 5, 6, 7, 1, -6 },
  { 503, 5, 8, 7, 1, -8 },
  { 508, 6, 6, 7, 1, -6 },
  { 513, 6, 6, 7, 1, -6 },
  { 518, 6, 6, 7, 1, -6 },
  { 523, 7, 6, 7, 0, -6 },
  { 529, 7, 9, 7, 0, -6 },
  { 537, 6, 6, 7, 0, -6 },
  { 542, 5, 11, 7, 2, -9 },
  { 549, 3, 11, 7, 2, -9 },
  { 554, 5, 11, 7, 1, -9 },
  { 561, 7, 3, 7, 0, -5 },
};

const GFXfont RobotoMono_Italic12pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic12pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOMONO_ITALIC12PT7B_H_
