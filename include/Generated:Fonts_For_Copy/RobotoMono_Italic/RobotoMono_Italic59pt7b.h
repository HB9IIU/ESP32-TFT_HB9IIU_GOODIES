#ifndef _ROBOTOMONO_ITALIC59PT7B_H_
#define _ROBOTOMONO_ITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x3E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x01, 0x0F, 0x01, 0xE0,
  0x3C, 0xF0, 0x1E, 0x07, 0xCF, 0x01, 0xE0, 0x78, 0xF0, 0x1E, 0x0F, 0x0F,
  0x01, 0xE1, 0xF0, 0xF0, 0x1E, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF8, 0x7C,
  0x78, 0x07, 0xFF, 0x8F, 0x80, 0x7F, 0xF0, 0xF0, 0x03, 0xFE, 0x1E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x01,
  0xF3, 0xFF, 0xE0, 0x1E, 0x3C, 0x1E, 0x03, 0xC7, 0x81, 0xF0, 0x78, 0x78,
  0x0F, 0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x78, 0x0F, 0x1E, 0x0F, 0x00, 0xF3,
  0xE0, 0xF0, 0x0E, 0x1C, 0x0F, 0x01, 0xE0, 0x40, 0xF0, 0x1E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xF8, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x01,
  0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x1F, 0x07, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xEF, 0xC0, 0x3C, 0x7F, 0x1F, 0x01, 0xF3, 0xF8, 0x7E, 0x07,
  0xCF, 0xC0, 0xF8, 0x1F, 0x7E, 0x03, 0xF0, 0xF9, 0xF0, 0x07, 0xE3, 0xEF,
  0xC0, 0x1F, 0x9F, 0xBE, 0x00, 0x3F, 0x7C, 0xF8, 0x00, 0x7F, 0xF3, 0xE0,
  0x01, 0xFF, 0x8F, 0x80, 0x03, 0xFC, 0x3E, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x81, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0x0F, 0xC0, 0x3F, 0xF0, 0x3F,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x79,
  0xF3, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x30, 0x0F, 0x00, 0x47, 0x81, 0xE0,
  0x7D, 0xFC, 0x3C, 0x3F, 0xBF, 0xE7, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xC0, 0x02, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E,
  0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E,
  0x07, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0C, 0x1F, 0x9F, 0xCF, 0xFF, 0xFB, 0xFD,
  0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xF3, 0xE0, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0xF7, 0xE0, 0x07, 0xFF,
  0x7C, 0x00, 0xFF, 0xF7, 0xC0, 0x3F, 0xBE, 0x7C, 0x07, 0xF3, 0xE7, 0xC1,
  0xFC, 0x3E, 0x7C, 0x3F, 0x83, 0xEF, 0xCF, 0xE0, 0x3E, 0xF9, 0xFC, 0x07,
  0xEF, 0xFF, 0x80, 0x7E, 0xFF, 0xE0, 0x07, 0xCF, 0xFC, 0x00, 0x7C, 0xFF,
  0x00, 0x07, 0xCF, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0x7E, 0x7E, 0x1F, 0x3E, 0x07, 0xCC, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x20, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF7, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x0C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x10,
  0x00, 0x7C, 0x7F, 0xC0, 0x1F, 0x3F, 0xFC, 0x0F, 0xBF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFE, 0x3F, 0xC0, 0x1F, 0x9F, 0xE0, 0x03, 0xE7,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF9, 0xF8,
  0x01, 0xFC, 0xFE, 0x03, 0xFE, 0x3F, 0xCF, 0xFF, 0x1F, 0xFF, 0xEF, 0x07,
  0xFF, 0xEF, 0x80, 0xFF, 0xE7, 0xC0, 0x1F, 0x83, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x7E, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x7E, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x18, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0xFE, 0x0E,
  0x07, 0x03, 0xFF, 0x0E, 0x0F, 0x07, 0xFF, 0x8F, 0x1E, 0x0F, 0xC7, 0x0F,
  0x1E, 0x1F, 0x07, 0x07, 0x1C, 0x1E, 0x07, 0x07, 0x3C, 0x3C, 0x0F, 0x07,
  0x38, 0x3C, 0x0E, 0x07, 0x78, 0x78, 0x0E, 0x07, 0x78, 0x78, 0x0E, 0x0E,
  0x70, 0x70, 0x1E, 0x0E, 0x70, 0x70, 0x1C, 0x0E, 0xF0, 0xF0, 0x1C, 0x0E,
  0xF0, 0xF0, 0x1C, 0x0E, 0xF0, 0xF0, 0x3C, 0x0C, 0xF0, 0xE0, 0x38, 0x1C,
  0xE0, 0xE0, 0x38, 0x1C, 0xE0, 0xE0, 0x78, 0x38, 0xE0, 0xF0, 0xF8, 0x38,
  0xE0, 0xF1, 0xF8, 0x70, 0xF0, 0xFF, 0xFC, 0xF0, 0xF0, 0x7F, 0xBF, 0xE0,
  0xF0, 0x7F, 0x1F, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x30, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x0F, 0x80, 0x03, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xF0, 0x7F, 0xF0, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0x7C,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0xFF, 0xBE, 0x00, 0x7F, 0xFE, 0xF8, 0x01, 0xFF, 0xF3, 0xE0,
  0x07, 0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x01,
  0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xC0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x0F, 0x83,
  0xF8, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00,
  0x07, 0xDF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0x00, 0x00, 0x1F, 0xE3,
  0xF0, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xF7, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x3E, 0xF0, 0x1F, 0x78, 0x0F, 0x7C, 0x07, 0xDF, 0x07, 0xDF,
  0x01, 0xF7, 0xC1, 0xE7, 0xC0, 0x7C, 0xF0, 0xF9, 0xF0, 0x1F, 0x3C, 0x7C,
  0x78, 0x07, 0x8F, 0x1F, 0x3E, 0x03, 0xE3, 0xCF, 0x8F, 0x80, 0xF8, 0xF3,
  0xE3, 0xE0, 0x3E, 0x3D, 0xF0, 0xF8, 0x0F, 0x8F, 0xFC, 0x3C, 0x03, 0xE1,
  0xFE, 0x1F, 0x00, 0xF0, 0x7F, 0x87, 0xC0, 0x7C, 0x1F, 0xC1, 0xF0, 0x1F,
  0x07, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x0F, 0x80,
  0x7C, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xE0, 0x3E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x3E, 0x03, 0xFC, 0x00,
  0x0F, 0x80, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0x01, 0xF8, 0x0F, 0xF8,
  0x00, 0x7C, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x7F,
  0xF0, 0x01, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x07, 0xDF, 0x80, 0x3F, 0x01,
  0xF3, 0xE0, 0x0F, 0x80, 0x7C, 0xF8, 0x03, 0xE0, 0x1F, 0x3F, 0x00, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7E, 0x03, 0xF1, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x07,
  0xC0, 0x3E, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x03, 0xE0, 0xFC,
  0x1F, 0x01, 0xF8, 0x1F, 0x0F, 0xC0, 0x7E, 0x07, 0xC3, 0xF0, 0x1F, 0x01,
  0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0xFC,
  0x03, 0xE3, 0xE0, 0x3F, 0x00, 0x7D, 0xF8, 0x0F, 0x80, 0x1F, 0x7E, 0x03,
  0xE0, 0x07, 0xDF, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xF0,
  0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0x01, 0xF0, 0x00, 0x7F,
  0xC0, 0x7C, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF0, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x06, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x7F, 0x80, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x0F, 0x9F, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0x07,
  0xC7, 0xC0, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0x01, 0xF1, 0xF0, 0x3F, 0x80,
  0xF0, 0xF0, 0x1F, 0xC0, 0xF8, 0x78, 0x0F, 0xE0, 0x7C, 0x3C, 0x0F, 0xF0,
  0x3E, 0x1E, 0x07, 0xF8, 0x3E, 0x0F, 0x03, 0xFC, 0x1F, 0x0F, 0x83, 0xFE,
  0x0F, 0x87, 0xC1, 0xEF, 0x07, 0xC3, 0xE0, 0xF7, 0x87, 0xC1, 0xF0, 0xFB,
  0xC3, 0xE0, 0xF8, 0x79, 0xE1, 0xF0, 0x7C, 0x3C, 0xF0, 0xF0, 0x3E, 0x3E,
  0x78, 0xF8, 0x1F, 0x1E, 0x3C, 0x7C, 0x0F, 0x8F, 0x1E, 0x3E, 0x07, 0xCF,
  0x8F, 0x1E, 0x03, 0xE7, 0x87, 0x9F, 0x01, 0xF3, 0xC3, 0xCF, 0x80, 0xFB,
  0xE1, 0xE7, 0xC0, 0x79, 0xE0, 0xF3, 0xC0, 0x3C, 0xF0, 0x7B, 0xE0, 0x1E,
  0xF8, 0x3D, 0xF0, 0x0F, 0x78, 0x1E, 0xF0, 0x07, 0xBC, 0x0F, 0x78, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xF7, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x10, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x07,
  0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xE7, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x3E, 0x1F, 0x87,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0,
  0x3F, 0x83, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC7, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xFC,
  0x3F, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xBE, 0x07, 0xFF,
  0xC7, 0xC0, 0x3F, 0xE0, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x7F, 0xE0, 0x07, 0xDF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFE,
  0x0F, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x80,
  0x3F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xC0,
  0xF8, 0xFF, 0xF8, 0x0F, 0x87, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFE, 0x3F, 0x00, 0x3F, 0xFF,
  0x7E, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F,
  0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xBE, 0x00, 0x1F, 0xFE,
  0x7C, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x02, 0x03, 0xE0, 0x00, 0x70, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xC0, 0x60, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0xFF, 0xFC, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x7F, 0xF9, 0xF0, 0x00,
  0x7F, 0xE7, 0xE0, 0x00, 0x0C, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x03, 0x00, 0x03, 0xF0, 0x07, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x7C, 0x3F, 0xF0, 0x07, 0xC7, 0xFF, 0x80, 0x7D, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x7C, 0x00,
  0x3F, 0x81, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0xFE,
  0x00, 0xFC, 0x07, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00,
  0x3E, 0x0F, 0xE0, 0x00, 0xF8, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x7D, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFC,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0,
  0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xFC, 0x3E, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x02, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0x80, 0x78, 0x03, 0xEF, 0xF0, 0xFF, 0x01, 0xEF, 0xFD,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F,
  0xF0, 0xFC, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80,
  0xF8, 0x0F, 0x8F, 0x80, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xF0, 0x07, 0xCF, 0xFF, 0x80,
  0x7D, 0xFF, 0xFC, 0x07, 0xBF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7E, 0x0F, 0xF0,
  0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0x3E, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC7, 0xFE, 0x00, 0x1F, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x0F,
  0x80, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xE7, 0xFF, 0xE0, 0x0F, 0x87, 0xFE,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFF, 0x87, 0xC0, 0x3F, 0xFF, 0x3E, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFE, 0x7C, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x30, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x20, 0x3F, 0x01, 0xF0, 0x7F, 0xF0, 0x7C, 0x7F, 0xFC,
  0x1F, 0x3F, 0xFF, 0x07, 0xDF, 0xFF, 0x81, 0xFF, 0xFB, 0xE0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x06, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7F, 0x07, 0xC0,
  0x0F, 0xE0, 0x7F, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xBE,
  0x01, 0xFF, 0xF3, 0xE0, 0x0F, 0xFC, 0x3E, 0x00, 0x0C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xF0, 0x07, 0x80, 0x3E,
  0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x7C,
  0xF0, 0x0F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x78, 0xF0, 0x1F, 0xC0, 0xF8,
  0xF0, 0x3F, 0xC0, 0xF0, 0xF0, 0x3F, 0xC0, 0xF0, 0xF0, 0x3B, 0xC1, 0xF0,
  0xF0, 0x7B, 0xC1, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF0, 0xF1, 0xC3, 0xE0,
  0xF0, 0xF1, 0xC3, 0xC0, 0xF1, 0xE1, 0xC3, 0xC0, 0xF1, 0xE1, 0xC7, 0x80,
  0xF1, 0xE1, 0xE7, 0x80, 0xF3, 0xC1, 0xE7, 0x80, 0xF3, 0xC1, 0xEF, 0x00,
  0xF7, 0x81, 0xEF, 0x00, 0x77, 0x81, 0xEF, 0x00, 0x77, 0x81, 0xFE, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x06, 0x1F, 0xFF, 0x00, 0x0F, 0x3F,
  0xFF, 0x80, 0x0F, 0x7F, 0xFF, 0xC0, 0x1F, 0x7C, 0x0F, 0xF0, 0x1E, 0xF8,
  0x03, 0xFC, 0x7E, 0xF0, 0x01, 0xFF, 0xFC, 0xF0, 0x00, 0xFF, 0xFC, 0x70,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
};

const GFXglyph RobotoMono_Italic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 13, 42, 35, 11, -42 },
  { 70, 16, 14, 35, 12, -44 },
  { 98, 34, 42, 35, 1, -42 },
  { 277, 29, 55, 35, 3, -49 },
  { 477, 28, 44, 35, 4, -43 },
  { 631, 30, 44, 35, 2, -43 },
  { 796, 7, 14, 35, 16, -44 },
  { 809, 20, 61, 35, 9, -47 },
  { 962, 19, 61, 35, 5, -47 },
  { 1107, 27, 28, 35, 6, -42 },
  { 1202, 29, 31, 35, 3, -35 },
  { 1315, 10, 16, 35, 6, -6 },
  { 1335, 22, 5, 35, 6, -21 },
  { 1349, 9, 9, 35, 11, -8 },
  { 1360, 30, 46, 35, 3, -42 },
  { 1533, 28, 44, 35, 4, -43 },
  { 1687, 18, 42, 35, 8, -42 },
  { 1782, 30, 43, 35, 0, -43 },
  { 1944, 29, 44, 35, 1, -43 },
  { 2104, 30, 42, 35, 1, -42 },
  { 2262, 30, 43, 35, 4, -42 },
  { 2424, 26, 43, 35, 3, -42 },
  { 2564, 30, 42, 35, 5, -42 },
  { 2722, 29, 44, 35, 4, -43 },
  { 2882, 25, 43, 35, 6, -43 },
  { 3017, 12, 34, 35, 13, -33 },
  { 3068, 16, 43, 35, 9, -33 },
  { 3154, 26, 26, 35, 5, -32 },
  { 3239, 28, 16, 35, 4, -27 },
  { 3295, 27, 26, 35, 3, -32 },
  { 3383, 24, 43, 35, 8, -43 },
  { 3512, 32, 42, 35, 2, -42 },
  { 3680, 31, 42, 35, -1, -42 },
  { 3843, 31, 42, 35, 2, -42 },
  { 4006, 30, 44, 35, 3, -43 },
  { 4171, 32, 42, 35, 1, -42 },
  { 4339, 32, 42, 35, 2, -42 },
  { 4507, 33, 42, 35, 2, -42 },
  { 4681, 30, 44, 35, 3, -43 },
  { 4846, 34, 42, 35, 1, -42 },
  { 5025, 32, 42, 35, 2, -42 },
  { 5193, 32, 43, 35, 2, -42 },
  { 5365, 35, 42, 35, 2, -42 },
  { 5549, 25, 42, 35, 3, -42 },
  { 5681, 34, 42, 35, 1, -42 },
  { 5860, 34, 42, 35, 1, -42 },
  { 6039, 30, 44, 35, 3, -43 },
  { 6204, 32, 42, 35, 2, -42 },
  { 6372, 30, 50, 35, 3, -43 },
  { 6560, 31, 42, 35, 2, -42 },
  { 6723, 32, 44, 35, 2, -43 },
  { 6899, 31, 42, 35, 6, -42 },
  { 7062, 32, 43, 35, 3, -42 },
  { 7234, 30, 42, 35, 6, -42 },
  { 7392, 33, 42, 35, 4, -42 },
  { 7566, 36, 42, 35, 0, -42 },
  { 7755, 30, 42, 35, 6, -42 },
  { 7913, 32, 42, 35, 1, -42 },
  { 8081, 20, 57, 35, 8, -48 },
  { 8224, 13, 46, 35, 11, -42 },
  { 8299, 20, 57, 35, 7, -48 },
  { 8442, 21, 23, 35, 7, -42 },
  { 8503, 26, 4, 35, 1, 0 },
  { 8516, 9, 8, 35, 16, -43 },
  { 8525, 27, 33, 35, 3, -32 },
  { 8637, 28, 45, 35, 2, -44 },
  { 8795, 27, 33, 35, 4, -32 },
  { 8907, 31, 45, 35, 3, -44 },
  { 9082, 28, 33, 35, 3, -32 },
  { 9198, 30, 46, 35, 6, -46 },
  { 9371, 31, 44, 35, 1, -32 },
  { 9542, 28, 44, 35, 2, -44 },
  { 9696, 26, 43, 35, 3, -43 },
  { 9836, 27, 56, 35, 1, -43 },
  { 10025, 30, 44, 35, 2, -44 },
  { 10190, 26, 44, 35, 3, -44 },
  { 10333, 33, 32, 35, 0, -32 },
  { 10465, 28, 32, 35, 2, -32 },
  { 10577, 28, 33, 35, 3, -32 },
  { 10693, 30, 44, 35, 0, -32 },
  { 10858, 29, 44, 35, 3, -32 },
  { 11018, 26, 32, 35, 6, -32 },
  { 11122, 27, 33, 35, 4, -32 },
  { 11234, 25, 40, 35, 6, -39 },
  { 11359, 28, 32, 35, 4, -31 },
  { 11471, 29, 31, 35, 5, -31 },
  { 11584, 32, 31, 35, 4, -31 },
  { 11708, 34, 31, 35, 0, -31 },
  { 11840, 36, 44, 35, -1, -31 },
  { 12038, 30, 31, 35, 2, -31 },
  { 12155, 23, 57, 35, 9, -46 },
  { 12319, 12, 53, 35, 11, -42 },
  { 12399, 23, 57, 35, 5, -46 },
  { 12563, 32, 11, 35, 1, -23 },
};

const GFXfont RobotoMono_Italic59pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic59pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _ROBOTOMONO_ITALIC59PT7B_H_
