#ifndef _ROBOTOMONO_ITALIC23PT7B_H_
#define _ROBOTOMONO_ITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x33, 0x18, 0x00, 0x03, 0x9C, 0xCF,
  0x3C, 0xE2, 0x88, 0x01, 0x98, 0x0C, 0x60, 0x31, 0x00, 0x8C, 0x3F, 0xFC,
  0xFF, 0xE0, 0x46, 0x03, 0x10, 0x0C, 0xC0, 0x23, 0x0F, 0xFF, 0x04, 0x60,
  0x31, 0x80, 0xC4, 0x02, 0x30, 0x18, 0x80, 0x01, 0x80, 0x18, 0x01, 0x00,
  0xFC, 0x1C, 0xE1, 0x86, 0x30, 0x73, 0x07, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0C, 0xC0, 0xE6, 0x0C, 0x60, 0xC7, 0xF8, 0x3F, 0x00,
  0xC0, 0x08, 0x00, 0x18, 0x0F, 0x81, 0x10, 0x22, 0x3C, 0x4C, 0x89, 0x1F,
  0x41, 0x98, 0x06, 0x00, 0x80, 0x37, 0x0D, 0xB1, 0x22, 0x6C, 0x59, 0x88,
  0x13, 0x03, 0xC0, 0x03, 0x00, 0xF8, 0x18, 0xC1, 0x8C, 0x30, 0xC1, 0x98,
  0x1B, 0x01, 0xE0, 0x1C, 0x03, 0xC3, 0x66, 0x2C, 0x76, 0xC3, 0x6C, 0x1C,
  0xC1, 0x8F, 0x7C, 0x7E, 0xE0, 0x69, 0x6C, 0x06, 0x1C, 0x70, 0xC3, 0x06,
  0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x02,
  0x06, 0x04, 0x04, 0x00, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x87, 0x1C, 0x20,
  0x00, 0x06, 0x00, 0xC0, 0x18, 0x33, 0x3F, 0xFE, 0x1E, 0x03, 0x80, 0xD8,
  0x33, 0x0C, 0x30, 0x84, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x07, 0xFF, 0xFF, 0xE0, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x33,
  0x76, 0xE4, 0x7F, 0xFF, 0xC0, 0x6F, 0x60, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xFC,
  0x18, 0xE3, 0x06, 0x30, 0x26, 0x06, 0x60, 0xE6, 0x1E, 0x67, 0x66, 0xC6,
  0x78, 0x6F, 0x06, 0xC0, 0xC4, 0x0C, 0x61, 0xC7, 0x38, 0x3F, 0x00, 0x06,
  0x7F, 0xDC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x18, 0x03, 0x00, 0xFC, 0x1C, 0x63, 0x07, 0x30, 0x30, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xFE, 0xFF, 0xE0, 0x06, 0x03, 0xF8, 0xE3, 0x18, 0x36, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x0F, 0x03, 0xF0, 0x06, 0x00, 0x60, 0x0D, 0x83, 0x30, 0x67,
  0xB8, 0x7E, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3E, 0x03, 0x60, 0x66,
  0x0C, 0x61, 0x8C, 0x38, 0xC3, 0x0C, 0x60, 0xCF, 0xFF, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x1F, 0xE3, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0xDC, 0x1F,
  0xE3, 0x9C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x6C, 0x19, 0x83, 0x3D, 0xC1,
  0xF0, 0x03, 0xC3, 0xE1, 0xC0, 0xE0, 0x30, 0x19, 0xC7, 0xF9, 0xC7, 0x60,
  0xD8, 0x3C, 0x0F, 0x03, 0x60, 0xD8, 0x67, 0xF8, 0xFC, 0x7F, 0xF0, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0x03, 0x00, 0xFC, 0x1C, 0x61,
  0x87, 0x30, 0x33, 0x06, 0x30, 0x61, 0x8C, 0x0F, 0x83, 0x9C, 0x70, 0xC6,
  0x06, 0x60, 0x66, 0x0C, 0x60, 0xC7, 0xB8, 0x3F, 0x00, 0x06, 0x07, 0xE3,
  0x19, 0x83, 0x60, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xD8, 0xF3, 0xE8, 0x26,
  0x01, 0x80, 0xC0, 0xE1, 0xF0, 0x70, 0x00, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x39, 0xCE, 0x00, 0x18, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x61, 0x86, 0x30, 0x80, 0x00, 0xC0, 0xF1, 0xF1, 0xE0, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x20, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xBF, 0xF0, 0x30, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0x07,
  0xC3, 0xC3, 0xE0, 0xE0, 0x10, 0x00, 0x0C, 0x1F, 0x9C, 0xFC, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x0E, 0x0E, 0x06, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0F, 0xC1, 0x86, 0x30, 0x32, 0x39, 0x66, 0x94, 0x89, 0xD8,
  0x99, 0x99, 0x91, 0x19, 0x12, 0x93, 0x29, 0xDC, 0x80, 0x0C, 0x00, 0x72,
  0x03, 0xF0, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0C,
  0xC0, 0xC4, 0x18, 0x61, 0x86, 0x3F, 0xE3, 0xFE, 0x60, 0x66, 0x06, 0xC0,
  0x6C, 0x03, 0x3F, 0xC3, 0x0E, 0x30, 0x73, 0x03, 0x30, 0x33, 0x06, 0x61,
  0xC7, 0xF8, 0x61, 0xC6, 0x0E, 0x60, 0x6E, 0x06, 0xC0, 0xEC, 0x1C, 0xFF,
  0x8F, 0xF0, 0x03, 0x00, 0xFC, 0x1C, 0x63, 0x07, 0x30, 0x36, 0x03, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0x60,
  0xC7, 0x38, 0x3F, 0x00, 0x3F, 0x83, 0x1C, 0x30, 0x63, 0x06, 0x30, 0x36,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x06, 0xE0, 0x6C, 0x0E, 0xC0, 0xCC,
  0x38, 0xFF, 0x0F, 0xC0, 0x1F, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x60, 0x07, 0xFC, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0xFC, 0x1C, 0xE3, 0x07,
  0x30, 0x36, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x3E, 0xC3, 0xEC, 0x06,
  0xC0, 0x6E, 0x06, 0x60, 0xE7, 0xFC, 0x1F, 0x00, 0x18, 0x1C, 0x60, 0x61,
  0x81, 0x84, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x0F, 0xFC, 0x30, 0x31,
  0x80, 0xC6, 0x03, 0x18, 0x08, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30, 0x18,
  0x3F, 0xF0, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xCF, 0xF8,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xCC, 0x0C, 0xC0, 0xCC, 0x18, 0x7F, 0x03, 0xE0,
  0x38, 0x39, 0x83, 0x8C, 0x38, 0x63, 0x83, 0x38, 0x1B, 0x81, 0xB8, 0x0F,
  0xC0, 0x7E, 0x03, 0xB8, 0x18, 0xC1, 0xC7, 0x0C, 0x18, 0x60, 0xE3, 0x03,
  0x18, 0x1C, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0F, 0xFF, 0xFF, 0x1C, 0x1C,
  0x70, 0xE1, 0xC3, 0x85, 0x1E, 0x34, 0x58, 0xDB, 0x63, 0x69, 0x0D, 0xEC,
  0x37, 0x30, 0xDC, 0xC6, 0x23, 0x18, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x06,
  0x38, 0x18, 0x1C, 0x1C, 0x70, 0x61, 0xC1, 0x87, 0x06, 0x36, 0x18, 0xD8,
  0xC3, 0x23, 0x0C, 0xCC, 0x33, 0x30, 0xC4, 0xC6, 0x1B, 0x18, 0x78, 0x60,
  0xE1, 0x83, 0x86, 0x0E, 0x38, 0x18, 0x03, 0x00, 0xFC, 0x1C, 0xE3, 0x06,
  0x30, 0x36, 0x03, 0x60, 0x36, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x06,
  0xC0, 0x6C, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x1F, 0xE3, 0x0F, 0x30,
  0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x76, 0x0E, 0x7F, 0xC6, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0xFC, 0x1C,
  0xE3, 0x06, 0x30, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x0C, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x18, 0x00,
  0xC0, 0x08, 0x3F, 0xC3, 0x0E, 0x30, 0x73, 0x03, 0x30, 0x33, 0x03, 0x60,
  0x66, 0x1C, 0x7F, 0x86, 0x30, 0x61, 0x86, 0x18, 0xC1, 0x8C, 0x1C, 0xC0,
  0xCC, 0x0C, 0x03, 0x00, 0xFC, 0x1C, 0xE3, 0x03, 0x30, 0x33, 0x00, 0x30,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xC0, 0x06, 0xC0, 0x6C, 0x06, 0xE0,
  0xC7, 0xFC, 0x3F, 0x00, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x39, 0x81, 0x8C, 0x0C, 0x40, 0x66, 0x03,
  0x30, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0x62, 0x03, 0x30, 0x19, 0x81, 0x8C,
  0x0C, 0x30, 0xE1, 0xFE, 0x07, 0xC0, 0xE0, 0x76, 0x06, 0x60, 0x66, 0x0C,
  0x60, 0xC6, 0x18, 0x61, 0x86, 0x30, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60,
  0x3C, 0x03, 0xC0, 0x18, 0x01, 0x80, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0xE6,
  0xCA, 0x6C, 0xA6, 0xDA, 0x6D, 0xAC, 0xD2, 0xCF, 0x2C, 0xF2, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0x18, 0x1C, 0x70, 0xE0, 0xC3, 0x03,
  0x18, 0x06, 0xE0, 0x1B, 0x00, 0x78, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0xD8, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x86, 0x06, 0x38, 0x1C, 0xE0, 0x76,
  0x06, 0x60, 0xC3, 0x1C, 0x31, 0x83, 0x30, 0x33, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x1F, 0xF8,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0x9F, 0xFC,
  0x1F, 0x1F, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xF8, 0xF0, 0xC1,
  0x06, 0x18, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x04, 0x18, 0x61, 0x86, 0x0C,
  0x1F, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0xF0, 0xF0, 0x0C,
  0x0C, 0x1E, 0x36, 0x36, 0x62, 0x63, 0xC3, 0xFF, 0xFF, 0xF8, 0xC6, 0x30,
  0x1F, 0x87, 0x39, 0xC3, 0x80, 0x30, 0x0C, 0x7F, 0x9C, 0x37, 0x06, 0xC0,
  0xD8, 0x39, 0xFF, 0x3E, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x7F, 0x0E, 0x73, 0x87, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0D, 0x81,
  0xB8, 0x77, 0xFC, 0xDF, 0x00, 0x0F, 0x87, 0x18, 0xC1, 0xB0, 0x36, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x60, 0xCC, 0x19, 0xCE, 0x1F, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x61, 0xFE, 0x39, 0xE7, 0x06, 0x60, 0x66,
  0x06, 0xE0, 0xCC, 0x0C, 0xC0, 0xCE, 0x0C, 0x61, 0xC7, 0xFC, 0x3F, 0x80,
  0x0F, 0x87, 0x38, 0xC1, 0xB0, 0x36, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x0C, 0x19, 0xEE, 0x0F, 0x80, 0x01, 0xE0, 0x3F, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0xFF, 0xC0, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0F, 0xF1, 0xCF, 0x38,
  0x33, 0x03, 0x30, 0x37, 0x06, 0x60, 0x66, 0x06, 0x70, 0x63, 0x0E, 0x3F,
  0xE1, 0xFC, 0x00, 0xC4, 0x0C, 0xE1, 0x87, 0xF0, 0x1E, 0x00, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x6F, 0x8B, 0x73, 0x83, 0x60, 0x6C, 0x0D,
  0x81, 0xB0, 0x66, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0xC0, 0x01, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x1C, 0x01,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x07,
  0xE1, 0xF0, 0x00, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x13, 0x0E,
  0x31, 0xC6, 0x38, 0x67, 0x06, 0xC0, 0x7C, 0x07, 0xE0, 0x66, 0x0C, 0x30,
  0xC3, 0x8C, 0x18, 0xC1, 0xC0, 0x1F, 0x87, 0xE0, 0x18, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE3,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF1, 0x9D, 0xD8, 0xC6, 0xC6, 0x36, 0x31, 0x31,
  0x99, 0x88, 0xCC, 0xC6, 0xC6, 0x36, 0x31, 0xB1, 0x89, 0x8C, 0xC0, 0x37,
  0xC7, 0xB9, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x37, 0x06, 0xC0, 0xD8,
  0x1B, 0x03, 0x60, 0xE0, 0x1F, 0x87, 0x39, 0xC3, 0xB0, 0x36, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xCC, 0x39, 0xDE, 0x1F, 0x80, 0x1F, 0xC1, 0xCE,
  0x38, 0x73, 0x03, 0x30, 0x33, 0x03, 0x30, 0x37, 0x06, 0x60, 0x67, 0x0E,
  0x7B, 0xC6, 0xF8, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x1F,
  0xE7, 0x3D, 0xC1, 0xB0, 0x36, 0x07, 0xC1, 0xB0, 0x36, 0x06, 0xE0, 0xCC,
  0x39, 0xDF, 0x1F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x33,
  0xE7, 0xF8, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x00, 0x1F, 0xC7, 0x38, 0xC1, 0x98, 0x03, 0x00, 0x3E,
  0x01, 0xE0, 0x06, 0xC0, 0xCC, 0x19, 0xEE, 0x1F, 0x80, 0x0C, 0x03, 0x00,
  0xC3, 0xFF, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x07, 0xC1, 0xF8, 0x60, 0xD8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x6C,
  0x1B, 0x06, 0xC1, 0xB0, 0xEF, 0xF9, 0xEC, 0xC0, 0x78, 0x19, 0x03, 0x30,
  0xC6, 0x18, 0xC6, 0x08, 0x81, 0xB0, 0x34, 0x07, 0x80, 0x60, 0x0C, 0x00,
  0xC2, 0x1A, 0x30, 0x91, 0xCC, 0x9E, 0x64, 0xF2, 0x25, 0xB1, 0x6D, 0x0A,
  0x78, 0x73, 0xC3, 0x8C, 0x18, 0x60, 0xC3, 0x00, 0x38, 0x38, 0xC3, 0x83,
  0x38, 0x19, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xB0, 0x1D, 0x81, 0xC6,
  0x1C, 0x31, 0xC0, 0xC0, 0x30, 0x1C, 0xC0, 0xE3, 0x83, 0x06, 0x18, 0x18,
  0x60, 0x63, 0x01, 0x8C, 0x03, 0x60, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x3F, 0xEF,
  0xFC, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0x7F, 0xE0, 0x01, 0x81, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x0C, 0x1C, 0x1E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x08, 0x46,
  0x31, 0x8C, 0x42, 0x31, 0x80, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x1C, 0x06, 0x03, 0x00, 0xE0, 0xF0, 0xE0, 0x60, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x00, 0x3C, 0x13, 0xF0, 0xD0, 0xED, 0x83,
  0xE0, 0x04, 0x00,
};

const GFXglyph RobotoMono_Italic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 16, 14, 4, -16 },
  { 11, 6, 5, 14, 5, -17 },
  { 15, 14, 16, 14, 0, -16 },
  { 43, 12, 21, 14, 1, -19 },
  { 75, 11, 17, 14, 1, -17 },
  { 99, 12, 17, 14, 1, -17 },
  { 125, 3, 5, 14, 6, -17 },
  { 127, 7, 23, 14, 4, -18 },
  { 148, 7, 23, 14, 2, -18 },
  { 169, 11, 11, 14, 2, -16 },
  { 185, 12, 12, 14, 1, -14 },
  { 203, 4, 6, 14, 2, -2 },
  { 206, 9, 2, 14, 2, -8 },
  { 209, 4, 3, 14, 4, -3 },
  { 211, 12, 17, 14, 1, -16 },
  { 237, 12, 17, 14, 1, -17 },
  { 263, 7, 16, 14, 3, -16 },
  { 277, 12, 17, 14, 0, -17 },
  { 303, 11, 17, 14, 1, -17 },
  { 327, 12, 16, 14, 0, -16 },
  { 351, 11, 16, 14, 2, -16 },
  { 373, 10, 16, 14, 1, -16 },
  { 393, 11, 16, 14, 2, -16 },
  { 415, 12, 17, 14, 1, -17 },
  { 441, 10, 17, 14, 2, -17 },
  { 463, 5, 13, 14, 5, -13 },
  { 472, 6, 17, 14, 4, -13 },
  { 485, 10, 10, 14, 2, -12 },
  { 498, 11, 7, 14, 1, -11 },
  { 508, 11, 10, 14, 1, -12 },
  { 522, 9, 17, 14, 3, -17 },
  { 542, 12, 16, 14, 1, -16 },
  { 566, 12, 16, 14, 0, -16 },
  { 590, 12, 16, 14, 1, -16 },
  { 614, 12, 17, 14, 1, -17 },
  { 640, 12, 16, 14, 1, -16 },
  { 664, 12, 16, 14, 1, -16 },
  { 688, 13, 16, 14, 1, -16 },
  { 714, 12, 17, 14, 1, -17 },
  { 740, 14, 16, 14, 0, -16 },
  { 768, 12, 16, 14, 1, -16 },
  { 792, 12, 16, 14, 1, -16 },
  { 816, 13, 16, 14, 1, -16 },
  { 842, 10, 16, 14, 1, -16 },
  { 862, 14, 16, 14, 0, -16 },
  { 890, 14, 16, 14, 0, -16 },
  { 918, 12, 17, 14, 1, -17 },
  { 944, 12, 16, 14, 1, -16 },
  { 968, 12, 20, 14, 1, -17 },
  { 998, 12, 16, 14, 1, -16 },
  { 1022, 12, 17, 14, 1, -17 },
  { 1048, 12, 16, 14, 2, -16 },
  { 1072, 13, 16, 14, 1, -16 },
  { 1098, 12, 16, 14, 2, -16 },
  { 1122, 12, 16, 14, 2, -16 },
  { 1146, 14, 16, 14, 0, -16 },
  { 1174, 12, 16, 14, 2, -16 },
  { 1198, 13, 16, 14, 0, -16 },
  { 1224, 8, 23, 14, 3, -19 },
  { 1247, 6, 17, 14, 4, -16 },
  { 1260, 8, 23, 14, 3, -19 },
  { 1283, 8, 8, 14, 3, -16 },
  { 1291, 11, 2, 14, 0, 0 },
  { 1294, 4, 3, 14, 6, -17 },
  { 1296, 11, 12, 14, 1, -12 },
  { 1313, 11, 17, 14, 1, -17 },
  { 1337, 11, 12, 14, 1, -12 },
  { 1354, 12, 17, 14, 1, -17 },
  { 1380, 11, 12, 14, 1, -12 },
  { 1397, 12, 18, 14, 2, -18 },
  { 1424, 12, 17, 14, 0, -12 },
  { 1450, 11, 17, 14, 1, -17 },
  { 1474, 10, 17, 14, 1, -17 },
  { 1496, 11, 22, 14, 0, -17 },
  { 1527, 12, 17, 14, 1, -17 },
  { 1553, 10, 17, 14, 1, -17 },
  { 1575, 13, 12, 14, 0, -12 },
  { 1595, 11, 12, 14, 1, -12 },
  { 1612, 11, 12, 14, 1, -12 },
  { 1629, 12, 17, 14, 0, -12 },
  { 1655, 11, 17, 14, 1, -12 },
  { 1679, 11, 12, 14, 2, -12 },
  { 1696, 11, 12, 14, 1, -12 },
  { 1713, 10, 15, 14, 2, -15 },
  { 1732, 10, 12, 14, 2, -12 },
  { 1747, 11, 12, 14, 2, -12 },
  { 1764, 13, 12, 14, 1, -12 },
  { 1784, 13, 12, 14, 0, -12 },
  { 1804, 14, 17, 14, 0, -12 },
  { 1834, 11, 12, 14, 1, -12 },
  { 1851, 9, 22, 14, 3, -18 },
  { 1876, 5, 20, 14, 4, -16 },
  { 1889, 9, 22, 14, 2, -18 },
  { 1914, 13, 5, 14, 0, -9 },
};

const GFXfont RobotoMono_Italic23pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic23pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOMONO_ITALIC23PT7B_H_
