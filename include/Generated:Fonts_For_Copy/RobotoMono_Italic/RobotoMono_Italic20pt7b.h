#ifndef _ROBOTOMONO_ITALIC20PT7B_H_
#define _ROBOTOMONO_ITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x66, 0x40, 0x00, 0xCC, 0x4D, 0x2C, 0xB2, 0x98,
  0x03, 0x20, 0x26, 0x06, 0x40, 0x44, 0x3F, 0xF0, 0xC8, 0x08, 0x81, 0x98,
  0x11, 0x0F, 0xFC, 0x33, 0x02, 0x20, 0x26, 0x06, 0x40, 0x03, 0x00, 0x80,
  0x20, 0x7E, 0x39, 0x8C, 0x33, 0x0C, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x06,
  0x01, 0xB0, 0x6C, 0x19, 0x9C, 0x3E, 0x06, 0x01, 0x80, 0x78, 0x12, 0x2C,
  0x9B, 0x24, 0x5B, 0x1D, 0x80, 0x40, 0x20, 0x1B, 0x85, 0x32, 0x4D, 0x93,
  0x04, 0x81, 0xE0, 0x1F, 0x0C, 0x43, 0x10, 0xCC, 0x37, 0x07, 0x01, 0x81,
  0xF3, 0xEC, 0xF1, 0xA8, 0x7B, 0x0C, 0xC7, 0x1F, 0x60, 0x69, 0x2C, 0x02,
  0x18, 0x60, 0xC3, 0x04, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0x40, 0xC0, 0x81, 0x81, 0x00, 0x10, 0xC0, 0x82, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x30, 0x80, 0x0C, 0x06,
  0x23, 0x3D, 0x73, 0xF0, 0xE0, 0xD0, 0xCC, 0x42, 0x00, 0x06, 0x01, 0x80,
  0x40, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x6D,
  0xBC, 0xFF, 0xFE, 0x5F, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x00,
  0x1F, 0x8C, 0x62, 0x0D, 0x83, 0x61, 0xD8, 0xF4, 0xEF, 0x62, 0xF1, 0xB8,
  0x6C, 0x1B, 0x04, 0x67, 0x0F, 0x80, 0x0D, 0xEE, 0xA6, 0x18, 0x61, 0x84,
  0x10, 0xC3, 0x0C, 0x30, 0x80, 0x1F, 0x8E, 0x33, 0x0D, 0x83, 0x00, 0xC0,
  0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x3F, 0xE0, 0x0F,
  0x86, 0x33, 0x0C, 0xC3, 0x00, 0xC0, 0x60, 0xF0, 0x1E, 0x01, 0x80, 0x24,
  0x19, 0x06, 0x63, 0x0F, 0x80, 0x00, 0xC0, 0x38, 0x0F, 0x03, 0x60, 0xC8,
  0x1B, 0x06, 0x61, 0x8C, 0x61, 0x9F, 0xFF, 0xFF, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x1F, 0xE3, 0xF8, 0x40, 0x18, 0x03, 0x00, 0x7E, 0x1C, 0xE0, 0x0C,
  0x01, 0x80, 0x33, 0x06, 0x20, 0xC6, 0x30, 0x7C, 0x00, 0x07, 0x0F, 0x0E,
  0x06, 0x06, 0x03, 0xF9, 0xCD, 0xC3, 0xC1, 0xE0, 0xF0, 0x68, 0x66, 0x71,
  0xF0, 0xFF, 0xC0, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x1F, 0x86, 0x33, 0x0C, 0xC3,
  0x30, 0xCC, 0x61, 0xF0, 0xCC, 0x61, 0xB0, 0x6C, 0x1B, 0x06, 0x63, 0x0F,
  0x80, 0x3E, 0x31, 0x90, 0x58, 0x3C, 0x1E, 0x0B, 0x0D, 0xCE, 0x7F, 0x01,
  0x81, 0x81, 0x87, 0x87, 0x80, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x02, 0x38,
  0xC0, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x61, 0x8C,
  0x00, 0x00, 0x83, 0x87, 0x8F, 0x0C, 0x07, 0x00, 0xF0, 0x1C, 0x02, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x38, 0x0F, 0x00, 0xE0,
  0x18, 0x3C, 0xF1, 0xE0, 0xC0, 0x00, 0x7E, 0xE7, 0xC3, 0x03, 0x02, 0x06,
  0x0C, 0x18, 0x30, 0x20, 0x00, 0x00, 0x60, 0x60, 0x0F, 0x82, 0x18, 0x81,
  0x27, 0xA5, 0x95, 0x26, 0xA4, 0x95, 0x92, 0xB2, 0x56, 0xD2, 0x6C, 0x40,
  0x04, 0x40, 0x78, 0x00, 0x03, 0x00, 0xC0, 0x70, 0x1E, 0x0D, 0x83, 0x61,
  0x98, 0x62, 0x30, 0x8F, 0xE6, 0x0D, 0x83, 0xC0, 0xF0, 0x30, 0x3F, 0x8C,
  0x72, 0x0D, 0x83, 0x60, 0xD8, 0x67, 0xF1, 0x8E, 0x41, 0xB0, 0x2C, 0x1B,
  0x06, 0xFF, 0x3F, 0x80, 0x1F, 0x8C, 0x32, 0x0D, 0x83, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1B, 0x06, 0x67, 0x0F, 0x80, 0x1F, 0x82,
  0x38, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x19, 0x03, 0x60, 0x6C, 0x19,
  0x83, 0x30, 0xC6, 0xF1, 0xF8, 0x00, 0x3F, 0xE6, 0x00, 0x80, 0x10, 0x06,
  0x00, 0xC0, 0x1F, 0xE3, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xF1,
  0xFE, 0x00, 0x3F, 0xE6, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x1F, 0xE3,
  0xF8, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x8E,
  0x72, 0x0D, 0x81, 0x40, 0x30, 0x0C, 0x03, 0x1F, 0xC0, 0xF0, 0x2C, 0x1B,
  0x06, 0x73, 0x8F, 0x80, 0x10, 0x33, 0x02, 0x30, 0x23, 0x06, 0x30, 0x62,
  0x06, 0x3F, 0xE6, 0x04, 0x60, 0x46, 0x0C, 0x60, 0xC4, 0x0C, 0x40, 0xCC,
  0x08, 0x3F, 0xC1, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0xFF, 0x3F, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x68, 0x13, 0x0C, 0xE6, 0x1F,
  0x00, 0x30, 0xE6, 0x18, 0x86, 0x31, 0x86, 0x60, 0xD8, 0x1F, 0x03, 0xE0,
  0x66, 0x18, 0xC3, 0x0C, 0x61, 0x8C, 0x31, 0x03, 0x00, 0x30, 0x18, 0x0C,
  0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0F, 0xFF,
  0xF8, 0x18, 0x71, 0x87, 0x38, 0xE3, 0xCA, 0x3D, 0xE3, 0xD6, 0x27, 0x62,
  0x66, 0x66, 0x46, 0x4C, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0x18, 0x33,
  0x82, 0x38, 0x63, 0xC6, 0x3C, 0x63, 0x46, 0x26, 0x66, 0x64, 0x62, 0xC6,
  0x3C, 0x63, 0xC6, 0x1C, 0x41, 0xCC, 0x18, 0x1F, 0x8E, 0x62, 0x0D, 0x83,
  0x40, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0x0C, 0x67, 0x0F,
  0x00, 0x3F, 0x86, 0x18, 0xC1, 0x10, 0x36, 0x04, 0xC1, 0x98, 0x73, 0xF8,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x8E, 0x62,
  0x0D, 0x83, 0x40, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x2C, 0x1B, 0x04,
  0x67, 0x0F, 0x80, 0x30, 0x06, 0x3F, 0x8C, 0x72, 0x0C, 0x83, 0x60, 0xD8,
  0x36, 0x39, 0xFC, 0x46, 0x30, 0x8C, 0x33, 0x0C, 0xC1, 0x30, 0x60, 0x1F,
  0x8E, 0x76, 0x0D, 0x81, 0x60, 0x0C, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x6C,
  0x1B, 0x06, 0x63, 0x0F, 0x80, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x20,
  0x6C, 0x09, 0x81, 0x30, 0x66, 0x0C, 0xC1, 0x90, 0x36, 0x04, 0xC0, 0x98,
  0x33, 0x06, 0x61, 0x86, 0x70, 0x78, 0x00, 0xC0, 0xF0, 0x2C, 0x19, 0x06,
  0x43, 0x18, 0xC6, 0x61, 0x98, 0x6C, 0x1B, 0x02, 0x80, 0xE0, 0x30, 0x0C,
  0x00, 0x66, 0x36, 0x66, 0x66, 0x64, 0xE6, 0x4A, 0x44, 0xAC, 0x5A, 0xC5,
  0x28, 0x52, 0x87, 0x38, 0x63, 0x86, 0x30, 0x63, 0x0C, 0x30, 0x38, 0x31,
  0x86, 0x18, 0xC0, 0xCC, 0x0D, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0F, 0x01,
  0xB0, 0x31, 0x83, 0x18, 0x60, 0x8C, 0x0C, 0xC0, 0xD0, 0x66, 0x19, 0x8C,
  0x26, 0x0D, 0x83, 0xC0, 0xE0, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x3F, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFD, 0xFF, 0x00, 0x1C, 0xC3, 0x0C,
  0x30, 0x82, 0x18, 0x61, 0x86, 0x10, 0x41, 0x0C, 0x30, 0xC3, 0x0F, 0x00,
  0x8C, 0xCC, 0x44, 0x66, 0x62, 0x23, 0x33, 0x10, 0x1E, 0x0C, 0x18, 0x30,
  0x40, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x23,
  0xC0, 0x0C, 0x0C, 0x1C, 0x36, 0x36, 0x62, 0xC3, 0xFF, 0x80, 0xE3, 0x0E,
  0x1F, 0x98, 0x60, 0x30, 0x19, 0xFD, 0x87, 0x82, 0xC3, 0x73, 0x9F, 0xC0,
  0x30, 0x18, 0x0C, 0x04, 0x06, 0xE3, 0xF9, 0xC6, 0xC3, 0x60, 0xA0, 0xF0,
  0x78, 0x3C, 0x37, 0x3A, 0xF8, 0x0E, 0x1F, 0xD8, 0x6C, 0x1C, 0x06, 0x03,
  0x01, 0x80, 0xC1, 0xB3, 0x8F, 0x80, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0xCC, 0x7F, 0x98, 0x63, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x30,
  0xCE, 0x0F, 0xC0, 0x0E, 0x1F, 0x9C, 0x6C, 0x1C, 0x0F, 0xFF, 0x01, 0x80,
  0xC1, 0x31, 0xCF, 0x80, 0x07, 0xC3, 0x01, 0x80, 0x60, 0xFF, 0xBF, 0xE1,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x00, 0x07,
  0x63, 0xFC, 0xC3, 0x18, 0x66, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x61, 0x86,
  0x70, 0x7E, 0x00, 0xC4, 0x19, 0xCE, 0x0F, 0x80, 0x30, 0x18, 0x0C, 0x04,
  0x06, 0x73, 0xFD, 0xC6, 0xC3, 0x61, 0xA0, 0xF0, 0x78, 0x3C, 0x1E, 0x0A,
  0x0C, 0x07, 0x01, 0x00, 0x07, 0xC7, 0xE0, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x01, 0x80, 0x40, 0x01, 0xF1, 0xF8, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x0C,
  0x7C, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0xD8, 0xE6, 0x71, 0xB8,
  0x78, 0x1E, 0x0E, 0xC3, 0x38, 0xC6, 0x30, 0xCC, 0x38, 0x3F, 0x1F, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC7,
  0xFF, 0xFE, 0x2C, 0xC7, 0xFD, 0x99, 0xB3, 0x36, 0x66, 0x8C, 0xD1, 0x1E,
  0x22, 0xCC, 0x59, 0x9B, 0x33, 0x00, 0x67, 0x3F, 0xDC, 0x6C, 0x36, 0x1A,
  0x0F, 0x07, 0x83, 0xC1, 0x60, 0xA0, 0xC0, 0x0E, 0x1F, 0x98, 0x6C, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0x33, 0x8F, 0x80, 0x37, 0x0F, 0xE3, 0x0C,
  0xC3, 0x30, 0xC8, 0x36, 0x0D, 0x83, 0x61, 0x9C, 0xE7, 0xF1, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x0E, 0xCF, 0xF6, 0x19, 0x82, 0xC1, 0xB0, 0x6C, 0x1B,
  0x06, 0xC1, 0x19, 0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x33, 0x97,
  0xCE, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x00, 0x0E,
  0x1F, 0xD8, 0x6C, 0x13, 0x01, 0xF0, 0x1C, 0x03, 0xC1, 0xB1, 0x8F, 0x80,
  0x18, 0x0C, 0x3F, 0xFF, 0xE3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08,
  0x06, 0x41, 0xE0, 0x20, 0xD8, 0x36, 0x09, 0x82, 0x61, 0x90, 0x64, 0x1B,
  0x06, 0xC3, 0x19, 0xC7, 0xF0, 0x80, 0xE0, 0xF0, 0x58, 0x64, 0x62, 0x31,
  0xB0, 0xD8, 0x38, 0x18, 0x0C, 0x00, 0xC4, 0x38, 0x8F, 0x31, 0x66, 0x6D,
  0xED, 0xAD, 0x35, 0xE3, 0x38, 0x63, 0x0C, 0x61, 0x08, 0x00, 0x30, 0x62,
  0x1C, 0x63, 0x06, 0xC0, 0xF0, 0x0C, 0x03, 0x80, 0xD8, 0x31, 0x0E, 0x33,
  0x83, 0x00, 0x60, 0x33, 0x06, 0x30, 0x63, 0x0C, 0x10, 0x81, 0x98, 0x1B,
  0x01, 0xB0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0xE0,
  0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x2F, 0xF0, 0x01, 0x07, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30,
  0xE0, 0xE0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x08, 0x33,
  0x22, 0x22, 0x66, 0x44, 0x44, 0xCC, 0xC8, 0x88, 0x20, 0x38, 0x08, 0x0C,
  0x0C, 0x0C, 0x08, 0x08, 0x0C, 0x07, 0x0E, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x60, 0xC0, 0x80, 0x38, 0x0F, 0x87, 0x1F, 0xA1, 0xE0,
};

const GFXglyph RobotoMono_Italic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 14, 12, 4, -14 },
  { 8, 6, 5, 12, 4, -15 },
  { 12, 12, 14, 12, 0, -14 },
  { 33, 10, 19, 12, 1, -17 },
  { 57, 10, 14, 12, 1, -14 },
  { 75, 10, 14, 12, 1, -14 },
  { 93, 3, 5, 12, 5, -15 },
  { 95, 7, 21, 12, 3, -16 },
  { 114, 6, 21, 12, 2, -16 },
  { 130, 9, 9, 12, 2, -14 },
  { 141, 10, 11, 12, 1, -12 },
  { 155, 3, 5, 12, 2, -2 },
  { 157, 8, 2, 12, 2, -7 },
  { 159, 3, 3, 12, 4, -3 },
  { 161, 10, 15, 12, 1, -14 },
  { 180, 10, 14, 12, 1, -14 },
  { 198, 6, 14, 12, 3, -14 },
  { 209, 10, 14, 12, 0, -14 },
  { 227, 10, 14, 12, 0, -14 },
  { 245, 11, 14, 12, 0, -14 },
  { 265, 11, 14, 12, 1, -14 },
  { 285, 9, 14, 12, 1, -14 },
  { 301, 10, 14, 12, 2, -14 },
  { 319, 10, 14, 12, 1, -14 },
  { 337, 9, 14, 12, 2, -14 },
  { 353, 5, 12, 12, 4, -12 },
  { 361, 6, 15, 12, 3, -12 },
  { 373, 9, 9, 12, 2, -11 },
  { 384, 10, 5, 12, 1, -9 },
  { 391, 9, 9, 12, 1, -11 },
  { 402, 8, 14, 12, 3, -14 },
  { 416, 11, 14, 12, 1, -14 },
  { 436, 10, 14, 12, 0, -14 },
  { 454, 10, 14, 12, 1, -14 },
  { 472, 10, 14, 12, 1, -14 },
  { 490, 11, 14, 12, 0, -14 },
  { 510, 11, 14, 12, 1, -14 },
  { 530, 11, 14, 12, 1, -14 },
  { 550, 10, 14, 12, 1, -14 },
  { 568, 12, 14, 12, 0, -14 },
  { 589, 10, 14, 12, 1, -14 },
  { 607, 10, 14, 12, 1, -14 },
  { 625, 11, 14, 12, 1, -14 },
  { 645, 9, 14, 12, 1, -14 },
  { 661, 12, 14, 12, 0, -14 },
  { 682, 12, 14, 12, 0, -14 },
  { 703, 10, 14, 12, 1, -14 },
  { 721, 11, 14, 12, 1, -14 },
  { 741, 10, 16, 12, 1, -14 },
  { 761, 10, 14, 12, 1, -14 },
  { 779, 10, 14, 12, 1, -14 },
  { 797, 10, 14, 12, 2, -14 },
  { 815, 11, 14, 12, 1, -14 },
  { 835, 10, 14, 12, 2, -14 },
  { 853, 12, 14, 12, 1, -14 },
  { 874, 12, 14, 12, 0, -14 },
  { 895, 10, 14, 12, 2, -14 },
  { 913, 11, 14, 12, 0, -14 },
  { 933, 6, 19, 12, 3, -16 },
  { 948, 4, 15, 12, 4, -14 },
  { 956, 7, 19, 12, 2, -16 },
  { 973, 8, 7, 12, 2, -14 },
  { 980, 9, 1, 12, 0, 0 },
  { 982, 4, 2, 12, 5, -14 },
  { 983, 9, 11, 12, 1, -11 },
  { 996, 9, 15, 12, 1, -15 },
  { 1013, 9, 11, 12, 1, -11 },
  { 1026, 11, 15, 12, 1, -15 },
  { 1047, 9, 11, 12, 1, -11 },
  { 1060, 10, 15, 12, 2, -15 },
  { 1079, 11, 15, 12, 0, -11 },
  { 1100, 9, 15, 12, 1, -15 },
  { 1117, 9, 14, 12, 1, -14 },
  { 1133, 9, 18, 12, 0, -14 },
  { 1154, 10, 15, 12, 1, -15 },
  { 1173, 9, 15, 12, 1, -15 },
  { 1190, 11, 11, 12, 0, -11 },
  { 1206, 9, 11, 12, 1, -11 },
  { 1219, 9, 11, 12, 1, -11 },
  { 1232, 10, 15, 12, 0, -11 },
  { 1251, 10, 15, 12, 1, -11 },
  { 1270, 9, 11, 12, 2, -11 },
  { 1283, 9, 11, 12, 1, -11 },
  { 1296, 9, 13, 12, 2, -13 },
  { 1311, 10, 11, 12, 1, -11 },
  { 1325, 9, 11, 12, 2, -11 },
  { 1338, 11, 11, 12, 1, -11 },
  { 1354, 11, 11, 12, 0, -11 },
  { 1370, 12, 15, 12, 0, -11 },
  { 1393, 10, 11, 12, 1, -11 },
  { 1407, 8, 20, 12, 3, -16 },
  { 1427, 4, 18, 12, 4, -14 },
  { 1436, 8, 20, 12, 2, -16 },
  { 1456, 11, 4, 12, 0, -8 },
};

const GFXfont RobotoMono_Italic20pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic20pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOMONO_ITALIC20PT7B_H_
