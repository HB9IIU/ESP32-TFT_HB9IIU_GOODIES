#ifndef _ROBOTOMONO_ITALIC15PT7B_H_
#define _ROBOTOMONO_ITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x96, 0x12, 0x00, 0xD9, 0x90, 0x05, 0x84, 0x82, 0x4F,
  0xF1, 0x20, 0x90, 0x91, 0xFE, 0x24, 0x24, 0x12, 0x00, 0x08, 0x38, 0xDB,
  0x14, 0x2C, 0x0E, 0x06, 0x07, 0x0B, 0x33, 0xC2, 0x04, 0x00, 0x61, 0x22,
  0x5C, 0xA6, 0x82, 0x0D, 0x15, 0x52, 0xA4, 0x30, 0x0C, 0x12, 0x32, 0x36,
  0x1C, 0x38, 0x69, 0x4D, 0xC6, 0x46, 0x7B, 0xE8, 0x08, 0xCC, 0x46, 0x21,
  0x08, 0xC6, 0x30, 0x84, 0x20, 0x80, 0x20, 0x86, 0x10, 0x84, 0x21, 0x08,
  0xC4, 0x22, 0x33, 0x00, 0x10, 0x49, 0x7F, 0x31, 0x4D, 0x84, 0x18, 0x30,
  0x47, 0xFF, 0xE2, 0x0C, 0x18, 0x2D, 0xE0, 0xFC, 0xF0, 0x02, 0x04, 0x10,
  0x60, 0x83, 0x04, 0x18, 0x20, 0x81, 0x04, 0x00, 0x1C, 0x4D, 0x0A, 0x1C,
  0xFB, 0x79, 0xE3, 0x85, 0x99, 0xE0, 0x0B, 0xB4, 0x21, 0x18, 0xC4, 0x21,
  0x18, 0x1C, 0x32, 0x63, 0x03, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE,
  0x1C, 0x32, 0x63, 0x03, 0x02, 0x1C, 0x06, 0x02, 0xC2, 0x44, 0x7C, 0x03,
  0x06, 0x0E, 0x0A, 0x12, 0x26, 0x66, 0xFF, 0xFF, 0x04, 0x0C, 0x3F, 0x3E,
  0x20, 0x60, 0x7C, 0x64, 0x06, 0x06, 0x84, 0xCC, 0x78, 0x0C, 0xF6, 0x10,
  0xFB, 0x18, 0x61, 0x87, 0x37, 0x80, 0x7F, 0x7E, 0x02, 0x04, 0x0C, 0x08,
  0x10, 0x10, 0x20, 0x60, 0xC0, 0x1C, 0x6D, 0x8A, 0x16, 0x67, 0x11, 0x63,
  0x85, 0x89, 0xE0, 0x18, 0xC9, 0x1A, 0x1C, 0x28, 0xDF, 0x82, 0x0C, 0x31,
  0xC0, 0x2C, 0x00, 0x36, 0x13, 0x00, 0x00, 0x26, 0x6C, 0x06, 0x39, 0xC6,
  0x03, 0x01, 0x81, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x40, 0xE0, 0x30, 0x73,
  0x98, 0x20, 0x00, 0x39, 0x38, 0x41, 0x08, 0x62, 0x18, 0x01, 0x04, 0x00,
  0x0E, 0x08, 0x89, 0x49, 0x55, 0x2A, 0xA6, 0x95, 0x3A, 0x56, 0x20, 0x0F,
  0x00, 0x04, 0x0C, 0x0C, 0x1E, 0x16, 0x32, 0x22, 0x7E, 0x42, 0x42, 0x83,
  0x3C, 0x3F, 0x21, 0x21, 0x23, 0x7C, 0x62, 0x43, 0x43, 0x46, 0xFC, 0x1C,
  0x4D, 0x0E, 0x18, 0x10, 0x20, 0x40, 0x87, 0x99, 0xE0, 0x3C, 0x26, 0x21,
  0x21, 0x61, 0x61, 0x41, 0x43, 0x42, 0x46, 0xF8, 0x7F, 0x7E, 0x40, 0x40,
  0x40, 0xFC, 0xC0, 0x80, 0x80, 0x80, 0xFC, 0x7F, 0x7F, 0x40, 0x40, 0x40,
  0x7C, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x1C, 0x4D, 0x0E, 0x08, 0x10, 0x23,
  0xC3, 0x87, 0x89, 0xE0, 0x20, 0x90, 0xC8, 0x44, 0x26, 0x13, 0xF9, 0x0C,
  0x86, 0x42, 0x61, 0x30, 0x80, 0x3F, 0x9F, 0x83, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x3F, 0x80, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30,
  0x18, 0x08, 0x04, 0xC2, 0x23, 0x0F, 0x00, 0x31, 0x90, 0x88, 0x84, 0x82,
  0x83, 0xC1, 0xB0, 0x88, 0x44, 0x23, 0x30, 0xC0, 0x61, 0x84, 0x10, 0x41,
  0x0C, 0x30, 0x82, 0x0F, 0xC0, 0x31, 0x98, 0xCC, 0xE6, 0x67, 0x52, 0xA9,
  0x24, 0x96, 0x42, 0x21, 0x30, 0x80, 0x21, 0x98, 0xCC, 0x46, 0x26, 0x93,
  0x49, 0x2C, 0x9E, 0x46, 0x23, 0x31, 0x80, 0x1C, 0x4D, 0x0E, 0x18, 0x30,
  0x60, 0xC3, 0x85, 0x99, 0xE0, 0x7C, 0x66, 0x43, 0x43, 0x42, 0x46, 0xF8,
  0xC0, 0x80, 0x80, 0x80, 0x1C, 0xCD, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x85,
  0x99, 0xE0, 0x60, 0x40, 0x78, 0x8D, 0x0A, 0x14, 0x39, 0xBE, 0x44, 0x8D,
  0x0A, 0x10, 0x1C, 0x66, 0x42, 0x41, 0x60, 0x38, 0x0C, 0x06, 0x86, 0xC4,
  0x78, 0x7F, 0xFF, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20,
  0x41, 0x43, 0x42, 0x42, 0xC2, 0x82, 0x86, 0x86, 0x84, 0xCC, 0x78, 0xC1,
  0x43, 0x42, 0x46, 0x44, 0x6C, 0x68, 0x28, 0x30, 0x30, 0x20, 0xC9, 0xD9,
  0xD9, 0xDB, 0xFA, 0xAA, 0xAA, 0xAC, 0xCC, 0xCC, 0xCC, 0x21, 0x98, 0x84,
  0xC2, 0xC1, 0xC0, 0x40, 0x70, 0x68, 0x26, 0x31, 0x30, 0xC0, 0x83, 0x0B,
  0x32, 0x45, 0x8A, 0x18, 0x30, 0x60, 0x81, 0x00, 0x3F, 0x3F, 0x02, 0x06,
  0x0C, 0x08, 0x10, 0x30, 0x60, 0x40, 0xFE, 0x39, 0x08, 0x42, 0x31, 0x08,
  0x42, 0x11, 0x8C, 0x70, 0x92, 0x64, 0x92, 0x64, 0x90, 0x38, 0xC6, 0x21,
  0x08, 0x46, 0x31, 0x08, 0x42, 0x70, 0x11, 0x8C, 0xB4, 0xC4, 0xFE, 0xD0,
  0x3C, 0x88, 0x19, 0xEC, 0x50, 0xA3, 0x7A, 0x30, 0x20, 0x20, 0x3E, 0x32,
  0x63, 0x63, 0x43, 0x42, 0x66, 0xFC, 0x3C, 0xCF, 0x0C, 0x08, 0x10, 0x73,
  0x3C, 0x03, 0x02, 0x02, 0x3A, 0x46, 0xC6, 0x86, 0x84, 0x84, 0xCC, 0x74,
  0x3C, 0xCB, 0x1F, 0xF8, 0x10, 0x31, 0x3C, 0x02, 0x0F, 0x18, 0x10, 0x7E,
  0x90, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x1D, 0x23, 0x63, 0x43, 0x42,
  0x42, 0x66, 0x3A, 0x06, 0xC4, 0x78, 0x30, 0x20, 0x20, 0x2E, 0x33, 0x63,
  0x63, 0x42, 0x42, 0x42, 0xC2, 0x08, 0x20, 0x1E, 0x18, 0x61, 0x04, 0x10,
  0x4F, 0xC0, 0x02, 0x0C, 0x00, 0xF0, 0x40, 0x81, 0x02, 0x0C, 0x18, 0x20,
  0x41, 0x9E, 0x00, 0x30, 0x20, 0x20, 0x23, 0x26, 0x6C, 0x78, 0x68, 0x4C,
  0x44, 0xC6, 0x7C, 0x20, 0x82, 0x18, 0x61, 0x04, 0x10, 0x4F, 0xC0, 0x7F,
  0x49, 0x49, 0x49, 0xC9, 0xDB, 0x93, 0x92, 0x2E, 0x33, 0x63, 0x63, 0x42,
  0x42, 0x42, 0xC6, 0x3C, 0x8B, 0x1C, 0x38, 0x70, 0xB3, 0x3C, 0x3E, 0x22,
  0x63, 0x63, 0x43, 0x42, 0x46, 0x7C, 0xC0, 0xC0, 0x80, 0x3A, 0x8F, 0x1C,
  0x28, 0x50, 0xB3, 0x3A, 0x0C, 0x10, 0x20, 0x5D, 0x84, 0x30, 0xC2, 0x08,
  0x20, 0x3C, 0x8D, 0x03, 0x81, 0xC0, 0xB1, 0x3C, 0x10, 0x23, 0xF9, 0x83,
  0x04, 0x08, 0x10, 0x20, 0x78, 0x42, 0x87, 0x1E, 0x38, 0x50, 0xB3, 0x3A,
  0xC3, 0x46, 0x44, 0x4C, 0x68, 0x38, 0x30, 0x20, 0x91, 0x9B, 0x9A, 0xAA,
  0xAC, 0xCC, 0xCC, 0x88, 0x61, 0x99, 0x05, 0x03, 0x81, 0x81, 0xA1, 0x91,
  0x84, 0x61, 0x90, 0x88, 0x84, 0xC3, 0x40, 0xE0, 0x60, 0x20, 0x30, 0x10,
  0x30, 0x00, 0x3F, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0x04, 0x21,
  0x04, 0x10, 0x42, 0x30, 0x20, 0x82, 0x08, 0x20, 0x81, 0x00, 0x25, 0xA4,
  0x92, 0x52, 0x49, 0x00, 0x20, 0x41, 0x86, 0x18, 0x61, 0x83, 0x10, 0x43,
  0x0C, 0x21, 0x88, 0x00, 0x71, 0xD9, 0x87,
};

const GFXglyph RobotoMono_Italic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 4, 3, 9, 3, -11 },
  { 8, 9, 11, 9, 0, -11 },
  { 21, 7, 14, 9, 1, -12 },
  { 34, 7, 11, 9, 1, -11 },
  { 44, 8, 11, 9, 0, -11 },
  { 55, 2, 3, 9, 4, -11 },
  { 56, 5, 15, 9, 2, -12 },
  { 66, 5, 15, 9, 1, -12 },
  { 76, 6, 8, 9, 2, -11 },
  { 82, 7, 8, 9, 1, -9 },
  { 89, 3, 4, 9, 1, -2 },
  { 91, 6, 1, 9, 1, -5 },
  { 92, 2, 2, 9, 3, -2 },
  { 93, 7, 12, 9, 1, -11 },
  { 104, 7, 11, 9, 1, -11 },
  { 114, 5, 11, 9, 2, -11 },
  { 121, 8, 11, 9, 0, -11 },
  { 132, 8, 11, 9, 0, -11 },
  { 143, 8, 11, 9, 0, -11 },
  { 154, 8, 11, 9, 1, -11 },
  { 165, 6, 11, 9, 1, -11 },
  { 174, 8, 11, 9, 1, -11 },
  { 185, 7, 11, 9, 1, -11 },
  { 195, 7, 11, 9, 1, -11 },
  { 205, 3, 8, 9, 3, -8 },
  { 208, 4, 10, 9, 2, -8 },
  { 213, 7, 7, 9, 1, -8 },
  { 220, 7, 4, 9, 1, -7 },
  { 224, 7, 7, 9, 1, -8 },
  { 231, 6, 11, 9, 2, -11 },
  { 240, 9, 11, 9, 0, -11 },
  { 253, 8, 11, 9, 0, -11 },
  { 264, 8, 11, 9, 0, -11 },
  { 275, 7, 11, 9, 1, -11 },
  { 285, 8, 11, 9, 0, -11 },
  { 296, 8, 11, 9, 1, -11 },
  { 307, 8, 11, 9, 1, -11 },
  { 318, 7, 11, 9, 1, -11 },
  { 328, 9, 11, 9, 0, -11 },
  { 341, 9, 11, 9, 0, -11 },
  { 354, 9, 11, 9, 0, -11 },
  { 367, 9, 11, 9, 0, -11 },
  { 380, 6, 11, 9, 1, -11 },
  { 389, 9, 11, 9, 0, -11 },
  { 402, 9, 11, 9, 0, -11 },
  { 415, 7, 11, 9, 1, -11 },
  { 425, 8, 11, 9, 1, -11 },
  { 436, 7, 13, 9, 1, -11 },
  { 448, 7, 11, 9, 1, -11 },
  { 458, 8, 11, 9, 1, -11 },
  { 469, 8, 11, 9, 1, -11 },
  { 480, 8, 11, 9, 1, -11 },
  { 491, 8, 11, 9, 1, -11 },
  { 502, 8, 11, 9, 1, -11 },
  { 513, 9, 11, 9, 0, -11 },
  { 526, 7, 11, 9, 2, -11 },
  { 536, 8, 11, 9, 0, -11 },
  { 547, 5, 14, 9, 2, -12 },
  { 556, 3, 12, 9, 3, -11 },
  { 561, 5, 14, 9, 2, -12 },
  { 570, 5, 6, 9, 2, -11 },
  { 574, 7, 1, 9, 0, 0 },
  { 575, 2, 2, 9, 4, -11 },
  { 576, 7, 8, 9, 1, -8 },
  { 583, 8, 11, 9, 0, -11 },
  { 594, 7, 8, 9, 1, -8 },
  { 601, 8, 11, 9, 1, -11 },
  { 612, 7, 8, 9, 1, -8 },
  { 619, 8, 12, 9, 1, -12 },
  { 631, 8, 11, 9, 0, -8 },
  { 642, 8, 11, 9, 0, -11 },
  { 653, 6, 11, 9, 1, -11 },
  { 662, 7, 14, 9, 0, -11 },
  { 675, 8, 11, 9, 0, -11 },
  { 686, 6, 11, 9, 1, -11 },
  { 695, 8, 8, 9, 0, -8 },
  { 703, 8, 8, 9, 0, -8 },
  { 711, 7, 8, 9, 1, -8 },
  { 718, 8, 11, 9, 0, -8 },
  { 729, 7, 11, 9, 1, -8 },
  { 739, 6, 8, 9, 2, -8 },
  { 745, 7, 8, 9, 1, -8 },
  { 752, 7, 10, 9, 1, -10 },
  { 761, 7, 8, 9, 1, -8 },
  { 768, 8, 8, 9, 1, -8 },
  { 776, 8, 8, 9, 1, -8 },
  { 784, 9, 8, 9, 0, -8 },
  { 793, 9, 11, 9, 0, -8 },
  { 806, 8, 8, 9, 0, -8 },
  { 814, 6, 15, 9, 2, -12 },
  { 826, 3, 14, 9, 3, -11 },
  { 832, 6, 15, 9, 1, -12 },
  { 844, 8, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_Italic15pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic15pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOMONO_ITALIC15PT7B_H_
