#ifndef _ROBOTOMONO_ITALIC44PT7B_H_
#define _ROBOTOMONO_ITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0xE0,
  0xF8, 0x3E, 0x07, 0x00, 0x78, 0x77, 0x07, 0x70, 0x77, 0x0F, 0x70, 0xE7,
  0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x07,
  0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x0E, 0x0F, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC0, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x83, 0xC0,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0x7C, 0x1F, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x04, 0x70, 0x70, 0x7B, 0x83, 0x83, 0x9C,
  0x1C, 0x38, 0xE0, 0xE3, 0xC7, 0x07, 0x1C, 0x38, 0x71, 0xC0, 0xFF, 0x9C,
  0x07, 0xF8, 0xE0, 0x1F, 0x8E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x9F, 0x80, 0x39, 0xFF,
  0x03, 0x9E, 0x78, 0x3C, 0xE1, 0xC1, 0xC7, 0x07, 0x1C, 0x70, 0x39, 0xE3,
  0x81, 0xCE, 0x1C, 0x1C, 0x20, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x70,
  0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x78, 0x03, 0x81, 0xE0, 0x07, 0x03,
  0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7C, 0xF0, 0x39, 0xF1, 0xE0, 0xF3, 0xC1, 0xE1, 0xEF, 0x03, 0xE3, 0x9E,
  0x03, 0xCF, 0x3C, 0x07, 0xFC, 0xF0, 0x07, 0xF9, 0xE0, 0x07, 0xE1, 0xE0,
  0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0x9E, 0x07, 0xFC, 0x3E, 0x7B, 0xDC, 0xE7, 0x3B, 0xDC, 0xE7, 0x00, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x03, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x60, 0x70, 0x6F, 0xC6, 0x3E, 0xFF, 0x6F, 0xF7,
  0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0x38, 0x01, 0xE3, 0xC0, 0x3E, 0x1C, 0x07, 0xC1, 0xE0, 0x78, 0x1F,
  0x03, 0x00, 0xC0, 0x10, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFA, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x0F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF0, 0x60, 0x7F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x33, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8,
  0x1F, 0x07, 0x80, 0x78, 0x78, 0x01, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xF7, 0x80, 0x7F, 0xBC, 0x07,
  0xFD, 0xE0, 0xFD, 0xCF, 0x0F, 0x9E, 0xF0, 0xF8, 0xF7, 0x9F, 0x07, 0xBD,
  0xF0, 0x3D, 0xFF, 0x01, 0xEF, 0xE0, 0x0E, 0x7E, 0x00, 0xF3, 0xC0, 0x07,
  0x9C, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF0, 0xF0,
  0x0F, 0x07, 0xC1, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x18, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x3F, 0x7B, 0xC3, 0xD0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0,
  0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x3E, 0x1E, 0x00, 0xF0, 0x7C, 0x0F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x07,
  0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x38,
  0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x07, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xBF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xF8, 0x7C, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x40, 0x3C,
  0xFF, 0x07, 0xBF, 0xF0, 0xEF, 0xFF, 0x1F, 0x81, 0xF7, 0xE0, 0x1E, 0xF8,
  0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF1, 0xE0,
  0x3E, 0x3E, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x7C, 0x0F, 0x07, 0xC0, 0x7C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE0, 0xF0,
  0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC1, 0xF0, 0x7C, 0x7C, 0x07, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x07, 0xEF, 0x81, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFD, 0xE0, 0xFF, 0x38, 0x03, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x05, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x06, 0x07, 0x87, 0xE3, 0xF1,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0xF8, 0x00,
  0x00, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x06, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0x10, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE,
  0x7C, 0x0F, 0x9E, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x7C,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x06, 0x0E, 0x07, 0x87,
  0x0E, 0x1F, 0xC7, 0x1C, 0x3F, 0xE3, 0x1C, 0x78, 0xC3, 0x38, 0x70, 0xC3,
  0x38, 0xE0, 0xC3, 0x30, 0xC1, 0xC3, 0x71, 0xC1, 0xC3, 0x71, 0xC1, 0x83,
  0x71, 0x81, 0x87, 0x61, 0x83, 0x86, 0x63, 0x83, 0x86, 0xE3, 0x83, 0x06,
  0xE3, 0x87, 0x0C, 0xE3, 0x8F, 0x0C, 0xE1, 0xFF, 0xB8, 0x61, 0xFB, 0xF8,
  0x60, 0xF1, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x02, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0x80, 0x07,
  0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0x38, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C,
  0x3C, 0x00, 0x38, 0x78, 0x00, 0x71, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0xC1,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0xF8, 0x78, 0x03, 0xE0, 0xE0, 0x1F, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1E, 0x03, 0xF0, 0x3C, 0x01, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xC3,
  0xC0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7C, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x0E, 0x1E,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0x81, 0xF8, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E,
  0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78,
  0x01, 0xF0, 0x78, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x7F, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C,
  0x07, 0x81, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0xFD,
  0xE0, 0x1F, 0xFB, 0xC0, 0x7F, 0xE7, 0x80, 0xFF, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xF0, 0x3E, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78,
  0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE0,
  0x78, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC3,
  0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0E, 0x7C, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xE7, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0xC0,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x07,
  0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1D, 0xC1,
  0xFE, 0x0E, 0xE0, 0xEF, 0x07, 0x70, 0xF7, 0x07, 0xBC, 0x73, 0x83, 0xDE,
  0x7B, 0xC1, 0xE7, 0x39, 0xE0, 0xF3, 0xBC, 0xF0, 0x71, 0xDC, 0x78, 0x38,
  0xFE, 0x38, 0x3C, 0x7E, 0x3C, 0x1E, 0x3F, 0x1E, 0x0F, 0x1F, 0x0F, 0x07,
  0x87, 0x87, 0x83, 0x83, 0x83, 0xC3, 0xC1, 0xC1, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E,
  0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xC0, 0xF8,
  0x01, 0xE0, 0xFE, 0x00, 0xF0, 0x7F, 0x00, 0x78, 0x3F, 0x80, 0x3C, 0x1F,
  0xE0, 0x1C, 0x0F, 0xF0, 0x1E, 0x0F, 0x78, 0x0F, 0x07, 0x9E, 0x07, 0x83,
  0xCF, 0x03, 0xC1, 0xE7, 0x81, 0xE0, 0xF1, 0xE1, 0xE0, 0x78, 0xF0, 0xF0,
  0x78, 0x78, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x8F,
  0x07, 0x81, 0xEF, 0x03, 0xC0, 0xF7, 0x83, 0xC0, 0x7B, 0xC1, 0xE0, 0x1F,
  0xE0, 0xF0, 0x0F, 0xF0, 0x78, 0x07, 0xF8, 0x3C, 0x01, 0xF8, 0x1C, 0x00,
  0xFC, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xE0,
  0x07, 0x87, 0x80, 0x3E, 0x0F, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C,
  0x1C, 0x01, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x73, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x38, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xF0, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xE0, 0x3E, 0x03,
  0xE0, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x78,
  0x07, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE1, 0xE0, 0x07, 0x83, 0x80, 0x1F, 0x0F, 0x00, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1, 0xF0,
  0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xE0,
  0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x7E, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x70, 0x00,
  0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0x78, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07,
  0x03, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xE7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x07,
  0xC1, 0xE7, 0x83, 0xE0, 0xE3, 0xC3, 0xF0, 0xF1, 0xE1, 0xF8, 0x78, 0xF0,
  0xFC, 0x38, 0x78, 0xFE, 0x1C, 0x3C, 0x77, 0x1E, 0x1C, 0x3B, 0x8F, 0x0E,
  0x3D, 0xC7, 0x07, 0x1C, 0xE3, 0x83, 0x8E, 0x73, 0xC1, 0xCF, 0x39, 0xE0,
  0xE7, 0x1C, 0xE0, 0x73, 0x8E, 0xF0, 0x3B, 0xC7, 0x78, 0x1D, 0xC3, 0xB8,
  0x0E, 0xE1, 0xDC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xC0,
  0x3C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x1F, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x81, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x78, 0x01,
  0xE1, 0xE0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00,
  0x70, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x39,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xFC, 0x03, 0xBC, 0x07, 0x9C, 0x07, 0x1C, 0x0F, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF1, 0xE1, 0xE1, 0xC1,
  0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF2, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xE0, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03,
  0xCF, 0x80, 0x7C, 0x7C, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFB, 0xC1, 0xFE,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0xF3, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0x03, 0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x38,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0xF0,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03,
  0xE3, 0x80, 0x0F, 0x1F, 0x00, 0x7C, 0x7E, 0x03, 0xE1, 0xFC, 0x1F, 0x87,
  0xFF, 0xFC, 0x1C, 0xFF, 0xE0, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x03, 0xE3,
  0xE0, 0x1E, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80,
  0x78, 0x7C, 0x0F, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x01, 0xC1, 0xE0, 0x3F, 0xE7, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7C, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x7E,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xE7, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x0F, 0x80,
  0x78, 0x78, 0x01, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x20, 0x78,
  0x03, 0x83, 0xE0, 0x7E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0xE0,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x3C, 0x0F, 0xFF, 0x70, 0x3F,
  0xFF, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x81,
  0xF0, 0x7E, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x00, 0x3E, 0x07, 0x00,
  0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0xF1, 0xFE, 0x03, 0xDF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x0E, 0x1E, 0x00, 0x78, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x78, 0x07, 0xC0, 0xF0, 0x1F,
  0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x1E, 0x3F, 0x00,
  0x3C, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x9E, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3E, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x18,
  0x07, 0x7F, 0x3F, 0x07, 0xFF, 0xBF, 0xC3, 0xFF, 0xFF, 0xE1, 0xE1, 0xF0,
  0xF0, 0xF0, 0x78, 0x38, 0x70, 0x38, 0x1C, 0x38, 0x1C, 0x0E, 0x3C, 0x1E,
  0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3, 0x81,
  0xC0, 0xE1, 0xC0, 0xE0, 0x71, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C, 0x78,
  0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x1C, 0x0E, 0x07, 0x1E, 0x07, 0x03, 0x8F,
  0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF1, 0xC0, 0xF0, 0x78,
  0x00, 0x07, 0x00, 0x3C, 0xFF, 0x80, 0xF7, 0xFF, 0x03, 0xBF, 0xFE, 0x0F,
  0xC0, 0xF8, 0x3E, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00,
  0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0,
  0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0x87, 0x80, 0x1E, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x1F, 0x0F, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF3, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x83, 0xE0,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7E, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0,
  0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3E,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3C, 0x7F, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xF3, 0xC3, 0xFF, 0xDC, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F,
  0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0xF3,
  0x80, 0x0F, 0x1C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xF1, 0xF0, 0x0F, 0x07, 0xC1, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFC, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC1, 0xC7, 0xFC, 0x79, 0xFF, 0x8F, 0x7F, 0xE1,
  0xFF, 0x04, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE3,
  0xE0, 0x1F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0x7C, 0x0F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x20, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x3C, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1C, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3E, 0x03, 0xF0, 0xF0, 0x3F,
  0x07, 0xFF, 0xB8, 0x1F, 0xFB, 0xC0, 0x7F, 0x9E, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xBC, 0x00, 0x3C, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xE1, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xE0, 0x78, 0x0F,
  0x07, 0x80, 0x38, 0x3C, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x79, 0xE0,
  0x01, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x1E, 0xE0, 0x78, 0x1C, 0xE0, 0xF8,
  0x1C, 0xE0, 0xF8, 0x3C, 0xE0, 0xD8, 0x38, 0xE1, 0xD8, 0x38, 0xE1, 0xDC,
  0x70, 0xE3, 0x9C, 0x70, 0xE3, 0x9C, 0xF0, 0xE7, 0x1C, 0xE0, 0xE7, 0x1C,
  0xE0, 0xE7, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEE, 0x1D, 0xC0, 0xEC, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0x83, 0xC0,
  0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x03, 0xC7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE3, 0xC0,
  0x03, 0xE1, 0xE0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F,
  0x03, 0xE0, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0xF0,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x00, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x07, 0x7F, 0xF8, 0x07, 0x78, 0xFC, 0x0E, 0xF0,
  0x3E, 0x1E, 0xE0, 0x1F, 0xFC, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Italic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 31, 26, 8, -31 },
  { 40, 12, 10, 26, 9, -33 },
  { 55, 25, 31, 26, 1, -31 },
  { 152, 21, 40, 26, 3, -36 },
  { 257, 21, 33, 26, 3, -32 },
  { 344, 23, 32, 26, 1, -32 },
  { 436, 5, 10, 26, 12, -33 },
  { 443, 15, 45, 26, 7, -35 },
  { 528, 15, 45, 26, 3, -35 },
  { 613, 20, 21, 26, 5, -31 },
  { 666, 22, 23, 26, 2, -26 },
  { 730, 8, 12, 26, 4, -5 },
  { 742, 17, 3, 26, 4, -15 },
  { 749, 6, 6, 26, 9, -6 },
  { 754, 23, 34, 26, 2, -31 },
  { 852, 21, 32, 26, 3, -32 },
  { 936, 13, 31, 26, 6, -31 },
  { 987, 23, 32, 26, 0, -32 },
  { 1079, 22, 32, 26, 1, -32 },
  { 1167, 22, 31, 26, 1, -31 },
  { 1253, 22, 32, 26, 3, -31 },
  { 1341, 19, 32, 26, 3, -31 },
  { 1417, 22, 31, 26, 4, -31 },
  { 1503, 21, 32, 26, 3, -32 },
  { 1587, 19, 32, 26, 4, -32 },
  { 1663, 9, 25, 26, 10, -25 },
  { 1692, 12, 32, 26, 7, -25 },
  { 1740, 20, 20, 26, 3, -24 },
  { 1790, 21, 12, 26, 3, -20 },
  { 1822, 21, 20, 26, 2, -24 },
  { 1875, 18, 32, 26, 6, -32 },
  { 1947, 24, 31, 26, 1, -31 },
  { 2040, 23, 31, 26, -1, -31 },
  { 2130, 23, 31, 26, 1, -31 },
  { 2220, 23, 33, 26, 2, -32 },
  { 2315, 24, 31, 26, 1, -31 },
  { 2408, 23, 31, 26, 2, -31 },
  { 2498, 24, 31, 26, 2, -31 },
  { 2591, 23, 33, 26, 2, -32 },
  { 2686, 25, 31, 26, 1, -31 },
  { 2783, 24, 31, 26, 1, -31 },
  { 2876, 24, 31, 26, 1, -31 },
  { 2969, 26, 31, 26, 1, -31 },
  { 3070, 19, 31, 26, 2, -31 },
  { 3144, 25, 31, 26, 1, -31 },
  { 3241, 25, 31, 26, 1, -31 },
  { 3338, 22, 32, 26, 2, -32 },
  { 3426, 24, 31, 26, 2, -31 },
  { 3519, 23, 37, 26, 2, -32 },
  { 3626, 23, 31, 26, 2, -31 },
  { 3716, 23, 32, 26, 2, -32 },
  { 3808, 23, 31, 26, 4, -31 },
  { 3898, 24, 31, 26, 2, -31 },
  { 3991, 23, 31, 26, 4, -31 },
  { 4081, 25, 31, 26, 3, -31 },
  { 4178, 27, 31, 26, 0, -31 },
  { 4283, 22, 31, 26, 5, -31 },
  { 4369, 25, 31, 26, 0, -31 },
  { 4466, 15, 43, 26, 6, -36 },
  { 4547, 10, 34, 26, 8, -31 },
  { 4590, 15, 43, 26, 5, -36 },
  { 4671, 16, 16, 26, 5, -31 },
  { 4703, 20, 3, 26, 0, 0 },
  { 4711, 7, 6, 26, 12, -32 },
  { 4717, 20, 24, 26, 2, -24 },
  { 4777, 22, 34, 26, 1, -33 },
  { 4871, 20, 25, 26, 3, -24 },
  { 4934, 22, 33, 26, 3, -33 },
  { 5025, 21, 24, 26, 2, -24 },
  { 5088, 23, 34, 26, 4, -34 },
  { 5186, 23, 33, 26, 1, -24 },
  { 5281, 22, 33, 26, 1, -33 },
  { 5372, 20, 32, 26, 2, -32 },
  { 5452, 20, 41, 26, 1, -32 },
  { 5555, 23, 33, 26, 1, -33 },
  { 5650, 20, 33, 26, 2, -33 },
  { 5733, 25, 24, 26, 0, -24 },
  { 5808, 22, 24, 26, 1, -24 },
  { 5874, 21, 25, 26, 2, -24 },
  { 5940, 23, 33, 26, 0, -24 },
  { 6035, 21, 33, 26, 3, -24 },
  { 6122, 19, 24, 26, 5, -24 },
  { 6179, 20, 24, 26, 3, -24 },
  { 6239, 19, 29, 26, 4, -29 },
  { 6308, 21, 23, 26, 3, -23 },
  { 6369, 21, 23, 26, 4, -23 },
  { 6430, 24, 23, 26, 3, -23 },
  { 6499, 25, 23, 26, 0, -23 },
  { 6571, 27, 32, 26, -1, -23 },
  { 6679, 23, 23, 26, 1, -23 },
  { 6746, 17, 42, 26, 7, -34 },
  { 6836, 9, 40, 26, 8, -31 },
  { 6881, 17, 42, 26, 4, -34 },
  { 6971, 24, 8, 26, 1, -17 },
};

const GFXfont RobotoMono_Italic44pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic44pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _ROBOTOMONO_ITALIC44PT7B_H_
