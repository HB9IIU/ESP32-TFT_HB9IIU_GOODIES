#ifndef _LIBERATIONMONO_BOLD44PT7B_H_
#define _LIBERATIONMONO_BOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78,
  0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x70, 0x01, 0xC0,
  0x70, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0x99, 0xFC, 0x3F, 0x18, 0xFE, 0x3E, 0x18, 0x7E, 0x3E, 0x18,
  0x78, 0x3E, 0x18, 0x00, 0x3F, 0x18, 0x00, 0x3F, 0xD8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x18, 0xFE, 0x00, 0x18, 0x7F, 0x00, 0x18,
  0x3F, 0x1C, 0x18, 0x3F, 0x7C, 0x18, 0x3F, 0x7E, 0x18, 0x3F, 0x7E, 0x18,
  0x7E, 0x3F, 0x98, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x07, 0x8F, 0xF0, 0x03, 0xC7, 0xFE,
  0x00, 0xE1, 0xE3, 0xC0, 0x78, 0xF0, 0xF0, 0x3C, 0x3C, 0x3C, 0x0E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xC3, 0xC0, 0xF0, 0xF1, 0xE0, 0x3C, 0x3C, 0x78,
  0x0F, 0x0F, 0x3C, 0x01, 0xE7, 0xDE, 0x00, 0x7F, 0xE7, 0x80, 0x0F, 0xF3,
  0xC0, 0x01, 0xF9, 0xE7, 0xE0, 0x00, 0x73, 0xFE, 0x00, 0x3D, 0xFF, 0x80,
  0x1E, 0x78, 0xF0, 0x07, 0x3C, 0x3C, 0x03, 0xCF, 0x0F, 0x01, 0xE3, 0xC1,
  0xC0, 0xF0, 0xF0, 0x70, 0x3C, 0x3C, 0x1C, 0x1E, 0x0F, 0x0F, 0x0F, 0x03,
  0xC3, 0xC3, 0xC0, 0x78, 0xF1, 0xE0, 0x1F, 0xF8, 0xF0, 0x03, 0xFC, 0x38,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xE0, 0xFF,
  0xC0, 0xF8, 0xFF, 0xF0, 0x7C, 0x7E, 0xFC, 0x3C, 0x7E, 0x3E, 0x3E, 0x3E,
  0x0F, 0x9F, 0x1F, 0x07, 0xFF, 0x0F, 0x81, 0xFF, 0x87, 0xC0, 0x7F, 0x83,
  0xE0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xF0, 0x7F, 0x80, 0x78, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x78, 0x03, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x06, 0x3C, 0x23, 0xFE, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x3F, 0xFE,
  0x03, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x83, 0xE7, 0xC3, 0xF1, 0xF0, 0x70,
  0xF0, 0x10, 0x20, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xF8,
  0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xCF, 0x1F, 0xFE, 0x78, 0xFF, 0xF3, 0xC7, 0xFF, 0x9E,
  0x3F, 0xFC, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x7E, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xE1, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x03, 0xFD, 0xF8, 0x0F, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFB,
  0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFC, 0x1F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xCF, 0xC0, 0x1F, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0,
  0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF0, 0x0F,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0xFC,
  0x07, 0xEF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7,
  0xF8, 0x7F, 0x9F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x1F,
  0xDF, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC3, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x78, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x81, 0xFB, 0xFF,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x87,
  0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x8F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xDF, 0x80, 0x7F, 0x7F, 0x83, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xE0,
  0x1F, 0xDF, 0x80, 0x7F, 0x7E, 0x01, 0xFD, 0xFC, 0x0F, 0xF7, 0xF8, 0x7F,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFE, 0xFC, 0x3F, 0xF3, 0xF0, 0x3F, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x78, 0x07, 0xE7, 0xE0, 0x3F, 0x0F, 0xC1,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFE, 0x0F, 0xEF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x78, 0x00,
  0x78, 0x38, 0x00, 0x1C, 0x38, 0x1E, 0x7F, 0x1C, 0x3F, 0xBB, 0x9E, 0x3F,
  0xDD, 0xCE, 0x3C, 0x6E, 0xE7, 0x1E, 0x1E, 0x73, 0x9E, 0x0F, 0x1B, 0x8E,
  0x07, 0x8F, 0xC7, 0x03, 0xC7, 0xE7, 0x81, 0xE3, 0xF3, 0xC0, 0xE1, 0xF9,
  0xC0, 0x70, 0xDC, 0xE0, 0x38, 0x6E, 0x70, 0x3C, 0x77, 0x38, 0x1E, 0x3B,
  0x9C, 0x0E, 0x1D, 0xCE, 0x07, 0x0E, 0xE7, 0x07, 0x86, 0x73, 0xC3, 0xC7,
  0x38, 0xE3, 0x67, 0x8E, 0x7F, 0xBF, 0x87, 0x1F, 0x9F, 0x83, 0x87, 0x87,
  0x80, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x10, 0x0F, 0x00,
  0x1C, 0x03, 0xE0, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F,
  0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFE, 0xFC,
  0x03, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xF8, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x03, 0x8F, 0xE0, 0x07, 0xEF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0,
  0x7F, 0xCF, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F,
  0x3F, 0x07, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7F,
  0xFE, 0x00, 0xC3, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD,
  0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xCF, 0xF0, 0x7F, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF1,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xE7, 0xF8, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xE0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFE, 0x0F, 0xC1,
  0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x07,
  0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x7B, 0xFF, 0xF1, 0xEF, 0xFB, 0xC7, 0xBF, 0xEF,
  0x3E, 0xFF, 0xBC, 0xF3, 0xFE, 0xFB, 0xCF, 0xF9, 0xEF, 0x3F, 0xE7, 0xBC,
  0xFF, 0x9F, 0xE3, 0xFE, 0x7F, 0x8F, 0xF8, 0xFE, 0x3F, 0xE3, 0xF8, 0xFF,
  0x8F, 0xC3, 0xFE, 0x3F, 0x0F, 0xF8, 0x7C, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xDF, 0x0F, 0xFE, 0xF8, 0x7F, 0xF7,
  0xC3, 0xFF, 0x9F, 0x1F, 0xFC, 0xF8, 0xFF, 0xE3, 0xE7, 0xFF, 0x1F, 0x3F,
  0xF8, 0xF9, 0xFF, 0xC3, 0xEF, 0xFE, 0x1F, 0x7F, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0,
  0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x9F, 0xC0,
  0xFF, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0x80, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF3,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC,
  0x3F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x7F, 0x01,
  0xFB, 0xF8, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x1E, 0x0F,
  0x9F, 0x87, 0xC3, 0xE3, 0xE3, 0xF0, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F,
  0x9F, 0x0F, 0x8F, 0xE7, 0xC3, 0xE7, 0xF9, 0xF0, 0xFD, 0xFE, 0x7C, 0x1F,
  0x7B, 0xDF, 0x07, 0xFE, 0xF7, 0xC1, 0xFF, 0x3D, 0xF0, 0x7F, 0xCF, 0x78,
  0x1F, 0xF3, 0xFE, 0x07, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87,
  0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F,
  0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x07,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF8,
  0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF,
  0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF8,
  0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x01, 0xF8, 0xFE, 0x03, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xC3, 0xF8, 0xFF, 0x87, 0xFF, 0xDF, 0xEF,
  0xFF, 0x3F, 0xCF, 0xFC, 0x3F, 0x87, 0xE0, 0x3E, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F,
  0xF9, 0xFB, 0xFF, 0xCF, 0xF8, 0xFF, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFD, 0xFF, 0x0F, 0xEF, 0xDF, 0xFE,
  0x7E, 0xFF, 0xE3, 0xF3, 0xFE, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x07,
  0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7F, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFD, 0xFC, 0x07, 0xF3, 0xF0, 0x1F,
  0x8F, 0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xE1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xF8, 0x7F,
  0xBF, 0x81, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0xC0,
  0xFE, 0x7F, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFE, 0xFC, 0x3F, 0xE7, 0xE0,
  0x7C, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0x83, 0xF1, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0xFF,
  0xCF, 0xCF, 0xFF, 0x7E, 0x7F, 0xFB, 0xF7, 0xF8, 0xFF, 0xBF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x81, 0xFE, 0xFE, 0x1F,
  0xF3, 0xFF, 0xDF, 0x9F, 0xFE, 0xFC, 0x7F, 0xE7, 0xE0, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x7F,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x87, 0xE3,
  0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFB,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x80, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03,
  0xF7, 0xE0, 0x3F, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E,
  0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFD, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xBF, 0x03, 0xF1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7F, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0xF0, 0x78, 0x79, 0xF9, 0xFC, 0x7B,
  0xF9, 0xFE, 0x7F, 0xFF, 0xFE, 0x7E, 0x7F, 0x3F, 0x7C, 0x7E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C,
  0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0xFC, 0x1F, 0x07, 0xE3, 0xFE, 0x3F, 0x3F,
  0xF9, 0xFB, 0xFF, 0xEF, 0xDF, 0xFF, 0x7F, 0xC3, 0xFB, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF9, 0xFC, 0x07,
  0xE7, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F,
  0x8F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x7F, 0x80, 0xFC, 0x3F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFB, 0xFF,
  0xCF, 0xF8, 0x7F, 0x7F, 0x81, 0xFB, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFD, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0x7E, 0xFF, 0xF3,
  0xF3, 0xFF, 0x1F, 0x87, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF,
  0x7E, 0x7F, 0xFF, 0xF3, 0xF8, 0xFF, 0xBF, 0x81, 0xFD, 0xF8, 0x0F, 0xEF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFE, 0xFC, 0x3F, 0xE7, 0xE0, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x0F, 0xEF, 0x87,
  0xFD, 0xF9, 0xFF, 0xBF, 0x7F, 0xF7, 0xFF, 0xFE, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xE0, 0x7F, 0x3E, 0x01, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF9, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFB,
  0xF3, 0xFF, 0x3F, 0x1F, 0xE3, 0xF0, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xFB, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xE7, 0xC1, 0xE0, 0xF9, 0xF0, 0x7C, 0x3E, 0x3C,
  0x3F, 0x0F, 0x8F, 0x0F, 0xC3, 0xE3, 0xE3, 0xF8, 0xF0, 0xF9, 0xFE, 0x3C,
  0x3E, 0x7F, 0x9F, 0x0F, 0x9E, 0xF7, 0xC1, 0xEF, 0x3D, 0xF0, 0x7B, 0xCF,
  0x7C, 0x1E, 0xF1, 0xDE, 0x07, 0xB8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x87, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x01, 0xF0, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0xFC,
  0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x0F,
  0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
};

const GFXglyph LiberationMono_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 29, 26, 10, -29 },
  { 23, 16, 13, 26, 5, -32 },
  { 49, 24, 29, 26, 1, -29 },
  { 136, 24, 36, 26, 1, -32 },
  { 244, 26, 29, 26, 0, -29 },
  { 339, 25, 29, 26, 1, -29 },
  { 430, 6, 13, 26, 10, -32 },
  { 440, 13, 41, 26, 7, -32 },
  { 507, 12, 41, 26, 7, -32 },
  { 569, 17, 16, 26, 5, -32 },
  { 603, 22, 23, 26, 2, -26 },
  { 667, 10, 14, 26, 6, -7 },
  { 685, 12, 5, 26, 7, -14 },
  { 693, 6, 7, 26, 10, -7 },
  { 699, 22, 32, 26, 2, -32 },
  { 787, 21, 29, 26, 3, -29 },
  { 864, 22, 29, 26, 3, -29 },
  { 944, 21, 29, 26, 3, -29 },
  { 1021, 22, 29, 26, 2, -29 },
  { 1101, 23, 29, 26, 2, -29 },
  { 1185, 22, 29, 26, 2, -29 },
  { 1265, 21, 29, 26, 3, -29 },
  { 1342, 20, 29, 26, 3, -29 },
  { 1415, 22, 29, 26, 2, -29 },
  { 1495, 22, 29, 26, 2, -29 },
  { 1575, 6, 24, 26, 10, -24 },
  { 1593, 10, 31, 26, 7, -24 },
  { 1632, 22, 23, 26, 2, -26 },
  { 1696, 22, 17, 26, 2, -23 },
  { 1743, 22, 23, 26, 2, -26 },
  { 1807, 22, 29, 26, 2, -29 },
  { 1887, 25, 38, 26, 1, -32 },
  { 2006, 26, 29, 26, 0, -29 },
  { 2101, 22, 29, 26, 3, -29 },
  { 2181, 23, 29, 26, 2, -29 },
  { 2265, 22, 29, 26, 3, -29 },
  { 2345, 22, 29, 26, 3, -29 },
  { 2425, 20, 29, 26, 4, -29 },
  { 2498, 22, 29, 26, 2, -29 },
  { 2578, 20, 29, 26, 3, -29 },
  { 2651, 20, 29, 26, 3, -29 },
  { 2724, 20, 29, 26, 2, -29 },
  { 2797, 23, 29, 26, 3, -29 },
  { 2881, 19, 29, 26, 5, -29 },
  { 2950, 22, 29, 26, 2, -29 },
  { 3030, 21, 29, 26, 3, -29 },
  { 3107, 23, 29, 26, 2, -29 },
  { 3191, 22, 29, 26, 3, -29 },
  { 3271, 23, 38, 26, 2, -29 },
  { 3381, 23, 29, 26, 3, -29 },
  { 3465, 24, 29, 26, 1, -29 },
  { 3552, 24, 29, 26, 1, -29 },
  { 3639, 21, 29, 26, 3, -29 },
  { 3716, 26, 29, 26, 0, -29 },
  { 3811, 26, 29, 26, 0, -29 },
  { 3906, 26, 29, 26, 0, -29 },
  { 4001, 26, 29, 26, 0, -29 },
  { 4096, 22, 29, 26, 2, -29 },
  { 4176, 13, 41, 26, 8, -32 },
  { 4243, 23, 32, 26, 2, -32 },
  { 4335, 13, 41, 26, 5, -32 },
  { 4402, 24, 19, 26, 1, -29 },
  { 4459, 26, 2, 26, 0, 3 },
  { 4466, 11, 6, 26, 7, -31 },
  { 4475, 23, 24, 26, 2, -24 },
  { 4544, 21, 32, 26, 3, -32 },
  { 4628, 22, 24, 26, 2, -24 },
  { 4694, 21, 32, 26, 2, -32 },
  { 4778, 22, 24, 26, 2, -24 },
  { 4844, 21, 32, 26, 3, -32 },
  { 4928, 21, 33, 26, 3, -24 },
  { 5015, 21, 32, 26, 3, -32 },
  { 5099, 22, 32, 26, 3, -32 },
  { 5187, 16, 41, 26, 3, -32 },
  { 5269, 21, 32, 26, 4, -32 },
  { 5353, 22, 32, 26, 3, -32 },
  { 5441, 24, 24, 26, 1, -24 },
  { 5513, 21, 24, 26, 3, -24 },
  { 5576, 22, 24, 26, 2, -24 },
  { 5642, 21, 33, 26, 3, -24 },
  { 5729, 21, 33, 26, 2, -24 },
  { 5816, 19, 24, 26, 4, -24 },
  { 5873, 21, 24, 26, 3, -24 },
  { 5936, 19, 30, 26, 3, -30 },
  { 6008, 20, 23, 26, 3, -23 },
  { 6066, 25, 24, 26, 1, -24 },
  { 6141, 26, 24, 26, 0, -24 },
  { 6219, 24, 24, 26, 1, -24 },
  { 6291, 25, 33, 26, 1, -24 },
  { 6395, 20, 24, 26, 3, -24 },
  { 6455, 18, 41, 26, 4, -32 },
  { 6548, 6, 42, 26, 10, -32 },
  { 6580, 18, 41, 26, 4, -32 },
  { 6673, 22, 7, 26, 2, -18 },
};

const GFXfont LiberationMono_Bold44pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold44pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold44pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _LIBERATIONMONO_BOLD44PT7B_H_
