#ifndef _LIBERATIONMONO_BOLD18PT7B_H_
#define _LIBERATIONMONO_BOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xC3, 0xF0, 0xEF, 0x9F, 0x36, 0x6C, 0xC0, 0x11,
  0x08, 0x8C, 0xDF, 0xF2, 0x21, 0x11, 0x99, 0xFF, 0x44, 0x22, 0x11, 0x18,
  0x80, 0x08, 0x1F, 0x3F, 0xDD, 0x7C, 0x87, 0x41, 0xF0, 0x7E, 0x0B, 0x84,
  0xF2, 0xFF, 0xF7, 0xE0, 0x40, 0x20, 0x70, 0xDB, 0x13, 0x66, 0x6D, 0x8D,
  0xA0, 0xEC, 0x03, 0x70, 0x5B, 0x12, 0x66, 0x4C, 0x8D, 0xA0, 0xE0, 0x1E,
  0x07, 0xE0, 0xCC, 0x19, 0x81, 0xE0, 0x71, 0x9B, 0x36, 0x7C, 0xC7, 0x9C,
  0x71, 0xFF, 0x9E, 0x70, 0xFB, 0x6C, 0x39, 0x9C, 0xC6, 0x73, 0x98, 0xC6,
  0x39, 0xC6, 0x31, 0xC6, 0x38, 0xE3, 0x1C, 0x63, 0x1C, 0xE7, 0x39, 0xCE,
  0x73, 0x19, 0xCC, 0xE0, 0x30, 0x23, 0x57, 0xF3, 0x8F, 0x1B, 0x24, 0x18,
  0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x33,
  0x98, 0xC4, 0x60, 0xFF, 0xC0, 0xFC, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x00, 0x3E, 0x3F, 0x98,
  0xDC, 0x7E, 0x3F, 0xDF, 0xEF, 0xC7, 0xE3, 0xB1, 0x9F, 0xC7, 0x80, 0x0C,
  0x1E, 0x3F, 0x19, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x3F, 0xFF,
  0xF0, 0x3E, 0x3F, 0xB8, 0xC0, 0x70, 0x30, 0x38, 0x78, 0x70, 0x70, 0x30,
  0x3F, 0xFF, 0xF0, 0x3E, 0x3F, 0xB8, 0xE0, 0x70, 0x30, 0xF0, 0x7C, 0x07,
  0x03, 0xF1, 0xFF, 0xC7, 0xC0, 0x07, 0x07, 0x87, 0xC3, 0xE3, 0x73, 0x39,
  0x9D, 0x8E, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0x7F, 0x3F, 0x98, 0x1C, 0x0F,
  0xE7, 0xFB, 0x8E, 0x07, 0x03, 0xF1, 0xFF, 0xC7, 0xC0, 0x3E, 0x3F, 0x98,
  0xDC, 0x0F, 0xE7, 0xFB, 0x8F, 0xC7, 0xE3, 0xB1, 0xDF, 0xC3, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07,
  0x00, 0x3E, 0x3F, 0xB8, 0xDC, 0x76, 0x33, 0xF1, 0xFD, 0xC7, 0xE3, 0xF1,
  0xDF, 0xC7, 0xC0, 0x3E, 0x3F, 0xB9, 0xDC, 0x6E, 0x3F, 0x1D, 0xFE, 0x77,
  0x03, 0x73, 0x9F, 0x87, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x77, 0x00, 0x00,
  0x00, 0x76, 0x6E, 0xCC, 0x00, 0x83, 0xC7, 0xDF, 0x0E, 0x07, 0x03, 0xE0,
  0x3E, 0x07, 0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80,
  0x78, 0x1F, 0x01, 0xF0, 0x38, 0x1C, 0x3E, 0xF8, 0xF0, 0x40, 0x00, 0x3E,
  0x3F, 0xB8, 0xF8, 0x70, 0x38, 0x38, 0x38, 0x38, 0x18, 0x00, 0x06, 0x03,
  0x00, 0x0F, 0x0C, 0x62, 0x0D, 0x3F, 0x5B, 0x54, 0x5D, 0x17, 0xCD, 0xF3,
  0x7C, 0x95, 0x65, 0x76, 0x60, 0x0C, 0x21, 0xF0, 0x0E, 0x03, 0xC0, 0x6C,
  0x0D, 0x83, 0xB0, 0x67, 0x0C, 0x63, 0xFC, 0x7F, 0xCC, 0x1B, 0x83, 0x70,
  0x70, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x37, 0xF3, 0xFD, 0xC7, 0xE1, 0xF1,
  0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xB8, 0xFC, 0x3C, 0x06, 0x03, 0x01, 0x80,
  0xE1, 0xF1, 0xDF, 0xC7, 0xC0, 0xFC, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF3, 0xBF, 0xDF, 0x80, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0xFB, 0xFD, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x3E,
  0x3F, 0xB8, 0xDC, 0x7C, 0x06, 0x7F, 0x3F, 0x83, 0xE1, 0xF1, 0xDF, 0xC7,
  0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x70, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0xFF, 0xFF, 0x1F, 0x1F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xE7,
  0xE7, 0x7E, 0x3C, 0xE3, 0xB8, 0xCE, 0x73, 0xB8, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF8, 0xE7, 0x39, 0xCE, 0x3B, 0x8E, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE3, 0xF1, 0xFD, 0xFE, 0xFF, 0x7E,
  0xAF, 0x77, 0xBB, 0xDD, 0xE0, 0xF0, 0x78, 0x30, 0xE3, 0xF9, 0xFC, 0xFE,
  0x7D, 0xBE, 0xDF, 0x3F, 0x9F, 0xCD, 0xE3, 0xF1, 0xF8, 0xF0, 0x3E, 0x3F,
  0xB8, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0x87, 0xE3, 0xF1, 0xDF, 0xC7, 0xC0,
  0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFD, 0xFC, 0xE0, 0x70, 0x38,
  0x1C, 0x00, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x3E, 0x0F, 0x07, 0x87, 0xE3,
  0xF1, 0xDF, 0xC7, 0xC1, 0xC0, 0x70, 0x3E, 0x0F, 0xFE, 0x3F, 0xEE, 0x3B,
  0x86, 0xE3, 0xBF, 0xCF, 0xE3, 0x98, 0xE7, 0x38, 0xCE, 0x3B, 0x87, 0x1F,
  0x0F, 0xE7, 0x1D, 0x80, 0x78, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xDC, 0x77,
  0xFC, 0x7C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0x9F, 0xC7, 0xC0, 0xE0, 0xEC, 0x19, 0x87, 0x38, 0xE3,
  0x18, 0x67, 0x0E, 0xE0, 0xD8, 0x1B, 0x03, 0xE0, 0x38, 0x07, 0x00, 0xC0,
  0xF8, 0x1F, 0x83, 0x36, 0x66, 0xEC, 0xDD, 0x9A, 0xB3, 0xD6, 0x7B, 0x8F,
  0x70, 0xCE, 0x18, 0xC0, 0x61, 0xCE, 0x30, 0xEE, 0x0D, 0x81, 0xE0, 0x1C,
  0x03, 0x80, 0xF8, 0x3B, 0x86, 0x31, 0xC7, 0x70, 0x60, 0xE0, 0xEC, 0x39,
  0xC6, 0x19, 0xC3, 0xB0, 0x36, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xFF, 0xFF, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x3F, 0xFC, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0xFF, 0xF1, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFC, 0x0E, 0x07, 0x81,
  0xB0, 0xCC, 0x31, 0x98, 0x66, 0x19, 0x83, 0xFF, 0xE0, 0xE3, 0x8C, 0x3E,
  0x3F, 0xB9, 0xC0, 0x67, 0xF7, 0xFB, 0x8D, 0xCE, 0xFF, 0xBD, 0xC0, 0xE0,
  0x70, 0x38, 0x1D, 0xCF, 0xF7, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF,
  0xEE, 0xE0, 0x3E, 0x3F, 0xB8, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0x7F,
  0x1F, 0x00, 0x03, 0x81, 0xC0, 0xE7, 0x77, 0xFF, 0x3F, 0x8F, 0x87, 0xC3,
  0xF1, 0xF9, 0xEF, 0xF3, 0xB8, 0x3E, 0x3F, 0xB8, 0xDC, 0x7F, 0xFF, 0xFF,
  0x81, 0xC7, 0x7F, 0x1F, 0x00, 0x1F, 0x9F, 0xCE, 0x1F, 0xFF, 0xF9, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x3B, 0xBF, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0x9D, 0xC0, 0xEC, 0x67, 0xF1, 0xF0,
  0xE0, 0x70, 0x38, 0x1D, 0xEF, 0xF7, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x38, 0x0C, 0x06, 0x00, 0x0F, 0x87, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x1F, 0xFF, 0xF8, 0x0E, 0x1C, 0x03, 0xF7, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x7E, 0xF8, 0xC0, 0xC0, 0xC0,
  0xC7, 0xCE, 0xDC, 0xD8, 0xF8, 0xFC, 0xCC, 0xCE, 0xC6, 0xC7, 0x7C, 0x3E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0xFF,
  0xF8, 0xBB, 0x5F, 0xF7, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xD9, 0xEC,
  0xC0, 0xEE, 0x7F, 0xBC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xC0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0x7F, 0x1F,
  0x00, 0xEE, 0x7F, 0xB8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0x77,
  0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3B, 0xBF, 0xF9, 0xFC, 0x7C, 0x3E, 0x1F,
  0x8F, 0xCF, 0x7F, 0x9D, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xCF, 0xDF, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3E, 0x3F, 0xB8, 0xDC, 0x07,
  0xE0, 0xF8, 0x0F, 0xC7, 0x7F, 0x1F, 0x00, 0x10, 0x30, 0xFF, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x3F, 0x1F, 0xE3, 0x71, 0xB8, 0xDC, 0x6E,
  0x37, 0x1B, 0x8D, 0xC6, 0x7F, 0x3D, 0xC0, 0xE0, 0xD8, 0x77, 0x1C, 0xC6,
  0x33, 0x8E, 0xC1, 0xB0, 0x7C, 0x1E, 0x03, 0x80, 0xC0, 0x78, 0x0B, 0x33,
  0x37, 0x66, 0xEC, 0xD5, 0x9E, 0xB3, 0xDC, 0x73, 0x86, 0x30, 0x71, 0xCC,
  0x63, 0xB0, 0x7C, 0x0E, 0x03, 0x81, 0xB0, 0xEE, 0x71, 0x98, 0x70, 0x60,
  0xD8, 0x77, 0x1C, 0xC6, 0x31, 0x86, 0xC1, 0xB0, 0x6C, 0x0A, 0x03, 0x80,
  0xE0, 0x70, 0x7C, 0x1E, 0x00, 0x7F, 0x7F, 0x07, 0x0E, 0x1C, 0x38, 0x70,
  0x60, 0xFF, 0xFF, 0x1E, 0x7C, 0xC1, 0x83, 0x06, 0x1C, 0x70, 0xE0, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x1F, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF1, 0xF0, 0x60, 0xC1, 0x83, 0x07, 0x07, 0x0E, 0x38, 0x60, 0xC1,
  0x83, 0x0E, 0x7C, 0xF0, 0x70, 0x7C, 0x63, 0xE0, 0xE0,
};

const GFXglyph LiberationMono_Bold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 12, 11, 4, -12 },
  { 6, 7, 5, 11, 2, -13 },
  { 11, 9, 12, 11, 1, -12 },
  { 25, 9, 15, 11, 1, -13 },
  { 42, 11, 12, 11, 0, -12 },
  { 59, 11, 12, 11, 0, -12 },
  { 76, 3, 5, 11, 4, -13 },
  { 78, 5, 17, 11, 3, -13 },
  { 89, 5, 17, 11, 3, -13 },
  { 100, 7, 8, 11, 2, -13 },
  { 107, 9, 10, 11, 1, -11 },
  { 119, 5, 6, 11, 2, -2 },
  { 123, 5, 2, 11, 3, -6 },
  { 125, 3, 2, 11, 4, -2 },
  { 126, 9, 13, 11, 1, -13 },
  { 141, 9, 12, 11, 1, -12 },
  { 155, 9, 12, 11, 1, -12 },
  { 169, 9, 12, 11, 1, -12 },
  { 183, 9, 12, 11, 1, -12 },
  { 197, 9, 12, 11, 1, -12 },
  { 211, 9, 12, 11, 1, -12 },
  { 225, 9, 12, 11, 1, -12 },
  { 239, 9, 12, 11, 1, -12 },
  { 253, 9, 12, 11, 1, -12 },
  { 267, 9, 12, 11, 1, -12 },
  { 281, 3, 10, 11, 4, -10 },
  { 285, 4, 14, 11, 3, -10 },
  { 292, 9, 10, 11, 1, -11 },
  { 304, 9, 6, 11, 1, -9 },
  { 311, 9, 10, 11, 1, -11 },
  { 323, 9, 12, 11, 1, -12 },
  { 337, 10, 15, 11, 0, -13 },
  { 356, 11, 12, 11, 0, -12 },
  { 373, 9, 12, 11, 1, -12 },
  { 387, 9, 12, 11, 1, -12 },
  { 401, 9, 12, 11, 1, -12 },
  { 415, 9, 12, 11, 1, -12 },
  { 429, 9, 12, 11, 1, -12 },
  { 443, 9, 12, 11, 1, -12 },
  { 457, 9, 12, 11, 1, -12 },
  { 471, 8, 12, 11, 1, -12 },
  { 483, 8, 12, 11, 1, -12 },
  { 495, 10, 12, 11, 1, -12 },
  { 510, 8, 12, 11, 2, -12 },
  { 522, 9, 12, 11, 1, -12 },
  { 536, 9, 12, 11, 1, -12 },
  { 550, 9, 12, 11, 1, -12 },
  { 564, 9, 12, 11, 1, -12 },
  { 578, 9, 16, 11, 1, -12 },
  { 596, 10, 12, 11, 1, -12 },
  { 611, 10, 12, 11, 0, -12 },
  { 626, 9, 12, 11, 1, -12 },
  { 640, 9, 12, 11, 1, -12 },
  { 654, 11, 12, 11, 0, -12 },
  { 671, 11, 12, 11, 0, -12 },
  { 688, 11, 12, 11, 0, -12 },
  { 705, 11, 12, 11, 0, -12 },
  { 722, 9, 12, 11, 1, -12 },
  { 736, 6, 17, 11, 3, -13 },
  { 749, 9, 13, 11, 1, -13 },
  { 764, 6, 17, 11, 2, -13 },
  { 777, 10, 8, 11, 0, -12 },
  { 787, 11, 1, 11, 0, 1 },
  { 789, 5, 3, 11, 3, -14 },
  { 791, 9, 10, 11, 1, -10 },
  { 803, 9, 13, 11, 1, -13 },
  { 818, 9, 10, 11, 1, -10 },
  { 830, 9, 13, 11, 1, -13 },
  { 845, 9, 10, 11, 1, -10 },
  { 857, 9, 13, 11, 1, -13 },
  { 872, 9, 14, 11, 1, -10 },
  { 888, 9, 13, 11, 1, -13 },
  { 903, 9, 13, 11, 1, -13 },
  { 918, 7, 17, 11, 1, -13 },
  { 933, 8, 13, 11, 2, -13 },
  { 946, 9, 13, 11, 1, -13 },
  { 961, 9, 10, 11, 1, -10 },
  { 973, 9, 10, 11, 1, -10 },
  { 985, 9, 10, 11, 1, -10 },
  { 997, 9, 14, 11, 1, -10 },
  { 1013, 9, 14, 11, 1, -10 },
  { 1029, 8, 10, 11, 2, -10 },
  { 1039, 9, 10, 11, 1, -10 },
  { 1051, 8, 12, 11, 1, -12 },
  { 1063, 9, 10, 11, 1, -10 },
  { 1075, 10, 10, 11, 0, -10 },
  { 1088, 11, 10, 11, 0, -10 },
  { 1102, 10, 10, 11, 0, -10 },
  { 1115, 10, 14, 11, 0, -10 },
  { 1133, 8, 10, 11, 1, -10 },
  { 1143, 7, 17, 11, 2, -13 },
  { 1158, 3, 17, 11, 4, -13 },
  { 1165, 7, 17, 11, 2, -13 },
  { 1180, 9, 4, 11, 1, -8 },
};

const GFXfont LiberationMono_Bold18pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold18pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold18pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _LIBERATIONMONO_BOLD18PT7B_H_
