#ifndef _LIBERATIONMONO_BOLD10PT7B_H_
#define _LIBERATIONMONO_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xCC, 0xF9, 0x90, 0x28, 0xA7, 0xD2, 0xF9, 0x45, 0x00, 0x11,
  0xE5, 0x94, 0x78, 0x7D, 0xDE, 0x10, 0xEA, 0xAF, 0x08, 0x3D, 0x55, 0xC0,
  0x31, 0x27, 0x1A, 0xBA, 0x67, 0xC0, 0xFC, 0x5A, 0x49, 0x26, 0x40, 0x4C,
  0x92, 0x4B, 0x40, 0x2F, 0x66, 0x30, 0xCF, 0xCC, 0x30, 0x4A, 0x00, 0xC0,
  0xC0, 0x08, 0x21, 0x0C, 0x21, 0x04, 0x00, 0xF9, 0x9F, 0x99, 0x60, 0x65,
  0x08, 0x42, 0x13, 0xE0, 0xF9, 0x13, 0x6C, 0xF0, 0x79, 0x20, 0x8C, 0x09,
  0x27, 0x80, 0x18, 0xE7, 0x96, 0xFC, 0x61, 0x80, 0xF8, 0xF1, 0x19, 0xF0,
  0x78, 0xF9, 0x99, 0x70, 0xF1, 0x22, 0x44, 0x40, 0xF9, 0x96, 0x99, 0xF0,
  0xE9, 0x99, 0xF1, 0xE0, 0xC0, 0xC0, 0xC0, 0xE8, 0x0D, 0xC8, 0x1C, 0x0C,
  0xFC, 0x0F, 0xC0, 0xC0, 0xE0, 0x4E, 0xC0, 0x7E, 0x42, 0x33, 0x00, 0x80,
  0x39, 0x18, 0x6F, 0xD6, 0xA8, 0x12, 0x70, 0x30, 0xC7, 0x92, 0x7B, 0x3C,
  0xC0, 0xF4, 0xA5, 0xC9, 0xCF, 0xC0, 0x79, 0x3C, 0x30, 0xC1, 0x33, 0x80,
  0xE4, 0xA7, 0x39, 0xCB, 0x80, 0xF4, 0x21, 0xE8, 0x43, 0xE0, 0xF8, 0x8F,
  0x88, 0x80, 0x79, 0x2C, 0x37, 0xCD, 0x33, 0x80, 0x99, 0x9F, 0x99, 0x90,
  0xF6, 0x66, 0x66, 0xF0, 0x38, 0x42, 0x10, 0xAD, 0xC0, 0x9D, 0xA9, 0xCB,
  0x5A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0xCF, 0xFF, 0xFF, 0xFF, 0x3C, 0xC0,
  0x9D, 0xDF, 0xBB, 0xB0, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x80, 0xF4, 0xE7,
  0xE8, 0x42, 0x00, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x84, 0x1C, 0xF4, 0xE7,
  0xEB, 0x4A, 0x60, 0x79, 0x24, 0x1E, 0x0F, 0x37, 0x80, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x00, 0x99, 0x99, 0x99, 0xF0, 0xCD, 0x34, 0x9A, 0x78, 0xC3,
  0x00, 0x86, 0x1F, 0xDE, 0x79, 0xE4, 0x80, 0x49, 0xE3, 0x0C, 0x31, 0x2C,
  0xC0, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x00, 0x78, 0x61, 0x0C, 0x61, 0x0F,
  0xC0, 0xF2, 0x49, 0x24, 0xE0, 0x41, 0x02, 0x0C, 0x10, 0x20, 0x80, 0xE4,
  0x92, 0x49, 0xE0, 0x31, 0xC4, 0xB2, 0xFC, 0x90, 0xF0, 0xBD, 0x6D, 0x80,
  0x84, 0x3D, 0x29, 0xCB, 0xC0, 0xF9, 0x89, 0xF0, 0x08, 0x5E, 0x9C, 0xA5,
  0xE0, 0x79, 0x2F, 0x90, 0x78, 0x74, 0xF4, 0x44, 0x40, 0xF9, 0x99, 0xF1,
  0xF0, 0x88, 0xF9, 0x99, 0x90, 0x60, 0x38, 0xC6, 0x33, 0xE0, 0x23, 0x92,
  0x49, 0xE0, 0x84, 0x25, 0x4E, 0x5A, 0x40, 0xE3, 0x18, 0xC6, 0x33, 0xE0,
  0xAB, 0xFB, 0x6D, 0xB4, 0xF9, 0x99, 0x90, 0x79, 0x2C, 0xD2, 0x78, 0xF4,
  0xA7, 0x2F, 0x42, 0x00, 0x7A, 0x72, 0x97, 0x84, 0x20, 0xBC, 0xCC, 0xC0,
  0xF8, 0xF1, 0xF0, 0x4F, 0x44, 0x47, 0x99, 0x99, 0xF0, 0xCD, 0x25, 0x8C,
  0x30, 0x86, 0xDF, 0x9E, 0x48, 0x49, 0xC3, 0x1E, 0x48, 0xCD, 0x26, 0x8C,
  0x30, 0xC6, 0x00, 0xF3, 0x6C, 0xF0, 0x74, 0x44, 0x84, 0x44, 0x70, 0xFF,
  0xFF, 0xC0, 0xE2, 0x22, 0x12, 0x22, 0xE0, 0x66, 0x70,
};

const GFXglyph LiberationMono_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 3, 6, 2, -7 },
  { 31, 3, 9, 6, 2, -7 },
  { 35, 3, 9, 6, 1, -7 },
  { 39, 4, 4, 6, 1, -7 },
  { 41, 6, 5, 6, 0, -6 },
  { 45, 3, 3, 6, 1, -1 },
  { 47, 2, 1, 6, 2, -4 },
  { 48, 2, 1, 6, 2, -1 },
  { 49, 6, 7, 6, 0, -7 },
  { 55, 4, 7, 6, 1, -7 },
  { 59, 5, 7, 6, 1, -7 },
  { 64, 4, 7, 6, 1, -7 },
  { 68, 6, 7, 6, 0, -7 },
  { 74, 6, 7, 6, 0, -7 },
  { 80, 4, 7, 6, 1, -7 },
  { 84, 4, 7, 6, 1, -7 },
  { 88, 4, 7, 6, 1, -7 },
  { 92, 4, 7, 6, 1, -7 },
  { 96, 4, 7, 6, 1, -7 },
  { 100, 2, 5, 6, 2, -5 },
  { 102, 2, 7, 6, 2, -5 },
  { 104, 6, 5, 6, 0, -6 },
  { 108, 6, 3, 6, 0, -5 },
  { 111, 6, 5, 6, 0, -6 },
  { 115, 5, 7, 6, 0, -7 },
  { 120, 6, 9, 6, 0, -7 },
  { 127, 6, 7, 6, 0, -7 },
  { 133, 5, 7, 6, 1, -7 },
  { 138, 6, 7, 6, 0, -7 },
  { 144, 5, 7, 6, 1, -7 },
  { 149, 5, 7, 6, 1, -7 },
  { 154, 4, 7, 6, 1, -7 },
  { 158, 6, 7, 6, 0, -7 },
  { 164, 4, 7, 6, 1, -7 },
  { 168, 4, 7, 6, 1, -7 },
  { 172, 5, 7, 6, 0, -7 },
  { 177, 5, 7, 6, 1, -7 },
  { 182, 4, 7, 6, 1, -7 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 4, 7, 6, 1, -7 },
  { 196, 6, 7, 6, 0, -7 },
  { 202, 5, 7, 6, 1, -7 },
  { 207, 6, 9, 6, 0, -7 },
  { 214, 5, 7, 6, 1, -7 },
  { 219, 6, 7, 6, 0, -7 },
  { 225, 6, 7, 6, 0, -7 },
  { 231, 4, 7, 6, 1, -7 },
  { 235, 6, 7, 6, 0, -7 },
  { 241, 6, 7, 6, 0, -7 },
  { 247, 6, 7, 6, 0, -7 },
  { 253, 6, 7, 6, 0, -7 },
  { 259, 6, 7, 6, 0, -7 },
  { 265, 3, 9, 6, 2, -7 },
  { 269, 6, 7, 6, 0, -7 },
  { 275, 3, 9, 6, 1, -7 },
  { 279, 6, 4, 6, 0, -7 },
  { 282, 6, 1, 6, 0, 1 },
  { 283, 2, 2, 6, 2, -8 },
  { 284, 5, 5, 6, 1, -5 },
  { 288, 5, 7, 6, 1, -7 },
  { 293, 4, 5, 6, 1, -5 },
  { 296, 5, 7, 6, 0, -7 },
  { 301, 6, 5, 6, 0, -5 },
  { 305, 4, 7, 6, 1, -7 },
  { 309, 4, 7, 6, 1, -5 },
  { 313, 4, 7, 6, 1, -7 },
  { 317, 5, 7, 6, 1, -7 },
  { 322, 3, 9, 6, 1, -7 },
  { 326, 5, 7, 6, 1, -7 },
  { 331, 5, 7, 6, 1, -7 },
  { 336, 6, 5, 6, 0, -5 },
  { 340, 4, 5, 6, 1, -5 },
  { 343, 6, 5, 6, 0, -5 },
  { 347, 5, 7, 6, 1, -5 },
  { 352, 5, 7, 6, 0, -5 },
  { 357, 4, 5, 6, 1, -5 },
  { 360, 4, 5, 6, 1, -5 },
  { 363, 4, 6, 6, 1, -6 },
  { 366, 4, 5, 6, 1, -5 },
  { 369, 6, 5, 6, 0, -5 },
  { 373, 6, 5, 6, 0, -5 },
  { 377, 6, 5, 6, 0, -5 },
  { 381, 6, 7, 6, 0, -5 },
  { 387, 4, 5, 6, 1, -5 },
  { 390, 4, 9, 6, 1, -7 },
  { 395, 2, 9, 6, 2, -7 },
  { 398, 4, 9, 6, 1, -7 },
  { 403, 6, 2, 6, 0, -5 },
};

const GFXfont LiberationMono_Bold10pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold10pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold10pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _LIBERATIONMONO_BOLD10PT7B_H_
