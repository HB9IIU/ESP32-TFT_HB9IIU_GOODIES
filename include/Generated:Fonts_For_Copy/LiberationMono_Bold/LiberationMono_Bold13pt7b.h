#ifndef _LIBERATIONMONO_BOLD13PT7B_H_
#define _LIBERATIONMONO_BOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0x99, 0x99, 0x12, 0x49, 0xF9, 0x22, 0x5F, 0xD2,
  0x24, 0x48, 0x10, 0x79, 0xDA, 0x87, 0x07, 0x85, 0x89, 0x56, 0xF8, 0x40,
  0x62, 0xB4, 0x94, 0xB8, 0x76, 0x19, 0x29, 0x49, 0x46, 0x38, 0x24, 0x2C,
  0x38, 0x72, 0xDE, 0xCC, 0xCC, 0x7B, 0xFF, 0x36, 0x64, 0xCC, 0xCC, 0xC4,
  0x66, 0x30, 0xC6, 0x62, 0x23, 0x33, 0x22, 0x66, 0xC0, 0x33, 0xDE, 0xE4,
  0x80, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x5A, 0x40, 0xF0, 0xF0, 0x04,
  0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x00, 0x7B, 0x2C, 0xFF, 0xFF, 0x3C,
  0xF2, 0x78, 0x33, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x7B, 0x30, 0xC7,
  0x18, 0xC6, 0x30, 0xFC, 0x7B, 0x30, 0xC3, 0x30, 0x30, 0xF3, 0x78, 0x0C,
  0x38, 0x51, 0xA6, 0x48, 0xBF, 0x82, 0x04, 0xFF, 0x0C, 0x3E, 0xCC, 0x30,
  0xF3, 0x78, 0x7B, 0x3C, 0x3E, 0xCF, 0x3C, 0xF3, 0x78, 0xFC, 0x31, 0x84,
  0x30, 0xC6, 0x18, 0x60, 0x7B, 0x3C, 0xF3, 0x33, 0x3C, 0xF3, 0x78, 0x7B,
  0x2C, 0xF3, 0xCD, 0xF0, 0xF2, 0x70, 0xF0, 0x3C, 0x6C, 0x00, 0xD6, 0x80,
  0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x81,
  0x19, 0x88, 0x00, 0x3C, 0xCD, 0x18, 0x71, 0xC3, 0x00, 0x08, 0x10, 0x1C,
  0x22, 0x42, 0x5D, 0xA5, 0xA5, 0xA6, 0xAA, 0xB6, 0x40, 0x42, 0x3C, 0x18,
  0x38, 0x3C, 0x2C, 0x64, 0x7E, 0x46, 0xC2, 0xC3, 0xF9, 0x9B, 0x36, 0x6F,
  0x99, 0xB1, 0xE6, 0xFC, 0x7B, 0x3C, 0xE0, 0x82, 0x0C, 0x73, 0x78, 0xF3,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xF8, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30,
  0xFC, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC0, 0x7B, 0x3C, 0xE0, 0x9E,
  0x3C, 0xF3, 0x78, 0xCF, 0x3C, 0xF3, 0xFF, 0x3C, 0xF3, 0xCC, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x38, 0x42, 0x10, 0x87, 0x3B, 0x70, 0xCD,
  0xBB, 0x67, 0x8F, 0x1B, 0x36, 0x66, 0xCE, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFC, 0xCF, 0x3D, 0xFD, 0xB6, 0xDB, 0x61, 0x84, 0xCF, 0xBE, 0xEB,
  0xBE, 0x79, 0xE7, 0x8C, 0x3C, 0xCD, 0x9E, 0x3C, 0x68, 0xD9, 0xB3, 0x3C,
  0xFB, 0x3C, 0xF3, 0xFB, 0x0C, 0x30, 0xC0, 0x3C, 0xCD, 0x9A, 0x3C, 0x68,
  0xD9, 0xB3, 0x3C, 0x30, 0x30, 0x70, 0xF9, 0x9B, 0x36, 0x6F, 0x9B, 0x32,
  0x66, 0xCE, 0x3C, 0xCD, 0x1B, 0x83, 0xC0, 0xF0, 0xB3, 0x3C, 0xFE, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0x78, 0xC3, 0x46, 0x66, 0x66, 0x64, 0x3C, 0x3C, 0x38, 0x18, 0xC3, 0xC3,
  0xC2, 0x5A, 0x5A, 0x5A, 0x7A, 0x66, 0x66, 0x66, 0x66, 0x3C, 0x38, 0x18,
  0x3C, 0x2C, 0x66, 0xC2, 0xC3, 0x66, 0x66, 0x2C, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0xFC, 0x31, 0x8C, 0x31, 0x86, 0x30, 0xFC, 0xFC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xF0, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x10, 0xE4,
  0x92, 0x49, 0x24, 0x9E, 0x18, 0x70, 0xB3, 0x24, 0x78, 0x40, 0xFF, 0xC4,
  0x7B, 0x20, 0xFF, 0xCF, 0x7E, 0xC0, 0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3,
  0xCF, 0xE0, 0x7B, 0x3C, 0x30, 0xC3, 0x37, 0x80, 0x0C, 0x30, 0xDF, 0xCF,
  0x38, 0xF3, 0xCD, 0xF0, 0x7B, 0x3C, 0xFF, 0xC3, 0x37, 0x80, 0x3C, 0x86,
  0x3F, 0x61, 0x86, 0x18, 0x61, 0x80, 0x7F, 0x3C, 0xF3, 0xCF, 0x37, 0xC3,
  0xCD, 0xE0, 0xC3, 0x0C, 0x3E, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x30, 0x00,
  0x3C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x10, 0x0F, 0x11, 0x11, 0x11, 0x13,
  0xE0, 0xC3, 0x0C, 0x33, 0xDB, 0xCF, 0x36, 0xCF, 0x30, 0xF0, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x33, 0xF0, 0xF7, 0xB7, 0x6E, 0xDD, 0xBB, 0x76, 0x80,
  0xFB, 0x3C, 0xF3, 0xCF, 0x3C, 0xC0, 0x7B, 0x3C, 0xE3, 0xCF, 0x37, 0x80,
  0xFB, 0x3C, 0xF3, 0xCF, 0x3F, 0xB0, 0xC3, 0x00, 0x7F, 0x3C, 0xE3, 0xCF,
  0x37, 0xC3, 0x0C, 0x30, 0xDD, 0x86, 0x10, 0x41, 0x04, 0x00, 0x7B, 0x3C,
  0x1E, 0x0F, 0x37, 0x80, 0x21, 0x8F, 0x98, 0x61, 0x86, 0x18, 0x3C, 0xCF,
  0x3C, 0xF3, 0xCF, 0x7F, 0xC0, 0xC2, 0x66, 0x66, 0x64, 0x3C, 0x38, 0x18,
  0xC3, 0xC2, 0xDA, 0x5A, 0x7A, 0x66, 0x66, 0x66, 0xC8, 0xF0, 0xC3, 0xCC,
  0x99, 0x80, 0xC2, 0x66, 0x66, 0x24, 0x3C, 0x38, 0x18, 0x18, 0x10, 0x70,
  0xFC, 0x63, 0x0C, 0x63, 0x0F, 0xC0, 0x3C, 0xC2, 0x08, 0x21, 0x8C, 0x18,
  0x20, 0x82, 0x0C, 0x3C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xC3, 0x0C, 0x30,
  0x40, 0xC4, 0x30, 0xC3, 0x0C, 0xF0, 0xE0, 0x70,
};

const GFXglyph LiberationMono_Bold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 7, 11, 8, 0, -10 },
  { 24, 8, 9, 8, 0, -9 },
  { 33, 8, 9, 8, 0, -9 },
  { 42, 2, 4, 8, 3, -10 },
  { 43, 4, 13, 8, 2, -10 },
  { 50, 4, 13, 8, 2, -10 },
  { 57, 5, 5, 8, 1, -10 },
  { 61, 6, 7, 8, 1, -8 },
  { 67, 3, 4, 8, 2, -2 },
  { 69, 4, 1, 8, 2, -4 },
  { 70, 2, 2, 8, 3, -2 },
  { 71, 6, 10, 8, 1, -10 },
  { 79, 6, 9, 8, 1, -9 },
  { 86, 6, 9, 8, 1, -9 },
  { 93, 6, 9, 8, 1, -9 },
  { 100, 6, 9, 8, 1, -9 },
  { 107, 7, 9, 8, 0, -9 },
  { 115, 6, 9, 8, 1, -9 },
  { 122, 6, 9, 8, 1, -9 },
  { 129, 6, 9, 8, 1, -9 },
  { 136, 6, 9, 8, 1, -9 },
  { 143, 6, 9, 8, 1, -9 },
  { 150, 2, 7, 8, 3, -7 },
  { 152, 3, 9, 8, 2, -7 },
  { 156, 6, 7, 8, 1, -8 },
  { 162, 6, 4, 8, 1, -6 },
  { 165, 6, 7, 8, 1, -8 },
  { 171, 7, 9, 8, 0, -9 },
  { 179, 8, 12, 8, 0, -10 },
  { 191, 8, 9, 8, 0, -9 },
  { 200, 7, 9, 8, 1, -9 },
  { 208, 6, 9, 8, 1, -9 },
  { 215, 6, 9, 8, 1, -9 },
  { 222, 6, 9, 8, 1, -9 },
  { 229, 6, 9, 8, 1, -9 },
  { 236, 6, 9, 8, 1, -9 },
  { 243, 6, 9, 8, 1, -9 },
  { 250, 6, 9, 8, 1, -9 },
  { 257, 5, 9, 8, 1, -9 },
  { 263, 7, 9, 8, 1, -9 },
  { 271, 6, 9, 8, 1, -9 },
  { 278, 6, 9, 8, 1, -9 },
  { 285, 6, 9, 8, 1, -9 },
  { 292, 7, 9, 8, 0, -9 },
  { 300, 6, 9, 8, 1, -9 },
  { 307, 7, 12, 8, 0, -9 },
  { 318, 7, 9, 8, 1, -9 },
  { 326, 7, 9, 8, 0, -9 },
  { 334, 7, 9, 8, 0, -9 },
  { 342, 6, 9, 8, 1, -9 },
  { 349, 8, 9, 8, 0, -9 },
  { 358, 8, 9, 8, 0, -9 },
  { 367, 8, 9, 8, 0, -9 },
  { 376, 8, 9, 8, 0, -9 },
  { 385, 6, 9, 8, 1, -9 },
  { 392, 4, 13, 8, 2, -10 },
  { 399, 6, 10, 8, 1, -10 },
  { 407, 3, 13, 8, 2, -10 },
  { 412, 7, 6, 8, 0, -9 },
  { 418, 8, 1, 8, 0, 1 },
  { 419, 3, 2, 8, 2, -10 },
  { 420, 6, 7, 8, 1, -7 },
  { 426, 6, 10, 8, 1, -10 },
  { 434, 6, 7, 8, 1, -7 },
  { 440, 6, 10, 8, 1, -10 },
  { 448, 6, 7, 8, 1, -7 },
  { 454, 6, 10, 8, 1, -10 },
  { 462, 6, 10, 8, 1, -7 },
  { 470, 6, 10, 8, 1, -10 },
  { 478, 6, 10, 8, 1, -10 },
  { 486, 4, 13, 8, 1, -10 },
  { 493, 6, 10, 8, 1, -10 },
  { 501, 6, 10, 8, 1, -10 },
  { 509, 7, 7, 8, 0, -7 },
  { 516, 6, 7, 8, 1, -7 },
  { 522, 6, 7, 8, 1, -7 },
  { 528, 6, 10, 8, 1, -7 },
  { 536, 6, 10, 8, 1, -7 },
  { 544, 6, 7, 8, 1, -7 },
  { 550, 6, 7, 8, 1, -7 },
  { 556, 6, 9, 8, 1, -9 },
  { 563, 6, 7, 8, 1, -7 },
  { 569, 8, 7, 8, 0, -7 },
  { 576, 8, 7, 8, 0, -7 },
  { 583, 7, 7, 8, 0, -7 },
  { 590, 8, 10, 8, 0, -7 },
  { 600, 6, 7, 8, 1, -7 },
  { 606, 6, 13, 8, 1, -10 },
  { 616, 2, 13, 8, 3, -10 },
  { 620, 6, 13, 8, 1, -10 },
  { 630, 6, 2, 8, 1, -6 },
};

const GFXfont LiberationMono_Bold13pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold13pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _LIBERATIONMONO_BOLD13PT7B_H_
