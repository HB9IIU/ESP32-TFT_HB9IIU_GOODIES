#ifndef _LIBERATIONMONO_BOLD9PT7B_H_
#define _LIBERATIONMONO_BOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x7E, 0xAF, 0xA9, 0x40, 0x23, 0x9A, 0xC7,
  0x17, 0xAE, 0x20, 0xCD, 0xB4, 0x43, 0xAE, 0x60, 0x72, 0x9C, 0xDA, 0xC9,
  0xA0, 0xE0, 0x6A, 0xAA, 0x40, 0x49, 0x92, 0x5A, 0x40, 0x5D, 0xD0, 0x21,
  0x3E, 0x42, 0x00, 0x58, 0xE0, 0x80, 0x08, 0x84, 0x42, 0x21, 0x00, 0xEB,
  0x9D, 0x9B, 0xE0, 0x6E, 0x66, 0x66, 0xF0, 0xEB, 0x36, 0x48, 0xF0, 0x72,
  0xC6, 0x60, 0xE5, 0xC0, 0x11, 0x94, 0xAF, 0x88, 0x40, 0x7A, 0x1C, 0x30,
  0xAD, 0xC0, 0xE8, 0xEB, 0x9B, 0xE0, 0xF2, 0x24, 0x44, 0xC0, 0x72, 0xD6,
  0x64, 0xA5, 0xC0, 0x72, 0xF2, 0xB7, 0x8D, 0xC0, 0x88, 0x40, 0x04, 0xA0,
  0x0B, 0xA0, 0xE0, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00, 0x76, 0x46,
  0x62, 0x00, 0x80, 0x32, 0x63, 0x5D, 0xFE, 0x09, 0x70, 0x31, 0x94, 0xA7,
  0xE6, 0x20, 0xEB, 0xBE, 0x99, 0xF0, 0x72, 0x71, 0x8C, 0x25, 0xC0, 0xEB,
  0x99, 0x9B, 0xE0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x72,
  0xF1, 0xBC, 0xA5, 0xC0, 0xBB, 0xBF, 0xBB, 0xB0, 0xF4, 0x44, 0x44, 0xF0,
  0x31, 0x11, 0x15, 0x70, 0x9A, 0xEE, 0xAB, 0x90, 0x88, 0x88, 0x88, 0xF0,
  0xDE, 0xEF, 0x7A, 0xC6, 0x20, 0x9D, 0xDD, 0xDB, 0xB0, 0x72, 0xF3, 0x9C,
  0xAD, 0xC0, 0xE9, 0x9E, 0x88, 0x80, 0x72, 0xF3, 0x9C, 0xAD, 0xC6, 0x18,
  0xF9, 0x9E, 0xAB, 0x90, 0x76, 0x50, 0xF0, 0xE5, 0xC0, 0xF9, 0x08, 0x42,
  0x10, 0x80, 0x99, 0x99, 0x9B, 0xE0, 0x8E, 0x56, 0xA7, 0x18, 0xC0, 0x8C,
  0x6B, 0xF7, 0xAD, 0x60, 0xCA, 0x8C, 0x47, 0x2F, 0x20, 0xCA, 0xD4, 0x62,
  0x10, 0x80, 0x78, 0x8C, 0x46, 0x23, 0xE0, 0xEA, 0xAA, 0xC0, 0x42, 0x08,
  0x41, 0x08, 0x20, 0xE4, 0x92, 0x49, 0xE0, 0x32, 0x95, 0x10, 0xF8, 0x90,
  0x70, 0xDF, 0xB6, 0x80, 0x88, 0xE9, 0x99, 0xE0, 0x72, 0xF0, 0x97, 0x00,
  0x08, 0x5A, 0xBC, 0xAD, 0xA0, 0x72, 0x7E, 0x87, 0x80, 0x74, 0xF4, 0x44,
  0x40, 0xDB, 0x9B, 0xD1, 0xE0, 0x88, 0xF9, 0x99, 0x90, 0x40, 0xC4, 0x44,
  0xF0, 0x23, 0x92, 0x4B, 0xC0, 0x88, 0xBE, 0xEA, 0x90, 0xC4, 0x44, 0x44,
  0xF0, 0xFD, 0x6B, 0x5A, 0x80, 0xF9, 0x99, 0x90, 0x72, 0x72, 0x97, 0x00,
  0xE9, 0x99, 0xE8, 0x80, 0x6A, 0xF2, 0xB6, 0x84, 0x20, 0xBC, 0x88, 0x80,
  0xE8, 0xE1, 0xE0, 0x4E, 0xCC, 0xC7, 0xBB, 0xBB, 0xD0, 0xCA, 0xD4, 0xE3,
  0x00, 0x8D, 0x6E, 0xB5, 0x80, 0x5B, 0x88, 0xA4, 0x80, 0xCA, 0xD4, 0x63,
  0x11, 0x80, 0xF2, 0x48, 0xF0, 0x74, 0x44, 0x84, 0x44, 0x70, 0xFF, 0x80,
  0xC6, 0x66, 0x36, 0x66, 0xC0, 0xE4, 0xC0,
};

const GFXglyph LiberationMono_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 5, 9, 5, 0, -8 },
  { 15, 5, 7, 5, 0, -7 },
  { 20, 5, 7, 5, 0, -7 },
  { 25, 1, 3, 5, 2, -7 },
  { 26, 2, 9, 5, 2, -7 },
  { 29, 3, 9, 5, 1, -7 },
  { 33, 3, 4, 5, 1, -7 },
  { 35, 5, 5, 5, 0, -6 },
  { 39, 2, 3, 5, 1, -1 },
  { 40, 3, 1, 5, 1, -4 },
  { 41, 1, 1, 5, 2, -1 },
  { 42, 5, 7, 5, 0, -7 },
  { 47, 4, 7, 5, 1, -7 },
  { 51, 4, 7, 5, 1, -7 },
  { 55, 4, 7, 5, 1, -7 },
  { 59, 5, 7, 5, 0, -7 },
  { 64, 5, 7, 5, 0, -7 },
  { 69, 5, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 1, -7 },
  { 78, 4, 7, 5, 1, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 5, 7, 5, 0, -7 },
  { 92, 1, 5, 5, 2, -5 },
  { 93, 3, 7, 5, 1, -5 },
  { 96, 5, 5, 5, 0, -6 },
  { 100, 5, 3, 5, 0, -5 },
  { 102, 5, 5, 5, 0, -6 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 9, 5, 0, -7 },
  { 117, 5, 7, 5, 0, -7 },
  { 122, 4, 7, 5, 1, -7 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 4, 7, 5, 1, -7 },
  { 135, 4, 7, 5, 1, -7 },
  { 139, 4, 7, 5, 1, -7 },
  { 143, 5, 7, 5, 0, -7 },
  { 148, 4, 7, 5, 1, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 4, 7, 5, 0, -7 },
  { 160, 4, 7, 5, 1, -7 },
  { 164, 4, 7, 5, 1, -7 },
  { 168, 5, 7, 5, 0, -7 },
  { 173, 4, 7, 5, 1, -7 },
  { 177, 5, 7, 5, 0, -7 },
  { 182, 4, 7, 5, 1, -7 },
  { 186, 5, 9, 5, 0, -7 },
  { 192, 4, 7, 5, 1, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 4, 7, 5, 1, -7 },
  { 210, 5, 7, 5, 0, -7 },
  { 215, 5, 7, 5, 0, -7 },
  { 220, 5, 7, 5, 0, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 5, 7, 5, 0, -7 },
  { 235, 2, 9, 5, 2, -7 },
  { 238, 5, 7, 5, 0, -7 },
  { 243, 3, 9, 5, 1, -7 },
  { 247, 5, 4, 5, 0, -7 },
  { 250, 5, 1, 5, 0, 1 },
  { 251, 2, 2, 5, 2, -8 },
  { 252, 5, 5, 5, 0, -5 },
  { 256, 4, 7, 5, 1, -7 },
  { 260, 5, 5, 5, 0, -5 },
  { 264, 5, 7, 5, 0, -7 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 4, 7, 5, 1, -7 },
  { 277, 4, 7, 5, 1, -5 },
  { 281, 4, 7, 5, 1, -7 },
  { 285, 4, 7, 5, 1, -7 },
  { 289, 3, 9, 5, 1, -7 },
  { 293, 4, 7, 5, 1, -7 },
  { 297, 4, 7, 5, 1, -7 },
  { 301, 5, 5, 5, 0, -5 },
  { 305, 4, 5, 5, 1, -5 },
  { 308, 5, 5, 5, 0, -5 },
  { 312, 4, 7, 5, 1, -5 },
  { 316, 5, 7, 5, 0, -5 },
  { 321, 4, 5, 5, 1, -5 },
  { 324, 4, 5, 5, 1, -5 },
  { 327, 4, 6, 5, 1, -6 },
  { 330, 4, 5, 5, 1, -5 },
  { 333, 5, 5, 5, 0, -5 },
  { 337, 5, 5, 5, 0, -5 },
  { 341, 5, 5, 5, 0, -5 },
  { 345, 5, 7, 5, 0, -5 },
  { 350, 4, 5, 5, 1, -5 },
  { 353, 4, 9, 5, 1, -7 },
  { 358, 1, 9, 5, 2, -7 },
  { 360, 4, 9, 5, 1, -7 },
  { 365, 5, 2, 5, 0, -5 },
};

const GFXfont LiberationMono_Bold9pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold9pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold9pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _LIBERATIONMONO_BOLD9PT7B_H_
