#ifndef _LIBERATIONMONO_BOLD42PT7B_H_
#define _LIBERATIONMONO_BOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xDE, 0x0F, 0xBC,
  0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x81,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x03,
  0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x8D, 0xFC, 0x3E, 0x18, 0xF8, 0xFC, 0x31,
  0xF9, 0xF8, 0x63, 0xC3, 0xF0, 0xC0, 0x03, 0xF1, 0x80, 0x07, 0xF3, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0x8F, 0xC0, 0x03, 0x0F, 0xC7,
  0x06, 0x1F, 0xBE, 0x0C, 0x3F, 0x7C, 0x18, 0x7E, 0xFC, 0x30, 0xF8, 0xFE,
  0x67, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x1F, 0x80, 0x0F, 0x1F, 0xE0, 0x0F, 0x1F, 0xF8, 0x07, 0x1F, 0x3C,
  0x07, 0x8F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0x83, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE3, 0xC0, 0xF0, 0xF1, 0xC0, 0x78, 0x79, 0xE0, 0x1E, 0x79, 0xE0, 0x0F,
  0xFD, 0xE0, 0x03, 0xFC, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x73, 0xFE, 0x00, 0x7B, 0xFF, 0x00, 0x79, 0xE3, 0xC0, 0x38, 0xE1,
  0xE0, 0x3C, 0xF0, 0x70, 0x3C, 0x78, 0x38, 0x1C, 0x3C, 0x1C, 0x1E, 0x0E,
  0x1E, 0x1E, 0x07, 0x0F, 0x0E, 0x03, 0xC7, 0x8F, 0x01, 0xFF, 0x8F, 0x00,
  0x7F, 0x87, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE7, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0xF0, 0x7F, 0xE0, 0xF8, 0x7F, 0xF0, 0x78, 0x7E, 0x7C, 0x3C, 0x3E, 0x1F,
  0x3E, 0x1F, 0x0F, 0xDE, 0x1F, 0x03, 0xFF, 0x0F, 0xC0, 0xFF, 0x83, 0xE0,
  0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC3, 0xFF, 0x8F, 0xE0, 0x7F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x43, 0xC4, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3E, 0xF8, 0x3E, 0x7C, 0x7C, 0x7C, 0x38, 0x38, 0x08, 0x20,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x7F, 0xF9, 0xF3, 0xFF, 0xCF, 0x9F, 0xFE, 0x7C, 0xFF, 0xF3,
  0xE7, 0xFF, 0x9F, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C,
  0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x1F, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC0, 0xE0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xEF, 0xE0,
  0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFD, 0xFC, 0x1F, 0xEF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0x01, 0xFD, 0xFC, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE,
  0x7E, 0x07, 0xEF, 0xC0, 0x78, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x7E,
  0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xF7, 0xE0, 0x7F, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xE0, 0xFE, 0x7E, 0x03, 0xF3, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFD,
  0xF8, 0x0F, 0xEF, 0xE0, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0xDF, 0xC0,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0xFE, 0xFC, 0x07, 0xF7,
  0xE0, 0x3F, 0xBF, 0x83, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xF9,
  0xF8, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE1, 0xC0, 0x3F, 0x3F,
  0x03, 0xF1, 0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE1, 0xFF,
  0xFE, 0x7F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07,
  0x07, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x38, 0x3C, 0xEE, 0xF0, 0xFD, 0xDD,
  0xC3, 0xFB, 0xBB, 0x8F, 0x1F, 0x77, 0x3C, 0x3C, 0x7C, 0x70, 0x78, 0xF8,
  0xE0, 0xF1, 0xF3, 0x81, 0xE3, 0xE7, 0x03, 0x87, 0xCE, 0x07, 0x0F, 0x9C,
  0x0E, 0x3F, 0x38, 0x1C, 0x7E, 0x70, 0x38, 0xFC, 0xE0, 0xF1, 0xF9, 0xC1,
  0xC3, 0x73, 0x87, 0x8E, 0xE7, 0x9F, 0x1D, 0xC7, 0xF7, 0xF1, 0xCF, 0xCF,
  0xC3, 0x8F, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x08,
  0x0F, 0x00, 0x38, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0,
  0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x03, 0xF9,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFE,
  0x1F, 0xE7, 0xF0, 0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x00, 0xC3, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x0E, 0x3F, 0x80, 0x3F, 0x7E, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF8, 0x7F,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x7E, 0x1F, 0xF3, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x07, 0xF3,
  0xF0, 0x7F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC3, 0xF9, 0xFC, 0x0F, 0xDF, 0xC0,
  0x7E, 0xFC, 0x01, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF,
  0x80, 0x7D, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x70, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x1F,
  0xDF, 0xC7, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0x3F,
  0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F,
  0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x07, 0xF3,
  0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFB, 0xC3, 0xFF, 0xDE, 0x1D, 0xFE, 0xF1, 0xEF,
  0xFF, 0x8F, 0x7F, 0xFE, 0x7B, 0xFE, 0xF3, 0xDF, 0xF7, 0xBC, 0xFF, 0xBD,
  0xE7, 0xFD, 0xEF, 0x3F, 0xE7, 0xF9, 0xFF, 0x3F, 0x8F, 0xF9, 0xFC, 0x7F,
  0xCF, 0xE3, 0xFE, 0x3F, 0x1F, 0xF1, 0xF0, 0xFF, 0x8F, 0x87, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xF0, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xEF, 0x8F, 0xFD, 0xF1, 0xFF, 0x9E, 0x3F,
  0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xC7, 0x9F, 0xF8, 0xFB, 0xFF, 0x1F, 0x7F,
  0xE1, 0xFF, 0xFC, 0x3E, 0xFF, 0x83, 0xDF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x0F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F,
  0x0F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xF0,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00,
  0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC,
  0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xF3,
  0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0,
  0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xF9, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF,
  0xE0, 0x7F, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x1F, 0xE7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0xFD, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x3E, 0x1F, 0x3F, 0x1F, 0x0F, 0x8F,
  0x8F, 0x87, 0xC7, 0xC7, 0xE7, 0xC3, 0xE7, 0xF3, 0xE1, 0xF3, 0xF9, 0xF0,
  0xF9, 0xFE, 0xF8, 0x7D, 0xFF, 0x7C, 0x1E, 0xF7, 0xBE, 0x0F, 0x7B, 0xDF,
  0x07, 0xBD, 0xEF, 0x03, 0xDE, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x7F, 0x00, 0x3F, 0x1F,
  0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0x7F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x3F,
  0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0x83,
  0xF0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xE0,
  0x03, 0xC3, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x3C, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x07, 0xE1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x8F, 0xE1, 0xFE, 0x1F, 0xFE, 0xFF, 0x7F, 0xFB, 0xFC, 0xFF, 0xC7,
  0xF0, 0xFC, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0xFC, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0xFE, 0x07,
  0xEF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xF0, 0xFE, 0xFF, 0xFF, 0xCF,
  0xDF, 0xFC, 0xFC, 0xFF, 0x8F, 0xC7, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7E, 0x3F, 0x81, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0x7E, 0x01, 0xF3, 0xF8, 0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x3F, 0x0F, 0xFB, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xF0, 0xFF, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0,
  0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0x7E, 0x1F, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0x7E,
  0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xCF, 0xE0,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE3, 0xF1, 0xFF, 0x3F,
  0x3F, 0xFB, 0xF7, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0x7F, 0x1F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF1,
  0xFF, 0x3F, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF3, 0xC0, 0x7E,
  0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0xFC,
  0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF,
  0xE0, 0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x80, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8,
  0xF8, 0x3F, 0x0F, 0x87, 0xF0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8,
  0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFE, 0xFC, 0x0F, 0x87, 0xE0, 0xF8, 0x7F, 0x0F, 0x83, 0xF0, 0xF8,
  0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0xFE, 0xF8, 0x07, 0xEF,
  0x80, 0x7F, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF9, 0xE0, 0xF1, 0xF7, 0xE3, 0xF3, 0xFF, 0xEF, 0xF3, 0xFF, 0xDF,
  0xE7, 0xE7, 0xE7, 0xCF, 0x8F, 0xC7, 0xDF, 0x1F, 0x0F, 0xBC, 0x3E, 0x1F,
  0x78, 0x7C, 0x3E, 0xF0, 0xF8, 0x7D, 0xE1, 0xF0, 0xFB, 0xC3, 0xE1, 0xF7,
  0x87, 0xC3, 0xEF, 0x0F, 0x87, 0xDE, 0x1F, 0x0F, 0xBC, 0x3E, 0x1F, 0x78,
  0x7C, 0x3E, 0xF0, 0xF8, 0x7D, 0xE1, 0xF0, 0xFB, 0xC3, 0xE1, 0xF7, 0x87,
  0xC3, 0xEF, 0x0F, 0x87, 0xDE, 0x1F, 0x0F, 0x80, 0xF8, 0x3F, 0x0F, 0x8F,
  0xF8, 0xF9, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE,
  0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x3E, 0x0F, 0xCF, 0xF8,
  0xFD, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7E, 0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0xFD, 0xFF, 0xCF,
  0xCF, 0xF8, 0xFC, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0xFF, 0x1F, 0x1F, 0xFB, 0xF3, 0xFF,
  0xFF, 0x7F, 0x0F, 0xF7, 0xE0, 0x7F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7F,
  0x7F, 0x0F, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xBF, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC,
  0x1F, 0xFF, 0x1F, 0xF7, 0xCF, 0xFD, 0xF7, 0xFF, 0x7D, 0xE0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x3C, 0x01, 0xFB,
  0xE0, 0x0F, 0xDF, 0x80, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF, 0xBF, 0xF9, 0xF3, 0xFE, 0x3E,
  0x3F, 0x87, 0xC0, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C,
  0x1F, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xF7,
  0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3E, 0x3C,
  0x3E, 0x1F, 0x1E, 0x1F, 0x8F, 0x0F, 0x1F, 0xC7, 0x87, 0x8F, 0xE3, 0xC3,
  0xE7, 0x79, 0xE1, 0xF7, 0xBD, 0xF0, 0x7B, 0xDE, 0xF8, 0x3D, 0xC7, 0x78,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x00,
  0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x1F, 0xBF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF8,
  0x01, 0xF3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0,
  0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x3F, 0x80,
};

const GFXglyph LiberationMono_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 28, 25, 10, -28 },
  { 22, 15, 13, 25, 5, -30 },
  { 47, 23, 28, 25, 1, -28 },
  { 128, 23, 35, 25, 1, -31 },
  { 229, 25, 28, 25, 0, -28 },
  { 317, 25, 28, 25, 0, -28 },
  { 405, 5, 13, 25, 10, -30 },
  { 414, 12, 39, 25, 7, -30 },
  { 473, 12, 39, 25, 6, -30 },
  { 532, 16, 16, 25, 5, -30 },
  { 564, 21, 21, 25, 2, -24 },
  { 620, 10, 14, 25, 5, -6 },
  { 638, 12, 5, 25, 7, -13 },
  { 646, 6, 6, 25, 10, -6 },
  { 651, 21, 30, 25, 2, -30 },
  { 730, 21, 28, 25, 2, -28 },
  { 804, 20, 28, 25, 3, -28 },
  { 874, 20, 28, 25, 3, -28 },
  { 944, 21, 28, 25, 2, -28 },
  { 1018, 23, 28, 25, 1, -28 },
  { 1099, 21, 28, 25, 2, -28 },
  { 1173, 20, 28, 25, 3, -28 },
  { 1243, 19, 28, 25, 3, -28 },
  { 1310, 21, 28, 25, 2, -28 },
  { 1384, 21, 28, 25, 2, -28 },
  { 1458, 6, 23, 25, 10, -23 },
  { 1476, 10, 31, 25, 7, -23 },
  { 1515, 21, 22, 25, 2, -25 },
  { 1573, 21, 16, 25, 2, -22 },
  { 1615, 21, 22, 25, 2, -25 },
  { 1673, 21, 28, 25, 2, -28 },
  { 1747, 23, 36, 25, 1, -30 },
  { 1851, 25, 28, 25, 0, -28 },
  { 1939, 21, 28, 25, 3, -28 },
  { 2013, 22, 28, 25, 2, -28 },
  { 2090, 21, 28, 25, 3, -28 },
  { 2164, 21, 28, 25, 3, -28 },
  { 2238, 20, 28, 25, 3, -28 },
  { 2308, 21, 28, 25, 2, -28 },
  { 2382, 19, 28, 25, 3, -28 },
  { 2449, 19, 28, 25, 3, -28 },
  { 2516, 19, 28, 25, 2, -28 },
  { 2583, 22, 28, 25, 3, -28 },
  { 2660, 19, 28, 25, 4, -28 },
  { 2727, 21, 28, 25, 2, -28 },
  { 2801, 19, 28, 25, 3, -28 },
  { 2868, 23, 28, 25, 1, -28 },
  { 2949, 20, 28, 25, 3, -28 },
  { 3019, 23, 36, 25, 1, -28 },
  { 3123, 22, 28, 25, 3, -28 },
  { 3200, 23, 28, 25, 1, -28 },
  { 3281, 23, 28, 25, 1, -28 },
  { 3362, 20, 28, 25, 3, -28 },
  { 3432, 25, 28, 25, 0, -28 },
  { 3520, 25, 28, 25, 0, -28 },
  { 3608, 25, 28, 25, 0, -28 },
  { 3696, 25, 28, 25, 0, -28 },
  { 3784, 21, 28, 25, 2, -28 },
  { 3858, 12, 39, 25, 8, -30 },
  { 3917, 21, 30, 25, 2, -30 },
  { 3996, 13, 39, 25, 5, -30 },
  { 4060, 23, 18, 25, 1, -28 },
  { 4112, 25, 2, 25, 0, 3 },
  { 4119, 11, 6, 25, 7, -30 },
  { 4128, 22, 23, 25, 2, -23 },
  { 4192, 20, 30, 25, 3, -30 },
  { 4267, 21, 23, 25, 2, -23 },
  { 4328, 20, 30, 25, 2, -30 },
  { 4403, 21, 23, 25, 2, -23 },
  { 4464, 21, 30, 25, 2, -30 },
  { 4543, 20, 32, 25, 3, -23 },
  { 4623, 20, 30, 25, 3, -30 },
  { 4698, 22, 30, 25, 2, -30 },
  { 4781, 16, 39, 25, 2, -30 },
  { 4859, 20, 30, 25, 4, -30 },
  { 4934, 22, 30, 25, 2, -30 },
  { 5017, 23, 23, 25, 1, -23 },
  { 5084, 20, 23, 25, 3, -23 },
  { 5142, 21, 23, 25, 2, -23 },
  { 5203, 20, 32, 25, 3, -23 },
  { 5283, 20, 32, 25, 2, -23 },
  { 5363, 18, 23, 25, 4, -23 },
  { 5415, 21, 23, 25, 2, -23 },
  { 5476, 18, 29, 25, 3, -29 },
  { 5542, 19, 22, 25, 3, -22 },
  { 5595, 23, 23, 25, 1, -23 },
  { 5662, 25, 23, 25, 0, -23 },
  { 5734, 23, 23, 25, 1, -23 },
  { 5801, 23, 32, 25, 1, -23 },
  { 5893, 19, 23, 25, 3, -23 },
  { 5948, 17, 39, 25, 4, -30 },
  { 6031, 5, 39, 25, 10, -30 },
  { 6056, 17, 39, 25, 4, -30 },
  { 6139, 21, 7, 25, 2, -17 },
};

const GFXfont LiberationMono_Bold42pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold42pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold42pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _LIBERATIONMONO_BOLD42PT7B_H_
