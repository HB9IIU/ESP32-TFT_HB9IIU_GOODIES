#ifndef _LIBERATIONMONO_BOLD23PT7B_H_
#define _LIBERATIONMONO_BOLD23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xE6, 0x66, 0x00, 0xEE, 0xE0, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xC7, 0x0C, 0x60, 0x84, 0x18, 0xCF, 0xFF, 0xFF, 0xF1,
  0x0C, 0x30, 0x83, 0x18, 0xFF, 0xFF, 0xFF, 0x21, 0x06, 0x10, 0x63, 0x06,
  0x30, 0x63, 0x00, 0x06, 0x00, 0x60, 0x1F, 0x87, 0xFE, 0xF6, 0xEE, 0x67,
  0xE6, 0x07, 0x60, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x67, 0xE6, 0x7E, 0x67,
  0xF6, 0xF7, 0xFE, 0x1F, 0x80, 0x60, 0x06, 0x00, 0x78, 0x1B, 0xF0, 0xCC,
  0xC6, 0x33, 0x18, 0xCC, 0xC3, 0x36, 0x07, 0xD8, 0x1E, 0xDE, 0x06, 0xF8,
  0x1B, 0x30, 0xD8, 0xC6, 0x63, 0x30, 0xCC, 0xC3, 0xE6, 0x07, 0x00, 0x0F,
  0x80, 0x7F, 0x01, 0xCE, 0x06, 0x38, 0x18, 0xC0, 0x7F, 0x01, 0xF0, 0x0F,
  0x8C, 0x76, 0x33, 0x9D, 0xCE, 0x3F, 0x38, 0x78, 0x71, 0xF1, 0xFF, 0xF1,
  0xF1, 0xC0, 0xFD, 0xB6, 0xD8, 0x1C, 0xE3, 0x9C, 0x71, 0xCE, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x0E, 0x38, 0x70, 0x70, 0xF0,
  0xE1, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E,
  0x1C, 0x38, 0xF1, 0xC7, 0x8E, 0x00, 0x0C, 0x06, 0x13, 0x6F, 0xF7, 0xF0,
  0xF0, 0xFC, 0xE7, 0x12, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3B,
  0xDC, 0xE6, 0x73, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x70, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x1F, 0x07,
  0xF9, 0xC7, 0xB8, 0x77, 0x0F, 0xE1, 0xF9, 0xBF, 0x37, 0xE6, 0xFE, 0x1D,
  0xC3, 0xB8, 0x77, 0x1C, 0x7F, 0x87, 0xC0, 0x0E, 0x03, 0xC0, 0xF8, 0x7F,
  0x0C, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE1, 0xFF, 0xFF, 0xF8, 0x1F, 0x87, 0xF9, 0xC7, 0xB8, 0x70, 0x0E, 0x03,
  0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x07, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0x87, 0xFC, 0x71, 0xEF, 0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0x80,
  0xFC, 0x01, 0xE0, 0x0E, 0x00, 0xFE, 0x0F, 0xF0, 0xE7, 0xFC, 0x1F, 0x80,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x1D, 0xC3, 0x9C, 0x31, 0xC7, 0x1C,
  0xE1, 0xCF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F,
  0xE7, 0xFE, 0x70, 0x07, 0x00, 0x70, 0x07, 0x78, 0x7F, 0xC7, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xFE, 0x0E, 0x71, 0xE7, 0xFC, 0x1F, 0x80, 0x0F, 0x83,
  0xFC, 0x79, 0xE7, 0x0E, 0x70, 0x07, 0x78, 0xFF, 0xCF, 0x9E, 0xF0, 0xE7,
  0x0F, 0x70, 0xE7, 0x0E, 0x39, 0xE3, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x87, 0xFC, 0x71, 0xE7, 0x0E,
  0x70, 0xE7, 0x1E, 0x3F, 0xC3, 0xFC, 0x70, 0xEF, 0x0E, 0xE0, 0xFF, 0x0E,
  0x70, 0xE7, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xF9, 0xC7, 0x78, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3B, 0x8F, 0x7F, 0xE3, 0xDC, 0x03, 0xB8, 0x77, 0x1C, 0x7F,
  0x07, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x7B, 0xDE, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0xE7, 0x33, 0x98, 0xC0, 0x00, 0x10, 0x0F, 0x03,
  0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x70, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x0E, 0x00,
  0x80, 0x00, 0x1F, 0x87, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x60, 0x63, 0x37, 0xB3, 0xFD, 0xB3,
  0xA9, 0x99, 0x58, 0xCA, 0xC6, 0x56, 0x32, 0xB1, 0x95, 0x8D, 0xAC, 0xCD,
  0xBF, 0xCD, 0xCC, 0x30, 0x01, 0xC1, 0x07, 0xF8, 0x1F, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x1D, 0xC0, 0x73, 0x81, 0xCE, 0x0E, 0x38,
  0x38, 0x70, 0xFF, 0xC7, 0xFF, 0x1C, 0x0E, 0x70, 0x3B, 0xC0, 0xEE, 0x03,
  0xC0, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0xBF, 0xE7, 0xFC,
  0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xFF, 0xBF, 0xE0, 0x1F, 0x83,
  0xFC, 0x78, 0xE7, 0x0F, 0xF0, 0x6E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x77, 0x07, 0x78, 0xE3, 0xFC, 0x0F, 0x80, 0xFE, 0x1F, 0xF3,
  0x8F, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87,
  0xF0, 0xEE, 0x3D, 0xFF, 0x3F, 0x80, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xF7, 0xFE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0x83,
  0xFC, 0x79, 0xE7, 0x0E, 0xF0, 0xEE, 0x00, 0xE0, 0x0E, 0x3F, 0xE3, 0xFE,
  0x07, 0xF0, 0x77, 0x07, 0x78, 0xF3, 0xFE, 0x0F, 0x80, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0xFF, 0xF1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFC, 0x0F,
  0xC3, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7E,
  0x1F, 0xC7, 0x73, 0xDF, 0xE1, 0xF0, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x78,
  0xEF, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0x70, 0xE7, 0x8E, 0x3C,
  0xE3, 0xCE, 0x1E, 0xE0, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF,
  0xFF, 0xF8, 0xF0, 0xFF, 0x0F, 0xD9, 0xFF, 0x9F, 0xF9, 0xFF, 0xFF, 0xFF,
  0x7E, 0xF7, 0xEF, 0x7E, 0xF7, 0xE6, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x70, 0xE1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF9, 0xF6, 0x7D, 0xDF, 0x37, 0xCF,
  0xF3, 0xBC, 0x6F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3C, 0x1F, 0x83, 0xFC, 0x79,
  0xEF, 0x0E, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFF, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x1F, 0xFB, 0x87, 0x70,
  0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0xFE, 0xFF, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x1F, 0x83, 0xFC, 0x79, 0xEF, 0x0E, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x0E, 0x79, 0xE3,
  0xFC, 0x1F, 0x80, 0x70, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCF, 0xFC, 0xFF, 0x0E,
  0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE0, 0xE0, 0x0F, 0xC1, 0xFF,
  0x8E, 0x1C, 0xE0, 0xF7, 0x80, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x03, 0xF0,
  0x03, 0xFC, 0x0E, 0xE0, 0x77, 0x87, 0x9F, 0xF8, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xC3,
  0xB8, 0x77, 0x1E, 0x7F, 0x87, 0xE0, 0xF0, 0x3D, 0xC0, 0xE7, 0x03, 0x9E,
  0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0x98, 0x0E, 0x63, 0x39, 0xDC, 0xE7, 0x7B, 0x9D, 0xEE, 0x77,
  0xB0, 0xFF, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x87, 0x00,
  0x70, 0x39, 0xE1, 0xC3, 0xCF, 0x07, 0x38, 0x1F, 0xC0, 0x3F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xCE, 0x0F, 0x38, 0x38, 0x71, 0xC1,
  0xEF, 0x03, 0x80, 0xF0, 0x39, 0xC1, 0xE7, 0x87, 0x0E, 0x3C, 0x1C, 0xE0,
  0x77, 0x80, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF,
  0xC0, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xC0, 0x07,
  0x80, 0x7C, 0x03, 0x70, 0x39, 0x81, 0x8C, 0x1C, 0x70, 0xE1, 0x86, 0x0E,
  0x70, 0x33, 0x01, 0xC0, 0xFF, 0xFC, 0xE1, 0xC1, 0x80, 0x1F, 0x03, 0xFC,
  0x71, 0xC7, 0x1C, 0x01, 0xE3, 0xFE, 0x7F, 0xEF, 0x1E, 0xF1, 0xEE, 0x1E,
  0xF3, 0xE7, 0xEF, 0x3C, 0x70, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0xF1,
  0xFF, 0x3C, 0xF7, 0x0E, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xBC, 0xF7, 0xFC, 0xEF, 0x00, 0x1F, 0x87, 0xF9, 0xE7, 0xB8, 0x7F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x1D, 0xE3, 0x9F, 0xE1, 0xF8, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x71, 0xEE, 0xFF, 0xDC, 0x7F, 0x87, 0xF0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1, 0xDC, 0x7B, 0xFF, 0x1C, 0xE0, 0x1F,
  0x83, 0xFC, 0x70, 0xE7, 0x0E, 0xE0, 0x6F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0,
  0x07, 0x0E, 0x78, 0xE3, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0x1E, 0x01,
  0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0xE3, 0xFE,
  0x79, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xF0, 0xEF, 0x0E, 0x70, 0xE7, 0x0E,
  0x79, 0xE3, 0xFE, 0x1E, 0xE0, 0x0E, 0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0xBF, 0xFF, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0x81, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xEF, 0xE7,
  0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1D, 0xC7, 0xB9, 0xE7, 0x38,
  0xEE, 0x1F, 0xC3, 0xF8, 0x7B, 0x8E, 0x79, 0xC7, 0x38, 0xF7, 0x0E, 0xE1,
  0xE0, 0x7F, 0x07, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F,
  0xFF, 0xFF, 0xF0, 0xDC, 0xEF, 0xFF, 0xEF, 0x7E, 0x67, 0xC6, 0x7C, 0x67,
  0xC6, 0x7C, 0x67, 0xC6, 0x7C, 0x67, 0xC6, 0x7C, 0x67, 0xC6, 0x70, 0xEF,
  0xBF, 0xFF, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xC0, 0x1F, 0x83, 0xFC, 0x71, 0xEF, 0x0E, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF7, 0x0E, 0x71, 0xE3, 0xFC, 0x1F, 0x80,
  0xEF, 0x1F, 0xF3, 0xCF, 0x70, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3B, 0xCF, 0x7F, 0xCE, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0xEF, 0xFD, 0xC7, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xFE, 0x1D, 0xC7, 0xBF, 0xF3, 0xCE, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0xE3, 0xDF, 0xF7, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x1F, 0x87, 0xF9, 0xC3, 0xB8,
  0x77, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x1D, 0xC3, 0xBF, 0xE1,
  0xF8, 0x18, 0x0E, 0x03, 0x83, 0xFE, 0xFF, 0x8E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFC, 0x7F, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xFC, 0xFF, 0xDD, 0xF7,
  0x70, 0x3B, 0x81, 0xDC, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0x73, 0x83,
  0x9C, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x1F,
  0x80, 0x66, 0x01, 0x98, 0xC6, 0x67, 0x19, 0x9E, 0xE7, 0x7B, 0x9F, 0xEC,
  0x7D, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x38, 0x70, 0xE0, 0xF7, 0x0E,
  0x79, 0xC3, 0xBC, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0x9C,
  0x71, 0xE7, 0x0E, 0xE0, 0x70, 0x70, 0x3B, 0x81, 0xDE, 0x1C, 0x70, 0xE3,
  0x87, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x0F, 0xC0, 0x7E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC7, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x0F, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x7C, 0x1F, 0x0F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x3F, 0x00, 0x78, 0x0F, 0xC1,
  0xCF, 0x38, 0x3F, 0x01, 0xE0,
};

const GFXglyph LiberationMono_Bold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 15, 14, 5, -15 },
  { 9, 8, 7, 14, 3, -17 },
  { 16, 12, 15, 14, 1, -15 },
  { 39, 12, 19, 14, 1, -17 },
  { 68, 14, 15, 14, 0, -15 },
  { 95, 14, 15, 14, 0, -15 },
  { 122, 3, 7, 14, 5, -17 },
  { 125, 6, 22, 14, 4, -17 },
  { 142, 7, 22, 14, 3, -17 },
  { 162, 9, 9, 14, 2, -17 },
  { 173, 12, 12, 14, 1, -14 },
  { 191, 5, 7, 14, 3, -3 },
  { 196, 6, 2, 14, 4, -7 },
  { 198, 4, 3, 14, 5, -3 },
  { 200, 12, 17, 14, 1, -17 },
  { 226, 11, 15, 14, 1, -15 },
  { 247, 11, 15, 14, 2, -15 },
  { 268, 11, 15, 14, 1, -15 },
  { 289, 12, 15, 14, 1, -15 },
  { 312, 12, 15, 14, 1, -15 },
  { 335, 12, 15, 14, 1, -15 },
  { 358, 12, 15, 14, 1, -15 },
  { 381, 11, 15, 14, 1, -15 },
  { 402, 12, 15, 14, 1, -15 },
  { 425, 11, 15, 14, 1, -15 },
  { 446, 4, 13, 14, 5, -13 },
  { 453, 5, 17, 14, 4, -13 },
  { 464, 12, 13, 14, 1, -14 },
  { 484, 12, 9, 14, 1, -12 },
  { 498, 12, 13, 14, 1, -14 },
  { 518, 12, 15, 14, 1, -15 },
  { 541, 13, 20, 14, 0, -17 },
  { 574, 14, 15, 14, 0, -15 },
  { 601, 11, 15, 14, 2, -15 },
  { 622, 12, 15, 14, 1, -15 },
  { 645, 11, 15, 14, 2, -15 },
  { 666, 11, 15, 14, 2, -15 },
  { 687, 10, 15, 14, 2, -15 },
  { 706, 12, 15, 14, 1, -15 },
  { 729, 10, 15, 14, 2, -15 },
  { 748, 10, 15, 14, 2, -15 },
  { 767, 10, 15, 14, 1, -15 },
  { 786, 12, 15, 14, 2, -15 },
  { 809, 11, 15, 14, 2, -15 },
  { 830, 12, 15, 14, 1, -15 },
  { 853, 10, 15, 14, 2, -15 },
  { 872, 12, 15, 14, 1, -15 },
  { 895, 11, 15, 14, 2, -15 },
  { 916, 12, 20, 14, 1, -15 },
  { 946, 12, 15, 14, 2, -15 },
  { 969, 13, 15, 14, 0, -15 },
  { 994, 12, 15, 14, 1, -15 },
  { 1017, 11, 15, 14, 1, -15 },
  { 1038, 14, 15, 14, 0, -15 },
  { 1065, 14, 15, 14, 0, -15 },
  { 1092, 14, 15, 14, 0, -15 },
  { 1119, 14, 15, 14, 0, -15 },
  { 1146, 12, 15, 14, 1, -15 },
  { 1169, 7, 22, 14, 4, -17 },
  { 1189, 12, 17, 14, 1, -17 },
  { 1215, 7, 22, 14, 3, -17 },
  { 1235, 13, 10, 14, 0, -15 },
  { 1252, 14, 1, 14, 0, 1 },
  { 1254, 6, 3, 14, 4, -17 },
  { 1257, 12, 13, 14, 1, -13 },
  { 1277, 11, 17, 14, 2, -17 },
  { 1301, 11, 13, 14, 1, -13 },
  { 1319, 11, 17, 14, 1, -17 },
  { 1343, 12, 13, 14, 1, -13 },
  { 1363, 12, 17, 14, 1, -17 },
  { 1389, 12, 18, 14, 1, -13 },
  { 1416, 10, 17, 14, 2, -17 },
  { 1438, 12, 17, 14, 1, -17 },
  { 1464, 9, 22, 14, 1, -17 },
  { 1489, 11, 17, 14, 2, -17 },
  { 1513, 12, 17, 14, 1, -17 },
  { 1539, 12, 13, 14, 1, -13 },
  { 1559, 10, 13, 14, 2, -13 },
  { 1576, 12, 13, 14, 1, -13 },
  { 1596, 11, 18, 14, 2, -13 },
  { 1621, 11, 18, 14, 1, -13 },
  { 1646, 10, 13, 14, 2, -13 },
  { 1663, 11, 13, 14, 1, -13 },
  { 1681, 10, 16, 14, 2, -16 },
  { 1701, 10, 12, 14, 2, -12 },
  { 1716, 13, 13, 14, 0, -13 },
  { 1738, 14, 13, 14, 0, -13 },
  { 1761, 12, 13, 14, 1, -13 },
  { 1781, 13, 18, 14, 0, -13 },
  { 1811, 10, 13, 14, 2, -13 },
  { 1828, 10, 22, 14, 2, -17 },
  { 1856, 3, 22, 14, 5, -17 },
  { 1865, 10, 22, 14, 2, -17 },
  { 1893, 12, 5, 14, 1, -10 },
};

const GFXfont LiberationMono_Bold23pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold23pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold23pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _LIBERATIONMONO_BOLD23PT7B_H_
