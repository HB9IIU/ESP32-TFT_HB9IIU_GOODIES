#ifndef _LIBERATIONMONO_BOLD34PT7B_H_
#define _LIBERATIONMONO_BOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x03, 0x83, 0x00, 0xE0, 0xC0, 0x30,
  0x70, 0x1C, 0x1C, 0x07, 0x06, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC, 0x38, 0x38,
  0x0E, 0x0E, 0x03, 0x83, 0x00, 0xC0, 0xC0, 0x30, 0x70, 0x1C, 0x1C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0xE0, 0x18, 0x38, 0x0E, 0x0E, 0x03, 0x83,
  0x00, 0xE0, 0xC0, 0x30, 0x70, 0x0C, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x37, 0xE7, 0xCC, 0xF9,
  0xE3, 0x1E, 0x78, 0xC7, 0x1F, 0x30, 0x07, 0xEC, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0x7F, 0x00, 0xC7, 0xCC, 0x30,
  0xFF, 0x8C, 0x3D, 0xE3, 0x1F, 0x7C, 0xCF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xE7,
  0xF0, 0x1C, 0xF3, 0x81, 0xCE, 0x38, 0x38, 0xE1, 0x87, 0x0E, 0x1C, 0x70,
  0xE1, 0x8E, 0x0E, 0x39, 0xC0, 0x73, 0x98, 0x07, 0xF3, 0x80, 0x3E, 0x70,
  0x00, 0x0E, 0x7C, 0x00, 0xEF, 0xE0, 0x1D, 0xE7, 0x03, 0x9C, 0x70, 0x39,
  0xC7, 0x07, 0x1C, 0x70, 0xE1, 0xC7, 0x1C, 0x1C, 0x71, 0xC1, 0xE7, 0x38,
  0x0F, 0xE7, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0x77, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC1, 0xE3, 0xFC, 0x1C, 0x7D, 0xE3,
  0xC7, 0x8F, 0x3C, 0x78, 0xFB, 0x8F, 0x07, 0xF8, 0xF8, 0x3F, 0x07, 0x81,
  0xF0, 0x7C, 0x3F, 0xC7, 0xFF, 0xFF, 0x3F, 0xFB, 0xF0, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1,
  0xE0, 0xF8, 0x3C, 0x1F, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x8E, 0x6F, 0x7F, 0x7F, 0xF9, 0xFF, 0xC1, 0xF0, 0x1F, 0xC1, 0xEE,
  0x1E, 0x78, 0x71, 0xC1, 0x08, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x1F, 0x3E,
  0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFB, 0xCF, 0xFB, 0xCF,
  0xFB, 0xCF, 0xFB, 0xCF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F,
  0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0x07, 0xCF, 0x83, 0x87,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x1F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFF, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00,
  0x3D, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x0F, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0x87, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0x7E, 0x1F, 0x9F, 0xFF, 0xCF, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF1, 0xE0, 0x01, 0xF0, 0x00, 0xF9, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x87, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0,
  0x3E, 0xF0, 0x1E, 0x7C, 0x1F, 0x3F, 0x1F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x87, 0xEF, 0x81, 0xF7, 0xC0,
  0xFB, 0xE0, 0x7C, 0xF0, 0x3E, 0x7C, 0x3E, 0x1F, 0xFE, 0x01, 0xFC, 0x07,
  0xFF, 0x87, 0xC3, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xBF, 0x0F, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x07,
  0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x0F, 0x8F, 0x00, 0x1F, 0x00, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1E, 0x3E,
  0x3C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0x70, 0x00, 0x01, 0x80, 0x07, 0xC0,
  0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xE0,
  0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x3C, 0x0E, 0x01, 0xC3,
  0x80, 0x18, 0x60, 0x03, 0x9C, 0x39, 0xB3, 0x1F, 0xB6, 0x63, 0x96, 0xDC,
  0xE3, 0xDF, 0x98, 0x7B, 0xE7, 0x06, 0x3C, 0xE1, 0xC7, 0x98, 0x38, 0xF3,
  0x07, 0x3E, 0x60, 0xE7, 0xCC, 0x18, 0xD9, 0x83, 0x1B, 0x30, 0xE3, 0x66,
  0x1C, 0xEC, 0xE7, 0x99, 0xCF, 0xBE, 0x18, 0xE3, 0x83, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x60, 0x78, 0x3C, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00,
  0x3D, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C,
  0xF8, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x3E,
  0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x1F, 0x9F, 0x83, 0xF7, 0xC0, 0x7D,
  0xF0, 0x18, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x39, 0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0xC3,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x87, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x3F,
  0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xE7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x61, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7E, 0x07, 0xCF, 0xC3, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xDE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xBE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE,
  0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0x71, 0xFF, 0xB9,
  0xFF, 0xDE, 0xEF, 0xEF, 0x77, 0xF3, 0xBB, 0xF9, 0xFD, 0xFC, 0xFC, 0xFE,
  0x7E, 0x7F, 0x1F, 0x3F, 0x8F, 0x1F, 0xC7, 0x8F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3C, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xF7,
  0x8F, 0xF7, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xFB, 0xCF, 0xF9, 0xEF, 0xF9,
  0xEF, 0xF9, 0xEF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xF8, 0x1F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE,
  0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C,
  0x1F, 0x9F, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x83, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xE0, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x79,
  0xF0, 0x07, 0xDE, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F,
  0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78, 0xF9, 0xE3, 0xCF, 0x9E, 0x3D, 0xF9,
  0xE3, 0xDF, 0x9E, 0x3D, 0xFD, 0xC3, 0xFD, 0xFC, 0x3F, 0xDF, 0xC3, 0xF9,
  0xFC, 0x1F, 0x9F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC1,
  0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x07, 0xDE, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x81, 0xF0,
  0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x1F, 0xF8,
  0x01, 0xF7, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xE1, 0xC0, 0x78, 0x78, 0x1C, 0x0E, 0x0F, 0x03, 0xC3, 0x80, 0xF1, 0xE0,
  0x1E, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x78, 0x3C, 0x1E, 0x07, 0x0F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF,
  0xC1, 0xF1, 0xF8, 0x7C, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x8F, 0xE3, 0xFF, 0x7F, 0x7F, 0x8F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF1, 0xF0, 0xFB, 0xFC, 0x7F, 0xFF, 0x3F, 0x8F, 0xDF, 0x83,
  0xEF, 0xC1, 0xF7, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x83, 0xEF, 0xC1, 0xF7, 0xF1, 0xFB, 0xEF, 0xF9,
  0xF7, 0xF8, 0xF8, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E,
  0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x9F, 0x3F, 0xDF, 0x7F,
  0xFF, 0x7C, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7C,
  0x7F, 0x7F, 0xFF, 0x3F, 0xDF, 0x0F, 0x9F, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x8F, 0x87, 0xCF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x79, 0xF8, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x8F, 0x0F, 0xF7, 0x8F, 0xFB, 0xCF, 0xC7,
  0xE7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C,
  0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xF3, 0xE0, 0xF9, 0xF8, 0xFC,
  0x7F, 0xDE, 0x3F, 0xCF, 0x07, 0xC7, 0x80, 0x03, 0xC0, 0x01, 0xE7, 0xC1,
  0xF3, 0xF1, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0xF8, 0xF9, 0xFE, 0xFB, 0xFE, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x3F, 0xF3, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF3, 0x87, 0x3D, 0xF7, 0xEF, 0xFD, 0xFF, 0xE7, 0xCF, 0xF9,
  0xF3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78,
  0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F,
  0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xF0, 0xF8, 0xF8, 0xF9, 0xFE, 0xFB,
  0xFE, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x87, 0xEF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF7, 0xC0,
  0xF9, 0xF0, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF0, 0x00, 0xF8, 0xF8,
  0x7D, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xEF, 0xC1, 0xF7, 0xE0, 0xFB, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xC1, 0xF7, 0xE0, 0xFB, 0xF8, 0xFD, 0xFF, 0xFC, 0xFB, 0xFC, 0x7C, 0x7C,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0x7C, 0x7F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0x7C, 0x7F, 0x7F, 0xFF,
  0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x7E, 0xF3, 0xFD, 0xEF, 0xFB,
  0xDF, 0xF7, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1F,
  0x78, 0x0F, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3F, 0x7C, 0x7F, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0xF8, 0x03, 0xFF,
  0x00, 0xFB, 0xE0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x78, 0x1F, 0x0F,
  0x83, 0xC1, 0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x07,
  0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7,
  0x00, 0x0F, 0x78, 0xF0, 0xE7, 0x8F, 0x0E, 0x78, 0xF9, 0xE7, 0x8F, 0x9E,
  0x39, 0xF9, 0xE3, 0x9F, 0x9E, 0x39, 0xDD, 0xC3, 0xF9, 0xDC, 0x3F, 0x9D,
  0xC3, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0xFC, 0x07, 0xCF, 0x81, 0xF0, 0xF8, 0x7C, 0x0F, 0x8F, 0x81, 0xF3,
  0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xF3, 0xE0, 0x3E, 0x3C, 0x0F, 0x87,
  0xC1, 0xE0, 0x7C, 0x7C, 0x07, 0xDF, 0x00, 0xF8, 0xF8, 0x03, 0xFF, 0x00,
  0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xC0, 0xF0, 0xF8, 0x1F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0xDE,
  0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x0F, 0xE0, 0x3E, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFE,
  0x0F, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0,
  0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC3,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF8, 0x01, 0xF0,
};

const GFXglyph LiberationMono_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 22, 20, 8, -22 },
  { 15, 12, 10, 20, 4, -25 },
  { 30, 18, 22, 20, 1, -22 },
  { 80, 18, 27, 20, 1, -24 },
  { 141, 20, 22, 20, 0, -22 },
  { 196, 20, 22, 20, 0, -22 },
  { 251, 4, 10, 20, 8, -25 },
  { 256, 9, 32, 20, 6, -25 },
  { 292, 10, 32, 20, 5, -25 },
  { 332, 13, 13, 20, 4, -25 },
  { 354, 17, 18, 20, 2, -20 },
  { 393, 8, 11, 20, 4, -5 },
  { 404, 10, 4, 20, 5, -11 },
  { 409, 5, 5, 20, 8, -5 },
  { 413, 18, 25, 20, 1, -25 },
  { 470, 16, 22, 20, 2, -22 },
  { 514, 17, 22, 20, 2, -22 },
  { 561, 16, 22, 20, 2, -22 },
  { 605, 17, 22, 20, 2, -22 },
  { 652, 18, 22, 20, 1, -22 },
  { 702, 17, 22, 20, 2, -22 },
  { 749, 17, 22, 20, 2, -22 },
  { 796, 16, 22, 20, 2, -22 },
  { 840, 17, 22, 20, 2, -22 },
  { 887, 16, 22, 20, 2, -22 },
  { 931, 5, 18, 20, 8, -18 },
  { 943, 8, 24, 20, 5, -18 },
  { 967, 17, 18, 20, 2, -20 },
  { 1006, 17, 12, 20, 2, -17 },
  { 1032, 17, 18, 20, 2, -20 },
  { 1071, 17, 22, 20, 1, -22 },
  { 1118, 19, 29, 20, 1, -25 },
  { 1187, 20, 22, 20, 0, -22 },
  { 1242, 18, 22, 20, 2, -22 },
  { 1292, 18, 22, 20, 1, -22 },
  { 1342, 17, 22, 20, 2, -22 },
  { 1389, 17, 22, 20, 2, -22 },
  { 1436, 15, 22, 20, 3, -22 },
  { 1478, 18, 22, 20, 1, -22 },
  { 1528, 16, 22, 20, 2, -22 },
  { 1572, 15, 22, 20, 3, -22 },
  { 1614, 15, 22, 20, 2, -22 },
  { 1656, 18, 22, 20, 2, -22 },
  { 1706, 16, 22, 20, 3, -22 },
  { 1750, 17, 22, 20, 2, -22 },
  { 1797, 16, 22, 20, 2, -22 },
  { 1841, 18, 22, 20, 1, -22 },
  { 1891, 17, 22, 20, 2, -22 },
  { 1938, 18, 29, 20, 1, -22 },
  { 2004, 18, 22, 20, 2, -22 },
  { 2054, 18, 22, 20, 1, -22 },
  { 2104, 18, 22, 20, 1, -22 },
  { 2154, 16, 22, 20, 2, -22 },
  { 2198, 20, 22, 20, 0, -22 },
  { 2253, 20, 22, 20, 0, -22 },
  { 2308, 20, 22, 20, 0, -22 },
  { 2363, 20, 22, 20, 0, -22 },
  { 2418, 18, 22, 20, 1, -22 },
  { 2468, 10, 32, 20, 6, -25 },
  { 2508, 17, 25, 20, 2, -25 },
  { 2562, 10, 32, 20, 4, -25 },
  { 2602, 18, 15, 20, 1, -22 },
  { 2636, 20, 2, 20, 0, 2 },
  { 2641, 8, 5, 20, 6, -25 },
  { 2646, 18, 18, 20, 2, -18 },
  { 2687, 17, 25, 20, 2, -25 },
  { 2741, 16, 18, 20, 2, -18 },
  { 2777, 16, 25, 20, 2, -25 },
  { 2827, 17, 18, 20, 2, -18 },
  { 2866, 17, 25, 20, 2, -25 },
  { 2920, 17, 25, 20, 2, -18 },
  { 2974, 16, 25, 20, 2, -25 },
  { 3024, 17, 25, 20, 2, -25 },
  { 3078, 12, 32, 20, 2, -25 },
  { 3126, 16, 25, 20, 3, -25 },
  { 3176, 17, 25, 20, 2, -25 },
  { 3230, 18, 18, 20, 1, -18 },
  { 3271, 16, 18, 20, 2, -18 },
  { 3307, 17, 18, 20, 2, -18 },
  { 3346, 17, 25, 20, 2, -18 },
  { 3400, 16, 25, 20, 2, -18 },
  { 3450, 15, 18, 20, 3, -18 },
  { 3484, 16, 18, 20, 2, -18 },
  { 3520, 14, 23, 20, 3, -23 },
  { 3561, 16, 18, 20, 2, -18 },
  { 3597, 19, 18, 20, 1, -18 },
  { 3640, 20, 18, 20, 0, -18 },
  { 3685, 19, 18, 20, 1, -18 },
  { 3728, 19, 25, 20, 1, -18 },
  { 3788, 16, 18, 20, 2, -18 },
  { 3824, 14, 32, 20, 3, -25 },
  { 3880, 4, 33, 20, 8, -25 },
  { 3897, 14, 32, 20, 3, -25 },
  { 3953, 17, 6, 20, 2, -14 },
};

const GFXfont LiberationMono_Bold34pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold34pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold34pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _LIBERATIONMONO_BOLD34PT7B_H_
