#ifndef _LIBERATIONMONO_BOLD46PT7B_H_
#define _LIBERATIONMONO_BOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x3C,
  0x07, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xE0, 0x78, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x07, 0x80,
  0x0E, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x70,
  0x01, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x0F, 0x01,
  0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F,
  0x99, 0xFC, 0x7E, 0x18, 0xFE, 0x7E, 0x18, 0x7E, 0x7E, 0x18, 0x78, 0x7E,
  0x18, 0x00, 0x7E, 0x18, 0x00, 0x7F, 0x98, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x18, 0xFE, 0x00, 0x18, 0x7F, 0x00, 0x18, 0x3F, 0x18,
  0x18, 0x3F, 0xFC, 0x18, 0x3F, 0xFC, 0x18, 0x3F, 0xFE, 0x18, 0x7F, 0x7F,
  0x18, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x03, 0xC3, 0xFE, 0x00, 0x78,
  0x7F, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0xF0, 0xF0, 0x78, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x87, 0x80, 0xF0, 0x78, 0xF0,
  0x0F, 0x07, 0x8F, 0x00, 0xF0, 0xF9, 0xE0, 0x07, 0x8F, 0x3C, 0x00, 0x7F,
  0xF3, 0xC0, 0x03, 0xFE, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE3,
  0xF0, 0x00, 0x1E, 0x7F, 0xC0, 0x03, 0xCF, 0xFC, 0x00, 0x79, 0xF1, 0xE0,
  0x07, 0x9E, 0x1E, 0x00, 0xF1, 0xE0, 0xE0, 0x1E, 0x1E, 0x0F, 0x01, 0xE1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x1E, 0x1E,
  0x0F, 0x01, 0xF1, 0xE1, 0xE0, 0x0F, 0xFC, 0x3C, 0x00, 0x7F, 0xC3, 0xC0,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x0F,
  0x00, 0x1E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xE0, 0xFF, 0xE0, 0x7C, 0x7F, 0xF8, 0x1F, 0x1F, 0x9F, 0x07,
  0x8F, 0xC7, 0xE3, 0xE3, 0xE0, 0xFC, 0xF8, 0xF8, 0x1F, 0xFC, 0x3E, 0x03,
  0xFF, 0x0F, 0x80, 0xFF, 0x83, 0xE0, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F,
  0x83, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF, 0x1F,
  0xC0, 0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF,
  0xBE, 0xF9, 0xE0, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x61, 0xE1, 0x1E, 0x7B,
  0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0x7E, 0x0F, 0xCF, 0xC3, 0xE1, 0xF0, 0x70, 0x70, 0x04,
  0x08, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0xFE, 0x01,
  0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0xF8, 0xFF,
  0xF3, 0xE3, 0xFF, 0xCF, 0x8F, 0xFF, 0x3E, 0x3F, 0xFC, 0xF8, 0xFF, 0xF3,
  0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xBF, 0x00, 0xFC, 0x7E,
  0x01, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFE, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E,
  0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x83,
  0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xE3,
  0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x83, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x78, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0xFF,
  0xC3, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x87, 0xFB,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8,
  0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x3F, 0x87, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x3F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7F, 0x00,
  0xFC, 0xFE, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8,
  0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F,
  0x07, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFE,
  0xFC, 0x7F, 0xF3, 0xF0, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE3, 0xC0, 0x3F, 0xBF, 0x81, 0xFC, 0x7F, 0x0F, 0xF1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF1,
  0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F,
  0xBF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0x3E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x1C,
  0x3C, 0x1E, 0x3F, 0x8E, 0x0F, 0xCE, 0xE3, 0x87, 0xFB, 0xB9, 0xE3, 0xC7,
  0xCE, 0x71, 0xE0, 0xF3, 0x9C, 0x78, 0x3C, 0x77, 0x3C, 0x0F, 0x1F, 0xCF,
  0x03, 0xC7, 0xE3, 0x80, 0xF1, 0xF8, 0xE0, 0x38, 0x7E, 0x78, 0x0E, 0x1F,
  0x9E, 0x07, 0x87, 0xE7, 0x81, 0xE1, 0xB9, 0xE0, 0x78, 0xEE, 0x78, 0x1C,
  0x3B, 0x9E, 0x07, 0x0E, 0xE7, 0x83, 0xC3, 0xB9, 0xE0, 0xF1, 0xCE, 0x38,
  0x7C, 0x71, 0xCF, 0x3B, 0x3C, 0x73, 0xFC, 0xFE, 0x1C, 0x7F, 0x3F, 0x07,
  0x8F, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x02,
  0x01, 0xF0, 0x01, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x7E, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xC1, 0xFC, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x70, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x38, 0xFE, 0x00, 0x3F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x80, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC3, 0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x01,
  0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xEF,
  0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFF, 0x7F, 0x03, 0xFC, 0xFE,
  0x0F, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x1F, 0xE0, 0x7F, 0x3F,
  0x80, 0x7E, 0x7E, 0x00, 0xFF, 0xFC, 0x01, 0xC3, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0xC0, 0x3F,
  0x3F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF1, 0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F,
  0x8F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xEF, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07,
  0xF8, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7B, 0xFF, 0xF0, 0xF7,
  0xFD, 0xE1, 0xFF, 0xFB, 0xC3, 0xFF, 0xF7, 0xCF, 0xFF, 0xEF, 0x9E, 0xFF,
  0xCF, 0x3D, 0xFF, 0x9E, 0xFB, 0xFF, 0x3F, 0xF7, 0xFE, 0x7F, 0xCF, 0xFC,
  0x7F, 0x9F, 0xF8, 0xFF, 0x3F, 0xF1, 0xFE, 0x7F, 0xE3, 0xF8, 0xFF, 0xC3,
  0xF1, 0xFF, 0x87, 0xE3, 0xFF, 0x0F, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFB, 0xE0, 0xFF, 0xEF, 0x83, 0xFF, 0xBF,
  0x0F, 0xFF, 0x7C, 0x3F, 0xFD, 0xF0, 0xFF, 0xF7, 0xE3, 0xFF, 0xCF, 0x8F,
  0xFF, 0x3F, 0x3F, 0xFC, 0x7C, 0xFF, 0xF1, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF,
  0x0F, 0xBF, 0xFC, 0x3E, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC,
  0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xC0, 0xFF, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x01, 0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x3F, 0xCF, 0xE0, 0x3F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF0, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFC, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x3E, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF1, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x7F, 0x7F, 0xC0, 0x7F, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x9F, 0x80, 0xFE,
  0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF9, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x7E, 0x1F, 0x07, 0xC7, 0xE1, 0xF0,
  0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x3F, 0x8F, 0xC3,
  0xF3, 0xFC, 0xF8, 0x3F, 0x3F, 0xCF, 0x83, 0xF7, 0xFC, 0xF8, 0x1F, 0x7F,
  0xCF, 0x81, 0xF7, 0xBE, 0xF8, 0x1F, 0x79, 0xEF, 0x81, 0xFF, 0x9E, 0xF8,
  0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xF8,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x1F,
  0xBF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xC7, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x7F, 0x81, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x7F,
  0x0E, 0xF8, 0x7F, 0xFE, 0xFF, 0x3F, 0xFC, 0xFF, 0x1F, 0xF8, 0x7F, 0x07,
  0xE0, 0x3E, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0x83, 0xF9, 0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0x87, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0xFF, 0xC7, 0xFB, 0xFF, 0xFF,
  0xCF, 0xEF, 0xFE, 0x3F, 0x1F, 0xF0, 0xFC, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x87,
  0xF0, 0x3F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xFC, 0x3F, 0x83, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0xF3,
  0xF1, 0xFF, 0xEF, 0xCF, 0xFF, 0xFF, 0x3F, 0x87, 0xFD, 0xFC, 0x0F, 0xF7,
  0xF0, 0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0xFF, 0x3F, 0x87, 0xFC, 0xFF, 0xFB, 0xF1, 0xFF, 0xEF, 0xC3, 0xFF,
  0x3F, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0x87, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F,
  0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF9, 0xFC,
  0x07, 0xF3, 0xFC, 0x1F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x3F, 0xE3, 0xF1, 0xFF, 0xCF, 0xCF, 0xFF, 0xBF, 0x7F, 0x87,
  0xFD, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0xFF, 0x7F, 0x87, 0xFC, 0xFF, 0xFB, 0xF1,
  0xFF, 0xCF, 0xC3, 0xFE, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x1E, 0x01, 0xF9, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0x83, 0xF9, 0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0x3F, 0xFE, 0xFD, 0xFF, 0xFB,
  0xFF, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC7,
  0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F,
  0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E,
  0xFC, 0x01, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF1, 0xE0, 0x78, 0xF3, 0xF9, 0xFC, 0xF7, 0xF9, 0xFE, 0xF7,
  0xFB, 0xFE, 0xFC, 0xFF, 0x3F, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E, 0x1F, 0xF8,
  0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0x8F, 0xCF,
  0xFF, 0x3F, 0x3F, 0xFE, 0xFD, 0xFF, 0xFB, 0xFF, 0x0F, 0xEF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F,
  0x01, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0x0F, 0xEF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xC7, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFE,
  0xFF, 0x87, 0xFB, 0xFF, 0xFF, 0xCF, 0xEF, 0xFE, 0x3F, 0x9F, 0xF0, 0xFE,
  0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0xF3, 0xF1,
  0xFF, 0xEF, 0xCF, 0xFF, 0xBF, 0x3F, 0x87, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0,
  0x1F, 0xDF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0,
  0xFF, 0x3F, 0x87, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xC3, 0xFF, 0x3F,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0xF7, 0xE3, 0xFF,
  0x7E, 0x7F, 0xF7, 0xE7, 0xFF, 0x7E, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF3,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0xFF,
  0x3F, 0xF7, 0xFF, 0xDF, 0x9F, 0xFE, 0xFC, 0xFF, 0xE7, 0xE1, 0xFC, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE0, 0xFE,
  0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x9F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8,
  0x3E, 0x3E, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0xF8, 0xF8, 0xFE, 0x1F, 0x1F,
  0x1F, 0xE3, 0xC3, 0xE3, 0xFC, 0xF8, 0x7C, 0xF7, 0x9F, 0x07, 0x9E, 0xFB,
  0xE0, 0xF3, 0xCF, 0x7C, 0x1F, 0xF9, 0xEF, 0x83, 0xFE, 0x3D, 0xE0, 0x7F,
  0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x80,
  0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01,
  0xFE, 0x00,
};

const GFXglyph LiberationMono_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 30, 28, 11, -30 },
  { 24, 16, 14, 28, 6, -33 },
  { 52, 25, 30, 28, 1, -30 },
  { 146, 24, 37, 28, 2, -33 },
  { 257, 28, 30, 28, 0, -30 },
  { 362, 26, 30, 28, 1, -30 },
  { 460, 6, 14, 28, 11, -33 },
  { 471, 13, 43, 28, 8, -33 },
  { 541, 13, 43, 28, 7, -33 },
  { 611, 18, 17, 28, 5, -33 },
  { 650, 23, 23, 28, 2, -27 },
  { 717, 11, 15, 28, 6, -7 },
  { 738, 13, 5, 28, 7, -15 },
  { 747, 6, 7, 28, 11, -7 },
  { 753, 24, 33, 28, 2, -33 },
  { 852, 22, 30, 28, 3, -30 },
  { 935, 23, 30, 28, 3, -30 },
  { 1022, 22, 30, 28, 3, -30 },
  { 1105, 23, 30, 28, 2, -30 },
  { 1192, 24, 30, 28, 2, -30 },
  { 1282, 23, 30, 28, 2, -30 },
  { 1369, 22, 30, 28, 3, -30 },
  { 1452, 22, 30, 28, 3, -30 },
  { 1535, 23, 30, 28, 2, -30 },
  { 1622, 22, 30, 28, 3, -30 },
  { 1705, 6, 25, 28, 11, -25 },
  { 1724, 11, 33, 28, 7, -25 },
  { 1770, 23, 25, 28, 2, -28 },
  { 1842, 23, 17, 28, 2, -24 },
  { 1891, 23, 25, 28, 2, -28 },
  { 1963, 23, 30, 28, 2, -30 },
  { 2050, 26, 39, 28, 1, -33 },
  { 2177, 28, 30, 28, 0, -30 },
  { 2282, 24, 30, 28, 3, -30 },
  { 2372, 24, 30, 28, 2, -30 },
  { 2462, 23, 30, 28, 3, -30 },
  { 2549, 23, 30, 28, 3, -30 },
  { 2636, 21, 30, 28, 4, -30 },
  { 2715, 23, 30, 28, 2, -30 },
  { 2802, 22, 30, 28, 3, -30 },
  { 2885, 20, 30, 28, 4, -30 },
  { 2960, 21, 30, 28, 2, -30 },
  { 3039, 25, 30, 28, 3, -30 },
  { 3133, 20, 30, 28, 5, -30 },
  { 3208, 23, 30, 28, 2, -30 },
  { 3295, 22, 30, 28, 3, -30 },
  { 3378, 24, 30, 28, 2, -30 },
  { 3468, 23, 30, 28, 3, -30 },
  { 3555, 24, 39, 28, 2, -30 },
  { 3672, 25, 30, 28, 3, -30 },
  { 3766, 25, 30, 28, 1, -30 },
  { 3860, 25, 30, 28, 1, -30 },
  { 3954, 22, 30, 28, 3, -30 },
  { 4037, 28, 30, 28, 0, -30 },
  { 4142, 28, 30, 28, 0, -30 },
  { 4247, 28, 30, 28, 0, -30 },
  { 4352, 28, 30, 28, 0, -30 },
  { 4457, 24, 30, 28, 2, -30 },
  { 4547, 14, 43, 28, 8, -33 },
  { 4623, 24, 33, 28, 2, -33 },
  { 4722, 13, 43, 28, 6, -33 },
  { 4792, 25, 20, 28, 1, -30 },
  { 4855, 28, 2, 28, 0, 3 },
  { 4862, 11, 6, 28, 8, -33 },
  { 4871, 24, 25, 28, 2, -25 },
  { 4946, 22, 33, 28, 3, -33 },
  { 5037, 23, 25, 28, 2, -25 },
  { 5109, 22, 33, 28, 2, -33 },
  { 5200, 23, 25, 28, 2, -25 },
  { 5272, 22, 33, 28, 3, -33 },
  { 5363, 22, 35, 28, 3, -25 },
  { 5460, 22, 33, 28, 3, -33 },
  { 5551, 23, 33, 28, 3, -33 },
  { 5646, 16, 43, 28, 3, -33 },
  { 5732, 22, 33, 28, 4, -33 },
  { 5823, 23, 33, 28, 3, -33 },
  { 5918, 24, 25, 28, 2, -25 },
  { 5993, 22, 25, 28, 3, -25 },
  { 6062, 24, 25, 28, 2, -25 },
  { 6137, 22, 35, 28, 3, -25 },
  { 6234, 22, 35, 28, 2, -25 },
  { 6331, 20, 25, 28, 4, -25 },
  { 6394, 22, 25, 28, 3, -25 },
  { 6463, 19, 31, 28, 4, -31 },
  { 6537, 21, 24, 28, 3, -24 },
  { 6600, 26, 25, 28, 1, -25 },
  { 6682, 27, 25, 28, 0, -25 },
  { 6767, 25, 25, 28, 1, -25 },
  { 6846, 26, 35, 28, 1, -25 },
  { 6960, 21, 25, 28, 3, -25 },
  { 7026, 19, 43, 28, 4, -33 },
  { 7129, 6, 43, 28, 11, -33 },
  { 7162, 19, 43, 28, 4, -33 },
  { 7265, 23, 7, 28, 2, -19 },
};

const GFXfont LiberationMono_Bold46pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold46pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold46pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _LIBERATIONMONO_BOLD46PT7B_H_
