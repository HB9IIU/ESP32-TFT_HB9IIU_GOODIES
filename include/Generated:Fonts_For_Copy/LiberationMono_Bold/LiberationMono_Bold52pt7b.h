#ifndef _LIBERATIONMONO_BOLD52PT7B_H_
#define _LIBERATIONMONO_BOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x83, 0xFB,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE7,
  0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x0F, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xCE, 0x7F, 0x8F, 0xE1, 0xC7, 0xF9, 0xFC,
  0x38, 0x7F, 0x3F, 0x87, 0x0F, 0xE7, 0xF0, 0xE0, 0xE0, 0xFE, 0x1C, 0x00,
  0x1F, 0xC3, 0x80, 0x03, 0xFC, 0x70, 0x00, 0x3F, 0xEE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0E,
  0x3F, 0xE0, 0x01, 0xC1, 0xFC, 0x00, 0x38, 0x3F, 0x8E, 0x07, 0x03, 0xFF,
  0xE0, 0xE0, 0x7F, 0xFC, 0x1C, 0x1F, 0xFF, 0x83, 0x83, 0xFB, 0xF8, 0x70,
  0xFF, 0x7F, 0xCE, 0x3F, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF1, 0xFF, 0xE0, 0x03, 0xE3, 0xE3,
  0xE0, 0x0F, 0x8F, 0x83, 0xC0, 0x1E, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x0F,
  0x01, 0xF0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0x7C,
  0x3E, 0x03, 0xE0, 0xF0, 0x78, 0x07, 0xC1, 0xE1, 0xE0, 0x07, 0x87, 0xC7,
  0xC0, 0x0F, 0x8F, 0x9F, 0x00, 0x0F, 0xFE, 0x3C, 0x00, 0x1F, 0xF8, 0xF8,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF1, 0xFF, 0x80, 0x03, 0xC7, 0xFF,
  0x80, 0x0F, 0x8F, 0x9F, 0x00, 0x1E, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x3E,
  0x01, 0xF0, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x87,
  0x80, 0x3E, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x3C, 0x00, 0x7F, 0xF8, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xE0,
  0x00, 0xF8, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x0F, 0x01, 0xFF, 0xC0, 0x3E, 0x0F, 0xFF, 0x80, 0xF8, 0x7F, 0xFF,
  0x07, 0xE1, 0xFC, 0xFC, 0x1F, 0x0F, 0xE1, 0xF8, 0x7C, 0x3F, 0x07, 0xF3,
  0xF0, 0xFC, 0x0F, 0xEF, 0x83, 0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0xF8,
  0x3F, 0x00, 0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xF0, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x80, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x41, 0xF0, 0x47, 0x9F, 0x1C, 0xFF, 0xF7, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x01, 0xFB, 0xF0, 0x3F, 0x9F, 0x83, 0xF1, 0xFC, 0x3E, 0x0F, 0x80, 0xE0,
  0xF0, 0x04, 0x04, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8,
  0xFF, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x7C, 0x7F, 0xFE, 0x3E, 0x3F, 0xFF, 0x1F, 0x1F, 0xFF, 0x8F,
  0x8F, 0xFF, 0xC7, 0xC7, 0xFF, 0xE3, 0xE3, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFD, 0xFC, 0x03, 0xFF, 0x7F, 0x00, 0xFF, 0x9F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3,
  0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC7, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xE7, 0xF8,
  0x03, 0xFC, 0xFF, 0xC1, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xCF,
  0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0xE7,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0x87, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x80, 0x7F, 0x3F,
  0x80, 0x3C, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7E, 0x03, 0xF9, 0xFF, 0xE1, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0xDF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xFC,
  0x07, 0xF8, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE3, 0xFE, 0x0F, 0xF9, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC3, 0xFC, 0x1F, 0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0x07, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFB, 0xF8, 0x3F, 0xF9,
  0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xE3, 0xFE,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFE,
  0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xF0, 0x3E, 0x00,
  0x3E, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x01, 0xE0,
  0x1C, 0x78, 0x3F, 0x9E, 0xE3, 0xC3, 0xFE, 0xF7, 0x9C, 0x3E, 0x37, 0x3D,
  0xE1, 0xE0, 0xF8, 0xEF, 0x1E, 0x07, 0xC7, 0x70, 0xF0, 0x3E, 0x3B, 0x8F,
  0x01, 0xF1, 0xDC, 0x78, 0x0F, 0x0F, 0xE3, 0xC0, 0x78, 0x7F, 0x1E, 0x03,
  0xC3, 0xF9, 0xE0, 0x1E, 0x1F, 0xCF, 0x00, 0xF0, 0xFE, 0x78, 0x07, 0x07,
  0xF3, 0xC0, 0x78, 0x3F, 0x9E, 0x03, 0xC3, 0xFC, 0xF0, 0x1E, 0x1F, 0xE7,
  0x80, 0xF0, 0xEF, 0x3C, 0x0F, 0x87, 0x79, 0xE0, 0x7C, 0x3B, 0xCF, 0x03,
  0xC3, 0x8E, 0x3C, 0x36, 0x1C, 0x71, 0xE3, 0xB9, 0xE3, 0xC7, 0xF9, 0xFE,
  0x1E, 0x3F, 0x8F, 0xE0, 0x70, 0x78, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x0F, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xC0, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0x07, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC3, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F,
  0xF3, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xE1, 0xFE, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0x70, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x01,
  0xFD, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xFE, 0x01, 0xFE, 0x3F,
  0xE0, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xE7, 0xFC, 0x7F, 0xCF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFE,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x87,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xE1, 0xFF, 0xFE,
  0xF8, 0x7B, 0xFF, 0xBE, 0x3E, 0xFF, 0xEF, 0x8F, 0xBF, 0xFB, 0xF3, 0xEF,
  0xFE, 0x7C, 0xF3, 0xFF, 0x9F, 0x7C, 0xFF, 0xE7, 0xDF, 0x3F, 0xF8, 0xF7,
  0xCF, 0xFE, 0x3F, 0xE3, 0xFF, 0x8F, 0xF8, 0xFF, 0xE3, 0xFE, 0x3F, 0xF8,
  0x7F, 0x8F, 0xFE, 0x1F, 0xC3, 0xFF, 0x87, 0xF0, 0xFF, 0xE1, 0xFC, 0x3F,
  0xF8, 0x3F, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFE, 0xFC, 0x1F, 0xFF, 0x7E, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xEF,
  0xC3, 0xFF, 0xF7, 0xE1, 0xFF, 0xF9, 0xF8, 0xFF, 0xFC, 0xFC, 0x7F, 0xFE,
  0x7E, 0x3F, 0xFF, 0x1F, 0x9F, 0xFF, 0x8F, 0xCF, 0xFF, 0xC7, 0xE7, 0xFF,
  0xE1, 0xFB, 0xFF, 0xF0, 0xFC, 0xFF, 0xF8, 0x3F, 0x7F, 0xFC, 0x1F, 0xBF,
  0xFE, 0x0F, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x7F,
  0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xC1,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xF0, 0x1F, 0xFB, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFB, 0xFC,
  0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0,
  0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC7,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F,
  0xF0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xE7, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFC, 0x1F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E,
  0x1F, 0xCF, 0xF8, 0xFC, 0x1F, 0x9F, 0xF1, 0xF8, 0x3F, 0x3F, 0xE7, 0xE0,
  0x7E, 0x7F, 0xEF, 0xC0, 0xFD, 0xF7, 0xDF, 0x81, 0xFB, 0xEF, 0xBF, 0x03,
  0xF7, 0xDF, 0x7E, 0x03, 0xEF, 0x9F, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0x81, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87,
  0xF8, 0x7F, 0xF8, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xCF, 0xFC, 0xFF, 0xF8,
  0xFF, 0x8F, 0xFC, 0x1F, 0xF0, 0x7E, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x1F, 0xC7, 0xFE, 0x0F, 0xEF, 0xFF,
  0x87, 0xF7, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFC, 0xFF, 0x81,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE,
  0xFF, 0x81, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xDF, 0xFF,
  0x8F, 0xE7, 0xFF, 0x87, 0xF1, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE1, 0xFF, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0x7F, 0xC3,
  0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F, 0xFC, 0xFE, 0x0F, 0xFF, 0xBF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0x87, 0xFE, 0x3F, 0xC0, 0xFF,
  0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFE, 0xFF, 0x0F, 0xFF, 0x9F, 0xC1, 0xFF, 0x87, 0xF0, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x1F, 0xE0, 0x0F, 0xE7,
  0xF8, 0x07, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF,
  0xF7, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xFD, 0xFF, 0x03, 0xFE, 0xFF,
  0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xFC, 0xFF, 0x87,
  0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x87, 0xFF, 0x9F, 0xC1, 0xFF,
  0x8F, 0xE0, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F,
  0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0xFE, 0x3F, 0xF8, 0xFE, 0x7F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC1, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x60, 0x3F, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03,
  0xFC, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFD,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x1F, 0x3F, 0x87,
  0xF3, 0xEF, 0xF9, 0xFF, 0x7D, 0xFF, 0x7F, 0xFF, 0xF3, 0xFC, 0xFF, 0xFC,
  0x7F, 0x8F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFC, 0x1F, 0x87,
  0xFF, 0x83, 0xF0, 0xFF, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1,
  0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F,
  0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F,
  0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x7E,
  0x0F, 0xFE, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xFE, 0x1F,
  0x8F, 0xFF, 0x8F, 0xCF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0x07, 0xF9,
  0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFE,
  0x7F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0xBF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00,
  0x7F, 0xBF, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x1F, 0xF8, 0x3F, 0x9F, 0xFE, 0x1F, 0xDF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xF3, 0xFE, 0x07, 0xF9, 0xFE, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x07, 0xF9, 0xFF,
  0x87, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0x7F, 0xFE, 0x3F, 0xBF, 0xFE, 0x1F,
  0xC7, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0xFF, 0xF9, 0xFC, 0x7F,
  0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xF8, 0x7F, 0xE3, 0xFC, 0x0F, 0xF9,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0,
  0x03, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFB, 0xF8, 0x1F, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFF, 0xDF, 0xCF, 0xFF, 0x7F, 0x7F, 0xFD, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0x7C, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x10, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07,
  0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0,
  0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7,
  0xF8, 0x1F, 0xF3, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0xFE,
  0x3F, 0xFE, 0x3F, 0x0F, 0xFE, 0x1F, 0x81, 0xFE, 0x0F, 0xC0, 0x08, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFC,
  0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x1F, 0x03, 0xE0, 0x7E, 0x3E, 0x07,
  0xE0, 0xF8, 0x7C, 0x1F, 0xC1, 0xF0, 0xFC, 0x3F, 0x83, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF1, 0xFF, 0x1F, 0x83, 0xE3, 0xDE, 0x3F, 0x07, 0xC7, 0xBC,
  0x7C, 0x0F, 0x9F, 0x7C, 0xF8, 0x1F, 0x3C, 0x79, 0xF0, 0x3E, 0x78, 0xF3,
  0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01,
  0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0,
  0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8,
};

const GFXglyph LiberationMono_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 34, 31, 12, -34 },
  { 31, 19, 16, 31, 6, -38 },
  { 69, 29, 34, 31, 1, -34 },
  { 193, 27, 42, 31, 2, -38 },
  { 335, 31, 36, 31, 0, -35 },
  { 475, 30, 36, 31, 1, -35 },
  { 610, 7, 16, 31, 12, -38 },
  { 624, 14, 49, 31, 9, -38 },
  { 710, 14, 49, 31, 8, -38 },
  { 796, 20, 19, 31, 6, -38 },
  { 844, 26, 26, 31, 3, -30 },
  { 929, 12, 17, 31, 7, -8 },
  { 955, 15, 6, 31, 8, -17 },
  { 967, 7, 8, 31, 12, -8 },
  { 974, 27, 39, 31, 2, -38 },
  { 1106, 25, 36, 31, 3, -35 },
  { 1219, 26, 34, 31, 3, -34 },
  { 1330, 25, 35, 31, 3, -35 },
  { 1440, 27, 36, 31, 2, -35 },
  { 1562, 28, 34, 31, 2, -34 },
  { 1681, 26, 35, 31, 3, -34 },
  { 1795, 25, 36, 31, 3, -35 },
  { 1908, 25, 34, 31, 3, -34 },
  { 2015, 25, 36, 31, 3, -35 },
  { 2128, 25, 36, 31, 3, -35 },
  { 2241, 7, 27, 31, 12, -27 },
  { 2265, 13, 36, 31, 8, -27 },
  { 2324, 26, 28, 31, 3, -31 },
  { 2415, 26, 20, 31, 3, -27 },
  { 2480, 26, 28, 31, 3, -31 },
  { 2571, 26, 35, 31, 2, -35 },
  { 2685, 29, 46, 31, 1, -38 },
  { 2852, 31, 34, 31, 0, -34 },
  { 2984, 27, 34, 31, 3, -34 },
  { 3099, 28, 36, 31, 2, -35 },
  { 3225, 26, 34, 31, 3, -34 },
  { 3336, 26, 34, 31, 3, -34 },
  { 3447, 24, 34, 31, 4, -34 },
  { 3549, 27, 36, 31, 2, -35 },
  { 3671, 25, 34, 31, 3, -34 },
  { 3778, 23, 34, 31, 4, -34 },
  { 3876, 23, 35, 31, 3, -34 },
  { 3977, 28, 34, 31, 3, -34 },
  { 4096, 23, 34, 31, 5, -34 },
  { 4194, 26, 34, 31, 3, -34 },
  { 4305, 25, 34, 31, 3, -34 },
  { 4412, 27, 36, 31, 2, -35 },
  { 4534, 26, 34, 31, 3, -34 },
  { 4645, 28, 45, 31, 2, -35 },
  { 4803, 28, 34, 31, 3, -34 },
  { 4922, 29, 36, 31, 1, -35 },
  { 5053, 28, 34, 31, 2, -34 },
  { 5172, 25, 35, 31, 3, -34 },
  { 5282, 31, 34, 31, 0, -34 },
  { 5414, 31, 34, 31, 0, -34 },
  { 5546, 31, 34, 31, 0, -34 },
  { 5678, 31, 34, 31, 0, -34 },
  { 5810, 27, 34, 31, 2, -34 },
  { 5925, 16, 49, 31, 9, -38 },
  { 6023, 27, 39, 31, 2, -38 },
  { 6155, 16, 49, 31, 6, -38 },
  { 6253, 28, 23, 31, 1, -36 },
  { 6334, 31, 2, 31, 0, 3 },
  { 6342, 13, 7, 31, 9, -37 },
  { 6354, 27, 29, 31, 3, -28 },
  { 6452, 25, 39, 31, 4, -38 },
  { 6574, 25, 29, 31, 3, -28 },
  { 6665, 26, 39, 31, 2, -38 },
  { 6792, 26, 29, 31, 3, -28 },
  { 6887, 25, 39, 31, 3, -39 },
  { 7009, 25, 39, 31, 3, -28 },
  { 7131, 24, 38, 31, 4, -38 },
  { 7245, 26, 38, 31, 3, -38 },
  { 7369, 19, 49, 31, 3, -38 },
  { 7486, 26, 38, 31, 4, -38 },
  { 7610, 26, 38, 31, 3, -38 },
  { 7734, 27, 28, 31, 2, -28 },
  { 7829, 25, 28, 31, 3, -28 },
  { 7917, 27, 29, 31, 2, -28 },
  { 8015, 25, 39, 31, 4, -28 },
  { 8137, 26, 39, 31, 2, -28 },
  { 8264, 22, 28, 31, 5, -28 },
  { 8341, 25, 29, 31, 3, -28 },
  { 8432, 22, 35, 31, 4, -34 },
  { 8529, 25, 28, 31, 3, -27 },
  { 8617, 29, 27, 31, 1, -27 },
  { 8715, 31, 27, 31, 0, -27 },
  { 8820, 29, 27, 31, 1, -27 },
  { 8918, 29, 38, 31, 1, -27 },
  { 9056, 24, 27, 31, 3, -27 },
  { 9137, 22, 49, 31, 5, -38 },
  { 9272, 7, 50, 31, 12, -38 },
  { 9316, 21, 49, 31, 5, -38 },
  { 9445, 27, 8, 31, 2, -21 },
};

const GFXfont LiberationMono_Bold52pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold52pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold52pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _LIBERATIONMONO_BOLD52PT7B_H_
