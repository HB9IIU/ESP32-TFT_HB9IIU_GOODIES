#ifndef _LIBERATIONMONO_BOLD51PT7B_H_
#define _LIBERATIONMONO_BOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8,
  0x3F, 0x7E, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0xDF, 0x03, 0xF7, 0xC0, 0xFC, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xCE, 0xFF, 0x8F, 0xE1,
  0xC7, 0xF1, 0xFC, 0x38, 0xFF, 0x3F, 0x07, 0x0F, 0xE7, 0xE0, 0xE1, 0xE0,
  0xFE, 0x1C, 0x00, 0x1F, 0xC3, 0x80, 0x03, 0xFC, 0x70, 0x00, 0x3F, 0xEE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0E, 0x3F, 0xC0, 0x01, 0xC3, 0xF8, 0x00, 0x38, 0x3F, 0x8E,
  0x07, 0x07, 0xFF, 0xC0, 0xE0, 0xFF, 0xFC, 0x1C, 0x1F, 0xFF, 0x83, 0x83,
  0xF3, 0xF8, 0x70, 0xFE, 0x7F, 0xCE, 0x7F, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF1, 0xFF, 0xE0,
  0x03, 0xC3, 0xE3, 0xC0, 0x0F, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x07, 0x80,
  0x78, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0xF8, 0x07, 0xC1, 0xE1, 0xE0,
  0x07, 0x87, 0xC7, 0x80, 0x0F, 0x8F, 0x1F, 0x00, 0x0F, 0xFE, 0x3C, 0x00,
  0x1F, 0xF8, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x7F, 0x00, 0x01, 0xF1, 0xFF, 0x00,
  0x03, 0xC7, 0xFF, 0x00, 0x0F, 0x1F, 0x1F, 0x00, 0x3E, 0x3C, 0x1E, 0x00,
  0x78, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0x0F,
  0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xE0,
  0x1E, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x1F, 0x00, 0x7C, 0x7C, 0x3C, 0x00,
  0x7F, 0xF0, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x3E, 0x7F, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x1E, 0x07, 0xFF, 0x01, 0xF8, 0x7F, 0xFC, 0x0F, 0x87, 0xFF,
  0xE0, 0x7C, 0x3F, 0x9F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0x83, 0xF9,
  0xF0, 0xFC, 0x0F, 0xDF, 0x87, 0xE0, 0x7F, 0xF8, 0x3F, 0x01, 0xFF, 0xC1,
  0xF8, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0xE0, 0x7E, 0x00, 0x7F, 0x83, 0xF8,
  0x07, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x7F, 0xC3, 0xFF, 0xE0, 0xFE, 0x07, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x20, 0xF8, 0x63,
  0x8F, 0x9E, 0x7E, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFD, 0xF0, 0x1F, 0x9F,
  0x83, 0xF8, 0xFC, 0x1F, 0x0F, 0xC0, 0xF0, 0x70, 0x02, 0x02, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x7C, 0x7F, 0xFE, 0x3E,
  0x3F, 0xFF, 0x1F, 0x1F, 0xFF, 0x8F, 0x8F, 0xFF, 0xC7, 0xC7, 0xFF, 0xE3,
  0xE3, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3C, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0x01,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xBF, 0x80, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F,
  0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xCF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F,
  0xDF, 0xF0, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x07, 0xF7, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F,
  0xE0, 0xFF, 0x9F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8, 0x1F,
  0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x81, 0xFC, 0x7F, 0x80, 0x7F,
  0x3F, 0x80, 0x38, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0xFE, 0x03, 0xF9, 0xFF, 0xC1, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0,
  0x07, 0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xFE,
  0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFC, 0x1F,
  0xE3, 0xF8, 0x07, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF9, 0xFE, 0x03,
  0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFE,
  0x01, 0xFE, 0x7F, 0x00, 0xFF, 0xBF, 0xE1, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xF7, 0xE1, 0xFF, 0xFB, 0xF0, 0x7F, 0xF1, 0xF8, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0x80, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x07, 0x0F, 0x01, 0xE0, 0x3C, 0x78, 0x3F, 0x9D, 0xE3, 0x83,
  0xFE, 0xE7, 0x3C, 0x3E, 0x7F, 0x39, 0xE1, 0xE1, 0xF9, 0xCE, 0x1E, 0x07,
  0x8E, 0x70, 0xE0, 0x3C, 0x7B, 0x8F, 0x01, 0xE3, 0xFC, 0x78, 0x0F, 0x1F,
  0xE3, 0x80, 0x78, 0xFF, 0x3C, 0x03, 0xC7, 0xF9, 0xE0, 0x3C, 0x3F, 0xCF,
  0x01, 0xE1, 0xDE, 0x78, 0x0F, 0x0E, 0xE3, 0xC0, 0x78, 0x77, 0x1E, 0x03,
  0xC3, 0xBC, 0xF0, 0x3C, 0x1D, 0xE7, 0x81, 0xE1, 0xEF, 0x3C, 0x0F, 0x0E,
  0x79, 0xE0, 0xF8, 0x73, 0xC7, 0x07, 0xC7, 0x8E, 0x3C, 0x7E, 0x38, 0x71,
  0xFF, 0x3F, 0x83, 0xC7, 0xF1, 0xFC, 0x1E, 0x1F, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x04,
  0x01, 0xE0, 0x00, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF8, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x07,
  0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x30, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0E, 0x0F, 0xF0, 0x01, 0xFD, 0xFE, 0x00,
  0x7F, 0xBF, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF3,
  0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0x81, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF8, 0x01, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC3, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x87, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xDF, 0xE0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF,
  0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x83, 0xDF, 0xFF, 0xE0, 0xF7, 0xFF, 0x7C, 0x7D, 0xFF,
  0xDF, 0x1F, 0x7F, 0xF7, 0xC7, 0xDF, 0xFD, 0xF3, 0xE7, 0xFF, 0x3E, 0xF9,
  0xFF, 0xCF, 0xBE, 0x7F, 0xF3, 0xEF, 0x9F, 0xFC, 0xFB, 0xC7, 0xFF, 0x1E,
  0xF1, 0xFF, 0xC7, 0xFC, 0x7F, 0xF1, 0xFE, 0x1F, 0xFC, 0x7F, 0x87, 0xFF,
  0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0xF0, 0xFC, 0x1F, 0xFC, 0x3F, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFD, 0xF8, 0x3F, 0xFD, 0xF8, 0x3F, 0xFC, 0xF8, 0x3F, 0xFE, 0xFC, 0x3F,
  0xFE, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F, 0xFE, 0x7E, 0x3F, 0xFE, 0x7E, 0x3F,
  0xFE, 0x3F, 0x3F, 0xFE, 0x3F, 0x3F, 0xFE, 0x1F, 0x3F, 0xFE, 0x1F, 0xBF,
  0xFE, 0x1F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xE1,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF9, 0xFC,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x01, 0xFE,
  0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF1,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x80,
  0x0F, 0xF7, 0xFC, 0x00, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0xC3, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x1F, 0x07,
  0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xF1, 0xF8, 0x1F, 0x9F, 0xF3, 0xF0,
  0x3F, 0x3F, 0xE7, 0xE0, 0x7E, 0xFF, 0xCF, 0xC0, 0xFD, 0xF7, 0xDF, 0x81,
  0xFB, 0xEF, 0xBE, 0x03, 0xF7, 0xDF, 0x7C, 0x07, 0xFF, 0x3E, 0xF8, 0x07,
  0xFE, 0x3D, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFD, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFF,
  0x8F, 0xE0, 0x3F, 0xE3, 0xFC, 0x3F, 0xF8, 0xFF, 0xFF, 0x7F, 0xDF, 0xFF,
  0x9F, 0xF7, 0xFF, 0xC7, 0xFC, 0x7F, 0xE0, 0xFF, 0x0F, 0xE0, 0x0F, 0x80,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x1F, 0xCF, 0xFE, 0x0F, 0xEF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0x87, 0xFC, 0xFF,
  0x81, 0xFE, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xF9, 0xFE, 0x01,
  0xFC, 0xFF, 0x81, 0xFE, 0x7F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xCF, 0xFF, 0x0F, 0xE3, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x0F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x03, 0xFC, 0x7F,
  0x83, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFC,
  0x1F, 0xC1, 0xFF, 0x8F, 0xE1, 0xFF, 0xE7, 0xF1, 0xFF, 0xFB, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0x87, 0xFE, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0x7F, 0xBF,
  0xC0, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x07,
  0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xE1,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xEF, 0xE1, 0xFF, 0xE7, 0xF0, 0x7F,
  0xE3, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x1F, 0x9F, 0xC0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0x0F, 0xE0, 0x07, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF,
  0xE3, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xF9, 0xFE, 0x1F, 0xFD, 0xFE, 0x03,
  0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFD,
  0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0x7F, 0x1F, 0xFF, 0xBF, 0x8F, 0xFF, 0x9F,
  0xC1, 0xFF, 0x8F, 0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x1F, 0xC0,
  0x7F, 0x0F, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0xFE,
  0x3F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFC, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFD,
  0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xFB, 0x01, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xE0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFF, 0x3F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF8, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF8, 0x1F, 0x1F, 0x3F, 0x8F, 0xF3, 0xEF, 0xF9, 0xFF, 0x7D, 0xFF,
  0x7F, 0xEF, 0xE7, 0xEC, 0xFD, 0xFC, 0x7F, 0x0F, 0xBF, 0x0F, 0xE1, 0xFF,
  0xE1, 0xFC, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC,
  0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F, 0xFF,
  0x0F, 0xC1, 0xFF, 0xE1, 0xF8, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0x87, 0xE0,
  0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8,
  0x7E, 0x0F, 0xFF, 0x0F, 0xC1, 0xFF, 0xE1, 0xF8, 0x3F, 0xFC, 0x3F, 0x07,
  0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0xFE, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0x0F, 0xFC, 0x3F, 0x8F, 0xFF, 0x1F, 0xCF, 0xFF, 0xC7,
  0xEF, 0xFF, 0xE3, 0xF7, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xFC,
  0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xF7,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0x9F,
  0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x0F, 0xF8, 0x1F, 0x8F, 0xFF, 0x0F,
  0xEF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0x0F, 0xF1, 0xFF, 0x03, 0xFC,
  0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFB, 0xFC, 0x03, 0xF9, 0xFF,
  0x03, 0xFC, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xDF, 0xFE, 0x0F, 0xE7, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xC3, 0xFF,
  0xCF, 0xE3, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xFC, 0xFF,
  0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0x80, 0x3F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03,
  0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xDF, 0xC3, 0xFF, 0xCF, 0xE0, 0xFF, 0xC7, 0xF0, 0x1F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFD, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x78,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFC, 0xFE,
  0x01, 0xFE, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x10, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x83,
  0xFF, 0x7F, 0xFF, 0x7F, 0x3F, 0xFF, 0x7F, 0x3F, 0xFE, 0x7F, 0x1F, 0xFC,
  0x7F, 0x0F, 0xF8, 0x7F, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0x8F,
  0x81, 0xF0, 0x3E, 0x3E, 0x0F, 0xC1, 0xF8, 0xF8, 0x3F, 0x07, 0xE3, 0xE0,
  0xFE, 0x1F, 0x0F, 0xC7, 0xF8, 0x7C, 0x3F, 0x1F, 0xE1, 0xF0, 0x7C, 0x7F,
  0xC7, 0xC1, 0xF3, 0xEF, 0x1F, 0x07, 0xCF, 0xBC, 0xFC, 0x1F, 0x3C, 0xFB,
  0xE0, 0x7D, 0xF1, 0xEF, 0x81, 0xF7, 0xC7, 0xBE, 0x03, 0xDE, 0x1F, 0xF8,
  0x0F, 0x78, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x81,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xF8,
};

const GFXglyph LiberationMono_Bold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 34, 31, 12, -34 },
  { 31, 18, 15, 31, 6, -37 },
  { 65, 28, 34, 31, 1, -34 },
  { 184, 27, 42, 31, 2, -38 },
  { 326, 31, 36, 31, 0, -35 },
  { 466, 29, 36, 31, 1, -35 },
  { 597, 7, 15, 31, 12, -37 },
  { 611, 14, 48, 31, 9, -37 },
  { 695, 14, 48, 31, 8, -37 },
  { 779, 20, 19, 31, 5, -37 },
  { 827, 25, 26, 31, 3, -30 },
  { 909, 12, 16, 31, 6, -8 },
  { 933, 15, 6, 31, 8, -16 },
  { 945, 7, 8, 31, 12, -8 },
  { 952, 26, 38, 31, 2, -37 },
  { 1076, 25, 36, 31, 3, -35 },
  { 1189, 25, 34, 31, 3, -34 },
  { 1296, 25, 35, 31, 3, -35 },
  { 1406, 26, 36, 31, 2, -35 },
  { 1523, 27, 34, 31, 2, -34 },
  { 1638, 25, 35, 31, 3, -34 },
  { 1748, 25, 36, 31, 3, -35 },
  { 1861, 24, 34, 31, 3, -34 },
  { 1963, 25, 36, 31, 3, -35 },
  { 2076, 25, 36, 31, 3, -35 },
  { 2189, 7, 27, 31, 12, -27 },
  { 2213, 12, 35, 31, 8, -27 },
  { 2266, 25, 28, 31, 3, -31 },
  { 2354, 25, 20, 31, 3, -27 },
  { 2417, 25, 28, 31, 3, -31 },
  { 2505, 26, 35, 31, 2, -35 },
  { 2619, 29, 45, 31, 1, -37 },
  { 2783, 31, 34, 31, 0, -34 },
  { 2915, 27, 34, 31, 3, -34 },
  { 3030, 27, 36, 31, 2, -35 },
  { 3152, 26, 34, 31, 3, -34 },
  { 3263, 26, 34, 31, 3, -34 },
  { 3374, 24, 34, 31, 4, -34 },
  { 3476, 26, 36, 31, 2, -35 },
  { 3593, 24, 34, 31, 3, -34 },
  { 3695, 23, 34, 31, 4, -34 },
  { 3793, 22, 35, 31, 3, -34 },
  { 3890, 28, 34, 31, 3, -34 },
  { 4009, 23, 34, 31, 5, -34 },
  { 4107, 26, 34, 31, 2, -34 },
  { 4218, 24, 34, 31, 3, -34 },
  { 4320, 27, 36, 31, 2, -35 },
  { 4442, 25, 34, 31, 3, -34 },
  { 4549, 27, 45, 31, 2, -35 },
  { 4701, 28, 34, 31, 3, -34 },
  { 4820, 28, 36, 31, 1, -35 },
  { 4946, 27, 34, 31, 2, -34 },
  { 5061, 24, 35, 31, 3, -34 },
  { 5166, 31, 34, 31, 0, -34 },
  { 5298, 31, 34, 31, 0, -34 },
  { 5430, 31, 34, 31, 0, -34 },
  { 5562, 31, 34, 31, 0, -34 },
  { 5694, 26, 34, 31, 2, -34 },
  { 5805, 15, 48, 31, 9, -37 },
  { 5895, 26, 38, 31, 2, -37 },
  { 6019, 15, 48, 31, 6, -37 },
  { 6109, 28, 22, 31, 1, -35 },
  { 6186, 31, 2, 31, 0, 3 },
  { 6194, 12, 7, 31, 9, -36 },
  { 6205, 26, 29, 31, 3, -28 },
  { 6300, 25, 38, 31, 3, -37 },
  { 6419, 25, 29, 31, 3, -28 },
  { 6510, 25, 38, 31, 2, -37 },
  { 6629, 26, 29, 31, 2, -28 },
  { 6724, 25, 38, 31, 3, -38 },
  { 6843, 25, 39, 31, 3, -28 },
  { 6965, 24, 37, 31, 4, -37 },
  { 7076, 26, 37, 31, 3, -37 },
  { 7197, 19, 48, 31, 3, -37 },
  { 7311, 25, 37, 31, 4, -37 },
  { 7427, 26, 37, 31, 3, -37 },
  { 7548, 27, 28, 31, 2, -28 },
  { 7643, 25, 28, 31, 3, -28 },
  { 7731, 26, 29, 31, 2, -28 },
  { 7826, 25, 39, 31, 3, -28 },
  { 7948, 25, 39, 31, 2, -28 },
  { 8070, 22, 28, 31, 5, -28 },
  { 8147, 25, 29, 31, 3, -28 },
  { 8238, 22, 35, 31, 4, -34 },
  { 8335, 24, 28, 31, 3, -27 },
  { 8419, 29, 27, 31, 1, -27 },
  { 8517, 30, 27, 31, 0, -27 },
  { 8619, 28, 27, 31, 1, -27 },
  { 8714, 29, 38, 31, 1, -27 },
  { 8852, 24, 27, 31, 3, -27 },
  { 8933, 21, 48, 31, 5, -37 },
  { 9059, 7, 48, 31, 12, -37 },
  { 9101, 21, 48, 31, 5, -37 },
  { 9227, 26, 8, 31, 2, -21 },
};

const GFXfont LiberationMono_Bold51pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold51pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold51pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _LIBERATIONMONO_BOLD51PT7B_H_
