#ifndef _LIBERATIONMONO_BOLD32PT7B_H_
#define _LIBERATIONMONO_BOLD32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB9, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF0, 0xFE, 0x1C, 0x03, 0x06, 0x01, 0x83, 0x01, 0xC1, 0x80,
  0xE1, 0xC0, 0x60, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0x1C, 0x38, 0x0C, 0x1C,
  0x06, 0x0C, 0x07, 0x06, 0x03, 0x87, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x60,
  0xC0, 0x70, 0x60, 0x38, 0x70, 0x18, 0x38, 0x0C, 0x18, 0x06, 0x0C, 0x03,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x40, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE3, 0xE4, 0xF9, 0xE2, 0x3C, 0xF1, 0x1E, 0x78, 0x80, 0x3E, 0x40, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x02, 0xFE, 0x01, 0x1F,
  0x70, 0x87, 0xF8, 0x43, 0xDE, 0x21, 0xEF, 0x91, 0xE3, 0xFF, 0xF0, 0xFF,
  0xF0, 0x1F, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x3E, 0x01,
  0xCF, 0xE0, 0x73, 0x8C, 0x0E, 0x71, 0xC3, 0x8E, 0x38, 0xE1, 0xC7, 0x18,
  0x38, 0xE7, 0x07, 0x1D, 0xC0, 0xE3, 0x30, 0x0F, 0xEE, 0x00, 0xFB, 0xBE,
  0x00, 0x6F, 0xE0, 0x1D, 0xCE, 0x07, 0x71, 0xC1, 0xCE, 0x38, 0x39, 0xC7,
  0x0E, 0x38, 0xE3, 0x87, 0x1C, 0x60, 0x73, 0x9C, 0x0F, 0xE7, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0x8F, 0x00, 0xE0, 0xE0,
  0x1C, 0x3C, 0x03, 0x87, 0x00, 0x7B, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x0E, 0x1F, 0xE1, 0xC7, 0x9E, 0x38, 0xF3, 0xCF, 0x3C, 0x3D, 0xC7,
  0x83, 0xF8, 0xF8, 0x3E, 0x0F, 0x07, 0xF5, 0xFF, 0xFF, 0x9F, 0xFB, 0xF0,
  0xFC, 0x1E, 0xFB, 0xDE, 0xF7, 0x39, 0xCE, 0x73, 0x80, 0x07, 0x87, 0x87,
  0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78,
  0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0xF8, 0x3C, 0x1F, 0x07, 0x83,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x1F,
  0x0F, 0x0F, 0x87, 0x87, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xCE, 0x67,
  0xFF, 0x3F, 0xFC, 0x7F, 0x01, 0xF8, 0x1D, 0xC1, 0xEF, 0x0E, 0x38, 0x10,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x3E, 0x3C,
  0x3C, 0x78, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x83, 0xDF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE7, 0x3F,
  0xCE, 0x7F, 0x9C, 0xFF, 0x39, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0x78,
  0x3C, 0xF8, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFB, 0xE0, 0xE3, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE1, 0xFF, 0x83,
  0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x87, 0xE7, 0x81, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00,
  0x7B, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83,
  0xFF, 0x80, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x0E,
  0x1E, 0x0F, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7B, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E, 0xFC,
  0x7E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xE3, 0xE7, 0xC3, 0xEF, 0x03, 0xBE, 0x00, 0x78, 0x00, 0xF3, 0xF1,
  0xEF, 0xF3, 0xFF, 0xF7, 0xE1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xBC,
  0x0F, 0x78, 0x1E, 0x78, 0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFC, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C, 0x3C, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F,
  0xF8, 0x7C, 0x3C, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF8,
  0x1E, 0xFC, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xE3, 0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFB, 0xFF, 0xF3, 0xFD, 0xE3, 0xF3, 0xC0,
  0x07, 0x80, 0x1F, 0xF0, 0x3C, 0xF0, 0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0x00, 0x03,
  0x00, 0x1F, 0x00, 0xFF, 0x07, 0xFF, 0x3F, 0xFE, 0xFF, 0xF0, 0xFF, 0x80,
  0xFC, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07,
  0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFE, 0x00,
  0xF0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFF,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0,
  0x01, 0xFF, 0x00, 0xE0, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x0C, 0x00, 0xE6,
  0x1E, 0xD9, 0x8F, 0xB6, 0xE7, 0x3D, 0xB1, 0x87, 0x7C, 0xE1, 0x8F, 0x30,
  0x63, 0xCC, 0x19, 0xF7, 0x0E, 0x6D, 0xC3, 0x9B, 0x70, 0xC6, 0xDC, 0x31,
  0xB3, 0x1C, 0x6C, 0xCD, 0x33, 0x3F, 0x7C, 0xE7, 0x1E, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x18, 0x1C, 0x1E, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x01, 0xE7, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x80,
  0x3E, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xE7,
  0xC0, 0xF3, 0xE0, 0x79, 0xF0, 0x7C, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0,
  0x39, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x1C, 0xF8, 0x1F, 0x7E, 0x1F, 0x9F, 0xFF,
  0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x31, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF7, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x0F, 0x8F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F, 0xDF, 0x03, 0xEF, 0x81, 0xF8, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFE, 0x7F, 0xEE, 0x7F, 0xEE, 0xEF, 0xEE, 0xEF, 0xEE, 0xEF, 0xE7,
  0xEF, 0xE7, 0xCF, 0xE7, 0xCF, 0xE3, 0xCF, 0xE3, 0x8F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFB, 0x8F,
  0xF7, 0x9F, 0xEF, 0x3F, 0xCE, 0x7F, 0x9E, 0xFF, 0x3D, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xE3, 0xF3,
  0xE0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x3E, 0xF8, 0x3E, 0x7E,
  0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xE0,
  0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E,
  0xF8, 0x3E, 0x7E, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xE0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8,
  0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0xF8, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF3, 0xC0, 0x7D,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xBF,
  0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x7E, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0xEF,
  0x00, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0, 0x7C, 0x7C, 0x0F, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x7C, 0x07,
  0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x80, 0x1C, 0xF0,
  0x07, 0x9E, 0x38, 0xF3, 0xC7, 0x9E, 0x79, 0xF3, 0xCF, 0x3E, 0x78, 0xE7,
  0xCF, 0x1F, 0xFD, 0xC3, 0xFB, 0xB8, 0x7F, 0x77, 0x0F, 0xEE, 0xE1, 0xFC,
  0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x87, 0x81, 0xE0,
  0xF0, 0x7C, 0x07, 0xC7, 0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x87, 0x80, 0xF1,
  0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xEF,
  0x80, 0x78, 0xF8, 0x1F, 0x0F, 0x07, 0xC1, 0xF0, 0xF0, 0x1F, 0x3E, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0xF0, 0x1F, 0x1F, 0x07,
  0xC1, 0xE0, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0x80, 0x3D, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFC,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xEE, 0x00, 0xE7, 0x80, 0xF1, 0xC0,
  0x70, 0xF0, 0x38, 0x38, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E, 0x03, 0x8E, 0x01,
  0xEF, 0x00, 0x77, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3C,
  0x1E, 0x07, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7C, 0x7C, 0xF8, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x1F, 0xFC, 0x7F, 0xFC, 0xF8, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xFC, 0xFF, 0xFF, 0x7F, 0x9F, 0x3E, 0x0F,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E, 0xFC, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E,
  0xFC, 0x3E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xEF, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xFF, 0x83, 0xEF, 0x87,
  0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0xCF, 0x9F, 0xEF, 0x7F, 0xDF, 0xF8,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xF7, 0xFD, 0xE7, 0xF3, 0xC7,
  0xC7, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3C, 0xF8, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x9E,
  0x7F, 0xBD, 0xFF, 0xFB, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xEF, 0x8F,
  0xDF, 0xFF, 0x9F, 0xEF, 0x0F, 0x1E, 0x00, 0x3C, 0x00, 0x7B, 0xC1, 0xF7,
  0xC7, 0xEF, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x7E, 0x7D, 0xFE, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF3,
  0xFF, 0x3F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0x78,
  0x3E, 0xF0, 0xF9, 0xE3, 0xE3, 0xCF, 0x87, 0xBE, 0x0F, 0x78, 0x1F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0xE7, 0x87, 0xCF,
  0x07, 0xDE, 0x07, 0xBC, 0x0F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x8E, 0x77, 0xCF, 0xBB, 0xFF, 0xFF, 0x7C,
  0xFF, 0x1E, 0x7F, 0x8F, 0x3F, 0xC7, 0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8,
  0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF, 0x1C, 0x7F, 0x8E, 0x3F, 0xC7, 0x1F,
  0xE3, 0x8F, 0xF1, 0xC7, 0x80, 0xF1, 0xF9, 0xE7, 0xFB, 0xDF, 0xF7, 0xF1,
  0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1E, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0xC1, 0xF3,
  0xC0, 0x79, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03,
  0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07,
  0xF0, 0x00, 0xF9, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFC, 0x7E, 0xFC, 0x3E,
  0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x1F, 0x1E, 0x7F, 0x3D, 0xFF, 0x7F, 0xE3, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFF, 0x83, 0xFF, 0x8F, 0xDF, 0xF7, 0x9F, 0xDF, 0x1F, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF0,
  0xFF, 0xEF, 0xF7, 0xBF, 0xDF, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xC1,
  0xF7, 0x81, 0xEF, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC,
  0x01, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xDF, 0xFF, 0x1F, 0xFC, 0x0F,
  0xE0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF,
  0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0x80,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x8F, 0xDF, 0xF7, 0xBF, 0xCF, 0x3F, 0x1E, 0x78, 0x03, 0xCF, 0x80,
  0x79, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83,
  0xC0, 0xF8, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0xF8, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x0E,
  0x1C, 0xE1, 0xE3, 0x9E, 0x7C, 0x73, 0xCF, 0x9E, 0x39, 0xF3, 0xC7, 0x77,
  0x70, 0xEE, 0xEE, 0x1D, 0xCD, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xC7,
  0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0xF8, 0x0F, 0xBE, 0x0F, 0x8F, 0x87,
  0x83, 0xC7, 0x81, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF8, 0x03, 0xFE, 0x01, 0xEF, 0x01, 0xE3, 0xC1, 0xF1, 0xF0,
  0xF0, 0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0xBE, 0x03, 0xE7,
  0x80, 0xF9, 0xF0, 0x3C, 0x7C, 0x1F, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0x78,
  0xF8, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0x01, 0xF0,
};

const GFXglyph LiberationMono_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 21, 19, 7, -21 },
  { 15, 11, 10, 19, 4, -23 },
  { 29, 17, 21, 19, 1, -21 },
  { 74, 17, 26, 19, 1, -23 },
  { 130, 19, 21, 19, 0, -21 },
  { 180, 19, 21, 19, 0, -21 },
  { 230, 5, 10, 19, 7, -23 },
  { 237, 9, 30, 19, 5, -23 },
  { 271, 9, 30, 19, 5, -23 },
  { 305, 13, 12, 19, 3, -23 },
  { 325, 16, 16, 19, 2, -18 },
  { 357, 8, 10, 19, 4, -5 },
  { 367, 9, 4, 19, 5, -10 },
  { 372, 5, 5, 19, 7, -5 },
  { 376, 17, 23, 19, 1, -23 },
  { 425, 15, 21, 19, 2, -21 },
  { 465, 16, 21, 19, 2, -21 },
  { 507, 15, 21, 19, 2, -21 },
  { 547, 17, 21, 19, 1, -21 },
  { 592, 17, 21, 19, 1, -21 },
  { 637, 16, 21, 19, 2, -21 },
  { 679, 15, 21, 19, 2, -21 },
  { 719, 15, 21, 19, 2, -21 },
  { 759, 16, 21, 19, 2, -21 },
  { 801, 15, 21, 19, 2, -21 },
  { 841, 5, 17, 19, 7, -17 },
  { 852, 8, 22, 19, 5, -17 },
  { 874, 16, 17, 19, 2, -19 },
  { 908, 16, 11, 19, 2, -16 },
  { 930, 16, 17, 19, 2, -19 },
  { 964, 16, 21, 19, 1, -21 },
  { 1006, 18, 27, 19, 1, -23 },
  { 1067, 19, 21, 19, 0, -21 },
  { 1117, 17, 21, 19, 2, -21 },
  { 1162, 17, 21, 19, 1, -21 },
  { 1207, 16, 21, 19, 2, -21 },
  { 1249, 16, 21, 19, 2, -21 },
  { 1291, 14, 21, 19, 3, -21 },
  { 1328, 17, 21, 19, 1, -21 },
  { 1373, 15, 21, 19, 2, -21 },
  { 1413, 15, 21, 19, 2, -21 },
  { 1453, 14, 21, 19, 2, -21 },
  { 1490, 17, 21, 19, 2, -21 },
  { 1535, 15, 21, 19, 3, -21 },
  { 1575, 16, 21, 19, 2, -21 },
  { 1617, 15, 21, 19, 2, -21 },
  { 1657, 17, 21, 19, 1, -21 },
  { 1702, 16, 21, 19, 2, -21 },
  { 1744, 17, 27, 19, 1, -21 },
  { 1802, 17, 21, 19, 2, -21 },
  { 1847, 17, 21, 19, 1, -21 },
  { 1892, 17, 21, 19, 1, -21 },
  { 1937, 15, 21, 19, 2, -21 },
  { 1977, 19, 21, 19, 0, -21 },
  { 2027, 19, 21, 19, 0, -21 },
  { 2077, 19, 21, 19, 0, -21 },
  { 2127, 19, 21, 19, 0, -21 },
  { 2177, 17, 21, 19, 1, -21 },
  { 2222, 9, 30, 19, 6, -23 },
  { 2256, 17, 23, 19, 1, -23 },
  { 2305, 9, 30, 19, 4, -23 },
  { 2339, 17, 14, 19, 1, -21 },
  { 2369, 19, 2, 19, 0, 2 },
  { 2374, 8, 4, 19, 5, -23 },
  { 2378, 16, 17, 19, 2, -17 },
  { 2412, 16, 23, 19, 2, -23 },
  { 2458, 15, 17, 19, 2, -17 },
  { 2490, 15, 23, 19, 2, -23 },
  { 2534, 16, 17, 19, 2, -17 },
  { 2568, 16, 23, 19, 2, -23 },
  { 2614, 15, 24, 19, 2, -17 },
  { 2659, 15, 23, 19, 2, -23 },
  { 2703, 16, 23, 19, 2, -23 },
  { 2749, 12, 30, 19, 2, -23 },
  { 2794, 15, 23, 19, 3, -23 },
  { 2838, 16, 23, 19, 2, -23 },
  { 2884, 17, 17, 19, 1, -17 },
  { 2921, 15, 17, 19, 2, -17 },
  { 2953, 17, 17, 19, 1, -17 },
  { 2990, 16, 24, 19, 2, -17 },
  { 3038, 15, 24, 19, 2, -17 },
  { 3083, 14, 17, 19, 3, -17 },
  { 3113, 15, 17, 19, 2, -17 },
  { 3145, 13, 21, 19, 3, -21 },
  { 3180, 15, 17, 19, 2, -17 },
  { 3212, 19, 17, 19, 0, -17 },
  { 3253, 19, 17, 19, 0, -17 },
  { 3294, 17, 17, 19, 1, -17 },
  { 3331, 18, 24, 19, 1, -17 },
  { 3385, 15, 17, 19, 2, -17 },
  { 3417, 13, 30, 19, 3, -23 },
  { 3466, 4, 30, 19, 8, -23 },
  { 3481, 13, 30, 19, 3, -23 },
  { 3530, 17, 6, 19, 1, -13 },
};

const GFXfont LiberationMono_Bold32pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold32pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold32pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _LIBERATIONMONO_BOLD32PT7B_H_
