#ifndef _LIBERATIONMONO_BOLD17PT7B_H_
#define _LIBERATIONMONO_BOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xCF, 0x3C, 0xF3, 0xCC, 0x09, 0x86, 0x41, 0x11,
  0xFF, 0x11, 0x0C, 0xC3, 0x23, 0xFE, 0x22, 0x09, 0x86, 0x60, 0x08, 0x3F,
  0x3F, 0xD9, 0x6C, 0x83, 0xE0, 0xFC, 0x1E, 0x0B, 0xE5, 0xBF, 0xCF, 0xC0,
  0x80, 0x70, 0xB6, 0x69, 0xB2, 0x68, 0xDE, 0x1F, 0xE0, 0xA4, 0x59, 0x36,
  0x48, 0x94, 0x38, 0x1E, 0x0F, 0xC3, 0x30, 0xD8, 0x1C, 0x1E, 0x66, 0xDB,
  0x3E, 0xE7, 0x1F, 0xF3, 0xCC, 0xFF, 0xC0, 0x33, 0x98, 0xCE, 0x63, 0x18,
  0xC6, 0x31, 0xC6, 0x31, 0xC6, 0xCE, 0x67, 0x33, 0x33, 0x33, 0x33, 0x76,
  0xEC, 0x32, 0xDF, 0xDE, 0x79, 0xB4, 0x80, 0x18, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x18, 0x18, 0x77, 0x66, 0xCC, 0xFF, 0xC0, 0xF0, 0x03, 0x03, 0x06,
  0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x3C, 0x7E, 0xE7,
  0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0x1C, 0x3C, 0xFC, 0xDC,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x3C, 0x7F, 0xE7, 0x03, 0x06,
  0x0E, 0x38, 0x70, 0xE0, 0xFF, 0xFF, 0x3E, 0xFF, 0xE7, 0x07, 0x1E, 0x1E,
  0x03, 0x03, 0xC3, 0xFF, 0x7E, 0x0E, 0x0F, 0x07, 0x86, 0xC6, 0x63, 0x33,
  0x19, 0xFF, 0xFF, 0x83, 0x01, 0x80, 0x7F, 0x7F, 0xE0, 0xFE, 0xFF, 0xE7,
  0x03, 0x03, 0xE7, 0xFE, 0x3C, 0x3C, 0x7E, 0x67, 0xE0, 0xDE, 0xFF, 0xE3,
  0xC3, 0x63, 0x7F, 0x3E, 0xFF, 0xFF, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x3E, 0xFF, 0xE7, 0xE7, 0x7E, 0x7E, 0xE3, 0xC3, 0xE3,
  0xFF, 0x3E, 0x3C, 0x7E, 0xE7, 0xC3, 0xE7, 0xFF, 0x7B, 0x03, 0xE7, 0x7E,
  0x3C, 0xF0, 0x03, 0xC0, 0x66, 0x00, 0x00, 0x07, 0x66, 0xCC, 0x80, 0x01,
  0x1F, 0xFE, 0xE0, 0xE0, 0xFE, 0x1F, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0xF8, 0x3F, 0x07, 0x07, 0x7F, 0xF8, 0xC0, 0x3C, 0x7F, 0xE3,
  0xC3, 0x07, 0x0E, 0x1C, 0x18, 0x00, 0x38, 0x38, 0x1F, 0x0C, 0x62, 0x09,
  0x37, 0x53, 0x54, 0xDF, 0x27, 0xC9, 0xF2, 0x5D, 0xA5, 0xB9, 0x00, 0x21,
  0x87, 0x80, 0x0E, 0x07, 0x81, 0xE0, 0x6C, 0x33, 0x0C, 0xC3, 0xF9, 0xFE,
  0x61, 0x98, 0x7E, 0x0C, 0xFE, 0x7F, 0xB8, 0xDC, 0x6F, 0xE7, 0xFB, 0x8F,
  0xC7, 0xE3, 0xFF, 0xBF, 0x80, 0x3C, 0x3F, 0xB9, 0xD8, 0x6C, 0x06, 0x03,
  0x01, 0x87, 0xE3, 0x3F, 0x8F, 0x80, 0xFC, 0x7F, 0x39, 0xDC, 0x6E, 0x37,
  0x1F, 0x8D, 0xC6, 0xE7, 0x7F, 0x3F, 0x00, 0xFF, 0x7F, 0xB8, 0x1C, 0x0F,
  0xF7, 0xFB, 0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3C, 0x7E, 0xE7, 0xC3, 0xC0,
  0xCF, 0xCF, 0xC3, 0xE3, 0x7F, 0x3E, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFF,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0xC1, 0xE3, 0xE6,
  0xFC, 0xF0, 0xE3, 0xF3, 0xBB, 0x9D, 0x8F, 0x87, 0xE3, 0xF1, 0xDC, 0xE7,
  0x73, 0xB8, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF,
  0xF8, 0xE7, 0xE7, 0xE5, 0xF5, 0xFD, 0xDD, 0xD9, 0xD9, 0xC1, 0xC1, 0xC1,
  0xE3, 0xF3, 0xF3, 0xF3, 0xDB, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0xC7, 0x3C,
  0x3F, 0xB9, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x86, 0xE7, 0x3F, 0x8F, 0x00,
  0xFE, 0xFF, 0xE3, 0xE3, 0xE3, 0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x3C,
  0x3F, 0xB9, 0xD8, 0x6C, 0x3E, 0x1F, 0x0F, 0x86, 0xE7, 0x3F, 0x8F, 0x83,
  0x81, 0xC0, 0x7C, 0x1E, 0xFE, 0x7F, 0xB8, 0xFC, 0x7E, 0x37, 0xFB, 0xF1,
  0xDC, 0xE7, 0x71, 0xB8, 0xE0, 0x1F, 0x1F, 0xE6, 0x19, 0x80, 0x7C, 0x0F,
  0xE0, 0x38, 0x07, 0xE1, 0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0x7E, 0x3C, 0xE0, 0xD8, 0x76, 0x19,
  0xC6, 0x33, 0x8C, 0xC3, 0xB0, 0x7C, 0x1E, 0x07, 0x80, 0xE0, 0xC0, 0xF0,
  0x3C, 0x0D, 0xB3, 0x6D, 0x9B, 0xE7, 0xF9, 0xEE, 0x73, 0x8C, 0xE3, 0x38,
  0x61, 0xDC, 0xE3, 0x30, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0xFC, 0x33, 0x9C,
  0x6E, 0x1C, 0xE1, 0xD8, 0x67, 0x38, 0xCC, 0x1F, 0x07, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0xFF, 0xFF, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x70,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0xFF, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF, 0x1E,
  0x07, 0x83, 0x20, 0xCC, 0x23, 0x18, 0x64, 0x18, 0xFF, 0xC0, 0xE3, 0x3C,
  0x3F, 0x39, 0xCF, 0xEF, 0xF6, 0x3B, 0x1D, 0xF7, 0x73, 0x80, 0xE0, 0xE0,
  0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xDE, 0x3C, 0x7F,
  0xE3, 0xC0, 0xC0, 0xC0, 0xE3, 0x7F, 0x3C, 0x03, 0x03, 0x03, 0x7B, 0xFF,
  0xE7, 0xC3, 0xC3, 0xC3, 0xE7, 0xFF, 0x7B, 0x3C, 0x7E, 0xE3, 0xFF, 0xFF,
  0xC0, 0xE3, 0x7F, 0x3C, 0x1F, 0x3F, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x3B, 0x7F, 0xE7, 0xE3, 0xC3, 0xE3, 0xE7, 0x7F,
  0x7B, 0x03, 0xE7, 0x7F, 0x3C, 0xE0, 0xE0, 0xE0, 0xEE, 0xDF, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x1C, 0x0E, 0x00, 0x0F, 0x87, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x3F, 0xFF, 0xF0, 0x0C, 0x30, 0x1F, 0x7C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x6E,
  0x67, 0x63, 0xE1, 0xF8, 0xEE, 0x73, 0x39, 0xDC, 0x60, 0x7C, 0x3E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0xFF, 0xF0, 0xB7,
  0x7F, 0xB6, 0x7B, 0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xD9, 0x80, 0xCE, 0xDF,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3E, 0x7F, 0xE3, 0xC3, 0xC3,
  0xC3, 0xE7, 0x7F, 0x3C, 0xCE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF,
  0xEE, 0xE0, 0xE0, 0xE0, 0xE0, 0x7B, 0x7F, 0xE7, 0xC3, 0xC3, 0xC3, 0xE7,
  0xFF, 0x7B, 0x03, 0x03, 0x03, 0x03, 0xDF, 0xBF, 0xC7, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0x3C, 0x7E, 0xE3, 0x78, 0x7E, 0x07, 0xC3, 0xFF, 0x3E, 0x30,
  0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xE7, 0xFB, 0x7B, 0xE1, 0xD8, 0x67, 0x18, 0xCE,
  0x33, 0x0E, 0xC1, 0xE0, 0x78, 0x1E, 0x00, 0xC0, 0xF0, 0x34, 0xCD, 0x32,
  0x6E, 0x9F, 0xE7, 0x39, 0xCE, 0x33, 0x80, 0x61, 0x8C, 0xC3, 0xB0, 0x78,
  0x0E, 0x07, 0x83, 0x31, 0xCE, 0x61, 0x80, 0x61, 0xD8, 0x67, 0x18, 0xCE,
  0x33, 0x06, 0xC1, 0xA0, 0x78, 0x0E, 0x03, 0x01, 0xC1, 0xE0, 0x70, 0x00,
  0xFF, 0xFF, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x3E, 0x7C, 0xC1,
  0x83, 0x0E, 0x1C, 0x70, 0xE0, 0xE1, 0xC1, 0x83, 0x06, 0x0F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0xE0, 0xC1, 0x83, 0x06, 0x0F, 0x1E, 0x30,
  0x60, 0xC1, 0x87, 0x3E, 0x78, 0xF0, 0xF9, 0x9F, 0x07,
};

const GFXglyph LiberationMono_Bold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 6, 5, 10, 2, -12 },
  { 8, 10, 11, 10, 0, -11 },
  { 22, 9, 13, 10, 1, -12 },
  { 37, 10, 11, 10, 0, -11 },
  { 51, 10, 11, 10, 0, -11 },
  { 65, 2, 5, 10, 4, -12 },
  { 67, 5, 16, 10, 3, -12 },
  { 77, 4, 16, 10, 3, -12 },
  { 85, 6, 7, 10, 2, -12 },
  { 91, 8, 8, 10, 1, -10 },
  { 99, 4, 6, 10, 2, -2 },
  { 102, 5, 2, 10, 3, -6 },
  { 104, 2, 2, 10, 4, -2 },
  { 105, 8, 12, 10, 1, -12 },
  { 117, 8, 11, 10, 1, -11 },
  { 128, 8, 11, 10, 1, -11 },
  { 139, 8, 11, 10, 1, -11 },
  { 150, 8, 11, 10, 1, -11 },
  { 161, 9, 11, 10, 1, -11 },
  { 174, 8, 11, 10, 1, -11 },
  { 185, 8, 11, 10, 1, -11 },
  { 196, 8, 11, 10, 1, -11 },
  { 207, 8, 11, 10, 1, -11 },
  { 218, 8, 11, 10, 1, -11 },
  { 229, 2, 9, 10, 4, -9 },
  { 232, 4, 13, 10, 3, -9 },
  { 239, 8, 8, 10, 1, -10 },
  { 247, 8, 6, 10, 1, -9 },
  { 253, 8, 8, 10, 1, -10 },
  { 261, 8, 11, 10, 1, -11 },
  { 272, 10, 14, 10, 0, -12 },
  { 290, 10, 11, 10, 0, -11 },
  { 304, 9, 11, 10, 1, -11 },
  { 317, 9, 11, 10, 1, -11 },
  { 330, 9, 11, 10, 1, -11 },
  { 343, 9, 11, 10, 1, -11 },
  { 356, 8, 11, 10, 1, -11 },
  { 367, 8, 11, 10, 1, -11 },
  { 378, 8, 11, 10, 1, -11 },
  { 389, 8, 11, 10, 1, -11 },
  { 400, 7, 11, 10, 1, -11 },
  { 410, 9, 11, 10, 1, -11 },
  { 423, 7, 11, 10, 2, -11 },
  { 433, 8, 11, 10, 1, -11 },
  { 444, 8, 11, 10, 1, -11 },
  { 455, 9, 11, 10, 1, -11 },
  { 468, 8, 11, 10, 1, -11 },
  { 479, 9, 15, 10, 1, -11 },
  { 496, 9, 11, 10, 1, -11 },
  { 509, 10, 11, 10, 0, -11 },
  { 523, 10, 11, 10, 0, -11 },
  { 537, 8, 11, 10, 1, -11 },
  { 548, 10, 11, 10, 0, -11 },
  { 562, 10, 11, 10, 0, -11 },
  { 576, 10, 11, 10, 0, -11 },
  { 590, 10, 11, 10, 0, -11 },
  { 604, 8, 11, 10, 1, -11 },
  { 615, 5, 16, 10, 3, -12 },
  { 625, 8, 12, 10, 1, -12 },
  { 637, 5, 16, 10, 2, -12 },
  { 647, 10, 7, 10, 0, -11 },
  { 656, 10, 1, 10, 0, 1 },
  { 658, 4, 2, 10, 3, -12 },
  { 659, 9, 9, 10, 1, -9 },
  { 670, 8, 12, 10, 1, -12 },
  { 682, 8, 9, 10, 1, -9 },
  { 691, 8, 12, 10, 1, -12 },
  { 703, 8, 9, 10, 1, -9 },
  { 712, 8, 12, 10, 1, -12 },
  { 724, 8, 13, 10, 1, -9 },
  { 737, 8, 12, 10, 1, -12 },
  { 749, 9, 12, 10, 1, -12 },
  { 763, 6, 16, 10, 1, -12 },
  { 775, 9, 12, 10, 1, -12 },
  { 789, 9, 12, 10, 1, -12 },
  { 803, 9, 9, 10, 1, -9 },
  { 814, 8, 9, 10, 1, -9 },
  { 823, 8, 9, 10, 1, -9 },
  { 832, 8, 13, 10, 1, -9 },
  { 845, 8, 13, 10, 1, -9 },
  { 858, 7, 9, 10, 2, -9 },
  { 866, 8, 9, 10, 1, -9 },
  { 875, 8, 11, 10, 1, -11 },
  { 886, 8, 9, 10, 1, -9 },
  { 895, 10, 9, 10, 0, -9 },
  { 907, 10, 9, 10, 0, -9 },
  { 919, 10, 9, 10, 0, -9 },
  { 931, 10, 13, 10, 0, -9 },
  { 948, 8, 9, 10, 1, -9 },
  { 957, 7, 16, 10, 2, -12 },
  { 971, 2, 16, 10, 4, -12 },
  { 975, 7, 16, 10, 2, -12 },
  { 989, 8, 4, 10, 1, -8 },
};

const GFXfont LiberationMono_Bold17pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold17pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold17pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _LIBERATIONMONO_BOLD17PT7B_H_
