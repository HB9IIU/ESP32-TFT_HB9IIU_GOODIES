#ifndef _LIBERATIONMONO_BOLD31PT7B_H_
#define _LIBERATIONMONO_BOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x38, 0x00, 0xF7,
  0xBD, 0xE0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xBC, 0x77,
  0x0E, 0xE1, 0xC0, 0x03, 0x06, 0x03, 0x87, 0x01, 0x83, 0x00, 0xC1, 0x87,
  0xFF, 0xFB, 0xFF, 0xFC, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0x06, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0xE1, 0xC0, 0x70,
  0xE0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x0E, 0x1C, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7D, 0xBE, 0x79, 0x9F,
  0x79, 0x8E, 0x79, 0x80, 0x7D, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x01, 0xBF, 0x01, 0x8F, 0x71, 0x8F, 0xF1, 0x8F, 0x7D, 0x9F,
  0x7F, 0xFF, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x3E, 0x01, 0x8F, 0xE0, 0x73, 0x9C, 0x1C, 0x71, 0xC3, 0x0E, 0x38, 0xE1,
  0xC7, 0x38, 0x38, 0xEE, 0x07, 0x39, 0x80, 0x7F, 0x70, 0x07, 0xDC, 0x00,
  0x03, 0x3E, 0x00, 0xEF, 0xE0, 0x3B, 0x9C, 0x0E, 0x71, 0xC1, 0x8E, 0x38,
  0x71, 0xC7, 0x1C, 0x38, 0xC3, 0x07, 0x38, 0xE0, 0x7F, 0x38, 0x07, 0x80,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x03,
  0x87, 0x00, 0xE7, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0xE3, 0xFC,
  0x79, 0xE7, 0x1C, 0x71, 0xE7, 0x3C, 0x3F, 0xCF, 0x07, 0xE3, 0xC0, 0xF8,
  0x78, 0x7F, 0x1F, 0xFF, 0xF3, 0xFF, 0x7C, 0x3F, 0x07, 0xFF, 0xFF, 0x77,
  0x77, 0x70, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78,
  0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x06, 0x72, 0x7F, 0xFF,
  0xFF, 0x1F, 0xC1, 0xF8, 0x1D, 0xC3, 0x9E, 0x38, 0xE1, 0x08, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0x8F, 0x1C, 0x38, 0xE1, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xE3, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF3, 0x9F, 0xE7,
  0x3F, 0xCE, 0x7F, 0x9D, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x3C, 0x1E,
  0x7C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x7F, 0x07, 0xFE, 0x0F, 0xBC, 0x1C, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xEF, 0x83, 0xDE, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x0F, 0x7C, 0x1F, 0x7F, 0xFF, 0x3F, 0xFE,
  0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x1E,
  0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7D, 0xF0, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xF8, 0x1F, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDF, 0x00,
  0x3C, 0x00, 0x79, 0xF0, 0xF7, 0xF9, 0xFF, 0xFB, 0xF1, 0xF7, 0xC1, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xBC, 0x1F, 0x7C, 0x7C, 0x7F, 0xF8, 0x7F,
  0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF7, 0xC3,
  0xEF, 0x83, 0xDF, 0x07, 0xBE, 0x0F, 0x3C, 0x3E, 0x3F, 0xF8, 0x1F, 0xC0,
  0xFF, 0xE3, 0xC3, 0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x7E, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF8, 0x3F,
  0xF0, 0xFD, 0xFF, 0xF9, 0xFE, 0xF1, 0xF3, 0xE0, 0x07, 0x80, 0x0F, 0x78,
  0x3E, 0xF8, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE7, 0xCF, 0x1E, 0x78, 0xF1, 0xC3, 0x8E,
  0x1C, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0x80, 0x7C, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x00, 0x0E,
  0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x70,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3E, 0x78,
  0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x07,
  0x87, 0x03, 0x00, 0xC3, 0x00, 0x73, 0x80, 0x19, 0x87, 0x3C, 0xC7, 0xDB,
  0xE7, 0x39, 0xE7, 0x1C, 0xF3, 0x0E, 0x79, 0x87, 0x3D, 0xC3, 0x9E, 0xE1,
  0x8F, 0x70, 0xC7, 0xB8, 0x63, 0xDC, 0x73, 0x6E, 0x39, 0xB3, 0x3C, 0xD9,
  0xF7, 0xCE, 0x71, 0xC3, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x08, 0x1C, 0x1E,
  0x07, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x01, 0xCF, 0x00, 0x78, 0xE0,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xFB,
  0xE0, 0x0F, 0x7C, 0x01, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8,
  0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF,
  0xE0, 0xFF, 0xFC, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x31,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x71, 0xE0, 0x3C, 0xF8, 0x3E, 0x3E, 0x1E, 0x1F, 0xFF, 0x03,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xEF,
  0x87, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3E, 0xF8, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1C, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x7C, 0x0F, 0x3E, 0x1F, 0x1F, 0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xF8, 0x3F, 0xC1,
  0xFF, 0x0F, 0xF8, 0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x7C,
  0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x0F, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0x81,
  0xF7, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xDF,
  0x07, 0xCF, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E,
  0x0F, 0xDF, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x37, 0xFF, 0x77, 0xF7, 0x77, 0xF7, 0x77, 0xF7, 0x67, 0xF7,
  0xE7, 0xF3, 0xE7, 0xF3, 0xE7, 0xF3, 0xC7, 0xF1, 0xC7, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x8F, 0xF7, 0x1F,
  0xEF, 0x3F, 0xCE, 0x7F, 0x9E, 0xFF, 0x3D, 0xFE, 0x3B, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x83, 0xF0, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x3D,
  0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x80,
  0xF7, 0xC0, 0x79, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x3E, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xC7, 0xC7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8,
  0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0x79,
  0xE0, 0x7C, 0xF8, 0x3E, 0x7E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x07, 0xCF, 0x81,
  0xE7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0xF8, 0x3C, 0x7C, 0x1F, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0x87, 0xC7, 0x81, 0xF3, 0xC0, 0x79, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1E, 0xFC, 0x1F, 0x3F, 0xFF, 0x0F,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0x7C, 0x1E, 0x7C, 0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E,
  0x00, 0xF8, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x1F, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x38, 0xF3, 0xCF, 0x1C, 0x79, 0xF3, 0x87, 0x3E,
  0xF0, 0xEF, 0xDE, 0x1D, 0xFB, 0xC3, 0xBB, 0xF8, 0x77, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x07,
  0x80, 0x7C, 0x07, 0xC7, 0x81, 0xF0, 0xF8, 0x3C, 0x0F, 0x8F, 0x80, 0xF3,
  0xE0, 0x1F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03, 0xCF,
  0x80, 0xF8, 0xF8, 0x3E, 0x0F, 0x07, 0x81, 0xF1, 0xF0, 0x1F, 0x7C, 0x01,
  0xE0, 0xF8, 0x03, 0xCF, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xE1,
  0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF,
  0xFF, 0xF8, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C,
  0x3C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x0F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xF8, 0x78, 0xF8, 0xF8, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0xFC,
  0x7F, 0xFC, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF8, 0xFC,
  0xFF, 0xBF, 0x7F, 0xBF, 0x3E, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x7C, 0x7B, 0xFC, 0xF7, 0xFD, 0xF8,
  0xFB, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE3, 0xEF, 0x7F, 0xDE, 0xFF, 0x3C,
  0x78, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xEF, 0x83, 0xDE,
  0x07, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x81,
  0xFF, 0x83, 0xCF, 0x8F, 0x9F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xE7, 0x8F,
  0xEF, 0x3F, 0xFE, 0xF8, 0xFD, 0xF0, 0xFB, 0xC0, 0xF7, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB, 0xE3, 0xF3,
  0xFF, 0xE3, 0xFB, 0xC3, 0xE7, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xE3, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x81, 0xEF, 0x87, 0x9F, 0xFF, 0x1F, 0xFC,
  0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1F, 0x1E,
  0x7F, 0xBD, 0xFF, 0x7B, 0xE3, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x8F,
  0xDF, 0xF7, 0x9F, 0xEF, 0x1F, 0x1E, 0x00, 0x7C, 0x00, 0xF3, 0xC3, 0xE7,
  0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x7C, 0x79, 0xFC, 0xF7, 0xFD, 0xF8,
  0xFB, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x7F, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7F, 0xFF, 0x7F,
  0xCF, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x1F, 0x78, 0x7C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x07, 0xBE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7D, 0xE0, 0xF3, 0xE1, 0xE3, 0xC3,
  0xC3, 0xC7, 0x87, 0xCF, 0x07, 0x9E, 0x0F, 0xBC, 0x0F, 0x00, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7, 0x1E, 0xEF, 0xBF, 0xFF, 0xBF,
  0xFB, 0xE7, 0xF3, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xF1, 0xE7, 0xF3, 0xDF, 0xF7, 0xE3, 0xEF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3E,
  0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F, 0x78, 0x1F,
  0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x78, 0x1F,
  0x7C, 0x1F, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF1, 0xE1,
  0xE7, 0xF3, 0xDF, 0xF7, 0xE3, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x8F,
  0xBD, 0xFF, 0x7B, 0xFC, 0xF1, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB,
  0xE3, 0xF7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0xC3, 0xEF, 0x8F, 0xCF, 0xFF, 0x8F, 0xEF,
  0x0F, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0xFF, 0x9F, 0xFF, 0xFE, 0xFE, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xC1, 0xEF, 0x03, 0xDF, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x07, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xFF, 0xC3,
  0xFF, 0x03, 0xFC, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F,
  0xF8, 0xFD, 0xFF, 0xF7, 0xFB, 0xCF, 0xCF, 0x78, 0x07, 0xDE, 0x01, 0xF7,
  0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x83, 0xC1, 0xE1, 0xF0, 0x78,
  0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xB8,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0xE3, 0xDC, 0x78, 0xF7,
  0x1F, 0x39, 0xE7, 0xCE, 0x3B, 0xF3, 0x8E, 0xEC, 0xE3, 0xBB, 0xF8, 0xEC,
  0xFE, 0x3F, 0x3F, 0x0F, 0xC7, 0xC1, 0xE1, 0xF0, 0x78, 0x7C, 0x1E, 0x0F,
  0x00, 0xF8, 0x0F, 0x3E, 0x0F, 0x0F, 0x0F, 0x83, 0xC7, 0x81, 0xF7, 0x80,
  0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xEF, 0x01, 0xE7, 0xC1, 0xF1, 0xE1, 0xF0, 0x78, 0xF0, 0x3E, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0xFC, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3C, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF0, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x7F,
  0xC3, 0xFE, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFC, 0x03,
  0xE0, 0x7F, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x3E,
};

const GFXglyph LiberationMono_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 20, 19, 7, -20 },
  { 14, 11, 9, 19, 4, -23 },
  { 27, 17, 20, 19, 1, -20 },
  { 70, 16, 25, 19, 1, -22 },
  { 120, 19, 20, 19, 0, -20 },
  { 168, 18, 20, 19, 0, -20 },
  { 213, 4, 9, 19, 7, -23 },
  { 218, 9, 29, 19, 5, -23 },
  { 251, 8, 29, 19, 5, -23 },
  { 280, 12, 12, 19, 3, -23 },
  { 298, 15, 15, 19, 2, -18 },
  { 327, 7, 10, 19, 4, -5 },
  { 336, 9, 4, 19, 5, -10 },
  { 341, 4, 5, 19, 7, -5 },
  { 344, 16, 23, 19, 1, -23 },
  { 390, 15, 20, 19, 2, -20 },
  { 428, 15, 20, 19, 2, -20 },
  { 466, 15, 20, 19, 2, -20 },
  { 504, 16, 20, 19, 1, -20 },
  { 544, 17, 20, 19, 1, -20 },
  { 587, 15, 20, 19, 2, -20 },
  { 625, 15, 20, 19, 2, -20 },
  { 663, 15, 20, 19, 2, -20 },
  { 701, 15, 20, 19, 2, -20 },
  { 739, 15, 20, 19, 2, -20 },
  { 777, 4, 17, 19, 7, -17 },
  { 786, 7, 22, 19, 5, -17 },
  { 806, 15, 17, 19, 2, -19 },
  { 838, 15, 11, 19, 2, -16 },
  { 859, 15, 17, 19, 2, -19 },
  { 891, 16, 20, 19, 1, -20 },
  { 931, 17, 27, 19, 1, -23 },
  { 989, 19, 20, 19, 0, -20 },
  { 1037, 16, 20, 19, 2, -20 },
  { 1077, 17, 20, 19, 1, -20 },
  { 1120, 15, 20, 19, 2, -20 },
  { 1158, 15, 20, 19, 2, -20 },
  { 1196, 14, 20, 19, 3, -20 },
  { 1231, 16, 20, 19, 1, -20 },
  { 1271, 15, 20, 19, 2, -20 },
  { 1309, 14, 20, 19, 2, -20 },
  { 1344, 13, 20, 19, 2, -20 },
  { 1377, 17, 20, 19, 2, -20 },
  { 1420, 14, 20, 19, 3, -20 },
  { 1455, 16, 20, 19, 1, -20 },
  { 1495, 15, 20, 19, 2, -20 },
  { 1533, 17, 20, 19, 1, -20 },
  { 1576, 15, 20, 19, 2, -20 },
  { 1614, 17, 26, 19, 1, -20 },
  { 1670, 17, 20, 19, 2, -20 },
  { 1713, 17, 20, 19, 1, -20 },
  { 1756, 17, 20, 19, 1, -20 },
  { 1799, 15, 20, 19, 2, -20 },
  { 1837, 19, 20, 19, 0, -20 },
  { 1885, 19, 20, 19, 0, -20 },
  { 1933, 19, 20, 19, 0, -20 },
  { 1981, 19, 20, 19, 0, -20 },
  { 2029, 16, 20, 19, 1, -20 },
  { 2069, 9, 29, 19, 6, -23 },
  { 2102, 16, 23, 19, 1, -23 },
  { 2148, 9, 29, 19, 4, -23 },
  { 2181, 16, 14, 19, 1, -20 },
  { 2209, 19, 1, 19, 0, 2 },
  { 2212, 8, 4, 19, 5, -22 },
  { 2216, 16, 17, 19, 2, -17 },
  { 2250, 15, 23, 19, 2, -23 },
  { 2294, 15, 17, 19, 2, -17 },
  { 2326, 15, 23, 19, 1, -23 },
  { 2370, 15, 17, 19, 2, -17 },
  { 2402, 15, 23, 19, 2, -23 },
  { 2446, 15, 23, 19, 2, -17 },
  { 2490, 15, 23, 19, 2, -23 },
  { 2534, 15, 23, 19, 2, -23 },
  { 2578, 11, 29, 19, 2, -23 },
  { 2618, 15, 23, 19, 3, -23 },
  { 2662, 15, 23, 19, 2, -23 },
  { 2706, 16, 17, 19, 1, -17 },
  { 2740, 15, 17, 19, 2, -17 },
  { 2772, 16, 17, 19, 1, -17 },
  { 2806, 15, 23, 19, 2, -17 },
  { 2850, 15, 23, 19, 1, -17 },
  { 2894, 13, 17, 19, 3, -17 },
  { 2922, 15, 17, 19, 2, -17 },
  { 2954, 14, 21, 19, 2, -21 },
  { 2991, 14, 16, 19, 2, -16 },
  { 3019, 18, 17, 19, 0, -17 },
  { 3058, 18, 17, 19, 0, -17 },
  { 3097, 17, 17, 19, 1, -17 },
  { 3134, 17, 23, 19, 1, -17 },
  { 3183, 14, 17, 19, 2, -17 },
  { 3213, 13, 29, 19, 3, -23 },
  { 3261, 4, 30, 19, 7, -23 },
  { 3276, 13, 29, 19, 3, -23 },
  { 3324, 16, 5, 19, 1, -13 },
};

const GFXfont LiberationMono_Bold31pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold31pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold31pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _LIBERATIONMONO_BOLD31PT7B_H_
