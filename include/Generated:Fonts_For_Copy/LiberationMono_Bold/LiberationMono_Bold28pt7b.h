#ifndef _LIBERATIONMONO_BOLD28PT7B_H_
#define _LIBERATIONMONO_BOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: LiberationMono-Bold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t LiberationMono_Bold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x00, 0xFF, 0xFF, 0xF1, 0xDC,
  0x77, 0x1D, 0xC7, 0x71, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0xC0, 0x06, 0x18,
  0x0C, 0x30, 0x38, 0x60, 0x61, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0x0C, 0x0C,
  0x18, 0x18, 0x60, 0x30, 0xC3, 0xFF, 0xF7, 0xFF, 0xE3, 0x0E, 0x06, 0x18,
  0x0C, 0x30, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x3F, 0x81, 0xFF, 0xC7, 0xFF, 0xCF, 0x27, 0x9C, 0x47, 0x38, 0x80, 0x79,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x17, 0xC0, 0x23, 0xDC, 0x47,
  0xF8, 0x8F, 0x79, 0x3E, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x3C, 0x07, 0x3F, 0x03, 0x39, 0xC3, 0x18, 0xE3, 0x8C, 0x73,
  0x86, 0x39, 0x83, 0x9D, 0x80, 0xFD, 0xC0, 0x3C, 0xC0, 0x00, 0xCF, 0x00,
  0xEF, 0xC0, 0xEE, 0x70, 0x66, 0x38, 0x63, 0x1C, 0x71, 0x8E, 0x30, 0xE7,
  0x30, 0x3F, 0x38, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x03,
  0xC7, 0x00, 0xC3, 0x80, 0x73, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x0E,
  0x1F, 0xC7, 0x1C, 0xE3, 0x9E, 0x3B, 0x8F, 0x1F, 0xC7, 0x87, 0xE1, 0xE1,
  0xF2, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x70, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x78, 0x70, 0x0E, 0x01, 0xC1, 0x39, 0x7F, 0xEF, 0xFE, 0x3E,
  0x07, 0xC1, 0xDC, 0x73, 0xC2, 0x20, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x3D, 0xE7, 0x9E,
  0x73, 0xCE, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0xEF,
  0xE7, 0x7F, 0x3B, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE3, 0xCF,
  0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x3F, 0xE0,
  0xF7, 0x83, 0x9E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xC3, 0xFF, 0x1F, 0xFD, 0xF1, 0xFF, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF,
  0x9E, 0x1F, 0x78, 0x3C, 0x00, 0xF0, 0x07, 0x81, 0xFC, 0x07, 0xC0, 0x1F,
  0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0xFF, 0x3F,
  0xF8, 0x3F, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x77,
  0x01, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x38, 0x70, 0xE0, 0xE3, 0xC1, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x3F, 0xF8, 0xFF, 0xE7, 0xFF, 0x9E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xBE, 0x1F, 0xFE, 0x7F, 0xF9, 0xE1, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F,
  0xC0, 0xF7, 0x87, 0xDF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x03, 0xDF, 0x1D, 0xFE, 0xFF, 0xF7,
  0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xE3, 0xEF, 0xFE, 0x3F,
  0xE0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9F, 0x1F, 0x78, 0x3D, 0xE0, 0xF7, 0xC7, 0x8F, 0xFC, 0x0F,
  0xC0, 0xFF, 0xE7, 0x87, 0xDE, 0x0F, 0xF0, 0x3D, 0xE0, 0xF7, 0x87, 0xDF,
  0xFF, 0x3F, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xFF, 0x1F, 0xFD, 0xF1, 0xEF,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xDF, 0xFE, 0x3E,
  0xF0, 0x07, 0xF8, 0x3B, 0xC3, 0xCF, 0xFC, 0x7F, 0xC0, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xC7, 0x8E, 0x1C, 0x70, 0xE1, 0xC3,
  0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x3F, 0xE3, 0xFC, 0x0F,
  0xC0, 0x38, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xC0, 0x03, 0x00, 0x7C, 0x07, 0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x03, 0xC0,
  0x0C, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F,
  0xC0, 0xF0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x03,
  0xE0, 0x1F, 0xE0, 0x70, 0xE1, 0xC0, 0xE7, 0x00, 0xCC, 0x72, 0xD9, 0xFD,
  0xE7, 0x3B, 0xCC, 0x77, 0xB8, 0xEF, 0x61, 0x9E, 0xC3, 0x39, 0x86, 0x73,
  0x0C, 0xF6, 0x39, 0xEC, 0x73, 0xD9, 0xED, 0x9E, 0xFB, 0x38, 0xE3, 0x00,
  0x07, 0x00, 0x87, 0x07, 0x07, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0xC0, 0x39, 0xE0, 0x1C,
  0x70, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x07, 0x07, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x03, 0xC0, 0xFF,
  0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBF,
  0xFC, 0xFF, 0xC3, 0xFF, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xE3, 0xE7, 0x83, 0xDF, 0x03, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x81, 0xCF, 0x03, 0xDF, 0x0F, 0x1F,
  0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x7C,
  0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x1F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE,
  0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78, 0x3F,
  0xE0, 0xEF, 0x00, 0x3C, 0x00, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x07,
  0x78, 0x1D, 0xE0, 0x77, 0xC3, 0xCF, 0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF7, 0x07, 0xBC, 0x3D, 0xE3, 0xCF,
  0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0xF0, 0x7D, 0xE0, 0xF3, 0xC3, 0xE7, 0x8F,
  0x8F, 0x3E, 0x1E, 0x78, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03,
  0xFF, 0x07, 0xDF, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3E, 0x78, 0x3C, 0xF0,
  0x7D, 0xE0, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1B, 0xEC, 0x7F, 0xBB, 0xFE, 0xEF, 0xFB, 0xB7, 0xE6, 0xDF, 0x9F, 0x7E,
  0x7D, 0xF8, 0xE7, 0xE3, 0x9F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x70, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0x3F,
  0xB9, 0xFD, 0xCF, 0xEF, 0x7F, 0x3B, 0xF9, 0xEF, 0xC7, 0x7E, 0x3B, 0xF1,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xCF, 0x07, 0x9F, 0x1F,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC,
  0x3E, 0xF0, 0x7B, 0xC0, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0xFB, 0xFF, 0xCF,
  0xFF, 0x3F, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDF,
  0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x83, 0xCF, 0x07, 0x9F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x3C, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0x8F, 0x0F, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3E, 0x78, 0x3C, 0xF0, 0x7D, 0xE0, 0x78, 0x0F, 0xE0, 0x7F,
  0xF1, 0xFF, 0xF3, 0xC3, 0xEF, 0x03, 0xDF, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0xF0,
  0x0F, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x03, 0x9E, 0x01, 0xEF,
  0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x73, 0x8E, 0x39, 0xC7, 0x3C, 0xF7, 0xDE, 0x7B, 0xEE, 0x1D, 0xF7, 0x0F,
  0xDB, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xF3, 0xF0, 0xF8, 0xF0, 0x7C, 0x78,
  0x1E, 0x3C, 0x0E, 0x1E, 0x00, 0x78, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x83,
  0xC7, 0x80, 0xF7, 0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF0,
  0xF0, 0x78, 0x3C, 0x78, 0x0F, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x3C, 0x07,
  0x9F, 0x07, 0x87, 0x83, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x3D, 0xE0, 0x1E,
  0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xE7, 0x01, 0xCE, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x1C, 0x70, 0x38,
  0xE0, 0x7B, 0x80, 0x77, 0x00, 0xF0, 0xFF, 0xFF, 0x80, 0xF0, 0xF0, 0xF0,
  0x70, 0x0F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC3, 0xC3, 0xC0, 0x07, 0x80, 0x0F,
  0x07, 0xFE, 0x1F, 0xFC, 0x78, 0x78, 0xF0, 0xF3, 0xC1, 0xE3, 0xC7, 0xC7,
  0xFB, 0xEF, 0xF7, 0xC7, 0x87, 0x80, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x79, 0xE3, 0xDF, 0xDF, 0xFE, 0xF8, 0xFF, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xBD,
  0xFD, 0xE7, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1F, 0x78, 0x3D,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xDF, 0x1F,
  0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x7C, 0xF3, 0xFB, 0xDF, 0xFF, 0x7C, 0x7D, 0xE1, 0xFF,
  0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xDE, 0x1F, 0x7C, 0x7D,
  0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E,
  0x78, 0x3D, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xC0, 0x07, 0x80,
  0x1F, 0x0F, 0x3F, 0xFC, 0x7F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0xC7,
  0xFE, 0x3C, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x3B, 0xFF, 0xDF, 0xFF, 0xF1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1,
  0xF7, 0xFF, 0xBF, 0xFC, 0x79, 0xE0, 0x0F, 0x00, 0x7F, 0xC7, 0xDF, 0xFC,
  0x7F, 0xC1, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x79, 0xF3, 0xDF, 0xDF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x1F, 0xF7, 0xFD, 0xFF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x7B, 0xFE, 0xFF, 0x3F, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xEF, 0x0F, 0x3C, 0x78, 0xF3,
  0xE3, 0xCF, 0x0F, 0x78, 0x3F, 0xE0, 0xFF, 0x83, 0xEF, 0x0F, 0x1E, 0x3C,
  0x78, 0xF0, 0xF3, 0xC3, 0xCF, 0x07, 0xBC, 0x0F, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x39, 0xFE, 0xFB, 0xFD,
  0xFF, 0xBE, 0xFF, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F,
  0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0x80,
  0xF3, 0xE7, 0xBF, 0xBF, 0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xDE, 0x07,
  0xBC, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x79, 0xE0, 0xF3, 0xE3, 0xE3,
  0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0xF3, 0xC7, 0xBF, 0xBF, 0xFD, 0xF1,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF1, 0xFF, 0xFF, 0x7B, 0xFB, 0xCF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0x1F,
  0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0x87,
  0xDF, 0x1F, 0x7F, 0xFC, 0xFE, 0xF1, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF3, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1F, 0xC3, 0xFF, 0x1F, 0xFD, 0xE0, 0xFF,
  0x00, 0x7E, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xF1, 0xFF, 0x07, 0xF0, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0xBF, 0xBC, 0xF9, 0xE0,
  0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C,
  0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0xE0, 0x07, 0xF0, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x1C, 0x73, 0x8E, 0x39, 0xCF, 0x9C, 0xE7, 0xDC, 0x33,
  0x6E, 0x1F, 0xB7, 0x0F, 0x9F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xE0,
  0x70, 0x70, 0xF0, 0x3C, 0xF0, 0x78, 0xF1, 0xE1, 0xE7, 0x81, 0xEF, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7B, 0xC1, 0xE3,
  0xC7, 0x87, 0x8F, 0x07, 0xBC, 0x07, 0x80, 0xF0, 0x1F, 0xE0, 0x3D, 0xC0,
  0xF3, 0xC1, 0xE7, 0x83, 0xC7, 0x8F, 0x0F, 0x1E, 0x0E, 0x38, 0x1E, 0xF0,
  0x3D, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xE3, 0xFC, 0x7F, 0x8F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x7C, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xFF, 0x0F, 0xE0, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F,
  0xC3, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xF0, 0x1E, 0x0F, 0xC1, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xF8, 0xFE, 0x1F, 0x80, 0x3E, 0x03,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0x00, 0xF8,
};

const GFXglyph LiberationMono_Bold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 18, 17, 6, -18 },
  { 10, 10, 9, 17, 3, -20 },
  { 22, 15, 18, 17, 1, -18 },
  { 56, 15, 22, 17, 1, -20 },
  { 98, 17, 18, 17, 0, -18 },
  { 137, 17, 18, 17, 0, -18 },
  { 176, 3, 9, 17, 7, -20 },
  { 180, 8, 26, 17, 5, -20 },
  { 206, 8, 26, 17, 4, -20 },
  { 232, 11, 10, 17, 3, -20 },
  { 246, 14, 15, 17, 1, -17 },
  { 273, 6, 9, 17, 4, -4 },
  { 280, 8, 3, 17, 4, -9 },
  { 283, 4, 4, 17, 6, -4 },
  { 285, 15, 20, 17, 1, -20 },
  { 323, 13, 18, 17, 2, -18 },
  { 353, 14, 18, 17, 2, -18 },
  { 385, 13, 18, 17, 2, -18 },
  { 415, 14, 18, 17, 1, -18 },
  { 447, 15, 18, 17, 1, -18 },
  { 481, 14, 18, 17, 1, -18 },
  { 513, 13, 18, 17, 2, -18 },
  { 543, 13, 18, 17, 2, -18 },
  { 573, 14, 18, 17, 1, -18 },
  { 605, 13, 18, 17, 2, -18 },
  { 635, 4, 15, 17, 6, -15 },
  { 643, 7, 20, 17, 4, -15 },
  { 661, 14, 15, 17, 1, -17 },
  { 688, 14, 11, 17, 1, -15 },
  { 708, 14, 15, 17, 1, -17 },
  { 735, 14, 18, 17, 1, -18 },
  { 767, 15, 24, 17, 1, -20 },
  { 812, 17, 18, 17, 0, -18 },
  { 851, 14, 18, 17, 2, -18 },
  { 883, 15, 18, 17, 1, -18 },
  { 917, 14, 18, 17, 2, -18 },
  { 949, 14, 18, 17, 2, -18 },
  { 981, 13, 18, 17, 2, -18 },
  { 1011, 14, 18, 17, 1, -18 },
  { 1043, 13, 18, 17, 2, -18 },
  { 1073, 13, 18, 17, 2, -18 },
  { 1103, 13, 18, 17, 1, -18 },
  { 1133, 15, 18, 17, 2, -18 },
  { 1167, 12, 18, 17, 3, -18 },
  { 1194, 14, 18, 17, 1, -18 },
  { 1226, 13, 18, 17, 2, -18 },
  { 1256, 15, 18, 17, 1, -18 },
  { 1290, 14, 18, 17, 2, -18 },
  { 1322, 15, 24, 17, 1, -18 },
  { 1367, 15, 18, 17, 2, -18 },
  { 1401, 15, 18, 17, 1, -18 },
  { 1435, 15, 18, 17, 1, -18 },
  { 1469, 13, 18, 17, 2, -18 },
  { 1499, 17, 18, 17, 0, -18 },
  { 1538, 17, 18, 17, 0, -18 },
  { 1577, 17, 18, 17, 0, -18 },
  { 1616, 17, 18, 17, 0, -18 },
  { 1655, 15, 18, 17, 1, -18 },
  { 1689, 8, 26, 17, 5, -20 },
  { 1715, 15, 20, 17, 1, -20 },
  { 1753, 9, 26, 17, 3, -20 },
  { 1783, 15, 12, 17, 1, -18 },
  { 1806, 17, 1, 17, 0, 2 },
  { 1809, 7, 4, 17, 5, -20 },
  { 1813, 15, 15, 17, 1, -15 },
  { 1842, 13, 20, 17, 2, -20 },
  { 1875, 14, 15, 17, 1, -15 },
  { 1902, 14, 20, 17, 1, -20 },
  { 1937, 14, 15, 17, 1, -15 },
  { 1964, 13, 20, 17, 2, -20 },
  { 1997, 13, 21, 17, 2, -15 },
  { 2032, 13, 20, 17, 2, -20 },
  { 2065, 14, 20, 17, 2, -20 },
  { 2100, 10, 26, 17, 2, -20 },
  { 2133, 14, 20, 17, 2, -20 },
  { 2168, 14, 20, 17, 2, -20 },
  { 2203, 15, 15, 17, 1, -15 },
  { 2232, 13, 15, 17, 2, -15 },
  { 2257, 15, 15, 17, 1, -15 },
  { 2286, 13, 21, 17, 2, -15 },
  { 2321, 14, 21, 17, 1, -15 },
  { 2358, 12, 15, 17, 3, -15 },
  { 2381, 13, 15, 17, 2, -15 },
  { 2406, 12, 19, 17, 2, -19 },
  { 2435, 13, 15, 17, 2, -15 },
  { 2460, 16, 15, 17, 0, -15 },
  { 2490, 17, 15, 17, 0, -15 },
  { 2522, 15, 15, 17, 1, -15 },
  { 2551, 15, 21, 17, 1, -15 },
  { 2591, 13, 15, 17, 2, -15 },
  { 2616, 11, 26, 17, 3, -20 },
  { 2652, 3, 26, 17, 7, -20 },
  { 2662, 11, 26, 17, 3, -20 },
  { 2698, 14, 5, 17, 1, -12 },
};

const GFXfont LiberationMono_Bold28pt7b PROGMEM = {
  (uint8_t  *)LiberationMono_Bold28pt7bBitmaps,
  (GFXglyph *)LiberationMono_Bold28pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _LIBERATIONMONO_BOLD28PT7B_H_
