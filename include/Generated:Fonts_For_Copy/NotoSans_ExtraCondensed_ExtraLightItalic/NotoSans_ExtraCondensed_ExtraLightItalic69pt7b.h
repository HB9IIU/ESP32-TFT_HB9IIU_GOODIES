#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x1C, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x06, 0x38, 0x38,
  0xC0, 0xE3, 0x03, 0x9C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x07, 0x18, 0x18,
  0x60, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x30, 0xC0, 0xC2, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x30, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x30, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x1C,
  0x00, 0x06, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x18, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x38, 0x61, 0xC0, 0x0E, 0x0C, 0x08, 0x03, 0x83, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x20, 0x00,
  0x0C, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xE0, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x04, 0x06, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x38, 0x00, 0x06, 0x0E, 0x00, 0x80, 0xC3, 0xC0, 0x3E, 0x19, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x30, 0x0F, 0x38, 0x00, 0xC0, 0x38, 0x30, 0x01, 0x80, 0x60, 0x60,
  0x06, 0x01, 0xC0, 0xC0, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x0E, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x0C,
  0x01, 0x80, 0x30, 0x18, 0x03, 0x00, 0x60, 0x60, 0x0E, 0x01, 0xC0, 0xC0,
  0x1C, 0x03, 0x83, 0x00, 0x30, 0x07, 0x06, 0x00, 0x60, 0x0C, 0x18, 0x00,
  0xC0, 0x18, 0x30, 0x01, 0x80, 0x70, 0xC0, 0x07, 0x00, 0xE1, 0x80, 0x0E,
  0x01, 0x86, 0x07, 0x9C, 0x03, 0x0C, 0x3F, 0xB8, 0x0E, 0x30, 0xE3, 0xF0,
  0x18, 0x63, 0x83, 0xE0, 0x71, 0x86, 0x07, 0xC0, 0xC3, 0x1C, 0x0F, 0x83,
  0x8E, 0x30, 0x1B, 0x06, 0x18, 0xE0, 0x37, 0x38, 0x71, 0x80, 0x67, 0xE0,
  0xC3, 0x00, 0xC7, 0x83, 0x8E, 0x01, 0x80, 0x06, 0x18, 0x03, 0x00, 0x1C,
  0x30, 0x06, 0x00, 0x30, 0xE0, 0x1C, 0x00, 0xE1, 0xC0, 0x38, 0x01, 0x83,
  0x00, 0x60, 0x07, 0x06, 0x00, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0x38, 0x18,
  0x07, 0x00, 0x60, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x18, 0x03, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x07,
  0x00, 0xC0, 0x1C, 0x0C, 0x03, 0x80, 0x38, 0x38, 0x06, 0x00, 0x30, 0xE0,
  0x1C, 0x00, 0x7F, 0x80, 0x70, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0x1C,
  0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x31, 0x80,
  0x00, 0x33, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x8C, 0x00,
  0x07, 0x0E, 0x01, 0x06, 0x0E, 0x06, 0x0E, 0x06, 0x06, 0x1C, 0x06, 0x0E,
  0x18, 0x07, 0x0C, 0x38, 0x07, 0x0C, 0x30, 0x03, 0x1C, 0x70, 0x03, 0x18,
  0x70, 0x03, 0x98, 0x60, 0x03, 0xB8, 0x60, 0x01, 0xB0, 0xE0, 0x01, 0xF0,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0xE0, 0x03, 0xE0, 0x60, 0x07, 0x60, 0x70, 0x0E, 0x60, 0x78, 0x1C, 0x70,
  0x3F, 0xF8, 0x70, 0x1F, 0xF0, 0x30, 0x03, 0x80, 0x00, 0x1C, 0x63, 0x8E,
  0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x40, 0xC0, 0x38, 0x30, 0x07, 0x8C,
  0x00, 0x73, 0x07, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x0D, 0x00,
  0x0E, 0x60, 0x07, 0x0C, 0x03, 0x83, 0x03, 0xC0, 0x60, 0x60, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x38,
  0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0xC0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x60, 0x07, 0x01, 0xC0, 0x06, 0x03,
  0x00, 0x0C, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x60, 0xE0,
  0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x00,
  0x1C, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x00, 0x01,
  0x86, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xC0, 0x00, 0x61, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80,
  0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0xF7, 0x0E, 0x30, 0xE1, 0x8E,
  0x1C, 0xE0, 0xE2, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0x10, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x40, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x20, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x30,
  0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x03,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x03, 0x00,
  0x0C, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x07, 0x00,
  0x0C, 0x01, 0x80, 0x03, 0x00, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01, 0x00,
  0x07, 0x80, 0x38, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xCE, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x7F, 0x00, 0x31, 0xFF, 0x80, 0x33, 0xC3,
  0xC0, 0x77, 0x01, 0xE0, 0x7C, 0x00, 0xE0, 0x7C, 0x00, 0x60, 0x78, 0x00,
  0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01,
  0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x78, 0x3C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC2, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0xF0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x03, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x18,
  0x07, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x18,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x0E,
  0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x1E, 0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x3E,
  0x0E, 0x00, 0x3C, 0x07, 0x00, 0x6C, 0x07, 0x01, 0xDC, 0x03, 0xCF, 0x9C,
  0x01, 0xFF, 0x1C, 0x00, 0xFC, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x80, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x08, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0x3F, 0x03, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x0C,
  0x1C, 0x00, 0x20, 0x06, 0x0C, 0x00, 0xFF, 0x03, 0x0E, 0x00, 0xFF, 0x81,
  0x86, 0x00, 0xC1, 0xC0, 0xC3, 0x00, 0xC0, 0xC0, 0x63, 0x80, 0xE0, 0x60,
  0x31, 0x80, 0xE0, 0x70, 0x38, 0xC0, 0x60, 0x38, 0x1C, 0xE0, 0x70, 0x18,
  0x0E, 0x60, 0x30, 0x0C, 0x06, 0x30, 0x18, 0x0E, 0x03, 0x38, 0x1C, 0x07,
  0x01, 0x9C, 0x0C, 0x03, 0x01, 0xCC, 0x06, 0x01, 0x80, 0xE6, 0x07, 0x01,
  0xC0, 0x63, 0x03, 0x80, 0xE0, 0x33, 0x81, 0x80, 0x60, 0x39, 0xC0, 0xC0,
  0x70, 0x18, 0xE0, 0x60, 0x38, 0x0C, 0x60, 0x30, 0x1C, 0x0E, 0x30, 0x38,
  0x1C, 0x06, 0x18, 0x1C, 0x0E, 0x03, 0x0C, 0x06, 0x07, 0x03, 0x06, 0x03,
  0x07, 0x81, 0x83, 0x01, 0x86, 0x41, 0x81, 0x80, 0xE7, 0x31, 0x80, 0xC0,
  0x3F, 0x1F, 0xC0, 0x60, 0x1F, 0x07, 0x80, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x04, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x73, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0xC7, 0x00, 0x01, 0x87, 0x00,
  0x01, 0x87, 0x00, 0x03, 0x87, 0x00, 0x03, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x06, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xE0, 0x07, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x06,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xE0, 0x3E, 0x00, 0x18, 0x01, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x70, 0x06, 0x00, 0x1C,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x03, 0xF0, 0x00, 0xE0, 0x0F, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x18, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x18, 0x07, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFE, 0x7C, 0x00, 0x78, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x08, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x38, 0x1F, 0x00, 0x03, 0x00, 0x78, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x60,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x38,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x0E, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0,
  0x30, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x00,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0xF0, 0x00, 0x60, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x20, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x40,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xC1, 0xC0, 0x01, 0xFF,
  0x83, 0x80, 0x03, 0xFE, 0x06, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80,
  0x01, 0x80, 0x07, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x60, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x01, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xC0,
  0x78, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x33, 0xC0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x07, 0x6E, 0x00, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x0F, 0x06,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0,
  0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x80, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x00, 0x03, 0x60, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xB8, 0x00, 0x00,
  0x6E, 0x00, 0x6E, 0x00, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x00, 0x0C, 0xC0,
  0x0E, 0xE0, 0x00, 0x07, 0x30, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x31, 0x80, 0x00, 0x31, 0xC0, 0x1C, 0x60, 0x00,
  0x1C, 0x60, 0x07, 0x18, 0x00, 0x07, 0x38, 0x01, 0xC6, 0x00, 0x03, 0x8E,
  0x00, 0x61, 0x80, 0x00, 0xE3, 0x80, 0x18, 0x60, 0x00, 0x30, 0xC0, 0x0E,
  0x18, 0x00, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x06, 0x1C, 0x00, 0xC1, 0x80,
  0x03, 0x87, 0x00, 0x30, 0x60, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0x70,
  0x60, 0x07, 0x06, 0x00, 0x18, 0x18, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00,
  0x60, 0x70, 0x03, 0x03, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07,
  0x00, 0x60, 0x30, 0x03, 0x81, 0xC0, 0x38, 0x0C, 0x00, 0xE0, 0x70, 0x0C,
  0x07, 0x00, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x07, 0x00, 0xC0, 0xE0, 0x18, 0x01, 0xC0, 0x30, 0x38, 0x0E, 0x00, 0x70,
  0x0C, 0x1C, 0x03, 0x80, 0x18, 0x03, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x03, 0x80, 0x30, 0xE0, 0x0C, 0x00, 0xE0, 0x0C, 0x30, 0x07,
  0x00, 0x30, 0x03, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC6, 0x00, 0x70, 0x03,
  0x00, 0x33, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0xF0, 0x03, 0x80, 0x18, 0x00, 0xF8, 0x00, 0xE0, 0x06, 0x00, 0x3E, 0x00,
  0x38, 0x03, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x60, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x03, 0x80, 0x1F,
  0x80, 0x00, 0xC0, 0x07, 0x60, 0x00, 0x30, 0x01, 0x98, 0x00, 0x1C, 0x00,
  0x66, 0x00, 0x07, 0x00, 0x39, 0x80, 0x01, 0xC0, 0x0E, 0x70, 0x00, 0x60,
  0x03, 0x9C, 0x00, 0x18, 0x00, 0xC3, 0x00, 0x0E, 0x00, 0x30, 0xC0, 0x03,
  0x80, 0x1C, 0x30, 0x00, 0xC0, 0x07, 0x0E, 0x00, 0x30, 0x01, 0xC3, 0x80,
  0x1C, 0x00, 0x60, 0xE0, 0x07, 0x00, 0x18, 0x18, 0x01, 0xC0, 0x0E, 0x06,
  0x00, 0x60, 0x03, 0x81, 0x80, 0x18, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x30,
  0x1C, 0x03, 0x80, 0x0C, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x30, 0x01,
  0xC0, 0x30, 0x0C, 0x00, 0x60, 0x0E, 0x07, 0x00, 0x18, 0x03, 0x81, 0xC0,
  0x0E, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x18, 0x18, 0x00, 0xE0, 0x06, 0x06,
  0x00, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x1C,
  0x30, 0x01, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0x00, 0xC7, 0x00, 0x18, 0x00,
  0x31, 0xC0, 0x06, 0x00, 0x0E, 0x70, 0x03, 0x80, 0x03, 0x98, 0x00, 0xE0,
  0x00, 0xE6, 0x00, 0x38, 0x00, 0x1B, 0x80, 0x0C, 0x00, 0x06, 0xE0, 0x03,
  0x00, 0x01, 0xB8, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x1F, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x06, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x73, 0x80, 0x00, 0x06, 0x38,
  0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0x83, 0xF0, 0x00, 0xC0, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0,
  0x30, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x03,
  0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x01, 0xC0, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x63, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x83, 0xE0, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x60, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x30,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x01,
  0xC0, 0x0C, 0x01, 0xE0, 0x07, 0x01, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00,
  0x60, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x70, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xE0,
  0x18, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF,
  0xF0, 0x01, 0xE0, 0x06, 0x00, 0x38, 0x00, 0x20, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x60, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x38, 0x06, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x18, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80,
  0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x38, 0x00,
  0xC0, 0x38, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0xC0, 0x00,
  0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xD8, 0x00, 0x03, 0x80, 0x00, 0x66, 0x00, 0x01, 0xE0, 0x00,
  0x39, 0x80, 0x00, 0x78, 0x00, 0x0E, 0x60, 0x00, 0x3E, 0x00, 0x07, 0x18,
  0x00, 0x0F, 0x80, 0x01, 0xC6, 0x00, 0x03, 0xE0, 0x00, 0x61, 0x80, 0x01,
  0xF8, 0x00, 0x38, 0x60, 0x00, 0x6E, 0x00, 0x0E, 0x18, 0x00, 0x3B, 0x80,
  0x07, 0x06, 0x00, 0x0E, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x30, 0x00, 0x60,
  0x60, 0x01, 0xCC, 0x00, 0x38, 0x18, 0x00, 0x63, 0x00, 0x0E, 0x06, 0x00,
  0x18, 0xC0, 0x07, 0x01, 0x80, 0x0E, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x0C,
  0x00, 0x60, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x06, 0x00, 0x60, 0xC0, 0x0E,
  0x01, 0x80, 0x18, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0xC0, 0x38, 0x03, 0x80, 0x60,
  0x30, 0x0E, 0x00, 0xE0, 0x18, 0x0C, 0x07, 0x00, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x30, 0x38, 0x00,
  0xE0, 0x60, 0x0C, 0x0E, 0x00, 0x38, 0x18, 0x03, 0x03, 0x00, 0x0E, 0x0E,
  0x00, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00, 0x0E, 0x18, 0x01, 0xC3, 0x00,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x00, 0x39,
  0xC0, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x03, 0x98, 0x00,
  0x63, 0x00, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x00, 0x06, 0x60,
  0x00, 0x0E, 0xC0, 0x01, 0xB8, 0x00, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38,
  0x18, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x61, 0xC0, 0x01,
  0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x18, 0x01, 0xC0, 0x30, 0x03, 0x80, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x70, 0x03, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xC7,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x0D, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x9C, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x70, 0x0C, 0x00,
  0x30, 0x07, 0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0x83, 0x83, 0x07, 0x06,
  0x0E, 0x0C, 0x08, 0x18, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE3, 0x00, 0xF8,
  0xE3, 0x01, 0xE0, 0x37, 0x03, 0xC0, 0x36, 0x03, 0x80, 0x16, 0x07, 0x00,
  0x1E, 0x06, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38, 0x00,
  0x18, 0x30, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03,
  0xC0, 0xE0, 0x07, 0xC0, 0x60, 0x0D, 0x80, 0x70, 0x0D, 0x80, 0x78, 0x39,
  0x80, 0x3F, 0xF1, 0x80, 0x1F, 0xE3, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC3, 0xF0,
  0x00, 0xC7, 0xFC, 0x00, 0x67, 0x9F, 0x00, 0x77, 0x03, 0x80, 0x3F, 0x00,
  0xE0, 0x1B, 0x00, 0x70, 0x0F, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x07, 0x80,
  0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0x60, 0x70, 0x00, 0x30, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x00, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xF0, 0x03,
  0x80, 0xF8, 0x03, 0x80, 0x6E, 0x01, 0xC0, 0x33, 0x83, 0xC0, 0x19, 0xFF,
  0xC0, 0x18, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x03, 0xE1, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x20, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x30, 0x00,
  0x7F, 0xE7, 0x00, 0x0F, 0x8E, 0x70, 0x01, 0xE0, 0x37, 0x00, 0x3C, 0x03,
  0x60, 0x03, 0x80, 0x16, 0x00, 0x70, 0x01, 0xE0, 0x06, 0x00, 0x1E, 0x00,
  0xE0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80,
  0x30, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0xC0, 0x06,
  0x00, 0xD8, 0x00, 0x70, 0x1D, 0x80, 0x07, 0x83, 0x98, 0x00, 0x3F, 0xF1,
  0x80, 0x01, 0xFE, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x07, 0xFE, 0x00, 0xF0, 0xE0, 0x1E, 0x07, 0x03, 0x80, 0x70, 0x38, 0x03,
  0x07, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0x63, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00,
  0x70, 0x70, 0x1E, 0x06, 0x7F, 0xC0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x06,
  0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0x8C, 0x00, 0x7C, 0x71, 0x80, 0x1E, 0x03, 0x70, 0x07, 0x80, 0x6C,
  0x00, 0xE0, 0x05, 0x80, 0x38, 0x00, 0xF0, 0x06, 0x00, 0x1E, 0x01, 0xC0,
  0x03, 0x80, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xF0,
  0x07, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0xC0, 0x0C, 0x01, 0xB0, 0x01, 0xC0,
  0x76, 0x00, 0x3C, 0x1C, 0xC0, 0x03, 0xFF, 0x38, 0x00, 0x3F, 0xC7, 0x00,
  0x01, 0xE0, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x10, 0x01, 0xC0, 0x03, 0x00, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71, 0xFC, 0x00, 0xC7, 0xFC, 0x01,
  0x9C, 0x3C, 0x07, 0x60, 0x38, 0x0F, 0x80, 0x30, 0x1A, 0x00, 0x60, 0x3C,
  0x00, 0xC0, 0x70, 0x01, 0x81, 0xE0, 0x03, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xE0, 0x03,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x38, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x06, 0x07,
  0x00, 0x0C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0xE0,
  0x01, 0x81, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07,
  0x07, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x01, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x01, 0x80,
  0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x03, 0x00, 0x03, 0x07,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x06, 0x38,
  0x00, 0x06, 0x7C, 0x00, 0x0E, 0xFC, 0x00, 0x0E, 0xDC, 0x00, 0x0D, 0x8C,
  0x00, 0x0F, 0x0C, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x38, 0x06,
  0x00, 0x38, 0x07, 0x00, 0x30, 0x07, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x80, 0x60, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x06, 0x7F, 0xC1, 0xFF, 0x00, 0x37, 0x8F, 0x3C,
  0x3C, 0x03, 0xB0, 0x19, 0x80, 0xE0, 0x1B, 0x00, 0xF8, 0x03, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x00, 0xC0, 0x38, 0x01, 0xC0, 0x06,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x01, 0x80, 0xE0, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x06, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0x1C, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x06, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x1C, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x1C,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x1C, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0x8F, 0xF8, 0x03, 0x38, 0x78,
  0x0E, 0xC0, 0x70, 0x1B, 0x00, 0x60, 0x3C, 0x00, 0xC0, 0x78, 0x01, 0x80,
  0xE0, 0x03, 0x03, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x00,
  0x0E, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18,
  0x18, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03,
  0x80, 0x0E, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70,
  0x00, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0x0F, 0x00, 0x70,
  0x1C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0x83, 0x80, 0x06,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0x63, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x98, 0x00, 0x0E, 0xE0, 0x00, 0x33,
  0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80,
  0x03, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x06,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x81, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0x8F, 0xF8, 0x00, 0x19, 0xE3, 0xC0, 0x03, 0xB8,
  0x1C, 0x00, 0x3B, 0x00, 0xE0, 0x03, 0x60, 0x0E, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x0E, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x0C, 0xC0,
  0xF0, 0x00, 0xCF, 0xFE, 0x00, 0x0C, 0x7F, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xE3, 0x00,
  0xF8, 0xE3, 0x01, 0xE0, 0x77, 0x03, 0xC0, 0x36, 0x03, 0x80, 0x16, 0x07,
  0x00, 0x1E, 0x06, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x38,
  0x00, 0x18, 0x30, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x30, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0,
  0x03, 0xC0, 0xE0, 0x07, 0xC0, 0xE0, 0x0D, 0x80, 0x70, 0x1D, 0x80, 0x78,
  0x3B, 0x80, 0x3F, 0xF3, 0x80, 0x1F, 0xE3, 0x80, 0x07, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x0C,
  0x7E, 0x00, 0xCF, 0x20, 0x19, 0xC0, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7C,
  0x1E, 0x03, 0x80, 0x20, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x04, 0x00, 0x70, 0x30, 0x0F,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x7F, 0xF1, 0xFF, 0x80, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x70, 0x00, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18,
  0x1C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x83,
  0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30,
  0x00, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xC0, 0x03,
  0x81, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x70,
  0x30, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x1C, 0x0C, 0x00, 0x78, 0x18, 0x00, 0xE0, 0x30, 0x03, 0xC0, 0x60,
  0x05, 0x80, 0xE0, 0x1B, 0x01, 0xE0, 0xEE, 0x01, 0xFF, 0x98, 0x01, 0xFE,
  0x30, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x38,
  0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0x81,
  0x80, 0x70, 0x30, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x03,
  0x03, 0x80, 0x60, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06,
  0x1C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x67, 0x00, 0x0C,
  0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0,
  0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x03, 0xC0, 0x0C, 0xE0,
  0x06, 0xC0, 0x0C, 0xE0, 0x06, 0xC0, 0x1C, 0xE0, 0x0E, 0xC0, 0x18, 0xE0,
  0x0C, 0xC0, 0x38, 0xE0, 0x0C, 0xC0, 0x38, 0xE0, 0x18, 0xC0, 0x30, 0xE0,
  0x18, 0xC0, 0x70, 0xE0, 0x39, 0xC0, 0x60, 0xE0, 0x31, 0xC0, 0x60, 0xE0,
  0x31, 0xC0, 0xE0, 0xE0, 0x61, 0xC0, 0xC0, 0xE0, 0x61, 0xC1, 0xC0, 0xE0,
  0xE1, 0xC1, 0x80, 0xE0, 0xC1, 0xC1, 0x80, 0xC1, 0xC1, 0xC3, 0x80, 0xC1,
  0x81, 0xC3, 0x00, 0xC1, 0x81, 0xC7, 0x00, 0xC3, 0x81, 0xC6, 0x00, 0xC3,
  0x01, 0x86, 0x00, 0xC7, 0x01, 0x8E, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0xC6,
  0x01, 0x8C, 0x00, 0xCE, 0x01, 0x98, 0x00, 0xCC, 0x01, 0x98, 0x00, 0xCC,
  0x01, 0xB8, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0xD8, 0x01, 0xB0, 0x00, 0xF8,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x0E, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x30,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x18, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x00, 0x70, 0x00, 0x03, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x07, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xD0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x0F,
  0xFE, 0x80, 0x07, 0xFC, 0x80, 0x00, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 49, 14, 1, -49 },
  { 87, 14, 18, 19, 7, -49 },
  { 119, 27, 49, 26, 0, -49 },
  { 285, 27, 56, 24, -1, -52 },
  { 474, 31, 51, 37, 3, -50 },
  { 672, 24, 51, 24, -1, -50 },
  { 825, 6, 18, 10, 7, -49 },
  { 839, 19, 60, 17, 2, -49 },
  { 982, 19, 60, 17, -5, -49 },
  { 1125, 18, 19, 23, 8, -52 },
  { 1168, 24, 32, 28, 2, -40 },
  { 1264, 9, 16, 11, -3, -7 },
  { 1282, 14, 2, 18, 2, -20 },
  { 1286, 4, 5, 11, 1, -5 },
  { 1289, 28, 49, 21, -3, -49 },
  { 1461, 23, 51, 24, 1, -50 },
  { 1608, 13, 49, 24, 8, -49 },
  { 1688, 26, 50, 24, -2, -50 },
  { 1851, 27, 51, 24, -2, -50 },
  { 2024, 26, 50, 24, -1, -50 },
  { 2187, 27, 50, 24, -2, -49 },
  { 2356, 24, 51, 24, 2, -50 },
  { 2509, 25, 49, 24, 2, -49 },
  { 2663, 26, 51, 24, -1, -50 },
  { 2829, 24, 51, 24, 0, -50 },
  { 2982, 11, 37, 11, 0, -37 },
  { 3033, 14, 46, 11, -3, -37 },
  { 3114, 24, 29, 28, 2, -39 },
  { 3201, 24, 17, 28, 2, -33 },
  { 3252, 24, 29, 28, 2, -39 },
  { 3339, 19, 50, 17, 1, -50 },
  { 3458, 33, 56, 36, 2, -50 },
  { 3689, 24, 49, 24, -5, -49 },
  { 3836, 27, 49, 27, 0, -49 },
  { 4002, 26, 51, 24, 3, -50 },
  { 4168, 28, 49, 29, 0, -49 },
  { 4340, 27, 49, 24, 0, -49 },
  { 4506, 27, 49, 22, 0, -49 },
  { 4672, 31, 51, 32, 2, -50 },
  { 4870, 32, 49, 31, 0, -49 },
  { 5066, 22, 49, 13, -4, -49 },
  { 5201, 23, 61, 11, -10, -49 },
  { 5377, 30, 49, 25, 0, -49 },
  { 5561, 16, 49, 21, 0, -49 },
  { 5659, 42, 49, 41, 0, -49 },
  { 5917, 34, 49, 33, 0, -49 },
  { 6126, 28, 51, 31, 2, -50 },
  { 6305, 26, 49, 25, 0, -49 },
  { 6465, 28, 62, 31, 2, -50 },
  { 6682, 26, 49, 25, 0, -49 },
  { 6842, 28, 51, 24, -2, -50 },
  { 7021, 22, 49, 21, 4, -49 },
  { 7156, 29, 50, 30, 2, -49 },
  { 7338, 24, 49, 25, 6, -49 },
  { 7485, 42, 49, 42, 5, -49 },
  { 7743, 31, 49, 22, -4, -49 },
  { 7933, 23, 49, 21, 4, -49 },
  { 8074, 29, 49, 21, -3, -49 },
  { 8252, 24, 60, 19, -1, -49 },
  { 8432, 10, 49, 22, 7, -49 },
  { 8494, 24, 60, 19, -4, -49 },
  { 8674, 25, 24, 27, 2, -49 },
  { 8749, 18, 2, 19, -5, 6 },
  { 8754, 7, 11, 15, 10, -53 },
  { 8764, 24, 38, 27, 2, -37 },
  { 8878, 25, 53, 26, 0, -52 },
  { 9044, 19, 38, 19, 2, -37 },
  { 9135, 28, 53, 27, 2, -52 },
  { 9321, 20, 38, 23, 2, -37 },
  { 9416, 30, 70, 13, -9, -53 },
  { 9679, 27, 54, 27, -1, -37 },
  { 9862, 23, 52, 25, 0, -52 },
  { 10012, 14, 49, 11, 0, -49 },
  { 10098, 23, 66, 12, -9, -49 },
  { 10288, 24, 52, 21, 0, -52 },
  { 10444, 14, 52, 11, 0, -52 },
  { 10535, 37, 37, 39, 0, -37 },
  { 10707, 23, 37, 25, 0, -37 },
  { 10814, 22, 38, 25, 2, -37 },
  { 10919, 28, 53, 26, -3, -37 },
  { 11105, 24, 53, 27, 2, -37 },
  { 11264, 20, 37, 17, 0, -37 },
  { 11357, 21, 38, 20, -1, -37 },
  { 11457, 14, 46, 13, 1, -45 },
  { 11538, 23, 37, 25, 2, -36 },
  { 11645, 19, 36, 20, 4, -36 },
  { 11731, 32, 36, 33, 4, -36 },
  { 11875, 26, 36, 20, -3, -36 },
  { 11992, 32, 53, 21, -8, -36 },
  { 12204, 21, 36, 17, -2, -36 },
  { 12299, 24, 60, 22, 2, -49 },
  { 12479, 2, 70, 24, 11, -53 },
  { 12497, 23, 60, 22, -4, -49 },
  { 12670, 24, 7, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC69PT7B_H_
