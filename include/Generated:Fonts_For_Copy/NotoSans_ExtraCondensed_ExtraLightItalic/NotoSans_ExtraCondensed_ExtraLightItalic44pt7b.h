#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x0C,
  0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0xCC, 0x62, 0x18,
  0x86, 0x61, 0x18, 0x44, 0x31, 0x0C, 0x42, 0x30, 0x8C, 0x20, 0x00, 0x20,
  0x80, 0x30, 0xC0, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x04, 0x10, 0x02,
  0x08, 0x03, 0x0C, 0x01, 0x86, 0x0F, 0xFF, 0xC0, 0xC3, 0x00, 0x61, 0x80,
  0x20, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x08, 0x20, 0x04, 0x10, 0x06, 0x18,
  0x02, 0x08, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x82, 0x00, 0x41, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x30, 0x04, 0x10, 0x02,
  0x08, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x7C,
  0x03, 0xFF, 0x06, 0x21, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x60, 0x08, 0x40,
  0x08, 0x40, 0x08, 0x40, 0x0C, 0x40, 0x0C, 0xC0, 0x06, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0x60, 0x01, 0x30, 0x01, 0x10,
  0x03, 0x18, 0x02, 0x18, 0x02, 0x18, 0x02, 0x18, 0x02, 0x10, 0x06, 0x30,
  0x84, 0x20, 0xE5, 0xE0, 0x7F, 0x80, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x07, 0x00, 0x20, 0xF8, 0x04, 0x18, 0xC0, 0xC1,
  0x0C, 0x08, 0x30, 0xC1, 0x82, 0x0C, 0x10, 0x60, 0xC3, 0x06, 0x0C, 0x20,
  0x40, 0x86, 0x04, 0x08, 0x40, 0xC0, 0x8C, 0x0C, 0x18, 0x80, 0xC1, 0x98,
  0x0C, 0x11, 0x1E, 0xC3, 0x33, 0x3C, 0x32, 0x63, 0xC2, 0x64, 0x3C, 0x64,
  0xC3, 0x7C, 0xC8, 0x33, 0x08, 0x83, 0x01, 0x98, 0x30, 0x11, 0x83, 0x03,
  0x10, 0x20, 0x21, 0x02, 0x06, 0x30, 0x60, 0x43, 0x06, 0x0C, 0x30, 0x40,
  0x83, 0x0C, 0x18, 0x30, 0xC1, 0x03, 0x18, 0x30, 0x11, 0x06, 0x01, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x07, 0xE0, 0x31, 0x80, 0xC2, 0x02, 0x08,
  0x18, 0x20, 0x61, 0x81, 0x86, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x01, 0x98,
  0x06, 0x40, 0x0B, 0x00, 0x38, 0x01, 0xC0, 0x0D, 0x00, 0x64, 0x01, 0x18,
  0x4C, 0x63, 0x60, 0x8D, 0x02, 0x2C, 0x0C, 0xB0, 0x36, 0x80, 0x52, 0x01,
  0xC8, 0x06, 0x20, 0x18, 0x80, 0xE3, 0x06, 0xCE, 0x33, 0x1F, 0x84, 0x33,
  0x22, 0x66, 0x44, 0x44, 0xC0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x02,
  0x00, 0x40, 0x08, 0x63, 0x03, 0x42, 0x3F, 0xC3, 0x00, 0xD0, 0x33, 0x1C,
  0x21, 0x06, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x31,
  0x86, 0x10, 0xC2, 0x18, 0x43, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x07, 0xE0,
  0x30, 0xC1, 0x83, 0x06, 0x04, 0x30, 0x10, 0x80, 0x46, 0x01, 0x18, 0x04,
  0x40, 0x13, 0x00, 0x4C, 0x03, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03,
  0x60, 0x09, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x03,
  0x30, 0x0C, 0xC0, 0x63, 0x01, 0x8C, 0x04, 0x30, 0x30, 0xC0, 0x83, 0x06,
  0x06, 0x30, 0x0F, 0x80, 0x07, 0x0F, 0x1A, 0x32, 0xE6, 0x86, 0x06, 0x04,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x00,
  0x3C, 0x00, 0x3F, 0xC0, 0x18, 0x38, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0xC0, 0xC0, 0x40, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x03, 0x07, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xA0, 0x00, 0xB0, 0x00, 0xD8, 0x00, 0x48, 0x00, 0x64,
  0x00, 0x66, 0x00, 0x23, 0x00, 0x31, 0x80, 0x10, 0x80, 0x18, 0x40, 0x18,
  0x60, 0x08, 0x30, 0x0C, 0x18, 0x04, 0x08, 0x06, 0x0C, 0x06, 0x06, 0x02,
  0x03, 0x03, 0x01, 0x01, 0x00, 0x81, 0x80, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x01, 0xFF, 0x80, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xBC, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x06, 0x0E, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0xFE, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x27,
  0xE0, 0x6C, 0x70, 0x78, 0x30, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x10, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0x40, 0xC0, 0x61, 0x80, 0x3F,
  0x00, 0x3F, 0xFE, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x60, 0xC0, 0x60, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x81, 0x80, 0xC0,
  0x40, 0xC0, 0x30, 0x40, 0x08, 0xC0, 0x06, 0xC0, 0x01, 0xC0, 0x03, 0xE0,
  0x03, 0x18, 0x07, 0x04, 0x03, 0x03, 0x03, 0x00, 0x83, 0x00, 0x61, 0x80,
  0x30, 0x80, 0x18, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x08, 0x01, 0x86,
  0x01, 0x83, 0x01, 0xC0, 0xE1, 0xC0, 0x3F, 0x80, 0x00, 0xF0, 0x03, 0xF8,
  0x0C, 0x30, 0x30, 0x30, 0xC0, 0x61, 0x80, 0x42, 0x00, 0x8C, 0x01, 0x18,
  0x02, 0x20, 0x04, 0x40, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03,
  0x98, 0x07, 0x18, 0x1C, 0x30, 0x78, 0x3F, 0xB0, 0x3C, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x21, 0xC0, 0x7E, 0x00, 0x06, 0x1C, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x1C, 0x30, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x10, 0x08,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x07, 0x81, 0xFE, 0x10, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x18,
  0x01, 0x00, 0x60, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x20, 0x80,
  0x01, 0x0C, 0x00, 0x08, 0x40, 0x70, 0x46, 0x0F, 0xC2, 0x20, 0xC6, 0x13,
  0x04, 0x30, 0x98, 0x61, 0x04, 0x82, 0x08, 0x2C, 0x30, 0xC3, 0x61, 0x06,
  0x1A, 0x18, 0x20, 0x90, 0xC1, 0x04, 0x86, 0x18, 0x6C, 0x20, 0xC3, 0x61,
  0x04, 0x13, 0x08, 0x61, 0x98, 0x43, 0x08, 0xC2, 0x28, 0xC6, 0x1B, 0x6C,
  0x30, 0x71, 0xC1, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x50, 0x01,
  0xA0, 0x02, 0x40, 0x04, 0x80, 0x19, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x18,
  0x06, 0x30, 0x0C, 0x60, 0x10, 0xC0, 0x61, 0x80, 0x83, 0x03, 0x06, 0x06,
  0x0C, 0x0F, 0xF8, 0x3F, 0xF0, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x84, 0x03,
  0x18, 0x06, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x36, 0x00, 0x6C, 0x00, 0xD0,
  0x01, 0xE0, 0x03, 0x01, 0xFE, 0x01, 0x83, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x20, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x82, 0x00,
  0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xE0, 0x41, 0xC0, 0x3F, 0x80, 0x30,
  0x70, 0x18, 0x0C, 0x0C, 0x06, 0x04, 0x01, 0x02, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x18, 0x40, 0x08, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x06,
  0x0C, 0x03, 0x04, 0x07, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0xC0, 0x60, 0x40, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC1, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xC3, 0xC0, 0x30, 0x30,
  0x0C, 0x06, 0x02, 0x01, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC1, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00,
  0x20, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x10,
  0x40, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x80, 0x18, 0x60,
  0x0C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x01, 0xC0, 0x40, 0xE0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x81, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x3F, 0xE0, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x07, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x3F, 0x18, 0x07, 0xE2, 0x00, 0x0C,
  0x40, 0x01, 0x88, 0x00, 0x21, 0x00, 0x04, 0x20, 0x01, 0x84, 0x00, 0x30,
  0x80, 0x06, 0x18, 0x00, 0x83, 0x00, 0x10, 0x60, 0x06, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x0E, 0x06, 0x00, 0xFF, 0xC0, 0x01, 0x00, 0x10, 0x30, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x20, 0x60, 0x02, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x08, 0x0F, 0xFF, 0x81, 0x80, 0x18, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x04, 0x00, 0x40, 0x40, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x00, 0x01, 0xFC, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x20, 0x0F, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x60, 0x18, 0x0C, 0x06,
  0x01, 0x81, 0x80, 0x20, 0x20, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0,
  0x04, 0x18, 0x00, 0x86, 0x00, 0x31, 0x80, 0x06, 0x60, 0x00, 0xCC, 0x00,
  0x13, 0x00, 0x02, 0xE0, 0x00, 0xD4, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00,
  0x43, 0x00, 0x08, 0x60, 0x03, 0x04, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01,
  0x03, 0x00, 0x60, 0x20, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x01, 0x80, 0x20, 0x30, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x3F, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0x40, 0x00, 0xA0,
  0x28, 0x00, 0x3C, 0x0D, 0x00, 0x05, 0x81, 0xA0, 0x01, 0xB0, 0x34, 0x00,
  0x24, 0x04, 0xC0, 0x0C, 0x80, 0x98, 0x01, 0x30, 0x33, 0x00, 0x66, 0x06,
  0x60, 0x0C, 0xC0, 0xCC, 0x03, 0x10, 0x11, 0x80, 0x66, 0x02, 0x30, 0x18,
  0xC0, 0xC6, 0x03, 0x18, 0x18, 0xC0, 0xC2, 0x03, 0x18, 0x18, 0x40, 0x43,
  0x02, 0x18, 0x08, 0x20, 0xC3, 0x03, 0x04, 0x10, 0x60, 0x60, 0x86, 0x08,
  0x08, 0x10, 0x81, 0x01, 0x02, 0x30, 0x60, 0x60, 0x44, 0x0C, 0x0C, 0x09,
  0x81, 0x81, 0x81, 0x20, 0x20, 0x20, 0x3C, 0x0C, 0x04, 0x07, 0x01, 0x81,
  0x80, 0xE0, 0x30, 0x30, 0x1C, 0x04, 0x00, 0x01, 0x80, 0x08, 0x1C, 0x00,
  0xC0, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x2C, 0x01, 0x03, 0x60, 0x08, 0x1B,
  0x00, 0xC0, 0xC8, 0x06, 0x04, 0x40, 0x30, 0x23, 0x01, 0x03, 0x18, 0x18,
  0x18, 0xC0, 0xC0, 0xC2, 0x06, 0x04, 0x10, 0x20, 0x20, 0x81, 0x03, 0x06,
  0x18, 0x18, 0x30, 0xC0, 0xC1, 0x86, 0x04, 0x04, 0x20, 0x20, 0x21, 0x03,
  0x01, 0x98, 0x18, 0x0C, 0xC0, 0xC0, 0x66, 0x04, 0x03, 0x20, 0x60, 0x09,
  0x03, 0x00, 0x58, 0x18, 0x03, 0xC0, 0x80, 0x1C, 0x04, 0x00, 0xE0, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x1C, 0x18,
  0x0C, 0x02, 0x02, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00,
  0x32, 0x00, 0x0D, 0x80, 0x02, 0x60, 0x00, 0x98, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x06, 0x40, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x08, 0x40,
  0x06, 0x10, 0x01, 0x84, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x18, 0x08, 0x0C,
  0x03, 0x8E, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x01, 0x87, 0x00, 0xC0, 0xC0,
  0x60, 0x60, 0x20, 0x10, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01,
  0x02, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x40, 0x30, 0x20,
  0x30, 0x30, 0x70, 0x1F, 0xF0, 0x0F, 0xC0, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xC0, 0x1C, 0x18, 0x0C, 0x02, 0x02, 0x00, 0xC1, 0x80,
  0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x00, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x40, 0x01, 0x10, 0x00,
  0xC4, 0x00, 0x33, 0x00, 0x08, 0x40, 0x06, 0x10, 0x01, 0x84, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x18, 0x08, 0x0C, 0x03, 0x8E, 0x00, 0x7F, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x01, 0x87, 0x00, 0xC0, 0xC0,
  0x60, 0x60, 0x20, 0x10, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x02, 0x06, 0x01,
  0x02, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x40, 0x20, 0x20,
  0x70, 0x30, 0xF0, 0x1F, 0xE0, 0x0C, 0x60, 0x04, 0x30, 0x02, 0x08, 0x03,
  0x04, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x08, 0x06, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00, 0x40, 0x00,
  0x3E, 0x00, 0x3F, 0xF0, 0x38, 0x08, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x20, 0x0C, 0x0C, 0x0E, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x01, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x20, 0x60,
  0x04, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x00,
  0x10, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x02, 0x04, 0x00,
  0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x03,
  0x02, 0x00, 0x60, 0xC0, 0x08, 0x18, 0x03, 0x03, 0x00, 0x60, 0x20, 0x18,
  0x06, 0x03, 0x00, 0x61, 0xC0, 0x07, 0xF0, 0x00, 0x80, 0x07, 0x00, 0x0A,
  0x00, 0x34, 0x00, 0x68, 0x01, 0x90, 0x03, 0x20, 0x0C, 0x40, 0x18, 0x80,
  0x21, 0x00, 0xC2, 0x01, 0x84, 0x06, 0x08, 0x0C, 0x10, 0x10, 0x20, 0x60,
  0x40, 0x80, 0x83, 0x01, 0x06, 0x02, 0x18, 0x04, 0x30, 0x08, 0x40, 0x11,
  0x80, 0x22, 0x00, 0x4C, 0x00, 0x98, 0x01, 0x60, 0x02, 0xC0, 0x05, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x40, 0x06, 0x00, 0x68, 0x01,
  0xC0, 0x09, 0x00, 0x38, 0x03, 0x20, 0x07, 0x00, 0x44, 0x01, 0xE0, 0x18,
  0x80, 0x2C, 0x03, 0x10, 0x0D, 0x80, 0x42, 0x01, 0xA0, 0x18, 0x40, 0x24,
  0x02, 0x08, 0x0C, 0x80, 0xC1, 0x01, 0x10, 0x18, 0x20, 0x62, 0x02, 0x04,
  0x0C, 0x40, 0xC1, 0x81, 0x08, 0x10, 0x30, 0x61, 0x06, 0x06, 0x08, 0x20,
  0xC0, 0xC3, 0x04, 0x10, 0x18, 0x60, 0x86, 0x03, 0x08, 0x10, 0x80, 0x63,
  0x02, 0x30, 0x0C, 0x60, 0x46, 0x01, 0x88, 0x08, 0x80, 0x33, 0x01, 0x30,
  0x06, 0x40, 0x64, 0x00, 0xD8, 0x0D, 0x80, 0x1B, 0x01, 0xB0, 0x03, 0x40,
  0x34, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0xC0, 0x40,
  0x04, 0x0C, 0x00, 0x40, 0x80, 0x04, 0x18, 0x00, 0x41, 0x00, 0x06, 0x30,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0D,
  0x00, 0x00, 0x90, 0x00, 0x19, 0x00, 0x03, 0x10, 0x00, 0x31, 0x00, 0x06,
  0x18, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18, 0x03,
  0x01, 0x80, 0x30, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x00, 0x40, 0x0D,
  0x00, 0x66, 0x01, 0x98, 0x0C, 0x60, 0x21, 0x81, 0x86, 0x04, 0x18, 0x30,
  0x60, 0x80, 0x86, 0x02, 0x10, 0x08, 0xC0, 0x22, 0x00, 0x98, 0x03, 0x40,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x82, 0x08, 0x30, 0xC3, 0x04,
  0x10, 0x41, 0x06, 0x18, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0x41,
  0x04, 0x18, 0x61, 0x86, 0x08, 0x20, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0xFF, 0x00, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x60, 0x03, 0x60, 0x02, 0x30, 0x06, 0x30, 0x04,
  0x10, 0x0C, 0x18, 0x18, 0x08, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x60,
  0x06, 0x60, 0x02, 0xC0, 0x03, 0xFF, 0xE0, 0xC2, 0x18, 0x43, 0x08, 0x60,
  0x00, 0xE0, 0x03, 0xF3, 0x06, 0x1A, 0x0C, 0x0A, 0x0C, 0x0E, 0x18, 0x06,
  0x10, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x08,
  0x40, 0x08, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0x60, 0xA0, 0x71, 0x20, 0x3E, 0x20,
  0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x38, 0x06, 0xFC, 0x05, 0x86,
  0x07, 0x06, 0x0E, 0x02, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03,
  0x18, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x04, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x50, 0x30,
  0x50, 0x20, 0x58, 0xE0, 0xCF, 0x80, 0x00, 0x68, 0x1F, 0x81, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0xC2, 0x07, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x30, 0xC0, 0x3F, 0x30, 0x18, 0x68,
  0x0C, 0x0A, 0x02, 0x03, 0x81, 0x80, 0x60, 0x40, 0x30, 0x30, 0x0C, 0x0C,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08, 0x10, 0x02, 0x04, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x04, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x70, 0x30, 0x1C, 0x06, 0x0A, 0x01, 0x84, 0x80, 0x3E, 0x60, 0x00,
  0x00, 0xC0, 0x1F, 0x81, 0x86, 0x18, 0x31, 0x81, 0x8C, 0x0C, 0xC0, 0x66,
  0x03, 0x20, 0x33, 0x03, 0x18, 0x30, 0x9F, 0x07, 0xE0, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0xC3, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0x30, 0x18, 0x68, 0x0C, 0x0A, 0x02, 0x03, 0x81, 0x80, 0x60, 0x40, 0x30,
  0x30, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08, 0x10,
  0x02, 0x04, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x70, 0x30, 0x1C, 0x06, 0x0A, 0x01, 0x84, 0x80,
  0x3E, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0xC1, 0xC0, 0x3F, 0xC0,
  0x00, 0x80, 0x00, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x70, 0x1B, 0xF0,
  0x2C, 0x30, 0x70, 0x61, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x10,
  0x08, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC2, 0x01, 0x0C, 0x02, 0x18, 0x0C,
  0x30, 0x18, 0x40, 0x30, 0x80, 0x43, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x10,
  0x0C, 0x20, 0x10, 0xC0, 0x60, 0x01, 0x01, 0xC0, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x02, 0x01, 0x01, 0x80, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x01, 0xF0, 0x01,
  0x00, 0x00, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x18, 0x20,
  0x60, 0x41, 0x81, 0x82, 0x03, 0x0C, 0x06, 0x30, 0x08, 0xC0, 0x31, 0x00,
  0x66, 0x00, 0xDC, 0x01, 0x78, 0x02, 0xB0, 0x0E, 0x60, 0x1C, 0x40, 0x30,
  0x80, 0x41, 0x80, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x08, 0x10, 0x10,
  0x60, 0x30, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x09, 0xF9, 0xF8,
  0x14, 0x36, 0x18, 0x30, 0x38, 0x30, 0xE0, 0x60, 0x21, 0x80, 0xC0, 0x43,
  0x01, 0x01, 0x84, 0x02, 0x03, 0x18, 0x0C, 0x06, 0x30, 0x18, 0x08, 0x60,
  0x30, 0x10, 0x80, 0x40, 0x61, 0x01, 0x80, 0xC6, 0x03, 0x01, 0x8C, 0x06,
  0x02, 0x18, 0x08, 0x04, 0x20, 0x10, 0x18, 0x40, 0x60, 0x31, 0x80, 0xC0,
  0x43, 0x01, 0x80, 0x86, 0x02, 0x03, 0x08, 0x0C, 0x06, 0x10, 0x18, 0x0C,
  0x60, 0x30, 0x10, 0x00, 0x30, 0x09, 0xF8, 0x16, 0x18, 0x30, 0x30, 0xE0,
  0x61, 0x80, 0xC3, 0x01, 0x86, 0x02, 0x18, 0x04, 0x30, 0x18, 0x60, 0x30,
  0x80, 0x61, 0x00, 0x86, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x20, 0x18, 0x40,
  0x21, 0x80, 0x43, 0x01, 0x86, 0x03, 0x08, 0x06, 0x10, 0x08, 0x60, 0x30,
  0x00, 0xE0, 0x0F, 0xC0, 0x61, 0x83, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x00,
  0xCC, 0x03, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x03, 0x40, 0x09, 0x00,
  0x2C, 0x01, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0xCC, 0x03, 0x30, 0x18, 0xC0,
  0x61, 0x83, 0x07, 0x18, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x4F, 0xC0, 0x16,
  0x18, 0x05, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x0C, 0x03,
  0x02, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08, 0x18, 0x02, 0x04, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x18, 0x30, 0x04, 0x0C, 0x03, 0x02, 0x00, 0xC1, 0x80,
  0x60, 0x60, 0x18, 0x1C, 0x0C, 0x05, 0x07, 0x01, 0x63, 0x80, 0xCF, 0x80,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x03, 0xF3, 0x06, 0x1A, 0x0C, 0x0A, 0x08, 0x0E, 0x18, 0x0E, 0x10,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0x40,
  0x08, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x70, 0xC0, 0x70, 0x60, 0xA0, 0x61, 0x60, 0x3E, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x38, 0x27, 0x81, 0x60,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x0F, 0xF0, 0x60, 0x83, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x0C, 0x18, 0x3F, 0xC0, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x3F, 0x08,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0xF8, 0x0C, 0x06, 0x10,
  0x08, 0x60, 0x10, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x84, 0x02, 0x18, 0x04,
  0x30, 0x18, 0x60, 0x30, 0x80, 0x61, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x18,
  0x0C, 0x20, 0x10, 0x40, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x07, 0x0C, 0x1C,
  0x1C, 0x68, 0x1F, 0x90, 0x00, 0x80, 0x38, 0x06, 0x80, 0x68, 0x0C, 0x80,
  0xC8, 0x08, 0x81, 0x88, 0x10, 0x83, 0x08, 0x20, 0x86, 0x08, 0x60, 0x8C,
  0x08, 0xC0, 0x88, 0x09, 0x80, 0x90, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x00, 0x80, 0x60, 0x38, 0x06, 0x02, 0x80, 0xA0, 0x68,
  0x0A, 0x06, 0x81, 0xE0, 0x48, 0x16, 0x0C, 0x81, 0x60, 0x88, 0x36, 0x18,
  0x82, 0x61, 0x88, 0x66, 0x10, 0x84, 0x63, 0x08, 0xC6, 0x20, 0x8C, 0x66,
  0x08, 0x86, 0x60, 0x98, 0x64, 0x09, 0x06, 0xC0, 0xB0, 0x68, 0x0B, 0x06,
  0x80, 0xA0, 0x78, 0x0E, 0x05, 0x00, 0xC0, 0x70, 0x0C, 0x06, 0x00, 0xC0,
  0x60, 0x00, 0x06, 0x03, 0x81, 0x01, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30,
  0xC0, 0x08, 0xC0, 0x04, 0x40, 0x02, 0x60, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x19, 0x00, 0x08, 0x80,
  0x0C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x06, 0x04, 0x02, 0x02, 0x03, 0x01,
  0x83, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x08, 0x01,
  0x80, 0xC0, 0x0C, 0x04, 0x00, 0x20, 0x60, 0x01, 0x03, 0x00, 0x08, 0x30,
  0x00, 0x41, 0x80, 0x02, 0x08, 0x00, 0x10, 0xC0, 0x00, 0x84, 0x00, 0x04,
  0x60, 0x00, 0x22, 0x00, 0x01, 0x30, 0x00, 0x09, 0x80, 0x00, 0x48, 0x00,
  0x02, 0xC0, 0x00, 0x14, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x38,
  0x01, 0xF0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70, 0x0F, 0xC0, 0x1E, 0x00, 0x00,
  0x08, 0x00, 0x7F, 0x01, 0xC1, 0xC7, 0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 31, 9, 1, -31 },
  { 32, 10, 11, 12, 4, -31 },
  { 46, 17, 31, 17, 0, -31 },
  { 112, 16, 36, 15, 0, -33 },
  { 184, 20, 33, 24, 2, -32 },
  { 267, 14, 32, 15, 0, -32 },
  { 323, 4, 11, 7, 4, -31 },
  { 329, 12, 38, 11, 1, -31 },
  { 386, 12, 38, 11, -3, -31 },
  { 443, 11, 12, 14, 5, -33 },
  { 460, 16, 21, 18, 1, -26 },
  { 502, 6, 10, 7, -2, -4 },
  { 510, 9, 2, 11, 1, -13 },
  { 513, 2, 3, 7, 1, -3 },
  { 514, 18, 31, 13, -2, -31 },
  { 584, 14, 32, 16, 1, -32 },
  { 640, 8, 31, 16, 5, -31 },
  { 671, 18, 32, 16, -2, -32 },
  { 743, 17, 32, 16, -1, -32 },
  { 811, 17, 32, 16, -1, -32 },
  { 879, 17, 31, 16, -1, -31 },
  { 945, 16, 32, 16, 1, -32 },
  { 1009, 15, 31, 16, 2, -31 },
  { 1068, 17, 32, 16, -1, -32 },
  { 1136, 15, 32, 16, 0, -32 },
  { 1196, 7, 23, 7, 0, -23 },
  { 1217, 9, 29, 7, -2, -23 },
  { 1250, 16, 19, 18, 1, -25 },
  { 1288, 16, 11, 18, 1, -21 },
  { 1310, 16, 19, 18, 1, -25 },
  { 1348, 12, 32, 11, 1, -32 },
  { 1396, 21, 36, 23, 1, -32 },
  { 1491, 15, 32, 15, -3, -32 },
  { 1551, 17, 31, 17, 0, -31 },
  { 1617, 17, 32, 15, 2, -32 },
  { 1685, 18, 31, 19, 0, -31 },
  { 1755, 17, 31, 15, 0, -31 },
  { 1821, 17, 31, 14, 0, -31 },
  { 1887, 19, 32, 20, 2, -32 },
  { 1963, 20, 31, 20, 0, -31 },
  { 2041, 14, 31, 8, -3, -31 },
  { 2096, 14, 39, 7, -6, -31 },
  { 2165, 19, 31, 16, 0, -31 },
  { 2239, 10, 31, 14, 0, -31 },
  { 2278, 27, 31, 26, 0, -31 },
  { 2383, 21, 31, 21, 0, -31 },
  { 2465, 18, 32, 20, 1, -32 },
  { 2537, 17, 31, 16, 0, -31 },
  { 2603, 18, 40, 20, 1, -32 },
  { 2693, 17, 31, 16, 0, -31 },
  { 2759, 18, 32, 15, -1, -32 },
  { 2831, 14, 31, 13, 3, -31 },
  { 2886, 19, 31, 19, 1, -31 },
  { 2960, 15, 31, 16, 4, -31 },
  { 3019, 27, 31, 27, 3, -31 },
  { 3124, 20, 31, 14, -3, -31 },
  { 3202, 14, 31, 13, 3, -31 },
  { 3257, 18, 31, 14, -2, -31 },
  { 3327, 16, 38, 12, -1, -31 },
  { 3403, 6, 31, 14, 5, -31 },
  { 3427, 16, 38, 12, -3, -31 },
  { 3503, 16, 15, 17, 1, -31 },
  { 3533, 11, 1, 12, -3, 4 },
  { 3535, 5, 7, 9, 6, -34 },
  { 3540, 16, 24, 17, 1, -24 },
  { 3588, 16, 33, 17, 0, -33 },
  { 3654, 13, 24, 12, 1, -24 },
  { 3693, 18, 33, 17, 1, -33 },
  { 3768, 13, 24, 15, 1, -24 },
  { 3807, 20, 45, 8, -6, -34 },
  { 3920, 18, 35, 17, -1, -24 },
  { 3999, 15, 33, 16, 0, -33 },
  { 4061, 9, 32, 7, 0, -32 },
  { 4097, 15, 43, 7, -6, -32 },
  { 4178, 15, 33, 14, 0, -33 },
  { 4240, 9, 33, 7, 0, -33 },
  { 4278, 23, 24, 25, 0, -24 },
  { 4347, 15, 24, 16, 0, -24 },
  { 4392, 14, 24, 16, 1, -24 },
  { 4434, 18, 34, 17, -2, -24 },
  { 4511, 16, 34, 17, 1, -24 },
  { 4579, 13, 24, 11, 0, -24 },
  { 4618, 14, 24, 12, -1, -24 },
  { 4660, 8, 29, 8, 1, -29 },
  { 4689, 15, 23, 16, 1, -23 },
  { 4733, 12, 23, 13, 3, -23 },
  { 4768, 20, 23, 21, 3, -23 },
  { 4826, 17, 23, 13, -2, -23 },
  { 4875, 21, 34, 13, -5, -23 },
  { 4965, 14, 23, 11, -2, -23 },
  { 5006, 16, 38, 14, 1, -31 },
  { 5082, 1, 45, 15, 7, -34 },
  { 5088, 15, 38, 14, -3, -31 },
  { 5160, 16, 4, 18, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC44PT7B_H_
