#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x31, 0x86, 0x38, 0x63,
  0x06, 0x30, 0x63, 0x04, 0x30, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60, 0x84,
  0x18, 0x41, 0x8C, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x04, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00,
  0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x03, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x81, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x03,
  0x06, 0x00, 0x08, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x20, 0x00, 0xC1,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x10, 0x00, 0x60, 0xC0, 0x01, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x18, 0x43,
  0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0x60, 0x80, 0x06, 0x08,
  0x00, 0x41, 0x80, 0x06, 0x18, 0x00, 0x61, 0x00, 0x06, 0x10, 0x00, 0x73,
  0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x5C, 0x00, 0x04, 0xC0, 0x00, 0x46, 0x00,
  0x0C, 0x60, 0x00, 0xC3, 0x00, 0x08, 0x30, 0x00, 0x83, 0x00, 0x08, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x06, 0x00, 0x10, 0x60, 0x83, 0x0C,
  0x0C, 0x33, 0x80, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x02,
  0x07, 0xE0, 0x04, 0x0C, 0x60, 0x0C, 0x18, 0x30, 0x08, 0x18, 0x30, 0x18,
  0x30, 0x30, 0x10, 0x30, 0x30, 0x30, 0x20, 0x30, 0x20, 0x60, 0x30, 0x60,
  0x60, 0x20, 0x40, 0x60, 0x60, 0xC0, 0xC0, 0x60, 0x80, 0xC0, 0x61, 0x80,
  0xC0, 0x61, 0x00, 0xC0, 0x63, 0x00, 0xC0, 0xC2, 0x00, 0xC0, 0xC6, 0x1E,
  0x80, 0xC4, 0x3F, 0x81, 0x8C, 0x63, 0x81, 0x88, 0xC3, 0x83, 0x19, 0x81,
  0xC3, 0x11, 0x81, 0xC6, 0x31, 0x81, 0x7C, 0x23, 0x03, 0x38, 0x63, 0x03,
  0x00, 0x43, 0x03, 0x00, 0xC6, 0x03, 0x00, 0x86, 0x03, 0x01, 0x86, 0x03,
  0x01, 0x06, 0x02, 0x03, 0x04, 0x06, 0x02, 0x0C, 0x06, 0x06, 0x0C, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x0C, 0x0C, 0x18, 0x0C, 0x18,
  0x10, 0x04, 0x30, 0x30, 0x06, 0x70, 0x60, 0x07, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x07, 0xF0, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0C,
  0x01, 0x81, 0x80, 0x30, 0x70, 0x06, 0x0C, 0x01, 0xC1, 0x80, 0x30, 0x30,
  0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x60, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x06, 0xC0, 0x01, 0x8C, 0x00, 0x61, 0x83, 0x1C, 0x30, 0x63,
  0x06, 0x18, 0xC0, 0x63, 0x18, 0x0C, 0x66, 0x01, 0x98, 0xC0, 0x1B, 0x18,
  0x03, 0xC3, 0x00, 0x78, 0xE0, 0x0E, 0x18, 0x00, 0xC3, 0x80, 0x38, 0x30,
  0x0F, 0x06, 0x01, 0xB0, 0xE0, 0x66, 0x0E, 0x38, 0xC0, 0xFE, 0x18, 0x02,
  0x00, 0x00, 0x18, 0xCE, 0x63, 0x18, 0xC4, 0x63, 0x18, 0x84, 0x60, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x41, 0x83, 0xC4, 0x03, 0x90, 0xC3, 0xFF, 0x03, 0x80, 0x1E, 0x00, 0xC8,
  0x06, 0x30, 0x30, 0x41, 0x81, 0x80, 0x03, 0x00, 0x08, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x1C, 0x30,
  0x61, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x0E,
  0x38, 0x03, 0x07, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x63, 0x00,
  0x18, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0C,
  0x60, 0x03, 0x38, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03,
  0x83, 0x00, 0xC0, 0x60, 0x60, 0x18, 0x38, 0x03, 0xBC, 0x00, 0xFE, 0x00,
  0x04, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x39, 0x9C, 0x6E, 0x19,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x3C, 0x1C,
  0x00, 0x80, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x78, 0x38, 0x03, 0x00, 0xE0,
  0x10, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x40, 0x1C, 0x03, 0xC3, 0xC0, 0x1F, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x31, 0x80, 0x03, 0x0C, 0x00,
  0x18, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0xC0, 0x0C, 0x06, 0x00, 0x60, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x08, 0x03, 0x80, 0x70,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x38, 0x20, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0xF8, 0x03, 0x3F, 0xC0, 0x36, 0x0E, 0x03, 0xC0, 0x70, 0x78, 0x03, 0x07,
  0x00, 0x30, 0x70, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xE0, 0x0C, 0x06, 0x01,
  0xC0, 0x60, 0x18, 0x07, 0x03, 0x00, 0x3D, 0xE0, 0x01, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x3C, 0x38,
  0x01, 0x80, 0x60, 0x18, 0x03, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x80, 0x30, 0x06, 0x03, 0x80, 0x30, 0x18, 0x00, 0xC3,
  0x80, 0x07, 0x38, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xC6, 0x00, 0x1C, 0x18, 0x01, 0x80, 0xE0, 0x18, 0x03, 0x01, 0x80, 0x1C,
  0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x80,
  0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x87, 0x00, 0x0C, 0x18, 0x00, 0xE0,
  0xC0, 0x06, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x78, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0x86, 0x00,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x60,
  0x07, 0x0C, 0x00, 0xE1, 0xC0, 0x3C, 0x18, 0x0D, 0x83, 0x87, 0x60, 0x3F,
  0xCC, 0x01, 0xE1, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x31, 0xE0,
  0x07, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x03, 0x01, 0xC1, 0xC0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x38,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x80,
  0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x38, 0x70,
  0x40, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x18, 0x18, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x86, 0x01,
  0xFC, 0x30, 0xC0, 0x73, 0x06, 0x10, 0x18, 0x60, 0xC6, 0x06, 0x0C, 0x18,
  0xC0, 0x81, 0x83, 0x10, 0x30, 0x60, 0x66, 0x0C, 0x0C, 0x08, 0xC1, 0x81,
  0x83, 0x18, 0x30, 0x30, 0x62, 0x0C, 0x0C, 0x0C, 0xC1, 0x81, 0x81, 0x98,
  0x30, 0x30, 0x23, 0x06, 0x06, 0x0C, 0x60, 0x81, 0x81, 0x8C, 0x30, 0x30,
  0x21, 0x06, 0x06, 0x0C, 0x20, 0xC1, 0xC1, 0x8C, 0x18, 0x38, 0x61, 0x83,
  0x0F, 0x0C, 0x30, 0x33, 0x63, 0x06, 0x07, 0xC7, 0xC0, 0xC0, 0x70, 0x60,
  0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0x00, 0x60, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18,
  0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x18, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x70, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x18, 0x01, 0x80, 0xC0, 0x1C, 0x06, 0x01, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x18, 0x3E, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x83, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x03, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0,
  0x0F, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x79, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x0C, 0x07, 0x00, 0x30, 0x0E, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0xC1,
  0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x70, 0x03,
  0x01, 0x80, 0x1C, 0x06, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x60, 0x78, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0x03, 0xE0, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x3F, 0x87, 0x00, 0x3F, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x18,
  0x03, 0x00, 0x1C, 0x01, 0xE0, 0x0C, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x11, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x01,
  0x80, 0x70, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0C, 0x00, 0x07,
  0x1C, 0x00, 0x06, 0x18, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x06,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0xF0, 0x00, 0x0F, 0x30, 0x00, 0x0E,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x30, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x6C, 0x00, 0x03, 0x60, 0x1B,
  0x00, 0x01, 0xF0, 0x06, 0xC0, 0x00, 0x6C, 0x01, 0xB0, 0x00, 0x3B, 0x00,
  0xCC, 0x00, 0x0C, 0xC0, 0x33, 0x00, 0x03, 0x70, 0x0C, 0xC0, 0x01, 0x98,
  0x03, 0x30, 0x00, 0x66, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x63, 0x00, 0x0C,
  0x60, 0x18, 0xC0, 0x06, 0x30, 0x06, 0x30, 0x01, 0x8C, 0x01, 0x8C, 0x00,
  0xC3, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x30,
  0x06, 0x18, 0x03, 0x04, 0x03, 0x06, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x60,
  0x60, 0x60, 0x60, 0x18, 0x18, 0x18, 0x18, 0x06, 0x06, 0x0C, 0x0C, 0x01,
  0x81, 0x83, 0x03, 0x00, 0x60, 0x61, 0xC0, 0xC0, 0x30, 0x18, 0x60, 0x30,
  0x0C, 0x06, 0x38, 0x1C, 0x03, 0x01, 0x8C, 0x06, 0x00, 0xC0, 0x63, 0x01,
  0x80, 0x60, 0x19, 0x80, 0x60, 0x18, 0x06, 0x60, 0x18, 0x06, 0x01, 0xB0,
  0x0C, 0x01, 0x80, 0x6C, 0x03, 0x00, 0x60, 0x1E, 0x00, 0xC0, 0x30, 0x07,
  0x80, 0x30, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x60, 0x1C,
  0x00, 0x18, 0x03, 0x80, 0x03, 0x00, 0x78, 0x00, 0x60, 0x1B, 0x00, 0x0C,
  0x03, 0x60, 0x01, 0x80, 0x6C, 0x00, 0x60, 0x0D, 0x80, 0x0C, 0x01, 0x98,
  0x01, 0x80, 0x63, 0x00, 0x30, 0x0C, 0x60, 0x0E, 0x01, 0x8C, 0x01, 0x80,
  0x31, 0x80, 0x30, 0x0E, 0x30, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x30, 0x60,
  0x30, 0x06, 0x0C, 0x06, 0x00, 0xC1, 0x80, 0xC0, 0x38, 0x30, 0x18, 0x06,
  0x03, 0x03, 0x00, 0xC0, 0x60, 0xC0, 0x18, 0x0C, 0x18, 0x03, 0x01, 0x83,
  0x00, 0xC0, 0x30, 0x60, 0x18, 0x06, 0x0C, 0x03, 0x00, 0x63, 0x00, 0x60,
  0x0C, 0x60, 0x0C, 0x01, 0x8C, 0x03, 0x00, 0x31, 0x80, 0x60, 0x06, 0x60,
  0x0C, 0x00, 0xCC, 0x01, 0x80, 0x0D, 0x80, 0x70, 0x01, 0xB0, 0x0C, 0x00,
  0x36, 0x01, 0x80, 0x07, 0x80, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x60,
  0x30, 0x01, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x1D, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0E,
  0x01, 0xC0, 0x70, 0x03, 0xCF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x30, 0x38, 0x01, 0x80, 0xE0, 0x1C,
  0x03, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x30, 0x03, 0x01, 0x80, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80,
  0x18, 0x18, 0x01, 0xC0, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x03,
  0x80, 0x60, 0x18, 0x0E, 0x00, 0xC7, 0xE0, 0x07, 0xFC, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x60,
  0x30, 0x01, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x1D, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x0E,
  0x01, 0xC0, 0x70, 0x03, 0xCF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x30, 0x38, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xE0, 0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01,
  0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x18, 0x18,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0xE0,
  0x18, 0x1E, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x30, 0xC0, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x01, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x01,
  0xE0, 0x78, 0x07, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x08, 0x01, 0xC0, 0x3F, 0x1F, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01,
  0x81, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38,
  0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x06,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x38, 0x07, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x0F, 0x9E, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0xF8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x07, 0x30,
  0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x01, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x0C, 0x01, 0x81,
  0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xD8, 0x00,
  0x70, 0x00, 0x66, 0x00, 0x1C, 0x00, 0x31, 0x80, 0x07, 0x00, 0x0C, 0x60,
  0x03, 0xC0, 0x07, 0x18, 0x00, 0xF0, 0x01, 0x86, 0x00, 0x2C, 0x00, 0x61,
  0x80, 0x1B, 0x00, 0x30, 0x60, 0x06, 0xC0, 0x0C, 0x10, 0x03, 0x30, 0x07,
  0x0C, 0x00, 0xCC, 0x01, 0x83, 0x00, 0x23, 0x00, 0x60, 0xC0, 0x18, 0xC0,
  0x30, 0x30, 0x06, 0x30, 0x0C, 0x0C, 0x03, 0x0C, 0x07, 0x03, 0x00, 0xC3,
  0x01, 0x80, 0xC0, 0x30, 0xC0, 0x60, 0x30, 0x18, 0x30, 0x30, 0x0C, 0x06,
  0x0C, 0x0C, 0x03, 0x03, 0x03, 0x07, 0x00, 0xC0, 0xC0, 0xC1, 0x80, 0x30,
  0x30, 0x20, 0x60, 0x0C, 0x18, 0x08, 0x30, 0x03, 0x06, 0x02, 0x0C, 0x00,
  0xC3, 0x00, 0x87, 0x00, 0x30, 0xC0, 0x61, 0x80, 0x0C, 0x30, 0x18, 0x60,
  0x03, 0x18, 0x06, 0x30, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x63,
  0x00, 0x0C, 0xC0, 0x19, 0x80, 0x03, 0x30, 0x06, 0x60, 0x00, 0xD8, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x1B, 0x00, 0x03, 0xC0,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x38, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x10, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x19, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x64, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x06, 0x00, 0x03, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x08, 0x0C,
  0x06, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x19, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x00,
  0x3F, 0xE0, 0x08, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x18, 0xE0, 0x01, 0x86, 0x00, 0x30,
  0x60, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x80, 0xC0, 0x18, 0x0C,
  0x01, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x06, 0x30, 0x00, 0x66,
  0x00, 0x07, 0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xF8, 0xC3, 0x86, 0x18,
  0x30, 0x41, 0x82, 0x0C, 0x00, 0x10, 0x00, 0x3F, 0x8C, 0x0F, 0x39, 0x83,
  0x81, 0x20, 0xE0, 0x3C, 0x18, 0x03, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x30,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0,
  0x06, 0x38, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x06, 0x00,
  0xE0, 0xC0, 0x1C, 0x18, 0x07, 0x83, 0x01, 0xB0, 0x70, 0x24, 0x07, 0xB9,
  0x80, 0x7E, 0x30, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x06, 0x00, 0x31, 0xF8, 0x03, 0x39, 0xC0, 0x36, 0x0E, 0x03, 0xC0,
  0x60, 0x78, 0x06, 0x07, 0x00, 0x60, 0x70, 0x07, 0x06, 0x00, 0x70, 0x60,
  0x07, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08,
  0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00, 0xC3,
  0x80, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x30,
  0x70, 0x03, 0x07, 0x80, 0x60, 0x78, 0x0E, 0x06, 0x81, 0xC0, 0x4E, 0x78,
  0x0C, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x03, 0xFC, 0x0F, 0x10,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x9C,
  0x07, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x10, 0x60, 0x07, 0xF1, 0x80, 0x3C, 0xE6, 0x01, 0xC0,
  0xF0, 0x0E, 0x03, 0xC0, 0x30, 0x07, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x60,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x0E, 0x03,
  0x00, 0x38, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x1C, 0x03, 0x00,
  0xF0, 0x0C, 0x06, 0x80, 0x38, 0x36, 0x00, 0x7B, 0x98, 0x00, 0xFC, 0x60,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x00, 0x79, 0xC0, 0x70,
  0x60, 0x70, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x38, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x8C, 0x01, 0x86, 0x01, 0xC3, 0x01, 0xC3, 0x83, 0xC1, 0xBF, 0x80,
  0xFF, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x02, 0x03, 0xC7, 0x00, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFE,
  0x30, 0x07, 0x9C, 0xC0, 0x38, 0x1A, 0x01, 0xC0, 0x78, 0x06, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60,
  0x03, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x18, 0x01, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x18, 0x06, 0x00,
  0xE0, 0x18, 0x03, 0x80, 0x60, 0x1E, 0x01, 0x80, 0xD0, 0x07, 0x06, 0xC0,
  0x0F, 0x7B, 0x00, 0x1F, 0x8C, 0x00, 0x10, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x80, 0x70, 0x03,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x60, 0x06, 0x7F, 0x00, 0xDC, 0x70, 0x1E, 0x06, 0x03, 0x80, 0x60, 0x70,
  0x0C, 0x1C, 0x01, 0x83, 0x80, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x80,
  0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x01, 0x80, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x01, 0xC0, 0xC0,
  0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xE0, 0x18, 0x18, 0x03, 0x06,
  0x00, 0x61, 0x80, 0x0C, 0x70, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0xE0,
  0x01, 0xBC, 0x00, 0x27, 0x80, 0x0D, 0xB0, 0x01, 0xE6, 0x00, 0x38, 0xC0,
  0x06, 0x0C, 0x01, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x00, 0x00, 0x04, 0x00, 0x80, 0x19, 0xFC, 0x3F, 0x80, 0xDC,
  0xF7, 0x1C, 0x07, 0x81, 0xB0, 0x30, 0x28, 0x0F, 0x01, 0x83, 0x80, 0x70,
  0x0C, 0x1C, 0x03, 0x80, 0x60, 0xC0, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x18,
  0x30, 0x06, 0x01, 0x83, 0x80, 0x70, 0x0C, 0x18, 0x03, 0x00, 0x60, 0xC0,
  0x18, 0x03, 0x06, 0x00, 0xC0, 0x18, 0x30, 0x06, 0x01, 0x83, 0x00, 0x60,
  0x0C, 0x18, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x18,
  0x70, 0x0E, 0x01, 0x83, 0x00, 0x60, 0x0C, 0x18, 0x03, 0x00, 0x60, 0xC0,
  0x18, 0x03, 0x06, 0x00, 0xC0, 0x18, 0x60, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0x0C, 0x18, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x30,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x67, 0xF0, 0x0D, 0xC7, 0x01,
  0xE0, 0x60, 0x28, 0x0E, 0x0F, 0x00, 0xC1, 0xC0, 0x38, 0x38, 0x06, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18,
  0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x60,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00,
  0xC1, 0x80, 0x18, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x1C, 0x70, 0x0E,
  0x0E, 0x07, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x67,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x31, 0x80,
  0x0C, 0x60, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x61, 0x80, 0x18, 0x60, 0x0C,
  0x18, 0x07, 0x06, 0x01, 0x81, 0xC0, 0xC0, 0x3C, 0xE0, 0x07, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x03, 0x1F, 0x80, 0x0C, 0xC7, 0x00, 0x36,
  0x0E, 0x00, 0xF0, 0x18, 0x06, 0x80, 0x60, 0x1C, 0x01, 0xC0, 0x70, 0x07,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x01, 0xC0, 0xC0, 0x06, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x70,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x70,
  0x06, 0x01, 0xE0, 0x38, 0x06, 0x81, 0xC0, 0x1B, 0x9E, 0x00, 0xC7, 0xF0,
  0x03, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0x8C, 0x0F, 0x39, 0x83, 0x81, 0xA0, 0xE0,
  0x3C, 0x18, 0x03, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x1C,
  0x18, 0x07, 0x83, 0x01, 0xB0, 0x70, 0x6C, 0x07, 0xBD, 0x80, 0x7E, 0x30,
  0x02, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x03, 0x3F,
  0x03, 0x7A, 0x03, 0xC0, 0x02, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0xFF,
  0x80, 0xF1, 0xE0, 0xE0, 0x20, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x10, 0x0E, 0x0F, 0x1E, 0x03, 0xFE, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x81,
  0xFF, 0x3F, 0xC0, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x90, 0x3E, 0x01, 0x00, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x60, 0x0C,
  0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x06, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x07, 0x07,
  0x00, 0xE0, 0xC0, 0x3C, 0x1C, 0x05, 0x01, 0x81, 0xE0, 0x38, 0xEC, 0x03,
  0xF9, 0x80, 0x08, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00,
  0x6C, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x31, 0x80, 0xC3,
  0x01, 0x86, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x61, 0xC0, 0xC3,
  0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x36, 0x00,
  0x6C, 0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x6C, 0x01, 0xC0, 0x1B, 0x00, 0x70,
  0x0C, 0xC0, 0x34, 0x03, 0x30, 0x0D, 0x00, 0xCC, 0x02, 0x40, 0x63, 0x01,
  0x90, 0x18, 0xC0, 0x64, 0x0C, 0x30, 0x31, 0x03, 0x0C, 0x0C, 0x40, 0xC3,
  0x02, 0x30, 0x60, 0xC1, 0x8C, 0x18, 0x30, 0x63, 0x0C, 0x0C, 0x30, 0xC3,
  0x03, 0x0C, 0x30, 0xC0, 0xC2, 0x0C, 0x60, 0x31, 0x83, 0x18, 0x0C, 0x60,
  0xC4, 0x03, 0x30, 0x33, 0x00, 0xCC, 0x0C, 0xC0, 0x32, 0x03, 0x60, 0x0D,
  0x80, 0xD8, 0x03, 0x60, 0x34, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x30, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0xC0,
  0x00, 0xCC, 0x00, 0x05, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0x73,
  0x00, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x38,
  0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x0C, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x08, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x02, 0x30, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x2F, 0xF0, 0x07, 0x87, 0x83, 0xC0,
  0x3F, 0xE8, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 39, 12, 1, -39 },
  { 55, 12, 14, 15, 5, -39 },
  { 76, 22, 39, 21, 0, -39 },
  { 184, 20, 45, 19, 0, -42 },
  { 297, 24, 41, 30, 3, -40 },
  { 420, 19, 41, 19, -1, -40 },
  { 518, 5, 14, 8, 5, -39 },
  { 527, 16, 48, 13, 1, -39 },
  { 623, 15, 48, 13, -4, -39 },
  { 713, 14, 16, 18, 6, -42 },
  { 741, 19, 25, 22, 2, -32 },
  { 801, 7, 12, 9, -2, -5 },
  { 812, 12, 2, 14, 1, -16 },
  { 815, 3, 4, 9, 1, -4 },
  { 817, 23, 39, 17, -3, -39 },
  { 930, 18, 41, 19, 1, -40 },
  { 1023, 10, 39, 19, 6, -39 },
  { 1072, 21, 40, 19, -2, -40 },
  { 1177, 21, 41, 19, -1, -40 },
  { 1285, 21, 40, 19, -1, -40 },
  { 1390, 21, 40, 19, -1, -39 },
  { 1495, 20, 41, 19, 1, -40 },
  { 1598, 20, 39, 19, 2, -39 },
  { 1696, 21, 41, 19, -1, -40 },
  { 1804, 19, 41, 19, 0, -40 },
  { 1902, 9, 29, 9, 0, -29 },
  { 1935, 12, 36, 9, -3, -29 },
  { 1989, 19, 23, 22, 2, -31 },
  { 2044, 19, 13, 22, 2, -26 },
  { 2075, 19, 23, 22, 2, -31 },
  { 2130, 15, 40, 14, 1, -40 },
  { 2205, 27, 44, 29, 1, -39 },
  { 2354, 19, 39, 19, -4, -39 },
  { 2447, 21, 39, 21, 0, -39 },
  { 2550, 21, 41, 19, 2, -40 },
  { 2658, 22, 39, 23, 0, -39 },
  { 2766, 21, 39, 19, 0, -39 },
  { 2869, 21, 39, 18, 0, -39 },
  { 2972, 25, 41, 25, 2, -40 },
  { 3101, 26, 39, 25, 0, -39 },
  { 3228, 17, 39, 10, -3, -39 },
  { 3311, 19, 49, 9, -8, -39 },
  { 3428, 24, 39, 20, 0, -39 },
  { 3545, 13, 39, 17, 0, -39 },
  { 3609, 34, 39, 33, 0, -39 },
  { 3775, 27, 39, 26, 0, -39 },
  { 3907, 22, 41, 25, 2, -40 },
  { 4020, 21, 39, 20, 0, -39 },
  { 4123, 22, 49, 25, 2, -40 },
  { 4258, 21, 39, 20, 0, -39 },
  { 4361, 23, 41, 19, -2, -40 },
  { 4479, 17, 39, 17, 4, -39 },
  { 4562, 23, 40, 24, 2, -39 },
  { 4677, 19, 39, 20, 5, -39 },
  { 4770, 34, 39, 34, 4, -39 },
  { 4936, 24, 39, 17, -3, -39 },
  { 5053, 17, 39, 17, 4, -39 },
  { 5136, 22, 39, 17, -2, -39 },
  { 5244, 20, 48, 15, -1, -39 },
  { 5364, 7, 39, 18, 6, -39 },
  { 5399, 19, 48, 15, -3, -39 },
  { 5513, 20, 19, 22, 1, -39 },
  { 5561, 15, 2, 15, -4, 5 },
  { 5565, 6, 9, 12, 8, -42 },
  { 5572, 19, 31, 21, 2, -30 },
  { 5646, 20, 43, 21, 0, -42 },
  { 5754, 15, 31, 15, 2, -30 },
  { 5813, 22, 43, 21, 2, -42 },
  { 5932, 17, 31, 19, 1, -30 },
  { 5998, 24, 55, 11, -7, -42 },
  { 6163, 22, 43, 21, -1, -30 },
  { 6282, 19, 42, 20, 0, -42 },
  { 6382, 11, 39, 9, 0, -39 },
  { 6436, 18, 52, 9, -7, -39 },
  { 6553, 19, 42, 17, 0, -42 },
  { 6653, 11, 42, 9, 0, -42 },
  { 6711, 29, 30, 31, 0, -30 },
  { 6820, 19, 30, 20, 0, -30 },
  { 6892, 18, 31, 20, 1, -30 },
  { 6962, 22, 43, 21, -2, -30 },
  { 7081, 19, 43, 21, 2, -30 },
  { 7184, 16, 30, 13, 0, -30 },
  { 7244, 17, 31, 16, -1, -30 },
  { 7310, 11, 37, 11, 1, -36 },
  { 7361, 19, 30, 20, 1, -29 },
  { 7433, 15, 29, 16, 3, -29 },
  { 7488, 26, 29, 26, 3, -29 },
  { 7583, 20, 29, 16, -2, -29 },
  { 7656, 25, 42, 17, -6, -29 },
  { 7788, 17, 29, 13, -2, -29 },
  { 7850, 19, 48, 17, 2, -39 },
  { 7964, 2, 55, 19, 8, -42 },
  { 7978, 19, 48, 17, -4, -39 },
  { 8092, 19, 5, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC55PT7B_H_
