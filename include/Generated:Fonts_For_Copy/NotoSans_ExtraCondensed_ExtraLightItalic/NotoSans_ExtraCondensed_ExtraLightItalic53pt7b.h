#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x00, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0x23, 0x0C, 0x61, 0x98, 0x33, 0x04,
  0x60, 0x8C, 0x31, 0x06, 0x20, 0xCC, 0x11, 0x82, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0xC0, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x02, 0x00, 0x18,
  0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x10, 0x30, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x40, 0xC0, 0x06, 0x04,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x10, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x20, 0x40, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0x81, 0x80,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x02, 0x06, 0x00, 0x30, 0x20, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0xC0, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03,
  0x02, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xCC, 0x60, 0x30, 0x80, 0x06, 0x08, 0x00,
  0x60, 0x80, 0x04, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x00, 0xC1, 0x00,
  0x04, 0x30, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x32, 0x00, 0x01, 0xA0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x05,
  0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x86, 0x00, 0x08, 0x60, 0x00,
  0x82, 0x00, 0x18, 0x20, 0x01, 0x86, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00,
  0x30, 0xE0, 0x03, 0x0C, 0x0C, 0x23, 0x80, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xE0, 0x06, 0x07, 0x70, 0x0C, 0x0C, 0x30, 0x0C, 0x0C, 0x30,
  0x18, 0x18, 0x30, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x60, 0x30, 0x30, 0x60, 0x20, 0x30, 0xC0, 0x60, 0x30, 0xC0, 0x60, 0x21,
  0x80, 0x60, 0x61, 0x80, 0x60, 0x63, 0x00, 0x40, 0x63, 0x00, 0x40, 0x66,
  0x1E, 0xC0, 0xC6, 0x3F, 0xC0, 0xCC, 0x63, 0xC1, 0x8C, 0xC1, 0x41, 0x98,
  0xC1, 0x63, 0x19, 0x81, 0x76, 0x31, 0x81, 0x3E, 0x33, 0x01, 0x00, 0x63,
  0x03, 0x00, 0x63, 0x03, 0x00, 0xC2, 0x03, 0x00, 0xC6, 0x03, 0x01, 0x86,
  0x03, 0x01, 0x86, 0x06, 0x03, 0x06, 0x06, 0x03, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x04, 0x0C, 0x0C, 0x04, 0x0C, 0x0C, 0x06, 0x18, 0x18, 0x06,
  0x18, 0x18, 0x06, 0x30, 0x30, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0x00, 0x1E, 0xC0, 0x06, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x18, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06,
  0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x07, 0x60, 0x03, 0x98, 0x01,
  0xC3, 0x0C, 0x60, 0xC3, 0x30, 0x30, 0xCC, 0x04, 0x66, 0x01, 0x99, 0x80,
  0x64, 0x60, 0x1B, 0x18, 0x03, 0xCC, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0C,
  0x38, 0x07, 0x86, 0x03, 0x61, 0x81, 0xD8, 0x38, 0xE2, 0x07, 0xE0, 0xC0,
  0x60, 0x00, 0x19, 0xCC, 0x63, 0x19, 0x8C, 0x63, 0x10, 0x8C, 0x60, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x06, 0x00, 0x10, 0x20, 0x40,
  0xE1, 0x00, 0xCC, 0x11, 0xF7, 0xC1, 0xF0, 0x07, 0x00, 0x34, 0x03, 0x88,
  0x1C, 0x30, 0xC0, 0x40, 0x01, 0x80, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x18,
  0x60, 0xC1, 0x06, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3D, 0xC0, 0x0C,
  0x18, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x0C, 0x18, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x1C, 0x06, 0x06,
  0x01, 0x83, 0x00, 0x7B, 0x80, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0xE0, 0x78, 0x36, 0x39, 0x9C, 0x6E, 0x31, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xDF, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x7C, 0x01, 0x80, 0xE0, 0x10, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x08, 0x03, 0x80, 0xF0, 0xF0, 0x0F, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xA0,
  0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x4C,
  0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x08, 0x00, 0x61,
  0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x30, 0x03, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC4, 0x00, 0x0F, 0xF8, 0x00, 0x61, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x08, 0x03, 0x80, 0xE1, 0xF0, 0x0F,
  0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xD8, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x8F, 0xC0, 0x33, 0xFC, 0x06, 0xC1, 0xC1,
  0xA0, 0x18, 0x3C, 0x03, 0x07, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x0C,
  0x03, 0x01, 0x80, 0xE0, 0x38, 0x38, 0x03, 0x9E, 0x00, 0x3F, 0x80, 0x00,
  0x80, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xBC, 0x00, 0xC0, 0x60, 0x18, 0x07, 0x03, 0x80, 0x30, 0x30, 0x03,
  0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x06, 0x03, 0x00, 0x60, 0x18, 0x0C, 0x01, 0x81, 0x80, 0x0C,
  0x30, 0x00, 0xCE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1D, 0x80, 0x07,
  0x0C, 0x00, 0xE0, 0xE0, 0x1C, 0x06, 0x03, 0x80, 0x30, 0x30, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x70, 0x06,
  0x03, 0x00, 0xC0, 0x1E, 0x38, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x3D, 0xE0, 0x18, 0x18, 0x0C, 0x03, 0x07, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x18,
  0x01, 0xC6, 0x00, 0x71, 0x80, 0x38, 0x70, 0x1E, 0x0C, 0x0D, 0x83, 0xFE,
  0x60, 0x7F, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x87, 0x80, 0x3F, 0xC0,
  0x01, 0x00, 0x00, 0x03, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0xE0, 0x00, 0xC0, 0x1C, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x3D, 0xE0, 0x81, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x70, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x08,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x0C, 0x30, 0x1F, 0xC3, 0x0C, 0x0E, 0x20, 0xC6, 0x06, 0x18, 0x31, 0x81,
  0x86, 0x0C, 0x40, 0xC1, 0x83, 0x30, 0x60, 0x40, 0xCC, 0x18, 0x30, 0x23,
  0x04, 0x0C, 0x18, 0x83, 0x03, 0x06, 0x60, 0xC0, 0x81, 0x98, 0x30, 0x60,
  0x66, 0x08, 0x18, 0x11, 0x86, 0x06, 0x0C, 0x41, 0x83, 0x83, 0x10, 0x60,
  0xC0, 0x8C, 0x18, 0x30, 0x63, 0x06, 0x1C, 0x10, 0xC1, 0x85, 0x0C, 0x30,
  0x63, 0x46, 0x0C, 0x0F, 0x9F, 0x03, 0x01, 0xC3, 0x80, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x04, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x60, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x36, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x30, 0x38,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x60, 0x30,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x80, 0xC0, 0x38, 0x06, 0x03,
  0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x18, 0x1E, 0x00, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x30, 0x18, 0x03, 0x80,
  0xC0, 0x78, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x01,
  0xF7, 0xC0, 0x1C, 0x04, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE3, 0x00, 0x07, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x30, 0x78, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x70,
  0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x60, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x38, 0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x0E,
  0x0C, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x70, 0x18, 0x0F, 0x00, 0xC0,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x07, 0xF0, 0xC0, 0x07, 0xF0, 0xC0, 0x00, 0x30, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0,
  0x00, 0xC0, 0xE0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x38, 0x01, 0x80, 0x1F, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03,
  0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x04,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x1B, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0xC0, 0x0E, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x07, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x06, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00,
  0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x60, 0x00, 0x19, 0xC0, 0x00,
  0x37, 0x80, 0x00, 0x6B, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xC6, 0x00, 0x07,
  0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x30, 0x00, 0x40,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0C, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x01, 0xB0, 0x0F, 0x00, 0x00, 0xD0, 0x07, 0x80, 0x00, 0xF8,
  0x02, 0xC0, 0x00, 0x6C, 0x03, 0x20, 0x00, 0x36, 0x01, 0x90, 0x00, 0x33,
  0x00, 0xC8, 0x00, 0x1B, 0x00, 0x66, 0x00, 0x19, 0x80, 0x63, 0x00, 0x0C,
  0xC0, 0x31, 0x80, 0x0C, 0x60, 0x18, 0xC0, 0x06, 0x30, 0x0C, 0x60, 0x06,
  0x30, 0x06, 0x30, 0x03, 0x18, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x0C, 0x01,
  0x86, 0x01, 0x86, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0xC1, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x60, 0x60, 0x18, 0x30,
  0x30, 0x60, 0x0C, 0x18, 0x30, 0x30, 0x04, 0x0C, 0x18, 0x18, 0x06, 0x06,
  0x0C, 0x0C, 0x03, 0x03, 0x0C, 0x06, 0x01, 0x80, 0x86, 0x06, 0x00, 0xC0,
  0x46, 0x03, 0x00, 0xC0, 0x33, 0x01, 0x80, 0x60, 0x1B, 0x00, 0xC0, 0x30,
  0x0D, 0x80, 0x60, 0x18, 0x07, 0x80, 0x60, 0x0C, 0x03, 0xC0, 0x30, 0x0C,
  0x01, 0xC0, 0x18, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0xC0,
  0x38, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x07, 0x80, 0x06, 0x01, 0xE0, 0x01,
  0x80, 0x6C, 0x00, 0x60, 0x1B, 0x00, 0x30, 0x06, 0xC0, 0x0C, 0x03, 0x30,
  0x03, 0x00, 0xCC, 0x00, 0xC0, 0x31, 0x00, 0x30, 0x0C, 0x60, 0x18, 0x06,
  0x18, 0x06, 0x01, 0x86, 0x01, 0x80, 0x61, 0x80, 0x60, 0x18, 0x60, 0x18,
  0x06, 0x08, 0x0C, 0x03, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0xC0, 0x30, 0x30,
  0x30, 0x0C, 0x0C, 0x08, 0x03, 0x03, 0x06, 0x01, 0x80, 0x61, 0x80, 0x60,
  0x18, 0x60, 0x18, 0x06, 0x18, 0x06, 0x01, 0x8C, 0x01, 0x80, 0x63, 0x00,
  0xC0, 0x08, 0xC0, 0x30, 0x03, 0x30, 0x0C, 0x00, 0xCC, 0x03, 0x00, 0x36,
  0x01, 0x80, 0x0D, 0x80, 0x60, 0x03, 0x60, 0x18, 0x00, 0x78, 0x06, 0x00,
  0x1E, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x60, 0x38,
  0x03, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18,
  0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60, 0x00, 0x3B, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x30, 0x00, 0x31, 0x80,
  0x01, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60,
  0xC0, 0x07, 0x07, 0x00, 0x30, 0x18, 0x03, 0x00, 0xE0, 0x30, 0x03, 0xCF,
  0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xC1, 0xC0, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0x80,
  0x30, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x07, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00,
  0x38, 0x1C, 0x03, 0x00, 0x60, 0x38, 0x03, 0x81, 0x80, 0x0C, 0x18, 0x00,
  0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x30,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00, 0x03,
  0x60, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66,
  0x00, 0x07, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x18, 0x60, 0x00,
  0xC3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xC0, 0x07, 0x07, 0x00, 0x30, 0x18,
  0x03, 0x00, 0xE0, 0x30, 0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0x0B, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xC1, 0xC0, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x18,
  0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x07, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x18, 0x0C, 0x07, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x30,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x01,
  0x80, 0x30, 0x18, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x70, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x01, 0x00, 0x38, 0x0F, 0x0F, 0x80, 0x7F, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xC0, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x40,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x01,
  0x80, 0x18, 0x0E, 0x00, 0x7C, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x07, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x06,
  0x06, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x06, 0xC0, 0x03, 0x80, 0x06,
  0xC0, 0x02, 0x80, 0x0C, 0xC0, 0x07, 0x80, 0x0C, 0xC0, 0x07, 0x80, 0x0C,
  0xC0, 0x05, 0x80, 0x18, 0xC0, 0x0D, 0x80, 0x18, 0xC0, 0x0D, 0x80, 0x30,
  0xC0, 0x19, 0x80, 0x30, 0xC0, 0x19, 0x80, 0x30, 0xC0, 0x11, 0x80, 0x60,
  0xC0, 0x31, 0x80, 0x60, 0xC0, 0x31, 0x80, 0xC0, 0xC0, 0x61, 0x80, 0xC0,
  0xC0, 0x61, 0x80, 0xC0, 0xC0, 0x41, 0x81, 0x80, 0xC0, 0xC1, 0x81, 0x80,
  0xC0, 0xC1, 0x83, 0x00, 0xC1, 0x81, 0x83, 0x00, 0xC1, 0x81, 0x83, 0x00,
  0xC1, 0x81, 0x86, 0x00, 0xC3, 0x01, 0x86, 0x00, 0xC3, 0x01, 0x8C, 0x00,
  0xC6, 0x01, 0x8C, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0xC6, 0x01, 0x18, 0x00,
  0xCC, 0x01, 0x18, 0x00, 0xCC, 0x01, 0x30, 0x00, 0xC8, 0x01, 0x30, 0x00,
  0xD8, 0x01, 0x30, 0x00, 0xD8, 0x01, 0x60, 0x00, 0xF0, 0x03, 0x60, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x20, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0x60, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x11, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x04, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x06, 0x00, 0x38, 0x06, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x01,
  0xC8, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x10, 0x60, 0x04, 0x18, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xC0,
  0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x03,
  0x03, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x0D,
  0x80, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0x60, 0x03,
  0x06, 0x00, 0x60, 0x70, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x01, 0x81,
  0x80, 0x18, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06,
  0xC0, 0x00, 0x70, 0xFF, 0xFC, 0xC6, 0x18, 0xC3, 0x08, 0x61, 0x00, 0x10,
  0x00, 0x1F, 0xCC, 0x07, 0x99, 0x81, 0xC1, 0xB0, 0x70, 0x14, 0x0C, 0x03,
  0x83, 0x00, 0x70, 0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x61,
  0xC0, 0x1C, 0x38, 0x03, 0x83, 0x00, 0xE0, 0x60, 0x1C, 0x0C, 0x07, 0x81,
  0xC1, 0xB0, 0x1C, 0xE6, 0x01, 0xF8, 0x80, 0x08, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x82, 0x00, 0x33, 0xF8, 0x06, 0xE7, 0x80, 0xF0, 0x30, 0x34, 0x06,
  0x07, 0x80, 0x60, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x08, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x18, 0x38, 0x03, 0x07,
  0x80, 0xC0, 0xB0, 0x30, 0x13, 0x9E, 0x06, 0x3F, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x07, 0xF0, 0x3C, 0xC1, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x20, 0x3F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x04, 0x18, 0x00, 0xFE, 0x60, 0x07, 0x99, 0x80, 0x38, 0x36, 0x01, 0xC0,
  0x70, 0x06, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x70,
  0x18, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x70,
  0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x38, 0x01, 0x80, 0xE0, 0x0E, 0x03,
  0x80, 0x38, 0x06, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x3C, 0x01, 0xC1,
  0xB0, 0x03, 0x9C, 0xC0, 0x07, 0xE2, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10,
  0x00, 0xFE, 0x01, 0xC6, 0x03, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03,
  0x18, 0x03, 0x18, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x1C, 0x70, 0x38,
  0x60, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x10, 0x3C, 0x70, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC8, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x01, 0xFC, 0xC0, 0x1E, 0x66, 0x01, 0xC1, 0xB0, 0x1C, 0x05, 0x00,
  0xC0, 0x38, 0x0C, 0x01, 0xC0, 0x60, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x78, 0x07, 0x06, 0xC0, 0x1C, 0xE6, 0x00,
  0x7E, 0x60, 0x00, 0x83, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x02, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x10, 0x03, 0x3F, 0x80, 0xDC, 0xE0, 0x3C, 0x0C, 0x1E,
  0x03, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0E, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x00, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C,
  0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x1C, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x38,
  0x18, 0x0C, 0x06, 0x06, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x0C,
  0x30, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x09, 0xC0, 0x06, 0xD8,
  0x01, 0xE6, 0x00, 0x71, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x06, 0x00,
  0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x60, 0x00, 0x60, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x00, 0x04, 0x01, 0x00, 0x33, 0xF0, 0xFE, 0x03, 0x63,
  0x9C, 0xE0, 0x2C, 0x1B, 0x03, 0x07, 0x80, 0xE0, 0x30, 0x70, 0x0C, 0x03,
  0x07, 0x00, 0xC0, 0x30, 0x60, 0x1C, 0x03, 0x06, 0x01, 0x80, 0x30, 0xC0,
  0x18, 0x06, 0x0C, 0x01, 0x80, 0x60, 0xC0, 0x18, 0x06, 0x0C, 0x03, 0x00,
  0x60, 0x80, 0x30, 0x06, 0x18, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x0C, 0x18,
  0x02, 0x00, 0xC1, 0x80, 0x60, 0x0C, 0x30, 0x06, 0x00, 0xC3, 0x00, 0x60,
  0x18, 0x30, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x18, 0x30, 0x0C, 0x01, 0x86,
  0x00, 0xC0, 0x10, 0x60, 0x0C, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x60, 0x18,
  0x03, 0x04, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x06, 0x00, 0x00, 0x04, 0x00,
  0xCF, 0xE0, 0x37, 0x38, 0x0B, 0x03, 0x07, 0x80, 0xC1, 0xC0, 0x30, 0x70,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x06,
  0x0C, 0x01, 0x82, 0x00, 0x61, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x61, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0xC0, 0x18, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0x71, 0xC0, 0x60, 0x60,
  0x60, 0x38, 0x70, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xDC, 0x00, 0xCC, 0x00, 0x66,
  0x00, 0x33, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30, 0x1C, 0x1C, 0x1C,
  0x07, 0x1C, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x06, 0x7F,
  0x00, 0x37, 0x3C, 0x01, 0x20, 0x60, 0x1A, 0x03, 0x00, 0xF0, 0x0C, 0x07,
  0x00, 0x60, 0x38, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x18, 0x00, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x30, 0x1C, 0x01,
  0x80, 0xF0, 0x18, 0x06, 0x81, 0x80, 0x37, 0x3C, 0x03, 0x1F, 0x80, 0x18,
  0x30, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xCC,
  0x07, 0x39, 0x81, 0x81, 0xB0, 0x60, 0x14, 0x0C, 0x03, 0x83, 0x00, 0x70,
  0xE0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3,
  0x00, 0x18, 0x60, 0x02, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x38,
  0x03, 0x83, 0x00, 0xE0, 0x60, 0x1C, 0x0C, 0x07, 0x81, 0xC1, 0xB0, 0x1C,
  0xE6, 0x01, 0xF9, 0x80, 0x08, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x06,
  0x7C, 0x09, 0xC8, 0x16, 0x00, 0x68, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x01, 0xFF, 0x03, 0x87, 0x07, 0x01,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x80, 0x60, 0xE1, 0xE0,
  0x7F, 0x80, 0x04, 0x00, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0xFF, 0x3F, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x39, 0x07, 0xC0,
  0xC0, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x60, 0x04, 0x18, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x18, 0x30, 0x06, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x1C,
  0x18, 0x07, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x78, 0x18, 0x16, 0x07,
  0x19, 0x00, 0xFC, 0x40, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61,
  0x80, 0xC3, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0xC0, 0x61,
  0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x00,
  0x36, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0xC0, 0x0C, 0x01, 0xE0, 0x0E, 0x01, 0xB0, 0x07, 0x00, 0xD8, 0x07, 0x80,
  0xCC, 0x03, 0xC0, 0x66, 0x01, 0x60, 0x33, 0x01, 0xB0, 0x31, 0x80, 0x98,
  0x18, 0xC0, 0xCC, 0x18, 0x60, 0x66, 0x0C, 0x30, 0x63, 0x06, 0x18, 0x31,
  0x86, 0x0C, 0x10, 0xC3, 0x06, 0x18, 0x61, 0x03, 0x0C, 0x31, 0x81, 0x8C,
  0x18, 0xC0, 0xC6, 0x0C, 0xC0, 0x62, 0x06, 0x60, 0x33, 0x02, 0x20, 0x19,
  0x81, 0x30, 0x0D, 0x80, 0x98, 0x06, 0xC0, 0x58, 0x03, 0x40, 0x2C, 0x01,
  0xE0, 0x14, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x03, 0x00, 0x60, 0x60, 0x1C, 0x06, 0x03, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x04, 0x30, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0D, 0x00, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x06, 0x06, 0x01, 0xC0,
  0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x06,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x7F, 0xE0, 0x1C, 0x0E, 0x1E, 0x01, 0xFE, 0x80, 0x0C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 38, 11, 1, -38 },
  { 49, 11, 14, 14, 5, -38 },
  { 69, 21, 38, 20, 0, -38 },
  { 169, 20, 43, 19, 0, -40 },
  { 277, 24, 39, 29, 2, -38 },
  { 394, 18, 39, 18, -1, -38 },
  { 482, 5, 14, 8, 5, -38 },
  { 491, 15, 46, 13, 1, -38 },
  { 578, 15, 46, 13, -4, -38 },
  { 665, 14, 15, 17, 6, -40 },
  { 692, 18, 25, 21, 2, -31 },
  { 749, 7, 12, 9, -2, -5 },
  { 760, 12, 2, 14, 1, -15 },
  { 763, 3, 4, 9, 1, -4 },
  { 765, 22, 38, 16, -2, -38 },
  { 870, 18, 39, 19, 1, -38 },
  { 958, 10, 38, 19, 6, -38 },
  { 1006, 21, 38, 19, -2, -38 },
  { 1106, 20, 39, 19, -1, -38 },
  { 1204, 20, 38, 19, -1, -38 },
  { 1299, 20, 39, 19, -1, -38 },
  { 1397, 19, 39, 19, 1, -38 },
  { 1490, 19, 38, 19, 2, -38 },
  { 1581, 20, 39, 19, -1, -38 },
  { 1679, 18, 39, 19, 0, -38 },
  { 1767, 8, 28, 9, 0, -28 },
  { 1795, 11, 35, 9, -2, -28 },
  { 1844, 18, 22, 21, 2, -30 },
  { 1894, 18, 13, 21, 2, -25 },
  { 1924, 18, 22, 21, 2, -30 },
  { 1974, 14, 38, 13, 1, -38 },
  { 2041, 26, 43, 28, 1, -38 },
  { 2181, 19, 38, 18, -4, -38 },
  { 2272, 21, 38, 20, 0, -38 },
  { 2372, 21, 39, 18, 2, -38 },
  { 2475, 21, 38, 22, 0, -38 },
  { 2575, 20, 38, 18, 0, -38 },
  { 2670, 20, 38, 17, 0, -38 },
  { 2765, 24, 39, 24, 2, -38 },
  { 2882, 25, 38, 24, 0, -38 },
  { 3001, 17, 38, 10, -3, -38 },
  { 3082, 18, 47, 9, -8, -38 },
  { 3188, 23, 38, 19, 0, -38 },
  { 3298, 12, 38, 16, 0, -38 },
  { 3355, 33, 38, 32, 0, -38 },
  { 3512, 26, 38, 25, 0, -38 },
  { 3636, 21, 39, 24, 2, -38 },
  { 3739, 20, 38, 19, 0, -38 },
  { 3834, 21, 47, 24, 2, -38 },
  { 3958, 20, 38, 20, 0, -38 },
  { 4053, 21, 39, 18, -1, -38 },
  { 4156, 17, 38, 16, 3, -38 },
  { 4237, 22, 39, 23, 2, -38 },
  { 4345, 19, 38, 19, 4, -38 },
  { 4436, 32, 38, 32, 4, -38 },
  { 4588, 24, 38, 17, -3, -38 },
  { 4702, 18, 38, 16, 3, -38 },
  { 4788, 22, 38, 16, -2, -38 },
  { 4893, 19, 46, 15, -1, -38 },
  { 5003, 8, 38, 17, 5, -38 },
  { 5041, 19, 46, 15, -3, -38 },
  { 5151, 20, 19, 21, 1, -38 },
  { 5199, 14, 1, 14, -4, 5 },
  { 5201, 5, 8, 11, 8, -40 },
  { 5206, 19, 30, 21, 1, -29 },
  { 5278, 19, 41, 20, 0, -40 },
  { 5376, 14, 30, 15, 2, -29 },
  { 5429, 22, 41, 21, 1, -40 },
  { 5542, 16, 30, 18, 1, -29 },
  { 5602, 23, 54, 10, -7, -41 },
  { 5758, 21, 42, 20, -1, -29 },
  { 5869, 18, 40, 20, 0, -40 },
  { 5959, 10, 38, 9, 0, -38 },
  { 6007, 18, 51, 9, -7, -38 },
  { 6122, 18, 40, 16, 0, -40 },
  { 6212, 11, 40, 8, 0, -40 },
  { 6267, 28, 29, 30, 0, -29 },
  { 6369, 18, 29, 20, 0, -29 },
  { 6435, 17, 30, 20, 1, -29 },
  { 6499, 21, 41, 20, -2, -29 },
  { 6607, 19, 41, 21, 1, -29 },
  { 6705, 15, 29, 13, 0, -29 },
  { 6760, 16, 30, 15, -1, -29 },
  { 6820, 10, 36, 10, 1, -35 },
  { 6865, 18, 29, 20, 1, -28 },
  { 6931, 15, 28, 15, 3, -28 },
  { 6984, 25, 28, 25, 3, -28 },
  { 7072, 19, 28, 16, -2, -28 },
  { 7139, 25, 41, 16, -6, -28 },
  { 7268, 16, 28, 13, -2, -28 },
  { 7324, 18, 46, 17, 2, -38 },
  { 7428, 2, 53, 18, 8, -40 },
  { 7442, 18, 46, 17, -3, -38 },
  { 7546, 18, 5, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC53PT7B_H_
