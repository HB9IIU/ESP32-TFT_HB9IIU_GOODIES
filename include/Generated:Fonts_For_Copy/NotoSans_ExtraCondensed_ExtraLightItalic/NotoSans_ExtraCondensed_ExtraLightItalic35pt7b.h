#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x00, 0x00, 0x00, 0x40,
  0x60, 0xC0, 0x23, 0x22, 0x22, 0x62, 0x46, 0x44, 0x44, 0x44, 0x84, 0x00,
  0x8C, 0x06, 0x20, 0x10, 0x80, 0x46, 0x03, 0x10, 0x08, 0x40, 0x21, 0x07,
  0xFF, 0x04, 0x20, 0x10, 0x80, 0x44, 0x02, 0x10, 0x08, 0x40, 0x23, 0x01,
  0x88, 0x04, 0x20, 0xFF, 0xE0, 0xC4, 0x02, 0x10, 0x08, 0xC0, 0x62, 0x01,
  0x08, 0x04, 0x20, 0x11, 0x00, 0x84, 0x00, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x03, 0x80, 0x7F, 0x84, 0x44, 0x62, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04,
  0x40, 0x32, 0x00, 0xE0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x02, 0x80, 0x26,
  0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x23, 0x11, 0x30, 0xFF, 0x00,
  0xE0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x1E, 0x04, 0x64, 0x18, 0x88,
  0x22, 0x10, 0xC4, 0x21, 0x08, 0x46, 0x20, 0x88, 0x41, 0x30, 0x86, 0x41,
  0x09, 0x82, 0x12, 0x7C, 0x2D, 0x98, 0x92, 0x33, 0x6C, 0x7C, 0x90, 0x83,
  0x21, 0x04, 0xC2, 0x19, 0x04, 0x22, 0x08, 0xC4, 0x31, 0x08, 0x46, 0x10,
  0x88, 0x22, 0x30, 0x44, 0x40, 0xF0, 0x03, 0xC0, 0xC8, 0x11, 0x86, 0x30,
  0x84, 0x10, 0x82, 0x10, 0x44, 0x08, 0x81, 0xA0, 0x18, 0x03, 0x00, 0xC0,
  0x2C, 0x08, 0x8B, 0x11, 0x43, 0x78, 0x2A, 0x05, 0x40, 0xE8, 0x19, 0x03,
  0x20, 0xE6, 0x34, 0x7C, 0xC0, 0x24, 0xB4, 0x92, 0x80, 0x00, 0xC0, 0x40,
  0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x04, 0x06, 0x02, 0x00, 0x08,
  0x02, 0x02, 0x19, 0x02, 0x98, 0xF0, 0x60, 0x48, 0xC6, 0x01, 0x00, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x13,
  0x26, 0x44, 0x80, 0xFE, 0xB8, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x8C, 0x20, 0x8C, 0x11, 0x02, 0x60,
  0x48, 0x09, 0x01, 0x60, 0x2C, 0x05, 0x01, 0xA0, 0x3C, 0x05, 0x80, 0xA0,
  0x14, 0x06, 0x80, 0xD0, 0x12, 0x02, 0x40, 0xC8, 0x11, 0x06, 0x20, 0x86,
  0x20, 0x78, 0x00, 0x0C, 0x73, 0x5B, 0x88, 0x20, 0x86, 0x18, 0x41, 0x04,
  0x30, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x80, 0x03, 0xF0,
  0x30, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x18, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x01, 0xF0,
  0x07, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x20, 0x60, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x60, 0x02, 0x80, 0x1E, 0x00, 0x58, 0x02, 0x40, 0x09, 0x00,
  0x44, 0x03, 0x30, 0x08, 0x80, 0x42, 0x01, 0x08, 0x08, 0x20, 0x61, 0x81,
  0x04, 0x08, 0x10, 0x60, 0x41, 0x03, 0x0F, 0xFF, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0xF8, 0x06, 0x70, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x20,
  0x60, 0xFE, 0x00, 0x01, 0xF0, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x4F, 0x85, 0x08, 0x60, 0xCC, 0x04,
  0xC0, 0x48, 0x04, 0x80, 0x48, 0x0C, 0x80, 0xC8, 0x08, 0x80, 0x88, 0x18,
  0xC1, 0x04, 0x20, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x00, 0x03, 0xE0,
  0x61, 0x82, 0x04, 0x30, 0x31, 0x01, 0x88, 0x0C, 0x40, 0x43, 0x02, 0x08,
  0x20, 0x43, 0x01, 0x30, 0x0E, 0x00, 0xF0, 0x0C, 0xC0, 0x82, 0x08, 0x18,
  0xC0, 0x44, 0x02, 0x20, 0x11, 0x00, 0x88, 0x04, 0x40, 0x23, 0x02, 0x08,
  0x30, 0x3F, 0x00, 0x03, 0xE0, 0x42, 0x08, 0x31, 0x81, 0x10, 0x11, 0x01,
  0x30, 0x12, 0x01, 0x20, 0x12, 0x03, 0x20, 0x32, 0x03, 0x30, 0x61, 0x0A,
  0x1F, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0xF8, 0x00, 0x08, 0x31, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x43, 0x0C, 0x00, 0x02, 0x03, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x10, 0x03, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x60, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x60, 0x18, 0x07,
  0x00, 0xC0, 0x30, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x84, 0x30, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01,
  0x80, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xC3, 0x00, 0x80, 0x40, 0x80, 0x20,
  0x80, 0x18, 0xC0, 0x04, 0x40, 0x02, 0x60, 0xF1, 0x21, 0x90, 0x90, 0x88,
  0x50, 0x84, 0x68, 0x46, 0x24, 0x42, 0x12, 0x21, 0x0B, 0x10, 0x85, 0x18,
  0xC4, 0x8C, 0x42, 0x46, 0x21, 0x23, 0x31, 0x10, 0x9D, 0x88, 0x73, 0x84,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x20,
  0x03, 0xE0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xB0, 0x0B,
  0x01, 0xB0, 0x13, 0x03, 0x30, 0x23, 0x02, 0x30, 0x63, 0x04, 0x30, 0xC3,
  0x0F, 0xF0, 0x83, 0x18, 0x31, 0x03, 0x30, 0x32, 0x03, 0x60, 0x36, 0x03,
  0x40, 0x3C, 0x03, 0x80, 0x30, 0x07, 0xE0, 0x10, 0xE0, 0x40, 0x81, 0x03,
  0x0C, 0x0C, 0x30, 0x30, 0x80, 0x82, 0x02, 0x08, 0x18, 0x60, 0x41, 0x02,
  0x07, 0xF0, 0x13, 0xC0, 0x41, 0x83, 0x02, 0x08, 0x0C, 0x20, 0x30, 0x80,
  0xC6, 0x02, 0x18, 0x08, 0x40, 0x21, 0x01, 0x04, 0x0C, 0x30, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x0C, 0x10, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x10,
  0xC0, 0x41, 0x81, 0x03, 0x0C, 0x0C, 0x30, 0x10, 0x80, 0x42, 0x01, 0x08,
  0x04, 0x60, 0x11, 0x00, 0x44, 0x03, 0x10, 0x0C, 0xC0, 0x23, 0x00, 0x88,
  0x06, 0x20, 0x18, 0x80, 0x46, 0x03, 0x18, 0x08, 0x40, 0x61, 0x03, 0x04,
  0x18, 0x31, 0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x3F,
  0xC1, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x1F, 0xC0, 0xFF, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x03, 0x03, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x7C, 0x40, 0x78, 0xC0, 0x08,
  0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x10, 0x40, 0x10,
  0x40, 0x30, 0x60, 0x20, 0x30, 0x20, 0x1F, 0xE0, 0x06, 0x01, 0x04, 0x01,
  0x04, 0x03, 0x04, 0x03, 0x0C, 0x02, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x06,
  0x08, 0x04, 0x18, 0x04, 0x10, 0x04, 0x1F, 0xFC, 0x10, 0x0C, 0x30, 0x08,
  0x30, 0x08, 0x20, 0x08, 0x20, 0x18, 0x20, 0x18, 0x60, 0x10, 0x60, 0x10,
  0x40, 0x10, 0x40, 0x30, 0x40, 0x20, 0xC0, 0x20, 0x80, 0x20, 0x07, 0xE0,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xFC, 0x00, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xF0, 0x00, 0x06, 0x06, 0x08, 0x08,
  0x10, 0x20, 0x20, 0xC0, 0xC3, 0x01, 0x84, 0x02, 0x10, 0x04, 0x60, 0x09,
  0x80, 0x32, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x60, 0x07, 0x60, 0x0C, 0xC0,
  0x10, 0x80, 0x21, 0x00, 0x42, 0x01, 0x86, 0x03, 0x04, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x30, 0x60, 0x60, 0x80, 0x40, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20,
  0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xFF, 0x06, 0x00, 0x1C, 0x18,
  0x00, 0x60, 0x60, 0x03, 0x81, 0x80, 0x0A, 0x0E, 0x00, 0x78, 0x28, 0x01,
  0x40, 0xB0, 0x0D, 0x02, 0xC0, 0x24, 0x0B, 0x01, 0xB0, 0x6C, 0x04, 0xC1,
  0x10, 0x12, 0x04, 0x40, 0x88, 0x11, 0x02, 0x20, 0xC4, 0x11, 0x83, 0x10,
  0x44, 0x08, 0x42, 0x10, 0x21, 0x08, 0x40, 0x84, 0x63, 0x06, 0x11, 0x0C,
  0x18, 0x4C, 0x20, 0x41, 0x20, 0x81, 0x05, 0x82, 0x04, 0x14, 0x18, 0x30,
  0x70, 0x60, 0x81, 0x81, 0x00, 0x06, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x60,
  0xE0, 0x20, 0xD0, 0x10, 0x48, 0x08, 0x24, 0x0C, 0x12, 0x04, 0x09, 0x82,
  0x0C, 0xC1, 0x04, 0x20, 0x82, 0x10, 0xC1, 0x08, 0x41, 0x84, 0x20, 0xC3,
  0x10, 0x41, 0x98, 0x20, 0x4C, 0x10, 0x24, 0x18, 0x12, 0x0C, 0x09, 0x04,
  0x07, 0x82, 0x01, 0x81, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0x00, 0x01,
  0xF0, 0x08, 0x60, 0x40, 0xC2, 0x01, 0x18, 0x04, 0x40, 0x13, 0x00, 0x4C,
  0x01, 0x20, 0x05, 0x80, 0x16, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x00, 0x2C,
  0x00, 0xB0, 0x02, 0xC0, 0x1B, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0, 0x23,
  0x01, 0x04, 0x0C, 0x18, 0x60, 0x3F, 0x00, 0x07, 0xE0, 0x21, 0x81, 0x06,
  0x08, 0x10, 0xC0, 0x86, 0x04, 0x20, 0x21, 0x01, 0x08, 0x18, 0xC0, 0x84,
  0x04, 0x20, 0x41, 0x0E, 0x1F, 0xC0, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x01, 0xF0, 0x08, 0x60, 0x40, 0xC2, 0x01, 0x18, 0x04, 0x40, 0x13, 0x00,
  0x4C, 0x01, 0x20, 0x05, 0x80, 0x16, 0x00, 0x50, 0x03, 0x40, 0x0D, 0x00,
  0x2C, 0x00, 0xB0, 0x02, 0xC0, 0x1B, 0x00, 0x4C, 0x01, 0x30, 0x0C, 0xC0,
  0x23, 0x01, 0x04, 0x0C, 0x18, 0x60, 0x3F, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x07, 0xE0, 0x21, 0x81, 0x06,
  0x08, 0x10, 0xC0, 0x86, 0x04, 0x20, 0x21, 0x01, 0x08, 0x18, 0xC0, 0x84,
  0x0C, 0x20, 0x41, 0x0C, 0x1F, 0xC0, 0xC4, 0x04, 0x20, 0x21, 0x01, 0x08,
  0x18, 0x60, 0xC3, 0x04, 0x08, 0x20, 0x41, 0x02, 0x18, 0x18, 0x80, 0xC0,
  0x01, 0xFC, 0x18, 0x10, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x20, 0x60, 0xFF, 0x00, 0x7F, 0xE0, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x10, 0x0C, 0x20,
  0x10, 0xC0, 0x21, 0x80, 0x42, 0x01, 0x84, 0x02, 0x08, 0x04, 0x30, 0x08,
  0x60, 0x10, 0x80, 0x61, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x10, 0x0C, 0x20,
  0x18, 0x40, 0x21, 0x80, 0x43, 0x00, 0x84, 0x03, 0x08, 0x04, 0x10, 0x18,
  0x30, 0x20, 0x30, 0xC0, 0x3F, 0x00, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06,
  0x80, 0x48, 0x04, 0x80, 0xC8, 0x08, 0x81, 0x88, 0x10, 0x83, 0x08, 0x20,
  0x82, 0x08, 0x60, 0x84, 0x08, 0xC0, 0x88, 0x09, 0x80, 0x90, 0x09, 0x00,
  0xB0, 0x0A, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x1C, 0x03,
  0x00, 0xA0, 0x18, 0x05, 0x01, 0xC0, 0x68, 0x0A, 0x02, 0x40, 0x50, 0x32,
  0x06, 0x81, 0x10, 0x24, 0x08, 0x83, 0x20, 0xC4, 0x11, 0x04, 0x20, 0x88,
  0x61, 0x0C, 0x42, 0x08, 0x42, 0x10, 0x42, 0x11, 0x82, 0x21, 0x88, 0x11,
  0x0C, 0xC0, 0x98, 0x64, 0x04, 0x83, 0x20, 0x24, 0x1A, 0x01, 0x40, 0x90,
  0x0A, 0x05, 0x80, 0x70, 0x28, 0x03, 0x01, 0x40, 0x18, 0x0C, 0x00, 0xC0,
  0x60, 0x00, 0x02, 0x03, 0x03, 0x06, 0x03, 0x04, 0x03, 0x0C, 0x01, 0x08,
  0x01, 0x18, 0x01, 0x10, 0x01, 0x20, 0x01, 0x20, 0x01, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80,
  0x0C, 0xC0, 0x08, 0xC0, 0x10, 0xC0, 0x30, 0x40, 0x20, 0x40, 0x60, 0x40,
  0x40, 0x40, 0xC0, 0x40, 0x40, 0x34, 0x06, 0x40, 0x44, 0x0C, 0x60, 0x86,
  0x18, 0x21, 0x02, 0x30, 0x22, 0x02, 0x60, 0x24, 0x02, 0xC0, 0x28, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x88, 0x88, 0x8C, 0x44, 0x44, 0x44, 0x62,
  0x22, 0x22, 0x23, 0x31, 0x11, 0x10, 0x03, 0xF0, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0x00, 0x18, 0x01, 0x40, 0x1B, 0x00,
  0x88, 0x0C, 0x60, 0x41, 0x06, 0x0C, 0x20, 0x23, 0x01, 0x10, 0x0D, 0x80,
  0x30, 0xFF, 0xC0, 0x8C, 0x42, 0x21, 0x03, 0x80, 0xED, 0x18, 0x51, 0x03,
  0x30, 0x22, 0x02, 0x60, 0x24, 0x06, 0x40, 0x6C, 0x04, 0xC0, 0x48, 0x04,
  0x80, 0xC8, 0x0C, 0x80, 0x88, 0x18, 0xC2, 0x84, 0x28, 0x7D, 0x80, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x09,
  0xC0, 0xB7, 0x0C, 0x11, 0xC1, 0x18, 0x11, 0x81, 0x10, 0x11, 0x01, 0x30,
  0x12, 0x01, 0x20, 0x32, 0x03, 0x20, 0x26, 0x02, 0x60, 0x66, 0x04, 0x60,
  0x8F, 0x18, 0x9F, 0x00, 0x03, 0xC3, 0xA1, 0x80, 0x40, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xC0, 0x10, 0x07, 0xE0, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x03, 0x90, 0x3B, 0x41, 0x85, 0x04,
  0x0C, 0x30, 0x20, 0x80, 0x86, 0x02, 0x10, 0x18, 0x40, 0x63, 0x01, 0x0C,
  0x04, 0x20, 0x10, 0x80, 0xC2, 0x03, 0x08, 0x08, 0x20, 0x60, 0xC2, 0x81,
  0x0A, 0x07, 0xD8, 0x00, 0x03, 0x83, 0x31, 0x84, 0x41, 0x20, 0x58, 0x14,
  0x09, 0x06, 0x43, 0x3F, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xC0, 0x10, 0x47, 0xE0, 0x00, 0x07, 0x00, 0x1D, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x01, 0xF8,
  0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x0E, 0xD0, 0x61, 0x41, 0x03, 0x0C, 0x08, 0x20,
  0x21, 0x80, 0x84, 0x06, 0x10, 0x18, 0xC0, 0x43, 0x01, 0x08, 0x04, 0x20,
  0x30, 0x80, 0xC2, 0x02, 0x08, 0x18, 0x30, 0xA0, 0x47, 0x81, 0xF4, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x82, 0x0C, 0x0F,
  0xE0, 0x00, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x09, 0xC0, 0xB6, 0x0C, 0x31, 0x81, 0x18, 0x31, 0x83, 0x10,
  0x21, 0x02, 0x30, 0x22, 0x06, 0x20, 0x62, 0x04, 0x20, 0x46, 0x04, 0x40,
  0xC4, 0x0C, 0x40, 0x84, 0x08, 0xC1, 0x80, 0x06, 0x0C, 0x10, 0x00, 0x00,
  0x00, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x83,
  0x04, 0x08, 0x10, 0x60, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0xF0, 0x00, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x10, 0x82, 0x08, 0x61,
  0x8C, 0x18, 0x81, 0x10, 0x13, 0x01, 0x60, 0x36, 0x02, 0xA0, 0x32, 0x03,
  0x20, 0x23, 0x06, 0x30, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x10, 0xC1, 0x80,
  0x02, 0x04, 0x18, 0x20, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x82,
  0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x00,
  0x01, 0xC3, 0x81, 0x4D, 0xD8, 0x30, 0xA1, 0x0C, 0x18, 0x31, 0x83, 0x04,
  0x20, 0x40, 0x84, 0x08, 0x10, 0x81, 0x02, 0x30, 0x60, 0xC4, 0x0C, 0x10,
  0x81, 0x02, 0x10, 0x20, 0x42, 0x04, 0x18, 0xC1, 0x83, 0x10, 0x20, 0x42,
  0x04, 0x08, 0x40, 0x81, 0x18, 0x30, 0x63, 0x06, 0x08, 0x00, 0x01, 0xC0,
  0xB6, 0x0C, 0x31, 0x81, 0x18, 0x31, 0x83, 0x10, 0x21, 0x02, 0x30, 0x22,
  0x06, 0x20, 0x62, 0x04, 0x20, 0x46, 0x04, 0x40, 0xC4, 0x08, 0x40, 0x8C,
  0x08, 0xC1, 0x80, 0x03, 0x81, 0x98, 0x61, 0x98, 0x32, 0x02, 0x40, 0x58,
  0x0A, 0x03, 0x40, 0x78, 0x0F, 0x01, 0x40, 0x28, 0x05, 0x01, 0xA0, 0x24,
  0x0C, 0xC1, 0x08, 0x41, 0xF0, 0x00, 0x00, 0x60, 0x16, 0xE0, 0x60, 0x83,
  0x82, 0x0C, 0x08, 0x30, 0x30, 0x80, 0x82, 0x02, 0x18, 0x08, 0x40, 0x21,
  0x00, 0x84, 0x06, 0x10, 0x10, 0xC0, 0x43, 0x03, 0x0C, 0x08, 0x30, 0x60,
  0xE3, 0x06, 0xF8, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0xED, 0x18, 0x51, 0x03,
  0x30, 0x22, 0x02, 0x60, 0x24, 0x02, 0x40, 0x6C, 0x04, 0xC0, 0x48, 0x04,
  0x80, 0xC8, 0x0C, 0x80, 0x88, 0x18, 0xC2, 0x84, 0x38, 0x7D, 0x80, 0x10,
  0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x01,
  0xC2, 0xD0, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x00, 0x03,
  0xC1, 0xCC, 0x20, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x10, 0x63,
  0xF8, 0x00, 0x08, 0x21, 0x84, 0x11, 0xF3, 0x0C, 0x20, 0x82, 0x18, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x0E, 0x00, 0x10, 0x31, 0x02, 0x30,
  0x22, 0x06, 0x20, 0x62, 0x04, 0x20, 0x46, 0x04, 0x40, 0xC4, 0x08, 0x40,
  0x8C, 0x08, 0xC1, 0x88, 0x18, 0x81, 0x08, 0x30, 0xC5, 0x07, 0x90, 0x80,
  0xE0, 0x68, 0x12, 0x04, 0x83, 0x20, 0x88, 0x62, 0x10, 0x8C, 0x22, 0x08,
  0x82, 0x40, 0x90, 0x2C, 0x0A, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x81, 0x81,
  0x81, 0x82, 0x81, 0x82, 0x82, 0x86, 0x82, 0x84, 0x86, 0x84, 0x84, 0x8C,
  0x8C, 0x88, 0x88, 0x88, 0x88, 0x90, 0x90, 0x90, 0x90, 0xB0, 0xB0, 0xA0,
  0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x04, 0x0C,
  0x10, 0x40, 0x63, 0x00, 0x88, 0x02, 0x40, 0x09, 0x00, 0x28, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0x50, 0x03, 0x60, 0x09, 0x80, 0x62, 0x01, 0x08,
  0x08, 0x20, 0x60, 0xC3, 0x03, 0x00, 0x01, 0x01, 0x01, 0x03, 0x01, 0x02,
  0x01, 0x06, 0x01, 0x04, 0x01, 0x0C, 0x01, 0x08, 0x01, 0x08, 0x01, 0x10,
  0x01, 0x10, 0x01, 0x30, 0x01, 0x20, 0x01, 0x60, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0xF0, 0x00, 0x40, 0x00,
  0x0F, 0xE0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x1F,
  0xC0, 0x00, 0x70, 0x1C, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x30, 0x0E,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x80, 0x00, 0x78, 0x1C, 0x61, 0x81,
  0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 25, 7, 0, -25 },
  { 26, 8, 9, 10, 3, -25 },
  { 35, 14, 25, 13, 0, -25 },
  { 79, 13, 29, 12, 0, -27 },
  { 127, 15, 25, 19, 2, -25 },
  { 174, 11, 25, 12, 0, -25 },
  { 209, 3, 9, 5, 3, -25 },
  { 213, 10, 31, 9, 1, -25 },
  { 252, 9, 31, 9, -2, -25 },
  { 287, 9, 10, 11, 4, -27 },
  { 299, 12, 16, 14, 1, -20 },
  { 323, 4, 7, 6, -1, -3 },
  { 327, 7, 1, 9, 1, -10 },
  { 328, 2, 3, 6, 1, -3 },
  { 329, 15, 25, 11, -2, -25 },
  { 376, 11, 25, 12, 1, -25 },
  { 411, 6, 25, 12, 4, -25 },
  { 430, 13, 25, 12, -1, -25 },
  { 471, 14, 25, 12, -1, -25 },
  { 515, 14, 25, 12, -1, -25 },
  { 559, 14, 25, 12, -1, -25 },
  { 603, 12, 25, 12, 1, -25 },
  { 641, 13, 25, 12, 1, -25 },
  { 682, 13, 25, 12, 0, -25 },
  { 723, 12, 25, 12, 0, -25 },
  { 761, 6, 19, 6, 0, -19 },
  { 776, 8, 23, 6, -2, -19 },
  { 799, 12, 15, 14, 1, -20 },
  { 822, 12, 9, 14, 1, -17 },
  { 836, 12, 15, 14, 1, -20 },
  { 859, 10, 25, 9, 0, -25 },
  { 891, 17, 28, 18, 1, -25 },
  { 951, 12, 25, 12, -2, -25 },
  { 989, 14, 25, 13, 0, -25 },
  { 1033, 14, 25, 12, 1, -25 },
  { 1077, 14, 25, 15, 0, -25 },
  { 1121, 13, 25, 12, 0, -25 },
  { 1162, 14, 25, 11, 0, -25 },
  { 1206, 16, 25, 16, 1, -25 },
  { 1256, 16, 25, 16, 0, -25 },
  { 1306, 11, 25, 6, -2, -25 },
  { 1341, 12, 31, 6, -5, -25 },
  { 1388, 15, 25, 13, 0, -25 },
  { 1435, 8, 25, 11, 0, -25 },
  { 1460, 22, 25, 21, 0, -25 },
  { 1529, 17, 25, 17, 0, -25 },
  { 1583, 14, 25, 16, 1, -25 },
  { 1627, 13, 25, 13, 0, -25 },
  { 1668, 14, 31, 16, 1, -25 },
  { 1723, 13, 25, 13, 0, -25 },
  { 1764, 14, 25, 12, -1, -25 },
  { 1808, 11, 25, 11, 2, -25 },
  { 1843, 15, 25, 15, 1, -25 },
  { 1890, 12, 25, 12, 3, -25 },
  { 1928, 21, 25, 21, 3, -25 },
  { 1994, 16, 25, 11, -2, -25 },
  { 2044, 12, 25, 11, 2, -25 },
  { 2082, 14, 25, 11, -1, -25 },
  { 2126, 13, 31, 10, -1, -25 },
  { 2177, 4, 25, 11, 4, -25 },
  { 2190, 12, 31, 10, -2, -25 },
  { 2237, 13, 12, 14, 1, -25 },
  { 2257, 10, 1, 9, -3, 3 },
  { 2259, 4, 6, 7, 5, -27 },
  { 2262, 12, 19, 14, 1, -19 },
  { 2291, 12, 27, 13, 0, -27 },
  { 2332, 10, 19, 10, 1, -19 },
  { 2356, 14, 27, 14, 1, -27 },
  { 2404, 10, 19, 12, 1, -19 },
  { 2428, 16, 35, 7, -5, -27 },
  { 2498, 14, 27, 14, -1, -19 },
  { 2546, 12, 27, 13, 0, -27 },
  { 2587, 7, 25, 6, 0, -25 },
  { 2609, 12, 33, 6, -5, -25 },
  { 2659, 12, 27, 11, 0, -27 },
  { 2700, 7, 27, 6, 0, -27 },
  { 2724, 19, 19, 20, 0, -19 },
  { 2770, 12, 19, 13, 0, -19 },
  { 2799, 11, 19, 13, 1, -19 },
  { 2826, 14, 27, 13, -1, -19 },
  { 2874, 12, 27, 14, 1, -19 },
  { 2915, 10, 19, 8, 0, -19 },
  { 2939, 11, 19, 10, -1, -19 },
  { 2966, 6, 23, 7, 1, -23 },
  { 2984, 12, 18, 13, 1, -18 },
  { 3011, 10, 18, 10, 2, -18 },
  { 3034, 16, 18, 17, 2, -18 },
  { 3070, 14, 18, 10, -2, -18 },
  { 3102, 16, 27, 11, -4, -18 },
  { 3156, 11, 18, 8, -1, -18 },
  { 3181, 12, 31, 11, 1, -25 },
  { 3228, 2, 36, 12, 5, -27 },
  { 3237, 12, 31, 11, -2, -25 },
  { 3284, 12, 3, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC35PT7B_H_
