#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x00, 0x00, 0x04, 0x08, 0x30, 0x00, 0x26, 0xCD,
  0x12, 0x24, 0x48, 0xA2, 0x44, 0x01, 0x18, 0x08, 0x80, 0x84, 0x04, 0x60,
  0x22, 0x03, 0x10, 0x10, 0x87, 0xFF, 0x04, 0x40, 0x42, 0x02, 0x20, 0x11,
  0x01, 0x08, 0x08, 0x80, 0x44, 0x1F, 0xF8, 0x22, 0x01, 0x10, 0x18, 0x80,
  0x8C, 0x04, 0x40, 0x22, 0x02, 0x30, 0x00, 0x00, 0x80, 0x08, 0x03, 0x80,
  0xF7, 0x19, 0x01, 0x10, 0x11, 0x01, 0x10, 0x12, 0x01, 0x20, 0x0A, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x05, 0x00, 0x48, 0x04, 0x80, 0x88, 0x08, 0x80,
  0x88, 0x09, 0x0C, 0xF0, 0x3C, 0x01, 0x00, 0x10, 0x01, 0x00, 0x0E, 0x04,
  0x24, 0x10, 0x8C, 0x21, 0x18, 0x86, 0x21, 0x08, 0x44, 0x10, 0x88, 0x21,
  0x20, 0x42, 0x40, 0x8D, 0x3B, 0x12, 0xCA, 0x29, 0x14, 0x94, 0x2E, 0x48,
  0x40, 0x90, 0x82, 0x61, 0x04, 0x84, 0x11, 0x08, 0x22, 0x10, 0x84, 0x61,
  0x08, 0x84, 0x13, 0x18, 0x3C, 0x00, 0x03, 0x81, 0x30, 0x8C, 0x23, 0x08,
  0xC2, 0x20, 0x88, 0x24, 0x09, 0x02, 0x80, 0xC0, 0x70, 0x34, 0x09, 0x14,
  0x27, 0x09, 0x82, 0xA0, 0xA8, 0x12, 0x04, 0x83, 0x21, 0x67, 0x88, 0x2D,
  0x24, 0xA4, 0x01, 0x81, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x00, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x20, 0x30, 0x10, 0x10, 0x10, 0x00, 0x08, 0x08, 0x90, 0x73, 0x1C, 0x28,
  0x48, 0x84, 0x04, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x32, 0x26, 0x44, 0x80, 0xFE, 0x5C, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x00, 0x07, 0x83, 0x31, 0x84,
  0x41, 0x30, 0x48, 0x12, 0x05, 0x81, 0x40, 0x50, 0x14, 0x0F, 0x02, 0x80,
  0xA0, 0x28, 0x0A, 0x06, 0x81, 0x20, 0x48, 0x22, 0x08, 0x84, 0x33, 0x07,
  0x80, 0x06, 0x18, 0xD3, 0x24, 0xC1, 0x02, 0x04, 0x08, 0x30, 0x40, 0x81,
  0x06, 0x08, 0x10, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30, 0x00, 0x03, 0xE0,
  0x43, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0xC3,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x01, 0x80, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x88, 0x30, 0xFE, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x50, 0x05, 0x00, 0xA0, 0x1A, 0x01, 0x20, 0x22, 0x02, 0x60, 0x44, 0x0C,
  0x40, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x84, 0x08, 0x40, 0x8F, 0xFE, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x03, 0xF8, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0xB0, 0x06,
  0xE0, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x41, 0x83, 0xF8, 0x00, 0x03, 0xE0, 0xC0,
  0x20, 0x0C, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x09, 0xC1, 0xC4,
  0x70, 0x4C, 0x09, 0x81, 0x20, 0x24, 0x04, 0x80, 0x90, 0x32, 0x04, 0x40,
  0x88, 0x21, 0x8C, 0x1F, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x21, 0x03, 0x10, 0x31,
  0x02, 0x10, 0x21, 0x06, 0x18, 0x40, 0x88, 0x07, 0x00, 0xE0, 0x13, 0x06,
  0x18, 0x40, 0x88, 0x08, 0x80, 0x88, 0x0C, 0x80, 0x88, 0x08, 0x81, 0x8C,
  0x10, 0x7E, 0x00, 0x07, 0xC1, 0x88, 0x60, 0x88, 0x11, 0x02, 0x40, 0x48,
  0x09, 0x01, 0x20, 0x24, 0x0C, 0x81, 0x90, 0x63, 0x1C, 0x3C, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x18, 0x3E, 0x00, 0x18,
  0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x18, 0xC0, 0x04, 0x30,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x21, 0x04,
  0x20, 0x80, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x02, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x08,
  0x00, 0x1F, 0x08, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x02, 0x03,
  0x01, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x00, 0x00, 0x04,
  0x02, 0x03, 0x00, 0x00, 0xF8, 0x06, 0x18, 0x10, 0x10, 0x40, 0x11, 0x80,
  0x22, 0x00, 0x48, 0x04, 0x90, 0xF1, 0x22, 0x22, 0x84, 0x45, 0x10, 0x8A,
  0x22, 0x1C, 0xC4, 0x71, 0x08, 0xA2, 0x31, 0x44, 0x42, 0x88, 0x89, 0x13,
  0x12, 0x39, 0xC4, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x61, 0x00, 0x3C, 0x00, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x1A, 0x02,
  0x40, 0x48, 0x11, 0x02, 0x20, 0xC4, 0x10, 0x82, 0x10, 0x82, 0x1F, 0xC6,
  0x08, 0x81, 0x10, 0x24, 0x04, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x60, 0x08,
  0x07, 0xC0, 0x47, 0x0C, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x81,
  0x10, 0x21, 0x06, 0x1F, 0x83, 0xF8, 0x30, 0xC2, 0x04, 0x20, 0x62, 0x06,
  0x60, 0x64, 0x04, 0x40, 0x44, 0x0C, 0x40, 0x8C, 0x30, 0xFE, 0x00, 0x01,
  0xF8, 0x30, 0x83, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x23, 0x03, 0x04, 0x10, 0x20, 0x81, 0x84, 0x04, 0x20,
  0x23, 0x01, 0x10, 0x08, 0x80, 0xC4, 0x06, 0x60, 0x22, 0x01, 0x10, 0x08,
  0x80, 0xC4, 0x04, 0x60, 0x22, 0x03, 0x10, 0x10, 0x81, 0x04, 0x18, 0x63,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x1F, 0xC3, 0xF8, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x04, 0x3F, 0x82, 0x00, 0x20,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x00, 0x01, 0xF8, 0x0C, 0x10, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0xF2,
  0x00, 0x48, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x00, 0x8C, 0x02, 0x10, 0x18,
  0x40, 0x40, 0x81, 0x01, 0xFC, 0x00, 0x04, 0x02, 0x08, 0x0C, 0x30, 0x10,
  0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x03, 0x0C, 0x04, 0x10, 0x08, 0x20,
  0x10, 0x7F, 0xE1, 0xFF, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x18,
  0x60, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x06, 0x18, 0x08, 0x20,
  0x10, 0x00, 0x07, 0xC0, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0x80, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x3C, 0x0E, 0x00, 0x04,
  0x0C, 0x10, 0x60, 0xC1, 0x02, 0x08, 0x08, 0x60, 0x21, 0x00, 0x88, 0x06,
  0x40, 0x13, 0x00, 0x48, 0x01, 0x40, 0x0F, 0x80, 0x32, 0x00, 0xC8, 0x02,
  0x20, 0x08, 0xC0, 0x61, 0x01, 0x04, 0x04, 0x10, 0x10, 0x60, 0x41, 0x83,
  0x02, 0x08, 0x08, 0x00, 0x04, 0x08, 0x30, 0x40, 0x81, 0x02, 0x0C, 0x10,
  0x20, 0x41, 0x82, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x18, 0x3F,
  0x80, 0x06, 0x00, 0x30, 0x60, 0x06, 0x0E, 0x00, 0x60, 0xA0, 0x0A, 0x0A,
  0x00, 0xA0, 0xA0, 0x16, 0x0A, 0x01, 0x41, 0xA0, 0x34, 0x12, 0x02, 0x41,
  0x20, 0x6C, 0x12, 0x04, 0x83, 0x20, 0xC8, 0x22, 0x08, 0x82, 0x21, 0x88,
  0x22, 0x11, 0x82, 0x21, 0x10, 0x62, 0x21, 0x04, 0x22, 0x10, 0x43, 0x41,
  0x04, 0x34, 0x30, 0x43, 0x82, 0x0C, 0x18, 0x20, 0x81, 0x02, 0x00, 0x04,
  0x03, 0x06, 0x02, 0x0E, 0x02, 0x0A, 0x02, 0x0A, 0x06, 0x0A, 0x04, 0x0B,
  0x04, 0x19, 0x04, 0x11, 0x04, 0x11, 0x0C, 0x11, 0x08, 0x31, 0x08, 0x21,
  0x88, 0x20, 0x88, 0x20, 0x98, 0x20, 0x90, 0x60, 0x90, 0x40, 0x90, 0x40,
  0x50, 0x40, 0x60, 0x40, 0x60, 0xC0, 0x60, 0x80, 0x60, 0x03, 0xE0, 0x31,
  0x83, 0x06, 0x30, 0x31, 0x00, 0x98, 0x04, 0x80, 0x24, 0x01, 0x60, 0x0A,
  0x00, 0xD0, 0x06, 0x80, 0x2C, 0x01, 0x60, 0x0A, 0x00, 0xD0, 0x04, 0x80,
  0x24, 0x03, 0x20, 0x11, 0x81, 0x84, 0x08, 0x30, 0x80, 0xF8, 0x00, 0x07,
  0x80, 0x46, 0x0C, 0x30, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x81, 0x10,
  0x31, 0x02, 0x10, 0x63, 0x0C, 0x3F, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x03, 0xE0,
  0x31, 0x83, 0x06, 0x30, 0x31, 0x00, 0x98, 0x04, 0x80, 0x24, 0x01, 0x60,
  0x0A, 0x00, 0xD0, 0x06, 0x80, 0x2C, 0x01, 0x60, 0x0A, 0x00, 0xD0, 0x04,
  0x80, 0x24, 0x03, 0x20, 0x11, 0x81, 0x84, 0x08, 0x30, 0x80, 0xF8, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x07, 0xC0, 0x46, 0x0C,
  0x30, 0x81, 0x08, 0x10, 0x81, 0x08, 0x11, 0x83, 0x10, 0x21, 0x02, 0x10,
  0x43, 0x1C, 0x3F, 0x02, 0x20, 0x22, 0x02, 0x30, 0x61, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x8C, 0x18, 0x80, 0x80, 0x03, 0xF0, 0x30, 0x43, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x40, 0xC3, 0xF8, 0x00, 0x7F, 0xC1, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x00, 0x08, 0x0C, 0x60, 0x21, 0x00, 0x84, 0x02, 0x10, 0x18, 0x40,
  0x43, 0x01, 0x08, 0x04, 0x20, 0x10, 0x80, 0x82, 0x02, 0x18, 0x08, 0x40,
  0x21, 0x01, 0x84, 0x04, 0x30, 0x10, 0x80, 0x42, 0x03, 0x08, 0x08, 0x20,
  0x20, 0x81, 0x81, 0x0C, 0x07, 0xE0, 0x00, 0x80, 0x30, 0x0A, 0x01, 0x40,
  0x68, 0x09, 0x03, 0x20, 0x44, 0x08, 0x82, 0x10, 0x42, 0x18, 0x42, 0x08,
  0xC1, 0x10, 0x22, 0x04, 0x80, 0x90, 0x16, 0x02, 0x80, 0x50, 0x0C, 0x01,
  0x80, 0x20, 0x00, 0x40, 0x20, 0x34, 0x06, 0x02, 0x40, 0x60, 0x24, 0x0E,
  0x06, 0x40, 0xA0, 0x44, 0x0A, 0x0C, 0x41, 0x20, 0x84, 0x12, 0x08, 0x43,
  0x21, 0x84, 0x22, 0x10, 0x42, 0x23, 0x04, 0x46, 0x20, 0x44, 0x62, 0x0C,
  0xC4, 0x60, 0xC8, 0x44, 0x0C, 0x84, 0xC0, 0xD0, 0x48, 0x0D, 0x04, 0x80,
  0xD0, 0x50, 0x0E, 0x05, 0x00, 0xA0, 0x50, 0x0E, 0x06, 0x00, 0xC0, 0x60,
  0x00, 0x02, 0x04, 0x08, 0x30, 0x20, 0x80, 0x86, 0x02, 0x10, 0x08, 0x80,
  0x32, 0x00, 0x50, 0x01, 0x40, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x80,
  0x1A, 0x00, 0x48, 0x03, 0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x08, 0x20,
  0x20, 0x81, 0x02, 0x0C, 0x0C, 0x00, 0x40, 0x50, 0x34, 0x09, 0x06, 0x41,
  0x10, 0xC4, 0x21, 0x18, 0x64, 0x0B, 0x02, 0x80, 0xE0, 0x30, 0x08, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08, 0x00, 0x07,
  0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0F, 0xC0, 0x86, 0x10, 0x84, 0x21, 0x08,
  0x61, 0x08, 0x42, 0x10, 0x86, 0x10, 0x84, 0x21, 0x08, 0x60, 0x03, 0xE0,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E,
  0x00, 0x06, 0x00, 0xC0, 0x3C, 0x04, 0x81, 0x90, 0x21, 0x0C, 0x21, 0x06,
  0x60, 0x48, 0x0E, 0x00, 0x80, 0xFF, 0x99, 0x12, 0x0F, 0xA3, 0x14, 0x41,
  0x90, 0x22, 0x04, 0x80, 0x90, 0x12, 0x06, 0xC0, 0x90, 0x12, 0x02, 0x40,
  0xC8, 0x19, 0x02, 0x20, 0xC6, 0x28, 0x79, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x5E, 0x1C, 0x63, 0x04, 0x60, 0x88,
  0x11, 0x02, 0x60, 0x48, 0x09, 0x01, 0x20, 0x24, 0x09, 0x81, 0x20, 0x24,
  0x08, 0xC3, 0x28, 0x44, 0xF0, 0x0F, 0x8C, 0x0C, 0x04, 0x06, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x7C,
  0x00, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00,
  0x81, 0xF4, 0x18, 0xA0, 0x83, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x21,
  0x03, 0x18, 0x10, 0x80, 0x84, 0x04, 0x20, 0x61, 0x03, 0x08, 0x10, 0x41,
  0x83, 0x14, 0x0F, 0x20, 0x0F, 0x8C, 0x4C, 0x24, 0x16, 0x0A, 0x0D, 0x0D,
  0x8C, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x84, 0x7E, 0x00,
  0x00, 0x3C, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0xF8, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x0B, 0x00, 0x30, 0x00, 0x03, 0xE8, 0x31, 0x41,
  0x06, 0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x42, 0x06, 0x30, 0x21, 0x01,
  0x08, 0x08, 0x40, 0xC2, 0x06, 0x10, 0x20, 0x83, 0x06, 0x28, 0x1E, 0x40,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x1D, 0xC0, 0x38,
  0x00, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10, 0x02, 0x00, 0x5E,
  0x1C, 0x63, 0x04, 0x60, 0x88, 0x31, 0x04, 0x60, 0x88, 0x11, 0x02, 0x20,
  0xC4, 0x11, 0x82, 0x20, 0x44, 0x08, 0x83, 0x30, 0x44, 0x08, 0x04, 0x30,
  0x40, 0x00, 0x00, 0x86, 0x10, 0x41, 0x04, 0x30, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x43, 0x08, 0x00, 0x00, 0x40, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x3C, 0x0C, 0x00, 0x04, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0x18, 0x42, 0x10, 0x46, 0x09, 0x81,
  0x20, 0x68, 0x0B, 0x01, 0xE0, 0x36, 0x0C, 0x41, 0x08, 0x21, 0x04, 0x20,
  0x84, 0x30, 0xC4, 0x08, 0x04, 0x10, 0x43, 0x08, 0x20, 0x82, 0x18, 0x41,
  0x04, 0x10, 0xC2, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x0B, 0xCF,
  0x0A, 0x28, 0xC6, 0x18, 0x23, 0x0C, 0x11, 0x04, 0x08, 0x82, 0x08, 0xC1,
  0x04, 0x40, 0x82, 0x20, 0xC1, 0x10, 0x41, 0x88, 0x20, 0x8C, 0x10, 0x44,
  0x18, 0x22, 0x08, 0x11, 0x04, 0x19, 0x82, 0x08, 0x81, 0x04, 0x00, 0x0B,
  0xC2, 0x8C, 0x60, 0x8C, 0x11, 0x06, 0x20, 0x8C, 0x11, 0x02, 0x20, 0x44,
  0x18, 0x82, 0x30, 0x44, 0x08, 0x81, 0x10, 0x66, 0x08, 0x81, 0x00, 0x0F,
  0x86, 0x23, 0x0C, 0x81, 0x60, 0x50, 0x14, 0x07, 0x03, 0xC0, 0xE0, 0x28,
  0x0A, 0x02, 0x81, 0x20, 0x48, 0x23, 0x18, 0x7C, 0x00, 0x05, 0xE0, 0xA3,
  0x0C, 0x10, 0xC1, 0x08, 0x10, 0x81, 0x18, 0x11, 0x01, 0x10, 0x11, 0x01,
  0x10, 0x33, 0x02, 0x30, 0x23, 0x04, 0x30, 0xC7, 0x08, 0x4F, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x0F, 0xA3, 0x14,
  0x42, 0x90, 0x26, 0x04, 0x80, 0x90, 0x12, 0x06, 0xC0, 0x90, 0x12, 0x02,
  0x40, 0xC8, 0x19, 0x02, 0x20, 0xC6, 0x28, 0x7B, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0B, 0x8A, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x01,
  0x01, 0x80, 0x80, 0x00, 0x0F, 0x88, 0x48, 0x04, 0x02, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x20, 0x10, 0x19, 0x08, 0xF8, 0x00,
  0x18, 0x41, 0x04, 0x7C, 0x82, 0x08, 0x21, 0x84, 0x10, 0x41, 0x0C, 0x20,
  0x82, 0x08, 0x20, 0xE0, 0x10, 0x4C, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x26,
  0x09, 0x02, 0x40, 0x90, 0x6C, 0x12, 0x04, 0x81, 0x20, 0xC8, 0x22, 0x18,
  0xFA, 0x00, 0x81, 0xC0, 0xA0, 0xD0, 0x48, 0x24, 0x22, 0x11, 0x10, 0x88,
  0x4C, 0x24, 0x16, 0x0A, 0x05, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x81, 0x07,
  0x06, 0x0A, 0x0C, 0x14, 0x18, 0x48, 0x50, 0x90, 0xA3, 0x22, 0x44, 0x44,
  0x88, 0x99, 0x21, 0x22, 0x42, 0x44, 0x85, 0x0A, 0x0A, 0x14, 0x1C, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0x81, 0x00, 0x08, 0x30, 0x86, 0x08, 0x40, 0x88,
  0x0C, 0x80, 0x50, 0x07, 0x00, 0x60, 0x04, 0x00, 0xA0, 0x0A, 0x01, 0x20,
  0x32, 0x02, 0x20, 0x43, 0x04, 0x10, 0x81, 0x00, 0x03, 0x02, 0x02, 0x0C,
  0x04, 0x10, 0x08, 0x20, 0x10, 0x80, 0x21, 0x00, 0x46, 0x00, 0x88, 0x01,
  0x30, 0x02, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x02, 0x00, 0x4C, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x20, 0x08, 0x04,
  0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x03, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x30, 0x08, 0x01, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0xE0,
  0x38, 0x01, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x01, 0x80, 0x38, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x40, 0x70, 0x00, 0x30, 0x39, 0x86, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 23, 7, 0, -23 },
  { 22, 7, 8, 9, 3, -23 },
  { 29, 13, 23, 12, 0, -23 },
  { 67, 12, 26, 11, 0, -24 },
  { 106, 15, 23, 17, 1, -23 },
  { 150, 10, 23, 11, 0, -23 },
  { 179, 3, 8, 5, 3, -23 },
  { 182, 9, 28, 8, 1, -23 },
  { 214, 9, 28, 8, -2, -23 },
  { 246, 8, 9, 10, 4, -24 },
  { 255, 11, 15, 13, 1, -19 },
  { 276, 4, 7, 5, -1, -3 },
  { 280, 7, 1, 8, 1, -9 },
  { 281, 2, 3, 5, 0, -3 },
  { 282, 13, 23, 10, -1, -23 },
  { 320, 10, 23, 11, 1, -23 },
  { 349, 7, 23, 11, 3, -23 },
  { 370, 12, 23, 11, -1, -23 },
  { 405, 12, 23, 11, -1, -23 },
  { 440, 12, 23, 11, -1, -23 },
  { 475, 13, 23, 11, -1, -23 },
  { 513, 11, 23, 11, 1, -23 },
  { 545, 12, 23, 11, 1, -23 },
  { 580, 12, 23, 11, 0, -23 },
  { 615, 11, 23, 11, 0, -23 },
  { 647, 5, 17, 5, 0, -17 },
  { 658, 6, 21, 5, -1, -17 },
  { 674, 11, 13, 13, 1, -18 },
  { 692, 11, 8, 13, 1, -15 },
  { 703, 11, 13, 13, 1, -18 },
  { 721, 9, 23, 8, 0, -23 },
  { 747, 15, 26, 17, 1, -23 },
  { 796, 11, 23, 11, -2, -23 },
  { 828, 12, 23, 12, 0, -23 },
  { 863, 13, 23, 11, 1, -23 },
  { 901, 13, 23, 14, 0, -23 },
  { 939, 12, 23, 11, 0, -23 },
  { 974, 12, 23, 10, 0, -23 },
  { 1009, 14, 23, 15, 1, -23 },
  { 1050, 15, 23, 14, 0, -23 },
  { 1094, 10, 23, 6, -2, -23 },
  { 1123, 11, 29, 5, -5, -23 },
  { 1163, 14, 23, 11, 0, -23 },
  { 1204, 7, 23, 10, 0, -23 },
  { 1225, 20, 23, 19, 0, -23 },
  { 1283, 16, 23, 15, 0, -23 },
  { 1329, 13, 23, 15, 1, -23 },
  { 1367, 12, 23, 12, 0, -23 },
  { 1402, 13, 28, 15, 1, -23 },
  { 1448, 12, 23, 12, 0, -23 },
  { 1483, 13, 23, 11, -1, -23 },
  { 1521, 10, 23, 10, 2, -23 },
  { 1550, 14, 23, 14, 1, -23 },
  { 1591, 11, 23, 11, 3, -23 },
  { 1623, 20, 23, 19, 2, -23 },
  { 1681, 14, 23, 10, -2, -23 },
  { 1722, 10, 23, 10, 2, -23 },
  { 1751, 13, 23, 10, -1, -23 },
  { 1789, 12, 28, 9, -1, -23 },
  { 1831, 5, 23, 10, 3, -23 },
  { 1846, 11, 28, 9, -2, -23 },
  { 1885, 11, 11, 13, 1, -23 },
  { 1901, 8, 1, 9, -2, 3 },
  { 1902, 3, 5, 7, 5, -24 },
  { 1904, 11, 17, 12, 1, -17 },
  { 1928, 11, 24, 12, 0, -24 },
  { 1961, 9, 17, 9, 1, -17 },
  { 1981, 13, 24, 12, 1, -24 },
  { 2020, 9, 17, 11, 1, -17 },
  { 2040, 14, 32, 6, -4, -24 },
  { 2096, 13, 25, 12, -1, -17 },
  { 2137, 11, 24, 12, 0, -24 },
  { 2170, 6, 23, 5, 0, -23 },
  { 2188, 10, 31, 5, -4, -23 },
  { 2227, 11, 24, 10, 0, -24 },
  { 2260, 6, 24, 5, 0, -24 },
  { 2278, 17, 17, 18, 0, -17 },
  { 2315, 11, 17, 12, 0, -17 },
  { 2339, 10, 17, 12, 1, -17 },
  { 2361, 12, 24, 12, -1, -17 },
  { 2397, 11, 25, 12, 1, -17 },
  { 2432, 9, 17, 8, 0, -17 },
  { 2452, 9, 17, 9, 0, -17 },
  { 2472, 6, 21, 6, 1, -21 },
  { 2488, 10, 17, 12, 1, -17 },
  { 2510, 9, 17, 9, 2, -17 },
  { 2530, 15, 17, 15, 2, -17 },
  { 2562, 12, 17, 9, -1, -17 },
  { 2588, 15, 25, 10, -4, -17 },
  { 2635, 10, 17, 8, -1, -17 },
  { 2657, 11, 28, 10, 1, -23 },
  { 2696, 1, 32, 11, 5, -24 },
  { 2700, 11, 28, 10, -2, -23 },
  { 2739, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC32PT7B_H_
