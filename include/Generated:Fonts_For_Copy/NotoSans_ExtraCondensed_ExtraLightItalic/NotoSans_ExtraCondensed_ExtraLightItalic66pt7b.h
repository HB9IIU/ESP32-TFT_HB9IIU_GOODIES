#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC6,
  0x06, 0x18, 0x18, 0xE0, 0x63, 0x83, 0x8C, 0x0C, 0x30, 0x30, 0xC0, 0xC3,
  0x03, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x10, 0x10, 0xC0, 0xC0,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0xE0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x06, 0x03, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00, 0x1C, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x78, 0xC1, 0x80, 0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x07, 0x06, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x04,
  0x00, 0x03, 0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0xC2, 0x00, 0x00, 0x39, 0x80, 0x00, 0x06, 0x60, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x70, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x18, 0x70, 0x00, 0x06, 0x1C, 0x00,
  0x01, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x18,
  0x18, 0x00, 0x06, 0x0E, 0x02, 0x01, 0x87, 0x00, 0x70, 0x47, 0x80, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xC0, 0x39, 0xC0, 0x06, 0x01, 0xC3, 0x00, 0x38, 0x0E, 0x0E, 0x00, 0xC0,
  0x30, 0x38, 0x07, 0x01, 0xC0, 0xE0, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x18,
  0x0E, 0x03, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x03,
  0x03, 0x80, 0x70, 0x0C, 0x0C, 0x01, 0xC0, 0x30, 0x70, 0x06, 0x00, 0xC1,
  0x80, 0x18, 0x07, 0x0E, 0x00, 0x60, 0x18, 0x30, 0x03, 0x80, 0x61, 0xC0,
  0x0E, 0x01, 0x86, 0x00, 0x30, 0x0E, 0x38, 0x38, 0xC0, 0x30, 0xC3, 0xFB,
  0x00, 0xC7, 0x1C, 0xEC, 0x07, 0x18, 0xE1, 0xF0, 0x18, 0xE3, 0x03, 0xC0,
  0xE3, 0x1C, 0x0F, 0x83, 0x1C, 0x60, 0x3E, 0x1C, 0x63, 0x80, 0xDD, 0xE3,
  0x8C, 0x03, 0x3F, 0x0C, 0x30, 0x0C, 0x70, 0x71, 0xC0, 0x70, 0x01, 0x86,
  0x01, 0xC0, 0x0E, 0x18, 0x06, 0x00, 0x30, 0xE0, 0x18, 0x01, 0xC3, 0x80,
  0x60, 0x06, 0x0C, 0x01, 0x80, 0x38, 0x30, 0x0E, 0x00, 0xC0, 0xC0, 0x30,
  0x07, 0x03, 0x00, 0xC0, 0x18, 0x1C, 0x03, 0x00, 0xE0, 0x70, 0x1C, 0x03,
  0x01, 0xC0, 0x60, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x1C, 0x0C, 0x03, 0x80,
  0x70, 0x30, 0x0C, 0x00, 0xC1, 0x80, 0x70, 0x03, 0x0E, 0x01, 0x80, 0x0E,
  0x70, 0x0E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80,
  0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C,
  0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00,
  0x0E, 0x70, 0x00, 0x38, 0x60, 0x10, 0xE0, 0xC0, 0xC1, 0x81, 0xC1, 0x87,
  0x03, 0x87, 0x1C, 0x03, 0x0C, 0x38, 0x06, 0x18, 0x60, 0x0E, 0x71, 0xC0,
  0x1C, 0xC3, 0x00, 0x19, 0x86, 0x00, 0x37, 0x1C, 0x00, 0x7C, 0x38, 0x00,
  0xF8, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x1F,
  0x03, 0x00, 0x36, 0x07, 0x00, 0xCE, 0x0F, 0x03, 0x9C, 0x0F, 0xFE, 0x18,
  0x0F, 0xF0, 0x30, 0x07, 0x00, 0x00, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C,
  0x30, 0xC3, 0x18, 0x61, 0x86, 0x10, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x08, 0x0C, 0x06, 0x04, 0x03, 0xC6, 0x00, 0x7B,
  0x0E, 0x0F, 0xFF, 0x81, 0xF8, 0x00, 0xE0, 0x00, 0xD8, 0x01, 0xCC, 0x01,
  0xC3, 0x01, 0xC1, 0x81, 0xC0, 0x60, 0x40, 0x38, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x18, 0x03, 0x80, 0x70,
  0x0C, 0x01, 0xC0, 0x70, 0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30,
  0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x38, 0x60,
  0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07, 0x01,
  0x80, 0x18, 0x06, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE1,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xE0, 0x77, 0x0F, 0x30, 0xE1, 0x9E, 0x0C, 0x60,
  0xE2, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x0F, 0x01, 0xE0, 0x02, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1E, 0x01, 0xC0, 0x0C, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x08, 0x00, 0x70, 0x06, 0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xB8, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x18,
  0x00, 0x0C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x06, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0x70, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x70, 0x01, 0x80, 0x30,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0D, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x02, 0x00, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x70, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC3, 0xE0, 0x03, 0x1F,
  0xF0, 0x06, 0x79, 0xF0, 0x1D, 0x80, 0xF0, 0x36, 0x00, 0xE0, 0x78, 0x00,
  0xC0, 0xF0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xE1,
  0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18,
  0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80,
  0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x06, 0x01, 0xC0, 0x0E, 0x07,
  0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x18, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x70,
  0x00, 0x30, 0x38, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1C, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0xFB, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x60,
  0x03, 0x01, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x86, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x30,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x0F, 0x06,
  0x00, 0x1E, 0x0E, 0x00, 0x7C, 0x1C, 0x01, 0xB0, 0x1C, 0x06, 0x60, 0x1F,
  0xF9, 0xC0, 0x1F, 0xE3, 0x80, 0x1F, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x10, 0x1E, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0xC0, 0x7D, 0xF8, 0x18, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x07, 0x06, 0x00, 0x7E, 0x07, 0x0C, 0x01, 0xFF, 0x07,
  0x0C, 0x03, 0x86, 0x07, 0x1C, 0x07, 0x06, 0x06, 0x18, 0x06, 0x06, 0x06,
  0x18, 0x0C, 0x0E, 0x06, 0x38, 0x1C, 0x0C, 0x06, 0x30, 0x18, 0x0C, 0x06,
  0x30, 0x38, 0x0C, 0x06, 0x30, 0x30, 0x1C, 0x06, 0x70, 0x30, 0x18, 0x0E,
  0x60, 0x70, 0x18, 0x0C, 0x60, 0x60, 0x18, 0x0C, 0x60, 0x60, 0x38, 0x0C,
  0x60, 0x60, 0x30, 0x1C, 0xE0, 0xE0, 0x30, 0x18, 0xC0, 0xE0, 0x70, 0x18,
  0xC0, 0xC0, 0x70, 0x38, 0xC0, 0xC0, 0x70, 0x30, 0xC0, 0xC0, 0xE0, 0x30,
  0xC0, 0xC0, 0xE0, 0x60, 0xC0, 0xC0, 0xE0, 0x60, 0xC0, 0xC1, 0xA0, 0xC0,
  0xC0, 0xE3, 0x31, 0xC0, 0xC0, 0x7F, 0x3F, 0x80, 0xC0, 0x7E, 0x1F, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00,
  0x60, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0,
  0xC0, 0x06, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xC0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x30, 0x0E, 0x00, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xFC, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xE0, 0x03,
  0x03, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x80, 0x03, 0x0E,
  0x00, 0x0C, 0x70, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x38, 0x00,
  0x0C, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xDC, 0x00, 0x03, 0x60, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0x01, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0x80,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0xF0, 0x03,
  0x00, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1C, 0x1F, 0x80,
  0x06, 0x00, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x01, 0x80, 0x0E, 0x00, 0x60, 0x1F, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x7C, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x40, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xC0, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0C, 0x00,
  0x07, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x06,
  0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x06, 0x03, 0x00,
  0x01, 0xC0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80,
  0x70, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x01, 0x80, 0x07, 0x80, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x30, 0x07, 0x80, 0x06,
  0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xBF, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xC1, 0xC0, 0x03, 0xFE, 0x06, 0x00, 0x0F, 0xF8, 0x18, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x38, 0x06, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00,
  0x0C, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x06,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x60, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x38, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x1C, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30,
  0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x1D, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x06, 0xCC, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x06, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0x60, 0x00, 0x01,
  0xF0, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00,
  0xEC, 0x00, 0x00, 0x6E, 0x00, 0x66, 0x00, 0x00, 0x77, 0x00, 0x33, 0x00,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x00, 0x39, 0x80, 0x1C, 0xC0, 0x00, 0x19,
  0xC0, 0x0E, 0x60, 0x00, 0x1C, 0xE0, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x03, 0x86,
  0x00, 0x30, 0xE0, 0x01, 0x83, 0x00, 0x18, 0x70, 0x01, 0xC1, 0x80, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00,
  0x70, 0x60, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x81, 0x80, 0x38, 0x38,
  0x01, 0xC0, 0xC0, 0x18, 0x1C, 0x00, 0xC0, 0x60, 0x1C, 0x0E, 0x00, 0x60,
  0x30, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x06,
  0x03, 0x80, 0x1C, 0x06, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x83, 0x80, 0x60, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x03, 0x80,
  0x61, 0xC0, 0x38, 0x01, 0xC0, 0x38, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0xE0,
  0x0C, 0x00, 0x60, 0x0E, 0x60, 0x06, 0x00, 0x70, 0x07, 0x70, 0x07, 0x00,
  0x38, 0x03, 0xB8, 0x03, 0x80, 0x18, 0x01, 0xD8, 0x01, 0xC0, 0x0C, 0x00,
  0xFC, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x07, 0x00, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x6C, 0x00, 0x06, 0x00, 0x6C, 0x00, 0x0E, 0x00, 0x6C, 0x00, 0x0E, 0x00,
  0xEE, 0x00, 0x0E, 0x00, 0xEE, 0x00, 0x0C, 0x00, 0xE6, 0x00, 0x0C, 0x00,
  0xC6, 0x00, 0x1C, 0x00, 0xC6, 0x00, 0x1C, 0x01, 0xC6, 0x00, 0x18, 0x01,
  0xC7, 0x00, 0x18, 0x01, 0x87, 0x00, 0x18, 0x01, 0x83, 0x00, 0x38, 0x01,
  0x83, 0x00, 0x38, 0x03, 0x83, 0x00, 0x30, 0x03, 0x83, 0x00, 0x30, 0x03,
  0x03, 0x80, 0x30, 0x03, 0x03, 0x80, 0x70, 0x03, 0x01, 0x80, 0x70, 0x07,
  0x01, 0x80, 0x60, 0x07, 0x01, 0x80, 0x60, 0x06, 0x01, 0xC0, 0xE0, 0x06,
  0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xC0, 0xC0, 0x0E, 0x00, 0xC0, 0xC0, 0x0E,
  0x00, 0xC0, 0xC0, 0x0C, 0x00, 0xC1, 0xC0, 0x0C, 0x00, 0xE1, 0xC0, 0x1C,
  0x00, 0xE1, 0x80, 0x1C, 0x00, 0x61, 0x80, 0x18, 0x00, 0x61, 0x80, 0x18,
  0x00, 0x63, 0x80, 0x18, 0x00, 0x73, 0x80, 0x38, 0x00, 0x73, 0x00, 0x38,
  0x00, 0x33, 0x00, 0x30, 0x00, 0x33, 0x00, 0x30, 0x00, 0x37, 0x00, 0x70,
  0x00, 0x37, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x60,
  0x00, 0x1E, 0x00, 0x60, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x0C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0C, 0x1F, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0x80, 0x60, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x1C, 0x01,
  0xE0, 0x0E, 0x01, 0xE0, 0x06, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x60, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x60, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00,
  0x38, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0C, 0x1F, 0x00, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x01, 0xC0,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x03,
  0x00, 0x0E, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80,
  0x60, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x03, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x1C,
  0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x03,
  0x80, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x1E, 0x00, 0x60, 0x07, 0x80, 0x04, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x08, 0x00, 0x3C, 0x01, 0xC0,
  0x0F, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x18,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x07,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0,
  0x38, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38,
  0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x00,
  0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03,
  0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0x60, 0x01, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x38, 0x06,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x1C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x01, 0x80, 0x06, 0x07,
  0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0,
  0x00, 0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x38, 0x00,
  0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x60, 0x00, 0x1C, 0x00, 0x06, 0x60, 0x00, 0x3C, 0x00, 0x0E,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x60, 0x00,
  0x78, 0x00, 0x1C, 0xE0, 0x00, 0x78, 0x00, 0x18, 0xE0, 0x00, 0xD8, 0x00,
  0x38, 0xE0, 0x00, 0xD8, 0x00, 0x38, 0xE0, 0x01, 0xD8, 0x00, 0x30, 0xE0,
  0x01, 0x98, 0x00, 0x70, 0xE0, 0x01, 0x98, 0x00, 0x60, 0xE0, 0x03, 0x98,
  0x00, 0xE0, 0xE0, 0x03, 0x18, 0x00, 0xE0, 0xE0, 0x07, 0x18, 0x00, 0xC0,
  0xE0, 0x06, 0x18, 0x01, 0xC0, 0xE0, 0x06, 0x18, 0x01, 0x80, 0xE0, 0x0E,
  0x18, 0x03, 0x80, 0xE0, 0x0C, 0x18, 0x03, 0x80, 0xE0, 0x1C, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x18, 0x06, 0x00, 0xE0,
  0x38, 0x18, 0x0E, 0x00, 0xE0, 0x30, 0x18, 0x0E, 0x00, 0xE0, 0x30, 0x18,
  0x0C, 0x00, 0xE0, 0x60, 0x18, 0x1C, 0x00, 0xE0, 0x60, 0x18, 0x18, 0x00,
  0xC0, 0xE0, 0x18, 0x38, 0x00, 0xC0, 0xC0, 0x38, 0x38, 0x00, 0xC0, 0xC0,
  0x38, 0x30, 0x00, 0xC1, 0xC0, 0x38, 0x70, 0x00, 0xC1, 0x80, 0x38, 0x60,
  0x00, 0xC3, 0x80, 0x38, 0xE0, 0x00, 0xC3, 0x00, 0x38, 0xE0, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x33, 0x80, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x00, 0xDC, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0xC0, 0x03, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x06,
  0x03, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x70, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x1C, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x1C, 0x0C, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0x60, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x18, 0x0E,
  0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00,
  0x60, 0xC0, 0x01, 0x87, 0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x33,
  0x00, 0x00, 0xDC, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x70,
  0x00, 0x70, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x86,
  0x1C, 0x30, 0xC1, 0x86, 0x0C, 0x10, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x0C,
  0x03, 0xFF, 0x18, 0x0F, 0x07, 0x70, 0x3C, 0x06, 0xC0, 0x70, 0x05, 0x81,
  0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0C, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x06,
  0x00, 0x1E, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0x60, 0x70,
  0x07, 0xC0, 0x70, 0x1B, 0x00, 0xE0, 0x66, 0x00, 0xFF, 0xCC, 0x00, 0xFE,
  0x18, 0x00, 0x70, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x40, 0x00, 0xC7, 0xF0, 0x01, 0xCF, 0xFC, 0x01, 0xDC, 0x1C, 0x01,
  0xB0, 0x0E, 0x01, 0xB0, 0x0E, 0x01, 0xE0, 0x06, 0x03, 0xC0, 0x06, 0x03,
  0xC0, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x07, 0x07, 0x00, 0x06, 0x07,
  0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0E,
  0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x0C,
  0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x38,
  0x00, 0x60, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xC0, 0x6C, 0x01, 0xC0, 0x6C,
  0x03, 0x80, 0x66, 0x07, 0x00, 0x67, 0xFE, 0x00, 0xC3, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x81, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x04, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x60, 0x00, 0xFE, 0x18, 0x00, 0xFF, 0xCE, 0x00, 0x78, 0x3B,
  0x80, 0x3C, 0x06, 0xC0, 0x0E, 0x00, 0xB0, 0x07, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00,
  0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x1E,
  0x00, 0xE0, 0x05, 0x80, 0x38, 0x03, 0xE0, 0x07, 0x01, 0xB0, 0x01, 0xC0,
  0xCC, 0x00, 0x3F, 0xE3, 0x00, 0x07, 0xF0, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xF0, 0x70, 0x38, 0x0E,
  0x0E, 0x00, 0xC1, 0xC0, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x1C,
  0x60, 0x03, 0x9C, 0x00, 0x63, 0x80, 0x1C, 0x60, 0x07, 0x1C, 0x01, 0xC3,
  0x80, 0x70, 0x60, 0x3C, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x01, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x33, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xFC, 0x30, 0x01, 0xFF, 0x8C, 0x00, 0xF0,
  0x77, 0x00, 0x78, 0x0D, 0x80, 0x1C, 0x01, 0x60, 0x0E, 0x00, 0x78, 0x07,
  0x00, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0E,
  0x01, 0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x07, 0x00,
  0x3C, 0x01, 0xC0, 0x0B, 0x00, 0x70, 0x07, 0xC0, 0x0C, 0x03, 0x60, 0x03,
  0x81, 0x98, 0x00, 0x7F, 0xE6, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x80, 0x1C, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x31, 0xFC, 0x01, 0xCF, 0xF8,
  0x07, 0x60, 0x70, 0x1B, 0x00, 0xC0, 0x78, 0x03, 0x01, 0xC0, 0x0C, 0x0F,
  0x00, 0x30, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x1C, 0x0C, 0x00,
  0x70, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0,
  0x60, 0x03, 0x83, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06,
  0x06, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x70, 0x30, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x60, 0x03, 0x83, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x9F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xC0, 0x0C, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60,
  0x01, 0x81, 0xC0, 0x03, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00,
  0x30, 0xE0, 0x00, 0x63, 0x80, 0x00, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x07,
  0x6C, 0x00, 0x0D, 0x98, 0x00, 0x1F, 0x30, 0x00, 0x3C, 0x70, 0x00, 0xF0,
  0xE0, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x1C, 0x06,
  0x00, 0x38, 0x0E, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x80,
  0x60, 0x07, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x18, 0xFE, 0x0F,
  0xF0, 0x06, 0x7F, 0xE3, 0xFF, 0x00, 0xDC, 0x1C, 0xE0, 0xE0, 0x1B, 0x01,
  0xF0, 0x0E, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x38, 0x1E,
  0x00, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C,
  0x0C, 0x00, 0x60, 0x03, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x80,
  0x0C, 0x0E, 0x00, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x00, 0x70, 0x30, 0x01,
  0x80, 0x0C, 0x0E, 0x00, 0x30, 0x01, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x30,
  0x01, 0xC0, 0x0E, 0x06, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x38, 0x00, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xC0, 0x07, 0x00,
  0x38, 0x18, 0x00, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xE0, 0x03,
  0x00, 0x18, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x60,
  0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x03, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x60, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x00,
  0x60, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x03, 0x1F, 0xC0,
  0x18, 0xFF, 0x80, 0x66, 0x07, 0x01, 0xB0, 0x1C, 0x07, 0x80, 0x30, 0x1C,
  0x00, 0xC0, 0xF0, 0x03, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0xE0, 0x60, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x60, 0x01,
  0x81, 0x80, 0x06, 0x06, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0x86,
  0x00, 0x0E, 0x70, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xCE, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00, 0x03, 0x98, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x33, 0x80, 0x03, 0x98, 0x00, 0x1C,
  0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00,
  0x38, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x81, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x03, 0x1F, 0xC0, 0x00, 0xC7, 0xFC, 0x00, 0x19, 0xC1,
  0xC0, 0x03, 0x70, 0x1C, 0x00, 0x6C, 0x03, 0x80, 0x0F, 0x00, 0x30, 0x03,
  0xC0, 0x06, 0x00, 0x78, 0x00, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38,
  0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x18, 0x07, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x7C, 0x01, 0xC0, 0x0D,
  0x80, 0x70, 0x01, 0x98, 0x1C, 0x00, 0x33, 0xFF, 0x00, 0x0E, 0x3F, 0xC0,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0x0C, 0x03, 0xFF,
  0x18, 0x0F, 0x07, 0x70, 0x38, 0x06, 0xC0, 0x60, 0x05, 0x81, 0xC0, 0x0F,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38,
  0x00, 0x18, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00,
  0x03, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x60, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x1C,
  0x0C, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0x60, 0x70, 0x07, 0xC0,
  0x60, 0x1B, 0x00, 0xE0, 0x66, 0x00, 0xFF, 0xCC, 0x00, 0xFE, 0x38, 0x00,
  0x70, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x80, 0x18, 0xFC, 0x06, 0x3F, 0x00, 0xCE, 0x00, 0x1B, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1C, 0x07, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x80, 0x1C, 0x0C, 0x03,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F, 0xF8,
  0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x38, 0x00, 0x03, 0x00, 0x1C,
  0x1C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x81,
  0x80, 0x0E, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x30,
  0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x00, 0x3C, 0x0C, 0x01, 0xE0, 0x30, 0x0D,
  0x80, 0xE0, 0x76, 0x01, 0xFF, 0x98, 0x03, 0xF8, 0xC0, 0x03, 0x80, 0x00,
  0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x03, 0x30,
  0x01, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01,
  0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0C, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0xC1, 0x80, 0x30,
  0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xC0,
  0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x06, 0xC0, 0x07,
  0x80, 0x3B, 0x00, 0x36, 0x00, 0xCC, 0x00, 0xD8, 0x03, 0x30, 0x07, 0x60,
  0x1C, 0xC0, 0x19, 0x80, 0x63, 0x00, 0x66, 0x03, 0x8C, 0x03, 0x18, 0x0C,
  0x30, 0x0C, 0x60, 0x30, 0xC0, 0x71, 0x81, 0xC3, 0x01, 0x86, 0x06, 0x0C,
  0x06, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xC0, 0xC1, 0x83, 0x03, 0x07,
  0x06, 0x1C, 0x0C, 0x18, 0x38, 0x60, 0x30, 0xE0, 0xE1, 0x80, 0xC3, 0x03,
  0x8C, 0x03, 0x0C, 0x0E, 0x30, 0x0C, 0x70, 0x39, 0xC0, 0x31, 0x80, 0xE6,
  0x00, 0xCE, 0x03, 0x18, 0x03, 0x30, 0x0C, 0xC0, 0x0C, 0xC0, 0x33, 0x00,
  0x37, 0x00, 0xCC, 0x00, 0xD8, 0x03, 0x60, 0x03, 0x60, 0x0D, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xC0, 0x03,
  0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00,
  0x18, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0x87,
  0x00, 0x01, 0xC1, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0,
  0x30, 0x00, 0x60, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x38, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0x8C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x8F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x3E,
  0x00, 0xFF, 0xE8, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 47, 14, 1, -47 },
  { 78, 14, 17, 18, 6, -47 },
  { 108, 26, 47, 25, 0, -47 },
  { 261, 26, 54, 23, -1, -50 },
  { 437, 30, 49, 36, 3, -48 },
  { 621, 23, 49, 23, -1, -48 },
  { 762, 6, 17, 10, 6, -47 },
  { 775, 18, 57, 16, 2, -47 },
  { 904, 19, 57, 16, -5, -47 },
  { 1040, 17, 18, 22, 8, -50 },
  { 1079, 23, 31, 27, 2, -39 },
  { 1169, 9, 14, 11, -3, -6 },
  { 1185, 15, 2, 17, 1, -19 },
  { 1189, 4, 5, 11, 1, -5 },
  { 1192, 27, 47, 20, -3, -47 },
  { 1351, 22, 49, 23, 1, -48 },
  { 1486, 13, 47, 23, 7, -47 },
  { 1563, 25, 48, 23, -2, -48 },
  { 1713, 25, 49, 23, -1, -48 },
  { 1867, 25, 48, 23, -1, -48 },
  { 2017, 26, 48, 23, -2, -47 },
  { 2173, 23, 49, 23, 2, -48 },
  { 2314, 24, 47, 23, 2, -47 },
  { 2455, 25, 49, 23, -1, -48 },
  { 2609, 23, 49, 23, 0, -48 },
  { 2750, 10, 35, 11, 0, -35 },
  { 2794, 14, 43, 11, -3, -35 },
  { 2870, 23, 27, 27, 2, -37 },
  { 2948, 23, 16, 27, 2, -31 },
  { 2994, 23, 27, 27, 2, -37 },
  { 3072, 18, 48, 17, 1, -48 },
  { 3180, 32, 53, 35, 2, -47 },
  { 3392, 22, 47, 23, -4, -47 },
  { 3522, 26, 47, 25, 0, -47 },
  { 3675, 26, 49, 23, 2, -48 },
  { 3835, 27, 47, 28, 0, -47 },
  { 3994, 25, 47, 23, 0, -47 },
  { 4141, 25, 47, 21, 0, -47 },
  { 4288, 30, 49, 30, 2, -48 },
  { 4472, 31, 47, 30, 0, -47 },
  { 4655, 21, 47, 12, -4, -47 },
  { 4779, 22, 59, 11, -9, -47 },
  { 4942, 29, 47, 24, 0, -47 },
  { 5113, 15, 47, 20, 0, -47 },
  { 5202, 41, 47, 40, 0, -47 },
  { 5443, 32, 47, 31, 0, -47 },
  { 5631, 27, 49, 30, 2, -48 },
  { 5797, 25, 47, 24, 0, -47 },
  { 5944, 27, 59, 30, 2, -48 },
  { 6144, 25, 47, 24, 0, -47 },
  { 6291, 27, 49, 23, -2, -48 },
  { 6457, 21, 47, 20, 4, -47 },
  { 6581, 28, 48, 29, 2, -47 },
  { 6749, 23, 47, 24, 6, -47 },
  { 6885, 40, 47, 40, 5, -47 },
  { 7120, 30, 47, 21, -4, -47 },
  { 7297, 22, 47, 20, 4, -47 },
  { 7427, 27, 47, 21, -3, -47 },
  { 7586, 23, 58, 18, -1, -47 },
  { 7753, 9, 47, 21, 7, -47 },
  { 7806, 23, 58, 18, -4, -47 },
  { 7973, 25, 23, 26, 1, -47 },
  { 8045, 18, 2, 18, -5, 6 },
  { 8050, 6, 10, 14, 10, -50 },
  { 8058, 23, 37, 26, 2, -36 },
  { 8165, 24, 51, 25, 0, -50 },
  { 8318, 18, 37, 18, 2, -36 },
  { 8402, 26, 51, 26, 2, -50 },
  { 8568, 19, 37, 22, 2, -36 },
  { 8656, 30, 66, 13, -9, -50 },
  { 8904, 26, 52, 25, -1, -36 },
  { 9073, 22, 50, 24, 0, -50 },
  { 9211, 13, 47, 11, 0, -47 },
  { 9288, 22, 63, 11, -9, -47 },
  { 9462, 23, 50, 20, 0, -50 },
  { 9606, 13, 50, 10, 0, -50 },
  { 9688, 35, 36, 37, 0, -36 },
  { 9846, 22, 36, 24, 0, -36 },
  { 9945, 21, 37, 24, 2, -36 },
  { 10043, 27, 51, 25, -3, -36 },
  { 10216, 23, 52, 26, 2, -36 },
  { 10366, 19, 36, 16, 0, -36 },
  { 10452, 20, 37, 19, -1, -36 },
  { 10545, 13, 44, 13, 1, -43 },
  { 10617, 22, 36, 24, 2, -35 },
  { 10716, 18, 35, 19, 4, -35 },
  { 10795, 30, 35, 31, 4, -35 },
  { 10927, 25, 35, 20, -3, -35 },
  { 11037, 30, 51, 20, -7, -35 },
  { 11229, 20, 35, 16, -2, -35 },
  { 11317, 23, 57, 21, 2, -47 },
  { 11481, 2, 66, 23, 10, -50 },
  { 11498, 22, 57, 21, -4, -47 },
  { 11655, 23, 6, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC66PT7B_H_
