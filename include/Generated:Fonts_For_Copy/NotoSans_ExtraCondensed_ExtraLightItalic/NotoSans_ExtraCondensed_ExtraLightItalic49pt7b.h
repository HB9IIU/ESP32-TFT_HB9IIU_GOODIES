#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0xE0, 0x30, 0x0C, 0x00, 0x30, 0xCC, 0x32,
  0x09, 0x86, 0x61, 0x98, 0x64, 0x11, 0x04, 0xC3, 0x30, 0xCC, 0x22, 0x08,
  0x82, 0x00, 0x00, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x60,
  0x02, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x20, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x18, 0x20, 0x02, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x20, 0x02, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x20, 0x03,
  0x04, 0x00, 0x41, 0x80, 0x18, 0x30, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x18,
  0x30, 0x03, 0x04, 0x00, 0x41, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x41,
  0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0x60, 0x80, 0x08, 0x30, 0x03, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0xFF, 0x00, 0x7F, 0xF0, 0x31, 0x84, 0x18, 0x40, 0x04, 0x10, 0x03, 0x04,
  0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x20, 0x03, 0x08, 0x00, 0xC6, 0x00,
  0x19, 0x80, 0x03, 0x40, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x2C, 0x00, 0x09, 0x80, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x43,
  0x00, 0x10, 0x40, 0x04, 0x10, 0x01, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0xC0,
  0x08, 0x60, 0x82, 0x30, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x18, 0x39,
  0x80, 0x40, 0xC6, 0x03, 0x06, 0x18, 0x08, 0x10, 0x60, 0x60, 0xC1, 0x81,
  0x03, 0x06, 0x0C, 0x08, 0x18, 0x20, 0x60, 0x61, 0x81, 0x81, 0x84, 0x06,
  0x04, 0x30, 0x10, 0x10, 0x80, 0x40, 0xC6, 0x03, 0x03, 0x10, 0x0C, 0x08,
  0xC7, 0xB0, 0x62, 0x33, 0xC1, 0x99, 0x87, 0x0C, 0x4C, 0x1C, 0x33, 0x30,
  0x59, 0x88, 0x81, 0x7C, 0x66, 0x04, 0x01, 0x18, 0x10, 0x0C, 0x40, 0xC0,
  0x23, 0x03, 0x01, 0x8C, 0x0C, 0x04, 0x30, 0x30, 0x30, 0xC0, 0x80, 0x82,
  0x06, 0x06, 0x08, 0x18, 0x10, 0x20, 0x40, 0xC0, 0x83, 0x02, 0x02, 0x0C,
  0x18, 0x08, 0x60, 0x40, 0x33, 0x03, 0x00, 0x78, 0x00, 0x00, 0x80, 0x00,
  0x3E, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x10, 0x60, 0x18, 0x30, 0x0C, 0x18,
  0x06, 0x0C, 0x03, 0x04, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x19, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0x90, 0x01, 0x8C, 0x01, 0xC6, 0x18, 0xC3, 0x0C, 0xC0, 0x8C,
  0x60, 0x66, 0x60, 0x33, 0x30, 0x1B, 0x18, 0x05, 0x88, 0x03, 0x8C, 0x01,
  0xC6, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x78, 0x60, 0x6C, 0x38, 0xE2, 0x0F,
  0xE1, 0x80, 0x33, 0x26, 0x66, 0x64, 0x4C, 0xC8, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x00, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x20, 0x02, 0x08, 0x20, 0xE2, 0x03, 0x63, 0x0F, 0xF0, 0xE0, 0x1A,
  0x03, 0x30, 0x61, 0x0C, 0x18, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x30, 0xC6, 0x18, 0x63, 0x0C,
  0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xF8, 0x5F, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xCE, 0x01, 0x83, 0x03, 0x03, 0x06, 0x03, 0x06, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x40, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60,
  0xC0, 0x60, 0xC0, 0xC0, 0x61, 0xC0, 0x73, 0x80, 0x3F, 0x00, 0x01, 0xC0,
  0xE0, 0x78, 0x76, 0x39, 0xBC, 0x44, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x00, 0x7F, 0x80, 0x3C, 0x38, 0x02,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x38, 0x70, 0x0C,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x80, 0x70,
  0x1C, 0x1C, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x19, 0x00, 0x03,
  0x60, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06, 0x20, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x0C, 0x30, 0x01, 0x06, 0x00, 0x60, 0x80, 0x18, 0x30, 0x03, 0x06,
  0x00, 0xC0, 0xC0, 0x10, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x03, 0x03, 0x00, 0x40, 0x60, 0x18, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x08, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x80, 0x70, 0x1C, 0x3C, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x38,
  0x40, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xCF, 0xC0, 0x4C, 0x70, 0x68, 0x0C, 0x38, 0x06, 0x1C, 0x03,
  0x0C, 0x00, 0x86, 0x00, 0x67, 0x00, 0x33, 0x00, 0x11, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x0C, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x18, 0xE0, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x70, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x06, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x40,
  0xC0, 0x18, 0x08, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x03, 0x06, 0x00,
  0x63, 0x80, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1C, 0x60, 0x07,
  0x0E, 0x01, 0x80, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x02, 0x0C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x60, 0x30, 0x1C, 0x07, 0x8F, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0xE3, 0x80, 0xC0, 0xC0, 0xE0, 0x20, 0x60,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x18, 0x80, 0x0C, 0x40, 0x0C, 0x20, 0x06,
  0x18, 0x07, 0x0C, 0x03, 0x87, 0x02, 0xC1, 0xC7, 0x60, 0x7E, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x43, 0xC0, 0x3F, 0x80, 0x00, 0x06, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0xC0, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x00, 0x0F, 0xE0, 0xE3, 0x84, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1E, 0x38, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x06, 0x01, 0x00, 0x02, 0x03, 0x00, 0x03, 0x06, 0x00, 0x03, 0x04,
  0x00, 0x03, 0x0C, 0x00, 0x03, 0x08, 0x0F, 0xC3, 0x18, 0x1C, 0xC3, 0x18,
  0x30, 0xC3, 0x10, 0x20, 0x83, 0x30, 0x61, 0x83, 0x30, 0x41, 0x82, 0x20,
  0xC1, 0x82, 0x60, 0x81, 0x02, 0x61, 0x83, 0x06, 0x61, 0x83, 0x06, 0x61,
  0x83, 0x04, 0x41, 0x02, 0x04, 0x41, 0x06, 0x0C, 0xC3, 0x06, 0x08, 0xC3,
  0x06, 0x18, 0xC3, 0x0E, 0x18, 0xC1, 0x0A, 0x30, 0xC1, 0x92, 0x60, 0xC1,
  0xF3, 0xC0, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x05, 0x00, 0x0D, 0x00, 0x0D, 0x00, 0x19, 0x00, 0x19,
  0x00, 0x11, 0x00, 0x31, 0x00, 0x31, 0x00, 0x61, 0x00, 0x61, 0x00, 0x41,
  0x00, 0xC1, 0x00, 0xC1, 0x01, 0x81, 0x01, 0x81, 0x03, 0x01, 0x03, 0x01,
  0x03, 0xFF, 0x07, 0xFF, 0x06, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x01,
  0x18, 0x01, 0x18, 0x01, 0x30, 0x01, 0x30, 0x01, 0x30, 0x01, 0x60, 0x01,
  0x60, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x06,
  0x07, 0x00, 0xC0, 0x70, 0x10, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18,
  0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x60, 0xF0, 0x0F, 0xF8, 0x01, 0x8F,
  0x80, 0x20, 0x38, 0x0C, 0x03, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01,
  0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0xE0, 0x40, 0x38,
  0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFC, 0x01,
  0xC3, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xF1, 0x80, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x01, 0x81, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0x60, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x08, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x0C, 0x30, 0x01, 0x83, 0x00,
  0x18, 0x30, 0x03, 0x02, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0xC0, 0x60,
  0x1C, 0x06, 0x03, 0x80, 0x40, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0F, 0xFE, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0x87, 0xC0, 0x30, 0x02, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0xFC, 0x30, 0x03, 0xF0, 0xC0, 0x00, 0xC3, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x20, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x60, 0x02, 0x00, 0xC0, 0x18, 0x01, 0xE0, 0xE0,
  0x03, 0xFF, 0x00, 0x01, 0x80, 0x06, 0x03, 0x00, 0x08, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x10, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x02, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x01, 0x80, 0x60, 0x03, 0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x10, 0x0F, 0xFF, 0xE0, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x04, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x40,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x8E, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x18, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0xC0, 0x10, 0x0C, 0x01,
  0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x01, 0x87, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x00, 0x02, 0x30, 0x00, 0x33,
  0x80, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x7E, 0x00, 0x02, 0x98, 0x00,
  0x38, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x02, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x06,
  0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x50, 0x00, 0x0A, 0x01, 0x40,
  0x00, 0x78, 0x0D, 0x00, 0x01, 0xE0, 0x34, 0x00, 0x0D, 0x80, 0xD0, 0x00,
  0x36, 0x03, 0x60, 0x01, 0xB0, 0x19, 0x80, 0x06, 0xC0, 0x66, 0x00, 0x33,
  0x01, 0x98, 0x00, 0xCC, 0x06, 0x60, 0x06, 0x20, 0x11, 0x80, 0x19, 0x80,
  0xC6, 0x00, 0xC6, 0x03, 0x18, 0x03, 0x18, 0x0C, 0x60, 0x18, 0x60, 0x31,
  0x80, 0x61, 0x00, 0x86, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60,
  0x20, 0xC0, 0x61, 0x81, 0x83, 0x01, 0x82, 0x04, 0x08, 0x04, 0x08, 0x30,
  0x60, 0x30, 0x20, 0xC1, 0x80, 0xC0, 0x86, 0x06, 0x03, 0x02, 0x18, 0x18,
  0x08, 0x0C, 0xC0, 0xC0, 0x60, 0x33, 0x03, 0x01, 0x80, 0xD8, 0x0C, 0x06,
  0x03, 0x60, 0x30, 0x18, 0x0F, 0x00, 0x80, 0x40, 0x3C, 0x06, 0x03, 0x00,
  0xE0, 0x18, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x03, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x06, 0x01, 0x60, 0x06, 0x03, 0x60,
  0x06, 0x03, 0x60, 0x04, 0x03, 0x60, 0x0C, 0x03, 0x20, 0x0C, 0x06, 0x20,
  0x0C, 0x06, 0x30, 0x0C, 0x06, 0x30, 0x08, 0x06, 0x30, 0x18, 0x04, 0x30,
  0x18, 0x0C, 0x10, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x10, 0x0C, 0x18,
  0x30, 0x08, 0x18, 0x30, 0x18, 0x18, 0x30, 0x18, 0x08, 0x30, 0x18, 0x0C,
  0x60, 0x18, 0x0C, 0x60, 0x10, 0x0C, 0x60, 0x30, 0x0C, 0x60, 0x30, 0x04,
  0x40, 0x30, 0x06, 0xC0, 0x30, 0x06, 0xC0, 0x60, 0x06, 0xC0, 0x60, 0x06,
  0xC0, 0x60, 0x06, 0x80, 0x60, 0x03, 0x80, 0x40, 0x03, 0x80, 0xC0, 0x03,
  0x80, 0xC0, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x1C, 0x78, 0x06, 0x03, 0x01,
  0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x68, 0x00, 0x0B, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00,
  0x0C, 0xC0, 0x01, 0x98, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x18, 0x30, 0x03, 0x07, 0x00, 0xC0, 0x60, 0x30, 0x07, 0x1C,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x18, 0x38, 0x06,
  0x07, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x04, 0x0C, 0x01, 0x03, 0x00,
  0x41, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x07, 0x03, 0x03, 0x80, 0x8F, 0x80, 0x7F,
  0xC0, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1C, 0x78, 0x06, 0x03, 0x01, 0x80, 0x30, 0x60, 0x06, 0x0C,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x68, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x07, 0x1C, 0x00, 0x7F, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x18,
  0x38, 0x06, 0x07, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x60, 0xC0, 0x18, 0x30, 0x0C, 0x0C, 0x06, 0x03, 0x07, 0x00, 0xFF,
  0x80, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x82, 0x00, 0x40, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x18, 0x18,
  0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x40, 0x18, 0x30, 0x02, 0x0C, 0x00,
  0xC0, 0x00, 0x7F, 0xC0, 0x1E, 0x3C, 0x06, 0x00, 0x81, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x80, 0x38, 0x1E, 0x1E, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x40, 0x02, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x41, 0x80, 0x0C,
  0x18, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x82, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0xC0,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x04, 0x08, 0x00, 0xC0, 0x80, 0x0C, 0x08,
  0x00, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xE0, 0x30, 0x07, 0x0E, 0x00,
  0x3F, 0xC0, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x26, 0x00, 0x33, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x01, 0x81, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x06,
  0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x6C, 0x00, 0xF0, 0x03,
  0x60, 0x05, 0x80, 0x33, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x60, 0x08, 0xC0,
  0x12, 0x00, 0xC6, 0x01, 0x90, 0x06, 0x30, 0x0C, 0x80, 0x61, 0x80, 0xC4,
  0x03, 0x0C, 0x06, 0x20, 0x10, 0x60, 0x21, 0x01, 0x83, 0x03, 0x08, 0x0C,
  0x18, 0x18, 0x40, 0xC0, 0xC1, 0x82, 0x06, 0x06, 0x0C, 0x10, 0x20, 0x30,
  0x40, 0x83, 0x01, 0x86, 0x0C, 0x18, 0x0C, 0x30, 0x61, 0x80, 0x61, 0x03,
  0x0C, 0x03, 0x18, 0x18, 0x40, 0x18, 0xC0, 0xC6, 0x00, 0x8C, 0x06, 0x30,
  0x04, 0x60, 0x33, 0x00, 0x22, 0x01, 0x98, 0x01, 0x30, 0x0C, 0x80, 0x09,
  0x80, 0x6C, 0x00, 0x58, 0x03, 0x60, 0x02, 0xC0, 0x1E, 0x00, 0x14, 0x00,
  0xF0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0,
  0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0x81, 0x80, 0x06, 0x04, 0x00, 0x08, 0x30, 0x00,
  0x21, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x36,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x20, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00, 0x03, 0x0C, 0x00, 0x08, 0x30,
  0x00, 0x60, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x80, 0xC0, 0x0C, 0x03, 0x00, 0x20, 0x04, 0x01, 0x80, 0x10, 0x0C, 0x00,
  0x60, 0x00, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C,
  0x20, 0x18, 0x20, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x30, 0x60,
  0x30, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0x31, 0x00, 0x13, 0x00, 0x12, 0x00,
  0x16, 0x00, 0x14, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xC1, 0x83, 0x02, 0x04, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC1, 0x83,
  0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x04, 0x0C, 0x18,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x18, 0x30, 0x06, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x0C, 0x18,
  0x03, 0x0C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC3, 0x18, 0x63, 0x08, 0x20, 0x00, 0xF8, 0xC0, 0xF3,
  0x20, 0x70, 0x68, 0x18, 0x0E, 0x0C, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x21, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x10, 0x0E, 0x06, 0x07, 0x81,
  0x81, 0x60, 0x31, 0x90, 0x0F, 0xC4, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x47, 0xC0, 0x66, 0x70, 0x34,
  0x0C, 0x1C, 0x06, 0x0E, 0x03, 0x06, 0x00, 0x87, 0x00, 0x43, 0x00, 0x21,
  0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01,
  0x88, 0x00, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0,
  0x18, 0xE0, 0x18, 0x70, 0x0C, 0x38, 0x0C, 0x16, 0x0E, 0x09, 0x8E, 0x0C,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x30, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0xC0, 0x7F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x0F, 0x8C, 0x03, 0xCC, 0x80, 0x70, 0x78, 0x06,
  0x03, 0x80, 0xC0, 0x38, 0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x03,
  0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x01, 0x80, 0x40, 0x38, 0x06, 0x07,
  0x80, 0x60, 0x58, 0x03, 0x19, 0x00, 0x3F, 0x10, 0x00, 0x00, 0xF8, 0x07,
  0x18, 0x1C, 0x10, 0x70, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x18, 0x06,
  0x30, 0x0C, 0x60, 0x31, 0x80, 0xC3, 0x07, 0x07, 0xF8, 0x0F, 0x80, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x38, 0x60, 0x3F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x0C, 0x40, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x30, 0x0F, 0x32,
  0x01, 0xC1, 0xA0, 0x18, 0x0E, 0x03, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00,
  0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0x81, 0x80,
  0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x30, 0x30,
  0x03, 0x03, 0x00, 0x30, 0x30, 0x07, 0x03, 0x00, 0x70, 0x30, 0x06, 0x01,
  0x00, 0xE0, 0x18, 0x1E, 0x01, 0x83, 0x60, 0x0C, 0x64, 0x00, 0xFC, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x0E,
  0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x4F, 0xC0, 0x6E, 0x70, 0x3C, 0x18,
  0x1C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x07, 0x00, 0x83, 0x00, 0xC1, 0x80,
  0x60, 0xC0, 0x30, 0x40, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x18, 0x06, 0x0C,
  0x03, 0x04, 0x01, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30,
  0xC0, 0x10, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x03, 0x0C, 0x03,
  0x00, 0x01, 0x80, 0x70, 0x18, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x30, 0x0C, 0x18, 0x04, 0x18, 0x06, 0x18, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0x8C, 0x00, 0xCC, 0x00, 0x6F, 0x00, 0x35, 0x80, 0x1E, 0xC0,
  0x0E, 0x60, 0x0E, 0x30, 0x06, 0x08, 0x03, 0x06, 0x01, 0x83, 0x00, 0x81,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x08, 0x06, 0x0C,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x00, 0x02, 0x7E, 0x1F, 0x01, 0xB1, 0xDC, 0xE0, 0x78, 0x34, 0x0C, 0x1C,
  0x0E, 0x03, 0x06, 0x03, 0x80, 0xC1, 0x80, 0xC0, 0x30, 0xC0, 0x30, 0x0C,
  0x30, 0x0C, 0x02, 0x0C, 0x03, 0x01, 0x83, 0x00, 0x80, 0x61, 0x80, 0x60,
  0x18, 0x60, 0x18, 0x06, 0x18, 0x06, 0x01, 0x06, 0x01, 0x80, 0xC1, 0x00,
  0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x30, 0x0C, 0x03, 0x0C, 0x03, 0x00, 0x83,
  0x00, 0x80, 0x60, 0x80, 0x60, 0x18, 0x60, 0x18, 0x06, 0x18, 0x06, 0x01,
  0x06, 0x01, 0x80, 0xC1, 0x80, 0x40, 0x30, 0x40, 0x30, 0x0C, 0x30, 0x0C,
  0x03, 0x00, 0x02, 0x7E, 0x03, 0x73, 0x81, 0xE0, 0xC0, 0xE0, 0x30, 0x60,
  0x18, 0x30, 0x08, 0x38, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x40, 0x18, 0x60, 0x08,
  0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x04, 0x01, 0x86, 0x00, 0x83, 0x00,
  0xC1, 0x80, 0x60, 0xC0, 0x30, 0x40, 0x18, 0x60, 0x18, 0x00, 0x01, 0xF8,
  0x03, 0x8C, 0x06, 0x06, 0x0E, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x60, 0x02, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0x30, 0x60, 0x60, 0x31, 0xC0,
  0x1F, 0x80, 0x00, 0x8F, 0x80, 0x19, 0x9C, 0x01, 0xA0, 0x60, 0x1E, 0x06,
  0x01, 0x40, 0x60, 0x18, 0x02, 0x03, 0x80, 0x30, 0x30, 0x02, 0x03, 0x00,
  0x20, 0x30, 0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x04, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C,
  0x01, 0x80, 0xC0, 0x18, 0x1C, 0x03, 0x01, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0xE0, 0xE0, 0x13, 0x1C, 0x03, 0x3F, 0x80, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0xC0, 0xF7, 0x20, 0x70, 0x68, 0x18, 0x0E, 0x0C, 0x03, 0x86, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x21,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x10, 0x40,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x10, 0x0E,
  0x06, 0x07, 0x81, 0x81, 0x60, 0x71, 0x90, 0x0F, 0xCC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x02, 0x7C, 0x1B, 0xD0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x00, 0x01,
  0xFC, 0x07, 0x1C, 0x18, 0x08, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x40, 0x30, 0xE1, 0xC1, 0xFF, 0x00,
  0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0xFE, 0x7F, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x10, 0xF0,
  0x04, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0xC0,
  0x10, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x06,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x10, 0x60, 0x18,
  0x30, 0x0C, 0x18, 0x06, 0x08, 0x07, 0x0C, 0x03, 0x06, 0x03, 0x83, 0x01,
  0xC1, 0x81, 0xE0, 0x61, 0xA0, 0x3F, 0x90, 0x00, 0xC0, 0x1E, 0x00, 0xF0,
  0x0D, 0x80, 0x6C, 0x02, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0xC6, 0x0C,
  0x30, 0x61, 0x82, 0x0C, 0x30, 0x61, 0x03, 0x18, 0x18, 0xC0, 0xCC, 0x06,
  0x60, 0x36, 0x01, 0xB0, 0x0D, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x1B, 0x00, 0xE0, 0x36,
  0x03, 0x80, 0xCC, 0x05, 0x01, 0x98, 0x1A, 0x02, 0x30, 0x34, 0x0C, 0x60,
  0x48, 0x18, 0xC1, 0x90, 0x21, 0x82, 0x20, 0xC3, 0x0C, 0x41, 0x86, 0x18,
  0x86, 0x0C, 0x21, 0x0C, 0x18, 0xC2, 0x10, 0x31, 0x04, 0x60, 0x66, 0x08,
  0xC0, 0xCC, 0x13, 0x01, 0x90, 0x26, 0x03, 0x60, 0x48, 0x06, 0x80, 0xB0,
  0x0F, 0x01, 0x60, 0x16, 0x02, 0x80, 0x28, 0x07, 0x00, 0x70, 0x0C, 0x00,
  0xC0, 0x38, 0x01, 0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x0C, 0x01, 0x02, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x30,
  0x01, 0x98, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x88, 0x00, 0xC2,
  0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x40,
  0x60, 0x18, 0x30, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x10, 0x01, 0x80, 0xC0, 0x06, 0x03,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0x84, 0x00, 0x06, 0x30, 0x00, 0x18,
  0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x68, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80,
  0x70, 0xF0, 0x70, 0x1F, 0xE8, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 10, 35, 10, 1, -35 },
  { 45, 10, 13, 13, 5, -35 },
  { 62, 19, 35, 19, 0, -35 },
  { 146, 18, 40, 17, 0, -37 },
  { 236, 22, 36, 26, 2, -35 },
  { 335, 17, 35, 17, -1, -35 },
  { 410, 4, 13, 7, 5, -35 },
  { 417, 14, 43, 12, 1, -35 },
  { 493, 13, 43, 12, -3, -35 },
  { 563, 12, 14, 16, 6, -37 },
  { 584, 16, 23, 20, 2, -29 },
  { 630, 6, 11, 8, -2, -5 },
  { 639, 11, 2, 13, 1, -14 },
  { 642, 3, 4, 8, 1, -4 },
  { 644, 20, 35, 15, -2, -35 },
  { 732, 16, 35, 17, 1, -35 },
  { 802, 10, 35, 17, 5, -35 },
  { 846, 19, 35, 17, -2, -35 },
  { 930, 19, 36, 17, -1, -35 },
  { 1016, 19, 35, 17, -1, -35 },
  { 1100, 19, 35, 17, -1, -35 },
  { 1184, 17, 35, 17, 1, -35 },
  { 1259, 17, 35, 17, 2, -35 },
  { 1334, 19, 35, 17, -1, -35 },
  { 1418, 17, 35, 17, 0, -35 },
  { 1493, 8, 26, 8, 0, -26 },
  { 1519, 10, 32, 8, -2, -26 },
  { 1559, 16, 21, 20, 2, -28 },
  { 1601, 16, 12, 20, 2, -23 },
  { 1625, 17, 21, 20, 2, -28 },
  { 1670, 13, 35, 12, 1, -35 },
  { 1727, 24, 39, 26, 1, -35 },
  { 1844, 16, 35, 17, -3, -35 },
  { 1914, 19, 35, 19, 0, -35 },
  { 1998, 19, 36, 17, 2, -36 },
  { 2084, 20, 35, 21, 0, -35 },
  { 2172, 19, 35, 17, 0, -35 },
  { 2256, 19, 35, 16, 0, -35 },
  { 2340, 22, 36, 23, 2, -36 },
  { 2439, 23, 35, 22, 0, -35 },
  { 2540, 16, 35, 9, -3, -35 },
  { 2610, 16, 44, 8, -7, -35 },
  { 2698, 21, 35, 18, 0, -35 },
  { 2790, 11, 35, 15, 0, -35 },
  { 2839, 30, 35, 29, 0, -35 },
  { 2971, 24, 35, 23, 0, -35 },
  { 3076, 19, 35, 22, 2, -35 },
  { 3160, 18, 35, 18, 0, -35 },
  { 3239, 19, 43, 22, 2, -35 },
  { 3342, 18, 35, 18, 0, -35 },
  { 3421, 19, 35, 17, -1, -35 },
  { 3505, 16, 35, 15, 3, -35 },
  { 3575, 20, 35, 21, 2, -35 },
  { 3663, 17, 35, 17, 4, -35 },
  { 3738, 29, 35, 30, 4, -35 },
  { 3865, 22, 35, 16, -3, -35 },
  { 3962, 16, 35, 15, 3, -35 },
  { 4032, 20, 35, 15, -2, -35 },
  { 4120, 18, 43, 14, -1, -35 },
  { 4217, 7, 35, 16, 5, -35 },
  { 4248, 17, 43, 14, -3, -35 },
  { 4340, 18, 17, 19, 1, -35 },
  { 4379, 13, 2, 13, -4, 4 },
  { 4383, 5, 7, 10, 7, -37 },
  { 4388, 18, 26, 19, 1, -26 },
  { 4447, 17, 37, 19, 0, -37 },
  { 4526, 14, 26, 14, 1, -26 },
  { 4572, 20, 37, 19, 1, -37 },
  { 4665, 15, 26, 17, 1, -26 },
  { 4714, 21, 49, 9, -6, -37 },
  { 4843, 20, 38, 19, -1, -26 },
  { 4938, 17, 37, 18, 0, -37 },
  { 5017, 10, 35, 8, 0, -35 },
  { 5061, 16, 47, 8, -6, -35 },
  { 5155, 17, 37, 15, 0, -37 },
  { 5234, 10, 37, 8, 0, -37 },
  { 5281, 26, 26, 27, 0, -26 },
  { 5366, 17, 26, 18, 0, -26 },
  { 5422, 16, 26, 18, 1, -26 },
  { 5474, 20, 37, 19, -2, -26 },
  { 5567, 18, 38, 19, 1, -26 },
  { 5653, 14, 26, 12, 0, -26 },
  { 5699, 15, 26, 14, -1, -26 },
  { 5748, 9, 32, 9, 1, -32 },
  { 5784, 17, 26, 18, 1, -26 },
  { 5840, 13, 26, 14, 3, -26 },
  { 5883, 23, 26, 23, 3, -26 },
  { 5958, 18, 26, 15, -2, -26 },
  { 6017, 22, 38, 15, -5, -26 },
  { 6122, 15, 26, 12, -2, -26 },
  { 6171, 16, 43, 15, 2, -35 },
  { 6257, 1, 49, 17, 8, -37 },
  { 6264, 17, 43, 15, -3, -35 },
  { 6356, 17, 5, 20, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC49PT7B_H_
