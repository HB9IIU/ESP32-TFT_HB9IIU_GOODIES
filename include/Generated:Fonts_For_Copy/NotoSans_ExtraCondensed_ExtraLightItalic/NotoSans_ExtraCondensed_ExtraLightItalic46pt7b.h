#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x00, 0x00, 0x00, 0x00, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x00, 0x18, 0xCC, 0x33, 0x0C, 0xC2, 0x21, 0x88, 0x66, 0x19,
  0x84, 0x41, 0x10, 0xC4, 0x33, 0x08, 0x00, 0x30, 0xC0, 0x08, 0x30, 0x02,
  0x08, 0x01, 0x86, 0x00, 0x41, 0x80, 0x10, 0x40, 0x0C, 0x10, 0x03, 0x0C,
  0x00, 0x82, 0x00, 0x60, 0x81, 0xFF, 0xFC, 0x04, 0x18, 0x03, 0x04, 0x00,
  0xC3, 0x00, 0x20, 0xC0, 0x18, 0x20, 0x06, 0x18, 0x01, 0x06, 0x00, 0x41,
  0x00, 0x30, 0xC0, 0x08, 0x30, 0x3F, 0xFF, 0x81, 0x82, 0x00, 0x61, 0x80,
  0x10, 0x40, 0x0C, 0x10, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x80, 0x18,
  0x60, 0x04, 0x18, 0x01, 0x04, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x0F, 0xE0, 0x1E, 0xBC, 0x18, 0xC2,
  0x08, 0x60, 0x0C, 0x20, 0x06, 0x10, 0x02, 0x08, 0x01, 0x0C, 0x00, 0xC4,
  0x00, 0x62, 0x00, 0x31, 0x00, 0x0C, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x04, 0x60, 0x02, 0x30,
  0x01, 0x08, 0x01, 0x84, 0x00, 0x82, 0x00, 0x41, 0x00, 0x21, 0x80, 0x10,
  0xC2, 0x18, 0xC1, 0xEB, 0xC0, 0x7F, 0x80, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x07, 0x80, 0x30, 0x66, 0x03, 0x06,
  0x10, 0x10, 0x20, 0x81, 0x83, 0x04, 0x08, 0x18, 0x20, 0xC0, 0x81, 0x04,
  0x0C, 0x08, 0x60, 0x60, 0xC2, 0x02, 0x06, 0x30, 0x10, 0x31, 0x01, 0x81,
  0x18, 0x0C, 0x08, 0x80, 0x60, 0xCC, 0x7B, 0x06, 0x46, 0xD8, 0x66, 0x63,
  0xC3, 0x22, 0x1E, 0x33, 0x30, 0xDB, 0x11, 0x06, 0xF1, 0x98, 0x30, 0x08,
  0xC1, 0x80, 0xC4, 0x0C, 0x04, 0x60, 0x40, 0x63, 0x02, 0x02, 0x18, 0x30,
  0x30, 0xC1, 0x81, 0x04, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x08,
  0x20, 0x40, 0x43, 0x06, 0x03, 0x30, 0x20, 0x0F, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7C, 0x00, 0xCC, 0x00, 0x86, 0x01, 0x86, 0x01, 0x86, 0x01, 0x06,
  0x03, 0x06, 0x03, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x01, 0x18,
  0x01, 0x30, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x06, 0xC0,
  0x0C, 0xC0, 0x18, 0x43, 0x10, 0x63, 0x30, 0x62, 0x20, 0x66, 0x60, 0x26,
  0x60, 0x3C, 0x40, 0x3C, 0x40, 0x38, 0xC0, 0x18, 0x40, 0x38, 0x40, 0x78,
  0x60, 0x48, 0x71, 0xC8, 0x3F, 0x0C, 0x19, 0x8C, 0x62, 0x11, 0x8C, 0x62,
  0x11, 0x80, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x30, 0x02, 0x04, 0x20, 0xE2, 0x03, 0xA7, 0x0F, 0xE0, 0x60,
  0x1B, 0x03, 0x10, 0x61, 0x84, 0x08, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x00, 0xFF, 0xC0,
  0x7F, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xB8,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x84, 0x03, 0x18,
  0x06, 0x30, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x64, 0x00, 0xD8, 0x01,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x00, 0x36, 0x00, 0x4C, 0x01, 0x98,
  0x03, 0x30, 0x06, 0x60, 0x08, 0xC0, 0x31, 0x80, 0x63, 0x01, 0x86, 0x03,
  0x0C, 0x0C, 0x18, 0x18, 0x10, 0x60, 0x31, 0x80, 0x3E, 0x00, 0x03, 0x83,
  0x83, 0xC3, 0x63, 0x37, 0x19, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x78, 0xE0, 0x08, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xE3, 0x80, 0xC0, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC1, 0x83, 0xC0, 0xFF,
  0x80, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xB0, 0x00, 0xD0, 0x00, 0x48, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x23, 0x00,
  0x31, 0x00, 0x10, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x10,
  0x04, 0x18, 0x06, 0x0C, 0x06, 0x06, 0x02, 0x02, 0x03, 0x01, 0x03, 0x01,
  0x81, 0x80, 0xC1, 0x80, 0x60, 0x80, 0x20, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x60, 0x00, 0xFF,
  0x00, 0x20, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x08, 0x07,
  0x03, 0x07, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0xF1, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x23, 0xE0, 0x6F, 0x70,
  0x68, 0x18, 0x70, 0x18, 0x60, 0x08, 0x60, 0x0C, 0x60, 0x0C, 0xC0, 0x0C,
  0xC0, 0x08, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0x60, 0xC0, 0x71, 0xC0, 0x3F, 0x00,
  0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x79, 0xC0, 0x18,
  0x18, 0x0C, 0x02, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03,
  0x06, 0x00, 0x81, 0x80, 0x60, 0x60, 0x18, 0x08, 0x0C, 0x03, 0x06, 0x00,
  0x63, 0x00, 0x1B, 0x80, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xCC, 0x00, 0xC1,
  0x80, 0x60, 0x60, 0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0x41, 0x80, 0x18,
  0x40, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x10, 0x40, 0x0C, 0x18,
  0x03, 0x07, 0x01, 0x80, 0xE1, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x01,
  0xCE, 0x03, 0x06, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30,
  0x07, 0x30, 0x06, 0x10, 0x0E, 0x18, 0x0E, 0x18, 0x1E, 0x0E, 0x76, 0x07,
  0xC4, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x87,
  0x00, 0xFE, 0x00, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1C, 0x38, 0x60,
  0x01, 0xC0, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x0F, 0xE1, 0xC7, 0x10, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xF3, 0xC0, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x60, 0x00, 0x41, 0x00, 0x01, 0x0C, 0x00, 0x04, 0x20, 0x1C, 0x11,
  0x81, 0xF8, 0x44, 0x0C, 0x61, 0x10, 0x61, 0x04, 0xC1, 0x04, 0x12, 0x0C,
  0x30, 0xC8, 0x20, 0xC3, 0x61, 0x82, 0x0D, 0x84, 0x08, 0x24, 0x10, 0x60,
  0x90, 0xC1, 0x86, 0x43, 0x04, 0x1B, 0x0C, 0x30, 0x4C, 0x30, 0xC3, 0x30,
  0xC3, 0x0C, 0xC3, 0x14, 0x63, 0x0C, 0xD1, 0x0C, 0x1E, 0x7C, 0x30, 0x30,
  0xC0, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0B,
  0x00, 0x1B, 0x00, 0x13, 0x00, 0x33, 0x00, 0x33, 0x00, 0x23, 0x00, 0x63,
  0x00, 0x43, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0x83, 0x01, 0x83, 0x01, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x07, 0xFF, 0x06, 0x03, 0x06, 0x03, 0x0C, 0x03,
  0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x10, 0x38, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x20, 0x0C,
  0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x18, 0x10, 0x06, 0x0C,
  0x03, 0x03, 0x01, 0x80, 0xC1, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x06, 0x03,
  0x01, 0x80, 0x60, 0x60, 0x18, 0x18, 0x06, 0x04, 0x00, 0x83, 0x00, 0x20,
  0xC0, 0x18, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x06, 0x04, 0x03, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x3C, 0x60, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xE1, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x04, 0x0E, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x80, 0x30, 0x30, 0x02, 0x06, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x00, 0x83,
  0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xC1, 0x00, 0x18, 0x20, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30,
  0x03, 0x04, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0,
  0x60, 0x10, 0x38, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0x8F, 0x01, 0xC0, 0x30, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x01, 0xF8,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x03,
  0x08, 0x00, 0x30, 0x80, 0x03, 0x0C, 0x00, 0x20, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xC0, 0x06, 0x06, 0x00, 0x40, 0x70, 0x04, 0x03, 0xC1, 0xC0, 0x0F,
  0xF8, 0x00, 0x01, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x30, 0x30, 0x01, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xC0,
  0x06, 0x06, 0x00, 0x20, 0x30, 0x01, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x20, 0x30, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x30, 0x03, 0x01, 0x00, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x04, 0x00, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x30, 0x10, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x18, 0x03, 0x01, 0x80, 0x30, 0x30, 0x02, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C,
  0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0B, 0xC0, 0x01,
  0xEC, 0x00, 0x1C, 0xC0, 0x01, 0x84, 0x00, 0x10, 0x60, 0x01, 0x06, 0x00,
  0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x20, 0x02, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x03, 0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0x40, 0x18, 0x0C, 0x01,
  0x80, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xA0, 0x3C, 0x00, 0x1E, 0x02,
  0xC0, 0x01, 0x60, 0x6C, 0x00, 0x36, 0x06, 0xC0, 0x02, 0x60, 0x6C, 0x00,
  0x64, 0x06, 0xC0, 0x04, 0xC0, 0x4C, 0x00, 0xCC, 0x0C, 0xC0, 0x0C, 0xC0,
  0xC4, 0x01, 0x88, 0x0C, 0x40, 0x18, 0x80, 0x84, 0x03, 0x18, 0x08, 0x40,
  0x31, 0x81, 0x84, 0x06, 0x18, 0x18, 0x40, 0x61, 0x01, 0x84, 0x0C, 0x30,
  0x10, 0x60, 0xC3, 0x01, 0x06, 0x18, 0x30, 0x30, 0x61, 0x83, 0x03, 0x06,
  0x10, 0x20, 0x30, 0x63, 0x06, 0x02, 0x06, 0x20, 0x60, 0x60, 0x66, 0x06,
  0x06, 0x06, 0x40, 0x40, 0x60, 0x6C, 0x04, 0x06, 0x06, 0x80, 0xC0, 0x40,
  0x78, 0x0C, 0x0C, 0x07, 0x80, 0xC0, 0xC0, 0x70, 0x08, 0x00, 0x01, 0x80,
  0x04, 0x06, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0xF0, 0x03, 0x03, 0xC0, 0x08,
  0x0F, 0x00, 0x20, 0x24, 0x01, 0x81, 0x90, 0x06, 0x06, 0x60, 0x18, 0x19,
  0x80, 0x40, 0x66, 0x01, 0x01, 0x08, 0x0C, 0x0C, 0x20, 0x30, 0x30, 0xC0,
  0xC0, 0xC3, 0x02, 0x03, 0x0C, 0x18, 0x08, 0x30, 0x60, 0x60, 0x41, 0x81,
  0x81, 0x06, 0x06, 0x06, 0x10, 0x10, 0x18, 0xC0, 0x40, 0x63, 0x03, 0x00,
  0x8C, 0x0C, 0x02, 0x20, 0x30, 0x0C, 0x80, 0x80, 0x36, 0x06, 0x00, 0xD8,
  0x18, 0x03, 0x60, 0x60, 0x05, 0x01, 0x80, 0x1C, 0x04, 0x00, 0x70, 0x30,
  0x01, 0xC0, 0xC0, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x79, 0xC0, 0x38, 0x18,
  0x18, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60, 0x03, 0x18,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0D, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x06, 0xC0, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00, 0x08, 0x80,
  0x06, 0x20, 0x01, 0x88, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x0C,
  0x06, 0x07, 0x01, 0xC3, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0x41, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x08, 0x02, 0x0C,
  0x01, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x10,
  0x60, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x08, 0x1C, 0x0C, 0x7C, 0x07, 0xF8,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x79, 0xC0,
  0x38, 0x18, 0x18, 0x06, 0x06, 0x00, 0xC3, 0x00, 0x30, 0x80, 0x0C, 0x60,
  0x03, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x80, 0x03, 0x60, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x02, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x32, 0x00,
  0x08, 0x80, 0x06, 0x20, 0x01, 0x88, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18,
  0x30, 0x0C, 0x06, 0x07, 0x01, 0xC3, 0x80, 0x3F, 0x80, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x40, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x08, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x18,
  0x18, 0x1C, 0x08, 0x1C, 0x0F, 0xF8, 0x06, 0x10, 0x03, 0x08, 0x01, 0x06,
  0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x20, 0x10, 0x18, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x81, 0x00, 0x41, 0x80, 0x30,
  0xC0, 0x18, 0x00, 0x00, 0x7F, 0x80, 0x7C, 0xF0, 0x38, 0x04, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x08, 0x03,
  0x03, 0x83, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x30, 0x20,
  0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x04, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x08, 0x00, 0xC1,
  0x80, 0x08, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x00, 0x18,
  0x30, 0x01, 0x03, 0x00, 0x30, 0x30, 0x03, 0x02, 0x00, 0x30, 0x20, 0x02,
  0x06, 0x00, 0x20, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x06, 0x04, 0x00,
  0x40, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x03, 0x8E, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x80, 0xC3, 0x00, 0xC3, 0x00, 0xC2,
  0x00, 0xC6, 0x00, 0xC6, 0x00, 0x8C, 0x00, 0x8C, 0x00, 0x98, 0x00, 0x98,
  0x00, 0x90, 0x00, 0xB0, 0x00, 0xB0, 0x00, 0xA0, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0x60, 0x03, 0x00, 0x36, 0x00, 0x60, 0x03, 0x60, 0x06, 0x00, 0x26,
  0x00, 0x60, 0x06, 0x60, 0x0E, 0x00, 0x64, 0x00, 0xA0, 0x0C, 0x40, 0x1A,
  0x00, 0xC4, 0x01, 0xA0, 0x08, 0x40, 0x12, 0x01, 0x84, 0x03, 0x20, 0x18,
  0x40, 0x22, 0x03, 0x04, 0x06, 0x20, 0x30, 0x40, 0x62, 0x02, 0x04, 0x04,
  0x20, 0x60, 0x40, 0xC2, 0x06, 0x04, 0x08, 0x20, 0xC0, 0x41, 0x86, 0x0C,
  0x04, 0x18, 0x60, 0x80, 0x41, 0x06, 0x18, 0x04, 0x30, 0x61, 0x80, 0x43,
  0x06, 0x30, 0x04, 0x60, 0x63, 0x00, 0x46, 0x06, 0x20, 0x04, 0x40, 0x66,
  0x00, 0xCC, 0x06, 0x60, 0x0C, 0xC0, 0x6C, 0x00, 0xD8, 0x06, 0xC0, 0x0D,
  0x80, 0x68, 0x00, 0xD0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x05,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x80, 0xC0, 0x06, 0x04, 0x00, 0x30,
  0x60, 0x01, 0x82, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x00, 0x03, 0x18, 0x00,
  0x09, 0x80, 0x00, 0x4C, 0x00, 0x02, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01,
  0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00,
  0x06, 0x18, 0x00, 0x20, 0xC0, 0x03, 0x02, 0x00, 0x30, 0x10, 0x01, 0x80,
  0x80, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x06, 0x18,
  0x0C, 0x30, 0x30, 0x20, 0x40, 0x41, 0x80, 0x82, 0x01, 0x0C, 0x03, 0x10,
  0x06, 0x60, 0x0C, 0x80, 0x1B, 0x00, 0x34, 0x00, 0x78, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFE, 0x00, 0x83, 0x0C,
  0x30, 0xC3, 0x04, 0x10, 0x61, 0x86, 0x18, 0x60, 0x82, 0x0C, 0x30, 0xC3,
  0x0C, 0x10, 0x41, 0x86, 0x18, 0x61, 0x82, 0x08, 0x30, 0xC3, 0x0C, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x01, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x24, 0x00, 0x33, 0x00, 0x11,
  0x80, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x08, 0x04, 0x06, 0x06, 0x01, 0x02,
  0x00, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xCC, 0x46, 0x23, 0x10, 0x00, 0x60, 0x03, 0xF9, 0x07, 0x09,
  0x06, 0x07, 0x0C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C,
  0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30,
  0x40, 0x50, 0x60, 0xF0, 0x71, 0xB0, 0x3F, 0x20, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x38, 0x06, 0x7E, 0x06, 0x87, 0x05, 0x03,
  0x06, 0x03, 0x0E, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x0C, 0x01, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x03, 0x10, 0x03, 0x10, 0x03, 0x30, 0x02, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x70, 0x0C, 0x70, 0x18, 0x50, 0x18,
  0x50, 0x30, 0x58, 0xE0, 0xCF, 0xC0, 0x00, 0x70, 0x1F, 0xC1, 0xC0, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0E, 0x10, 0x3F, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x03,
  0x86, 0x01, 0xFC, 0x80, 0x70, 0xF0, 0x0C, 0x0E, 0x03, 0x01, 0xC0, 0xC0,
  0x30, 0x18, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00,
  0x40, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x01,
  0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x70, 0x30, 0x0C,
  0x02, 0x03, 0x80, 0x60, 0xF0, 0x0E, 0x36, 0x00, 0xFC, 0x80, 0x00, 0x00,
  0xE0, 0x0F, 0xE0, 0x71, 0x83, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x00, 0x8C,
  0x06, 0x30, 0x19, 0x80, 0xC6, 0x06, 0x18, 0x70, 0x7F, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x1C, 0x30, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x39,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x80, 0x07,
  0xF0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x90, 0x1C, 0x24, 0x06, 0x07, 0x03,
  0x01, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x61, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x30,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x30, 0x30,
  0x0C, 0x04, 0x07, 0x01, 0x83, 0xC0, 0x71, 0xB0, 0x0F, 0xC8, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x20, 0x30, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x18, 0x06, 0xFE, 0x07,
  0x86, 0x05, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x02, 0x0C, 0x06, 0x0C,
  0x06, 0x08, 0x06, 0x18, 0x06, 0x18, 0x04, 0x18, 0x0C, 0x10, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30, 0x18, 0x20, 0x18, 0x60, 0x18, 0x60,
  0x10, 0x60, 0x10, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x30, 0x01, 0x81, 0xC0,
  0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x03, 0x06, 0x06,
  0x04, 0x0C, 0x04, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x08, 0xC0,
  0x19, 0x80, 0x19, 0x80, 0x1B, 0x80, 0x16, 0x80, 0x1C, 0x80, 0x38, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x20, 0x40, 0x60, 0x40, 0x60, 0x60,
  0x60, 0x60, 0x40, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x00,
  0x00, 0x38, 0x1C, 0x06, 0xFC, 0x7E, 0x05, 0x86, 0xC3, 0x07, 0x07, 0x83,
  0x06, 0x03, 0x01, 0x0E, 0x03, 0x01, 0x0C, 0x06, 0x03, 0x0C, 0x06, 0x03,
  0x0C, 0x06, 0x03, 0x18, 0x04, 0x02, 0x18, 0x04, 0x02, 0x18, 0x0C, 0x06,
  0x18, 0x0C, 0x06, 0x10, 0x0C, 0x06, 0x30, 0x08, 0x04, 0x30, 0x18, 0x04,
  0x30, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x20, 0x18, 0x0C, 0x60, 0x10, 0x08,
  0x60, 0x30, 0x18, 0x60, 0x30, 0x18, 0x40, 0x30, 0x18, 0x40, 0x20, 0x18,
  0xC0, 0x60, 0x10, 0x00, 0x18, 0x06, 0xFE, 0x05, 0x86, 0x05, 0x03, 0x06,
  0x03, 0x0E, 0x02, 0x0C, 0x02, 0x0C, 0x06, 0x0C, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x04, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x08, 0x20, 0x18, 0x20, 0x18, 0x60, 0x18, 0x60, 0x10, 0x60, 0x10, 0x40,
  0x30, 0x40, 0x30, 0xC0, 0x30, 0x00, 0xF0, 0x07, 0xF0, 0x18, 0x30, 0x60,
  0x60, 0xC0, 0x43, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x06, 0x40, 0x0D,
  0x80, 0x1B, 0x00, 0x26, 0x00, 0xC8, 0x01, 0x90, 0x03, 0x60, 0x06, 0xC0,
  0x09, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x08, 0x0C, 0x18, 0x38,
  0x38, 0xE0, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x67, 0xE0, 0x12, 0x1C, 0x05,
  0x03, 0x01, 0xC0, 0xC0, 0xE0, 0x10, 0x30, 0x04, 0x0C, 0x01, 0x03, 0x00,
  0x40, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x30,
  0xC0, 0x08, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x30, 0x70,
  0x0C, 0x1C, 0x06, 0x07, 0x01, 0x81, 0x40, 0xC0, 0x58, 0xE0, 0x33, 0xF0,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0xF9, 0x07, 0x0D, 0x0E, 0x07, 0x0C, 0x07, 0x18,
  0x06, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x04, 0x60,
  0x04, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0x40, 0x70, 0x60, 0xF0, 0x71,
  0xB0, 0x3F, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x38, 0x37, 0xC1, 0x60, 0x0A, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x60, 0x43,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x30, 0x70,
  0xFF, 0x00, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x60, 0xFE, 0x10, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x0C, 0x07, 0xC0,
  0x0C, 0x03, 0x0C, 0x06, 0x08, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x04,
  0x18, 0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30, 0x08, 0x20, 0x18,
  0x20, 0x18, 0x60, 0x18, 0x60, 0x10, 0x60, 0x30, 0x40, 0x30, 0x40, 0x30,
  0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xE0, 0xC0, 0xE0, 0x63, 0x60, 0x7E, 0x60,
  0x80, 0x38, 0x03, 0x80, 0x68, 0x06, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x18,
  0x81, 0x88, 0x30, 0x83, 0x08, 0x60, 0x86, 0x08, 0x40, 0x8C, 0x08, 0x80,
  0x98, 0x09, 0x80, 0xB0, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xA0, 0x1C, 0x0D, 0x01, 0xE0, 0x68, 0x0B,
  0x02, 0x40, 0xD0, 0x32, 0x06, 0x81, 0x10, 0x24, 0x18, 0x83, 0x20, 0xC4,
  0x11, 0x04, 0x21, 0x88, 0x61, 0x0C, 0x42, 0x08, 0x42, 0x30, 0x46, 0x11,
  0x82, 0x20, 0x88, 0x13, 0x04, 0xC0, 0x98, 0x24, 0x04, 0x81, 0x60, 0x2C,
  0x0B, 0x01, 0x40, 0x50, 0x0E, 0x03, 0x80, 0x70, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x02, 0x01, 0x81, 0x81, 0x80, 0xC0, 0x80, 0x60, 0xC0,
  0x10, 0xC0, 0x08, 0x60, 0x06, 0x60, 0x03, 0x20, 0x01, 0xB0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x0C,
  0xC0, 0x04, 0x60, 0x06, 0x30, 0x06, 0x08, 0x03, 0x04, 0x03, 0x03, 0x01,
  0x01, 0x81, 0x80, 0xC1, 0x80, 0x60, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x0C, 0x00, 0x80, 0x60, 0x04, 0x06, 0x00, 0x20, 0x30, 0x01, 0x01,
  0x00, 0x08, 0x18, 0x00, 0x40, 0x80, 0x02, 0x0C, 0x00, 0x10, 0x60, 0x00,
  0x86, 0x00, 0x04, 0x30, 0x00, 0x23, 0x00, 0x01, 0x18, 0x00, 0x08, 0x80,
  0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x05, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0x63, 0xC1, 0xC0, 0xFF, 0x80, 0x1C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 33, 10, 1, -33 },
  { 39, 10, 12, 13, 4, -33 },
  { 54, 18, 33, 17, 0, -33 },
  { 129, 17, 38, 16, 0, -35 },
  { 210, 21, 34, 25, 2, -33 },
  { 300, 16, 33, 16, -1, -33 },
  { 366, 5, 12, 7, 4, -33 },
  { 374, 13, 40, 11, 1, -33 },
  { 439, 13, 40, 11, -3, -33 },
  { 504, 12, 13, 15, 5, -35 },
  { 524, 16, 21, 19, 1, -27 },
  { 566, 6, 10, 8, -2, -4 },
  { 574, 10, 1, 12, 1, -13 },
  { 576, 2, 4, 8, 1, -4 },
  { 577, 19, 33, 14, -2, -33 },
  { 656, 15, 33, 16, 1, -33 },
  { 718, 9, 33, 16, 5, -33 },
  { 756, 18, 33, 16, -2, -33 },
  { 831, 17, 34, 16, -1, -33 },
  { 904, 17, 33, 16, -1, -33 },
  { 975, 18, 33, 16, -1, -33 },
  { 1050, 16, 33, 16, 1, -33 },
  { 1116, 16, 33, 16, 2, -33 },
  { 1182, 18, 33, 16, -1, -33 },
  { 1257, 16, 33, 16, 0, -33 },
  { 1323, 7, 24, 8, 0, -24 },
  { 1344, 10, 30, 8, -2, -24 },
  { 1382, 16, 19, 19, 1, -26 },
  { 1420, 16, 12, 19, 1, -22 },
  { 1444, 16, 19, 19, 1, -26 },
  { 1482, 12, 33, 12, 1, -33 },
  { 1532, 22, 37, 24, 1, -33 },
  { 1634, 16, 33, 16, -3, -33 },
  { 1700, 18, 33, 18, 0, -33 },
  { 1775, 18, 33, 16, 2, -33 },
  { 1850, 19, 33, 19, 0, -33 },
  { 1929, 18, 33, 16, 0, -33 },
  { 2004, 18, 33, 15, 0, -33 },
  { 2079, 20, 33, 21, 2, -33 },
  { 2162, 21, 33, 21, 0, -33 },
  { 2249, 15, 33, 8, -3, -33 },
  { 2311, 16, 41, 8, -7, -33 },
  { 2393, 20, 33, 16, 0, -33 },
  { 2476, 11, 33, 14, 0, -33 },
  { 2522, 28, 33, 28, 0, -33 },
  { 2638, 22, 33, 22, 0, -33 },
  { 2729, 18, 33, 21, 2, -33 },
  { 2804, 17, 33, 17, 0, -33 },
  { 2875, 18, 41, 21, 2, -33 },
  { 2968, 17, 33, 17, 0, -33 },
  { 3039, 18, 33, 16, -1, -33 },
  { 3114, 15, 33, 14, 3, -33 },
  { 3176, 20, 33, 20, 1, -33 },
  { 3259, 16, 33, 16, 4, -33 },
  { 3325, 28, 33, 28, 3, -33 },
  { 3441, 21, 33, 15, -3, -33 },
  { 3528, 15, 33, 14, 3, -33 },
  { 3590, 19, 33, 14, -2, -33 },
  { 3669, 17, 40, 13, -1, -33 },
  { 3754, 6, 33, 15, 5, -33 },
  { 3779, 17, 40, 13, -3, -33 },
  { 3864, 17, 16, 18, 1, -33 },
  { 3898, 13, 2, 12, -4, 4 },
  { 3902, 4, 7, 10, 7, -35 },
  { 3906, 16, 25, 18, 1, -25 },
  { 3956, 16, 35, 18, 0, -35 },
  { 4026, 13, 25, 13, 1, -25 },
  { 4067, 19, 35, 18, 1, -35 },
  { 4151, 14, 25, 16, 1, -25 },
  { 4195, 20, 46, 9, -6, -35 },
  { 4310, 18, 36, 18, -1, -25 },
  { 4391, 16, 35, 17, 0, -35 },
  { 4461, 9, 33, 8, 0, -33 },
  { 4499, 15, 44, 8, -6, -33 },
  { 4582, 16, 35, 14, 0, -35 },
  { 4652, 9, 35, 7, 0, -35 },
  { 4692, 24, 25, 26, 0, -25 },
  { 4767, 16, 25, 17, 0, -25 },
  { 4817, 15, 25, 17, 1, -25 },
  { 4864, 18, 36, 18, -2, -25 },
  { 4945, 16, 36, 18, 1, -25 },
  { 5017, 13, 25, 11, 0, -25 },
  { 5058, 14, 25, 13, -1, -25 },
  { 5102, 9, 30, 9, 1, -30 },
  { 5136, 16, 24, 17, 1, -24 },
  { 5184, 12, 24, 13, 3, -24 },
  { 5220, 21, 24, 22, 3, -24 },
  { 5283, 17, 24, 14, -2, -24 },
  { 5334, 21, 35, 14, -5, -24 },
  { 5426, 15, 24, 11, -2, -24 },
  { 5471, 16, 40, 14, 1, -33 },
  { 5551, 2, 46, 16, 7, -35 },
  { 5563, 16, 40, 14, -3, -33 },
  { 5643, 16, 4, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC46PT7B_H_
