#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x30, 0x90, 0xD8, 0x6C, 0x36, 0x12, 0x09, 0x0D,
  0x86, 0xC2, 0x41, 0x20, 0x90, 0xC8, 0x40, 0x00, 0x30, 0x40, 0x06, 0x08,
  0x00, 0x83, 0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x83, 0x00, 0x10, 0x60,
  0x06, 0x08, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0,
  0x10, 0x60, 0x06, 0x08, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x02, 0x08, 0x00,
  0xC1, 0x00, 0x10, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x60, 0x3F,
  0xFF, 0x80, 0xC1, 0x00, 0x18, 0x60, 0x02, 0x0C, 0x00, 0xC1, 0x00, 0x18,
  0x60, 0x02, 0x0C, 0x00, 0xC1, 0x00, 0x18, 0x20, 0x02, 0x0C, 0x00, 0x41,
  0x80, 0x18, 0x60, 0x00, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0C, 0x46, 0x0C, 0x20, 0x0C, 0x30, 0x06,
  0x10, 0x03, 0x08, 0x01, 0x84, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x00,
  0x0C, 0x80, 0x06, 0x40, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x05, 0x80, 0x06, 0x60, 0x02, 0x30, 0x01, 0x0C, 0x00, 0x86, 0x00,
  0x43, 0x00, 0x61, 0x80, 0x20, 0x80, 0x10, 0xC0, 0x08, 0x61, 0x0C, 0x60,
  0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x03, 0x80, 0x30, 0x7E, 0x01, 0x02, 0x10, 0x18, 0x30,
  0xC0, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x86, 0x0C, 0x08, 0x30,
  0x60, 0x43, 0x03, 0x06, 0x18, 0x10, 0x31, 0x80, 0x81, 0x8C, 0x0C, 0x0C,
  0xC0, 0x60, 0x46, 0x03, 0x06, 0x63, 0xF8, 0x33, 0x33, 0xC1, 0x33, 0x0E,
  0x19, 0x90, 0x71, 0x99, 0x82, 0xD8, 0xCC, 0x13, 0x8C, 0x40, 0x80, 0x66,
  0x04, 0x06, 0x30, 0x60, 0x31, 0x03, 0x03, 0x08, 0x18, 0x18, 0xC0, 0xC1,
  0x86, 0x04, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0x61,
  0x83, 0x03, 0x08, 0x30, 0x18, 0xC1, 0x80, 0x7C, 0x00, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0xC6, 0x01, 0x86, 0x01, 0x86, 0x01, 0x86, 0x01,
  0x06, 0x01, 0x06, 0x03, 0x06, 0x03, 0x0C, 0x01, 0x0C, 0x01, 0x18, 0x01,
  0x18, 0x01, 0xB0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x06,
  0xC0, 0x0C, 0x40, 0x18, 0x63, 0x30, 0x63, 0x30, 0x63, 0x60, 0x26, 0x60,
  0x36, 0x60, 0x34, 0x40, 0x3C, 0x40, 0x18, 0xC0, 0x18, 0x40, 0x38, 0x60,
  0x28, 0x60, 0x6C, 0x71, 0xCC, 0x3F, 0x8C, 0x32, 0x66, 0x64, 0x4C, 0xCC,
  0x88, 0x80, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x01, 0x00, 0x30, 0x03, 0x04, 0x30, 0xE2, 0x03, 0x21, 0x0F, 0xF0, 0x60,
  0x0F, 0x01, 0x90, 0x31, 0x86, 0x08, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xE0, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x31, 0x86, 0x10, 0xC2, 0x18,
  0x43, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x06, 0x18, 0x18, 0x30, 0x60,
  0x20, 0xC0, 0x43, 0x00, 0x86, 0x01, 0x18, 0x02, 0x30, 0x04, 0x60, 0x09,
  0x80, 0x33, 0x00, 0x66, 0x00, 0xC8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x19, 0x80, 0x32, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x30, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x18, 0x08, 0x30,
  0x30, 0x20, 0xC0, 0x63, 0x00, 0x7C, 0x00, 0x01, 0x81, 0xC1, 0xE3, 0xA3,
  0xB3, 0x1B, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xF0, 0x06, 0x07, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x30, 0x18, 0x08, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x02, 0x01, 0xC0, 0xC1, 0xE0, 0x3F, 0xE0, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x28, 0x00, 0x1E, 0x00,
  0x05, 0x80, 0x03, 0x60, 0x01, 0x90, 0x00, 0x64, 0x00, 0x33, 0x00, 0x08,
  0xC0, 0x06, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x10, 0x60,
  0x0C, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x02, 0x02, 0x01, 0x81, 0x80, 0x60, 0x40, 0x18, 0x3F, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x82, 0x01, 0xC0, 0xC1, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x84, 0x00, 0x9F, 0xC0, 0xD8, 0x70, 0x78, 0x18,
  0x38, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x08, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C,
  0x03, 0x06, 0x01, 0x81, 0x01, 0x80, 0xC1, 0xC0, 0x71, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xC0, 0x18, 0x18, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x18, 0x08, 0x06,
  0x03, 0x03, 0x00, 0xC1, 0x80, 0x18, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00,
  0xEC, 0x00, 0x63, 0x80, 0x30, 0x60, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x10, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x18, 0x03, 0x06, 0x00, 0xC1, 0xC0, 0x60, 0x38, 0x70, 0x07,
  0xF8, 0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0x06, 0x06, 0x03, 0x06, 0x03,
  0x0C, 0x03, 0x0C, 0x01, 0x08, 0x01, 0x18, 0x01, 0x18, 0x03, 0x18, 0x03,
  0x10, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x10, 0x07, 0x18, 0x06,
  0x18, 0x0A, 0x1C, 0x1E, 0x0F, 0xF6, 0x07, 0xC6, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x87, 0x00, 0xFE, 0x00, 0x06, 0x0C,
  0x18, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x38, 0x70, 0xC0, 0x00, 0x80, 0x70, 0x18,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x10, 0x08, 0x00, 0x00,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0xFF,
  0x84, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x01,
  0xC0, 0x60, 0x06, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x80,
  0x01, 0x83, 0x00, 0x03, 0x04, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x20, 0x3E,
  0x18, 0xC0, 0xC4, 0x31, 0x03, 0x18, 0x66, 0x0C, 0x30, 0xCC, 0x10, 0x41,
  0x90, 0x60, 0x82, 0x20, 0x83, 0x04, 0xC3, 0x06, 0x09, 0x86, 0x08, 0x33,
  0x08, 0x30, 0x64, 0x30, 0x60, 0x88, 0x60, 0xC3, 0x30, 0xC1, 0x06, 0x61,
  0x86, 0x08, 0xC3, 0x0C, 0x31, 0x86, 0x28, 0x43, 0x0C, 0x51, 0x86, 0x0F,
  0x3E, 0x0C, 0x0C, 0x30, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0B, 0x00, 0x1B, 0x00, 0x13, 0x00,
  0x33, 0x00, 0x33, 0x00, 0x63, 0x00, 0x63, 0x00, 0x43, 0x00, 0xC3, 0x00,
  0xC3, 0x01, 0x83, 0x01, 0x83, 0x01, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07,
  0xFF, 0x06, 0x03, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x18, 0x38, 0x04, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0xC0, 0xC0,
  0x60, 0x31, 0xF0, 0x0F, 0xF0, 0x02, 0x07, 0x01, 0x80, 0xE0, 0x60, 0x18,
  0x18, 0x02, 0x06, 0x00, 0xC1, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0x82, 0x00, 0x61, 0x80, 0x18, 0x60, 0x04, 0x18, 0x03, 0x06, 0x01,
  0x81, 0x00, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xF0, 0x1C, 0x08, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x60, 0x07, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x06, 0x1E, 0x00, 0x80, 0xE0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0x60, 0x03, 0x0C, 0x00, 0x41, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x20, 0x03, 0x04, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x03,
  0x06, 0x00, 0x60, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x30,
  0x18, 0x0C, 0x02, 0x07, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFC,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x60, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0x80, 0x38, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xFE, 0x30, 0x07, 0xE1, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0x60, 0x00, 0xC2, 0x00, 0x04, 0x10, 0x00, 0x60, 0x80,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80, 0x04, 0x0C, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0xC0, 0x3C, 0x1C, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0x80, 0x40,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x04,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x08, 0x04,
  0x00, 0x20, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0F, 0xFF,
  0xC0, 0x20, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x40, 0x02, 0x01, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0,
  0x04, 0x02, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x20, 0x10, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x01, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x4E, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x30, 0x18, 0x07, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x03, 0x00, 0x20, 0x60,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x00, 0x04, 0x70,
  0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x0D, 0xC0, 0x00, 0xAC,
  0x00, 0x1E, 0xC0, 0x01, 0xC4, 0x00, 0x18, 0x60, 0x01, 0x06, 0x00, 0x10,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00, 0x20, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x80,
  0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x06, 0xC0, 0x58, 0x00, 0x34, 0x06, 0xC0, 0x03,
  0x60, 0x32, 0x00, 0x1B, 0x01, 0x90, 0x01, 0x98, 0x0C, 0x80, 0x0C, 0xC0,
  0x44, 0x00, 0xC4, 0x06, 0x20, 0x06, 0x60, 0x31, 0x00, 0x63, 0x01, 0x88,
  0x03, 0x18, 0x0C, 0x60, 0x10, 0xC0, 0x43, 0x01, 0x84, 0x06, 0x18, 0x08,
  0x60, 0x30, 0xC0, 0xC3, 0x01, 0x86, 0x04, 0x18, 0x08, 0x30, 0x60, 0x80,
  0x41, 0x82, 0x0C, 0x06, 0x0C, 0x30, 0x60, 0x30, 0x61, 0x83, 0x01, 0x83,
  0x18, 0x18, 0x08, 0x18, 0xC0, 0x80, 0xC0, 0xCC, 0x0C, 0x06, 0x06, 0x60,
  0x60, 0x30, 0x16, 0x03, 0x01, 0x80, 0xB0, 0x18, 0x08, 0x07, 0x00, 0x80,
  0xC0, 0x38, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x06, 0x03,
  0x80, 0x0C, 0x07, 0x00, 0x10, 0x0E, 0x00, 0x60, 0x3C, 0x00, 0xC0, 0x68,
  0x01, 0x80, 0xD0, 0x03, 0x01, 0x30, 0x04, 0x06, 0x60, 0x18, 0x0C, 0xC0,
  0x30, 0x19, 0x80, 0x60, 0x31, 0x00, 0xC0, 0x43, 0x01, 0x01, 0x86, 0x06,
  0x03, 0x0C, 0x0C, 0x06, 0x18, 0x18, 0x0C, 0x10, 0x20, 0x10, 0x20, 0x40,
  0x60, 0x61, 0x80, 0xC0, 0xC3, 0x01, 0x81, 0x86, 0x02, 0x03, 0x08, 0x04,
  0x02, 0x30, 0x18, 0x06, 0x60, 0x30, 0x0C, 0xC0, 0x60, 0x19, 0x80, 0x80,
  0x32, 0x03, 0x00, 0x2C, 0x06, 0x00, 0x58, 0x0C, 0x00, 0xF0, 0x18, 0x01,
  0xE0, 0x20, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x06, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xC0, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x04, 0x60, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0xC0,
  0x01, 0x20, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x32, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x01, 0x88, 0x00, 0x63, 0x00,
  0x10, 0xC0, 0x0C, 0x30, 0x06, 0x0C, 0x03, 0x81, 0x81, 0xC0, 0x70, 0xE0,
  0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x18, 0x70, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x08, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x08, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x30, 0x30, 0x1C, 0x0C, 0x0E, 0x02, 0x07, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xC0, 0x18, 0x18, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x04,
  0x60, 0x01, 0x18, 0x00, 0x44, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0x20,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x40, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x32,
  0x00, 0x0C, 0x80, 0x03, 0x20, 0x01, 0x88, 0x00, 0x63, 0x00, 0x10, 0xC0,
  0x0C, 0x30, 0x06, 0x0C, 0x03, 0x81, 0x81, 0xC0, 0x70, 0xE0, 0x0F, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80,
  0x18, 0x70, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x30, 0x0C, 0x0C,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x08, 0x18, 0x06, 0x04, 0x01,
  0x83, 0x00, 0x40, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x02, 0x1E, 0x01,
  0xFF, 0x00, 0x61, 0x80, 0x18, 0x60, 0x04, 0x18, 0x01, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x20, 0x0C, 0x0C, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x06, 0x01, 0x81, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x06, 0x01, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x04, 0x01, 0x80, 0xE0, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x10, 0x30, 0x03, 0x02, 0x00, 0x30, 0x60, 0x03, 0x06,
  0x00, 0x20, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60,
  0xC0, 0x04, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08,
  0x18, 0x00, 0x81, 0x80, 0x18, 0x10, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01,
  0x03, 0x00, 0x30, 0x20, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x20, 0x60, 0x06, 0x04, 0x00, 0x60, 0x40, 0x06, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x38, 0x60, 0x01,
  0xFC, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x00, 0xC3, 0x00, 0xC3, 0x00, 0xC6, 0x00,
  0xC6, 0x00, 0xCC, 0x00, 0xCC, 0x00, 0xC8, 0x00, 0xD8, 0x00, 0xD8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x60, 0x03,
  0x00, 0x1B, 0x00, 0x18, 0x00, 0xD8, 0x01, 0xC0, 0x0C, 0xC0, 0x0E, 0x00,
  0x66, 0x00, 0x70, 0x02, 0x30, 0x07, 0x80, 0x31, 0x80, 0x2C, 0x01, 0x8C,
  0x03, 0x60, 0x18, 0x60, 0x1B, 0x00, 0xC3, 0x00, 0x98, 0x04, 0x18, 0x0C,
  0xC0, 0x60, 0xC0, 0x66, 0x03, 0x04, 0x06, 0x30, 0x30, 0x20, 0x31, 0x81,
  0x81, 0x01, 0x08, 0x08, 0x08, 0x18, 0x40, 0xC0, 0x40, 0xC2, 0x06, 0x02,
  0x04, 0x10, 0x60, 0x10, 0x60, 0x83, 0x00, 0x82, 0x04, 0x10, 0x04, 0x30,
  0x21, 0x80, 0x21, 0x81, 0x0C, 0x01, 0x08, 0x08, 0xC0, 0x08, 0xC0, 0x46,
  0x00, 0x44, 0x02, 0x20, 0x02, 0x60, 0x13, 0x00, 0x13, 0x00, 0x98, 0x00,
  0x90, 0x0D, 0x80, 0x05, 0x80, 0x6C, 0x00, 0x2C, 0x03, 0x40, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x0C, 0x00, 0xC0,
  0x60, 0x06, 0x06, 0x00, 0x30, 0x20, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00,
  0x61, 0x80, 0x01, 0x18, 0x00, 0x08, 0xC0, 0x00, 0x4C, 0x00, 0x02, 0x60,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x63, 0x00, 0x02, 0x18, 0x00, 0x30, 0x40, 0x01, 0x02,
  0x00, 0x18, 0x10, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x00, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x10, 0x18, 0x20,
  0x60, 0x40, 0xC0, 0x83, 0x01, 0x84, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0,
  0x19, 0x00, 0x36, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x83, 0x0C, 0x30, 0xC1, 0x04, 0x10, 0x61, 0x86, 0x18, 0x20, 0x82,
  0x0C, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x86, 0x18, 0x60, 0x82, 0x08, 0x30,
  0xC3, 0x0C, 0x10, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x34, 0x00, 0x13, 0x00, 0x19, 0x80, 0x08, 0x60, 0x0C, 0x30,
  0x04, 0x0C, 0x06, 0x06, 0x06, 0x01, 0x03, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x19, 0x80, 0x0C, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC6, 0x18, 0xC2, 0x18, 0x41, 0x01, 0xF9, 0x81, 0xCE, 0xC1, 0x81, 0x41,
  0x80, 0xA0, 0xC0, 0x70, 0xC0, 0x38, 0x60, 0x1C, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x86, 0x00, 0x43, 0x00, 0x61, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x07, 0x0C,
  0x03, 0x83, 0x02, 0x81, 0x83, 0x40, 0xE3, 0x60, 0x3F, 0x30, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xCF,
  0xC0, 0x6E, 0x70, 0x3C, 0x18, 0x14, 0x04, 0x0C, 0x03, 0x0E, 0x01, 0x86,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x08, 0x60, 0x0C,
  0x20, 0x06, 0x10, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x21, 0xC0, 0x30, 0xE0, 0x10, 0x50, 0x18, 0x28, 0x18, 0x16,
  0x18, 0x19, 0xF8, 0x00, 0x01, 0xF8, 0x1C, 0x41, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x10, 0x3F, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0xFC, 0xC0, 0x39, 0xD8, 0x0C, 0x0A, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x18,
  0x07, 0x03, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x03, 0x02, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x03, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x0E, 0x06, 0x01,
  0xC0, 0x40, 0x50, 0x0C, 0x1A, 0x01, 0xC6, 0xC0, 0x1F, 0x98, 0x00, 0x01,
  0xF8, 0x0E, 0x70, 0x60, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x00, 0xCC,
  0x02, 0x30, 0x19, 0x80, 0xC6, 0x06, 0x18, 0xF0, 0x7F, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x30, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x08, 0x00, 0x00, 0xC0, 0x00, 0x4C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x60, 0x1C, 0xEC, 0x06, 0x05, 0x01, 0x80, 0xA0, 0x30, 0x1C, 0x0C,
  0x03, 0x81, 0x80, 0x70, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x30, 0x06, 0x04, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x07, 0x03, 0x00,
  0xE0, 0x20, 0x28, 0x06, 0x0F, 0x00, 0xE3, 0x60, 0x0F, 0xCC, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x10, 0x1C, 0x03, 0x8F, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x7E, 0x06, 0xE6, 0x07, 0x83, 0x07, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C,
  0x03, 0x0C, 0x02, 0x0C, 0x02, 0x08, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x04, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x20,
  0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x10, 0x40, 0x30, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x40, 0x60, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x04, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x04,
  0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x08, 0xC0, 0x19, 0x80, 0x19,
  0x80, 0x1B, 0x80, 0x1E, 0x80, 0x1C, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30,
  0xC0, 0x20, 0x40, 0x20, 0x40, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40,
  0x60, 0xC0, 0x20, 0xC0, 0x30, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x00, 0x06, 0x7C, 0x3E, 0x03, 0x67, 0x33, 0x81, 0x40, 0xA0, 0x60,
  0xE0, 0x70, 0x30, 0x60, 0x30, 0x18, 0x60, 0x18, 0x0C, 0x30, 0x08, 0x06,
  0x18, 0x0C, 0x02, 0x0C, 0x06, 0x03, 0x0C, 0x03, 0x01, 0x86, 0x01, 0x80,
  0xC3, 0x01, 0x80, 0x41, 0x80, 0xC0, 0x20, 0x80, 0x60, 0x30, 0xC0, 0x30,
  0x18, 0x60, 0x10, 0x0C, 0x30, 0x18, 0x04, 0x18, 0x0C, 0x02, 0x08, 0x06,
  0x03, 0x0C, 0x03, 0x01, 0x86, 0x01, 0x00, 0xC3, 0x01, 0x80, 0x41, 0x00,
  0xC0, 0x60, 0x80, 0x60, 0x30, 0xC0, 0x20, 0x18, 0x00, 0x06, 0x7E, 0x06,
  0xE6, 0x05, 0x83, 0x07, 0x03, 0x06, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C,
  0x02, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x04, 0x10,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x20, 0x18, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40, 0x30, 0xC0, 0x30, 0x01,
  0xF8, 0x07, 0x38, 0x18, 0x30, 0x60, 0x30, 0xC0, 0x63, 0x00, 0xC4, 0x01,
  0x98, 0x03, 0x30, 0x06, 0x40, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C,
  0x00, 0x90, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x00,
  0x8C, 0x03, 0x08, 0x0C, 0x18, 0x18, 0x38, 0xE0, 0x3F, 0x80, 0x01, 0x9F,
  0x80, 0x37, 0x38, 0x07, 0x83, 0x00, 0xA0, 0x20, 0x18, 0x06, 0x07, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x40, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60, 0x04,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x04, 0x0E, 0x01, 0x81, 0xC0, 0x20,
  0x38, 0x0C, 0x05, 0x03, 0x00, 0xB1, 0xC0, 0x33, 0xF0, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xF9, 0x81, 0xCE, 0xC1, 0x83, 0x41, 0x80, 0xA0, 0xC0, 0x70, 0xC0,
  0x38, 0x60, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0x86, 0x00, 0x43, 0x00, 0x61, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x08,
  0x60, 0x0C, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x82, 0x02, 0x81, 0x83,
  0xC0, 0xE3, 0x60, 0x3F, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x06, 0x78, 0x37, 0x41, 0x60, 0x0A, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x01, 0xFC,
  0x0F, 0x3C, 0x18, 0x10, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x70, 0xE0, 0x7F, 0x80, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x40, 0x60, 0xFE, 0x7F, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xE0, 0x0C, 0x03, 0x0C, 0x03,
  0x0C, 0x02, 0x08, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x04,
  0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x20, 0x18,
  0x60, 0x18, 0x60, 0x18, 0x60, 0x10, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x30,
  0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xA0, 0x63, 0x20, 0x7E, 0x60, 0x80, 0x1C,
  0x01, 0xA0, 0x0D, 0x00, 0xC8, 0x06, 0x40, 0x22, 0x03, 0x10, 0x18, 0x81,
  0x84, 0x0C, 0x20, 0xC1, 0x06, 0x08, 0x20, 0x43, 0x02, 0x10, 0x11, 0x80,
  0x8C, 0x04, 0xC0, 0x26, 0x01, 0x60, 0x0B, 0x00, 0x50, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x6C, 0x07, 0x01, 0xB0,
  0x1C, 0x04, 0xC0, 0xF0, 0x33, 0x02, 0xC0, 0x8C, 0x0B, 0x06, 0x20, 0x6C,
  0x18, 0x81, 0x30, 0x42, 0x0C, 0xC3, 0x08, 0x23, 0x08, 0x21, 0x8C, 0x60,
  0x86, 0x31, 0x82, 0x10, 0xC4, 0x08, 0xC3, 0x30, 0x22, 0x0C, 0xC0, 0x98,
  0x32, 0x02, 0x60, 0xD8, 0x09, 0x03, 0x40, 0x2C, 0x0B, 0x00, 0xA0, 0x2C,
  0x03, 0x80, 0xA0, 0x0E, 0x03, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x00,
  0x03, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x08, 0x01, 0x06, 0x00,
  0x43, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x01, 0x90, 0x00, 0x2C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x80,
  0x06, 0x60, 0x01, 0x18, 0x00, 0xC2, 0x00, 0x60, 0x80, 0x18, 0x30, 0x0C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x10, 0x00, 0x00, 0x40, 0x0C,
  0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10, 0x0C, 0x00, 0x40, 0x30, 0x01,
  0x00, 0x80, 0x04, 0x06, 0x00, 0x10, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x03,
  0x00, 0x04, 0x18, 0x00, 0x10, 0x60, 0x00, 0x43, 0x00, 0x01, 0x0C, 0x00,
  0x04, 0x20, 0x00, 0x11, 0x80, 0x00, 0x44, 0x00, 0x01, 0xB0, 0x00, 0x04,
  0xC0, 0x00, 0x16, 0x00, 0x00, 0x58, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x09, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x78, 0x78, 0xF0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 34, 10, 1, -34 },
  { 40, 9, 13, 13, 5, -34 },
  { 55, 19, 34, 18, 0, -34 },
  { 136, 17, 39, 17, 0, -36 },
  { 219, 21, 35, 25, 2, -34 },
  { 311, 16, 34, 16, -1, -34 },
  { 379, 4, 13, 7, 5, -34 },
  { 386, 13, 40, 11, 1, -33 },
  { 451, 13, 40, 12, -3, -33 },
  { 516, 12, 14, 15, 5, -36 },
  { 537, 17, 21, 19, 1, -27 },
  { 582, 6, 10, 8, -2, -4 },
  { 590, 10, 2, 12, 1, -14 },
  { 593, 2, 4, 8, 1, -4 },
  { 594, 19, 34, 14, -2, -34 },
  { 675, 15, 34, 17, 1, -34 },
  { 739, 9, 34, 17, 5, -34 },
  { 778, 19, 34, 17, -2, -34 },
  { 859, 18, 35, 17, -1, -34 },
  { 938, 18, 34, 17, -1, -34 },
  { 1015, 18, 34, 17, -1, -34 },
  { 1092, 17, 34, 17, 1, -34 },
  { 1165, 16, 34, 17, 2, -34 },
  { 1233, 18, 34, 17, -1, -34 },
  { 1310, 16, 34, 17, 0, -34 },
  { 1378, 7, 25, 8, 0, -25 },
  { 1400, 10, 31, 8, -2, -25 },
  { 1439, 17, 19, 19, 1, -26 },
  { 1480, 17, 11, 19, 1, -22 },
  { 1504, 17, 19, 19, 1, -26 },
  { 1545, 13, 34, 12, 1, -34 },
  { 1601, 23, 38, 25, 1, -34 },
  { 1711, 16, 34, 16, -3, -34 },
  { 1779, 18, 34, 18, 0, -34 },
  { 1856, 18, 34, 16, 2, -34 },
  { 1933, 19, 34, 20, 0, -34 },
  { 2014, 18, 34, 16, 0, -34 },
  { 2091, 18, 34, 15, 0, -34 },
  { 2168, 21, 34, 22, 2, -34 },
  { 2258, 22, 34, 21, 0, -34 },
  { 2352, 15, 34, 9, -3, -34 },
  { 2416, 16, 42, 8, -7, -34 },
  { 2500, 20, 34, 17, 0, -34 },
  { 2585, 11, 34, 15, 0, -34 },
  { 2632, 29, 34, 28, 0, -34 },
  { 2756, 23, 34, 22, 0, -34 },
  { 2854, 18, 34, 21, 2, -34 },
  { 2931, 18, 34, 17, 0, -34 },
  { 3008, 18, 42, 21, 2, -34 },
  { 3103, 18, 34, 17, 0, -34 },
  { 3180, 19, 34, 16, -1, -34 },
  { 3261, 15, 34, 14, 3, -34 },
  { 3325, 20, 34, 20, 1, -34 },
  { 3410, 16, 34, 17, 4, -34 },
  { 3478, 29, 34, 29, 3, -34 },
  { 3602, 21, 34, 15, -3, -34 },
  { 3692, 15, 34, 14, 3, -34 },
  { 3756, 19, 34, 15, -2, -34 },
  { 3837, 17, 41, 13, -1, -34 },
  { 3925, 6, 34, 15, 5, -34 },
  { 3951, 17, 41, 13, -3, -34 },
  { 4039, 17, 17, 18, 1, -34 },
  { 4076, 13, 2, 13, -4, 4 },
  { 4080, 5, 8, 10, 7, -36 },
  { 4085, 17, 25, 18, 1, -25 },
  { 4139, 17, 36, 18, 0, -36 },
  { 4216, 13, 25, 13, 1, -25 },
  { 4257, 19, 36, 18, 1, -36 },
  { 4343, 14, 25, 16, 1, -25 },
  { 4387, 21, 47, 9, -6, -36 },
  { 4511, 19, 36, 18, -1, -25 },
  { 4597, 16, 36, 17, 0, -36 },
  { 4669, 9, 34, 8, 0, -34 },
  { 4708, 15, 45, 8, -6, -34 },
  { 4793, 16, 36, 15, 0, -36 },
  { 4865, 10, 36, 7, 0, -36 },
  { 4910, 25, 25, 26, 0, -25 },
  { 4989, 16, 25, 17, 0, -25 },
  { 5039, 15, 25, 17, 1, -25 },
  { 5086, 19, 36, 18, -2, -25 },
  { 5172, 17, 36, 18, 1, -25 },
  { 5249, 13, 25, 11, 0, -25 },
  { 5290, 15, 25, 13, -1, -25 },
  { 5337, 9, 31, 9, 1, -31 },
  { 5372, 16, 25, 17, 1, -25 },
  { 5422, 13, 25, 13, 3, -25 },
  { 5463, 22, 25, 22, 3, -25 },
  { 5532, 18, 25, 14, -2, -25 },
  { 5589, 22, 36, 14, -5, -25 },
  { 5688, 15, 25, 11, -2, -25 },
  { 5735, 17, 41, 15, 1, -34 },
  { 5823, 2, 47, 16, 7, -36 },
  { 5835, 16, 41, 15, -3, -34 },
  { 5917, 17, 4, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC47PT7B_H_
