#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x40, 0x08, 0xB6, 0xD0, 0x12, 0x28, 0x53,
  0xF2, 0x85, 0x0A, 0x7E, 0x50, 0xA2, 0x45, 0x00, 0x08, 0x62, 0xD4, 0x50,
  0xC2, 0x04, 0x28, 0xA2, 0xAC, 0x41, 0x00, 0x73, 0x2A, 0x54, 0xCA, 0x96,
  0xF6, 0x95, 0x2A, 0x95, 0x4C, 0x60, 0x38, 0xA2, 0x8A, 0x30, 0x86, 0x25,
  0x9A, 0x69, 0x3A, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x04,
  0x21, 0x00, 0x10, 0x82, 0x10, 0x84, 0x22, 0x10, 0x88, 0x44, 0x22, 0x00,
  0x2A, 0x76, 0x90, 0x21, 0x08, 0x4F, 0x90, 0x84, 0x29, 0x40, 0xF0, 0x80,
  0x02, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x1C,
  0x92, 0x51, 0x45, 0x18, 0x62, 0x8A, 0x29, 0x18, 0x74, 0xA4, 0x92, 0x92,
  0x40, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x07, 0xC0,
  0x3C, 0x10, 0x41, 0x08, 0xC0, 0x82, 0x08, 0x21, 0x38, 0x04, 0x31, 0x46,
  0x29, 0x24, 0xA2, 0xF8, 0x41, 0x04, 0x3C, 0x82, 0x10, 0x41, 0xC0, 0x82,
  0x08, 0x21, 0x38, 0x1C, 0x82, 0x10, 0x51, 0xA4, 0x61, 0x8A, 0x28, 0x9C,
  0x7C, 0x20, 0x84, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x3D, 0x14, 0x51,
  0x28, 0xC5, 0x22, 0x8A, 0x28, 0xBC, 0x3D, 0x14, 0x51, 0x45, 0x15, 0x8A,
  0x08, 0x21, 0x38, 0x20, 0x00, 0x00, 0x80, 0x10, 0x00, 0x00, 0x02, 0x44,
  0x80, 0x08, 0xD9, 0x0C, 0x10, 0x61, 0xF8, 0x01, 0xF0, 0x86, 0x0C, 0x11,
  0x93, 0x10, 0x78, 0x42, 0x11, 0x11, 0x08, 0x40, 0x01, 0x00, 0x0F, 0x08,
  0x48, 0x29, 0xD5, 0x2A, 0xA5, 0x55, 0x4A, 0xA5, 0x4F, 0x20, 0x10, 0x04,
  0x81, 0x80, 0x04, 0x30, 0xC5, 0x14, 0x92, 0x4F, 0x45, 0x18, 0x61, 0x3C,
  0x44, 0x89, 0x14, 0x4F, 0x12, 0x22, 0x45, 0x0A, 0x27, 0x80, 0x3D, 0x04,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x3C, 0x44, 0x89, 0x14, 0x28,
  0x50, 0xA2, 0x45, 0x0A, 0x27, 0x80, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x10,
  0x20, 0x41, 0x02, 0x07, 0x80, 0x3E, 0x40, 0x81, 0x04, 0x08, 0x1E, 0x20,
  0x41, 0x02, 0x04, 0x00, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x23, 0x42, 0x85,
  0x0A, 0x23, 0xC0, 0x21, 0x21, 0x21, 0x22, 0x42, 0x7E, 0x42, 0x44, 0x44,
  0x84, 0x84, 0x84, 0x18, 0x84, 0x22, 0x10, 0x84, 0x22, 0x11, 0xC0, 0x08,
  0x42, 0x11, 0x08, 0x42, 0x11, 0x08, 0x42, 0x23, 0x00, 0x22, 0x48, 0x91,
  0x45, 0x0C, 0x14, 0x28, 0x51, 0x12, 0x24, 0x40, 0x22, 0x22, 0x44, 0x44,
  0x48, 0x8F, 0x30, 0x4C, 0x13, 0x0C, 0xC3, 0x51, 0x54, 0x65, 0x29, 0x4A,
  0x54, 0xA5, 0x29, 0x92, 0x64, 0x31, 0x31, 0x31, 0x31, 0x52, 0x4A, 0x4A,
  0x4A, 0x4A, 0x8C, 0x84, 0x84, 0x3D, 0x14, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x28, 0xBC, 0x3C, 0x92, 0x49, 0x45, 0x17, 0x90, 0x42, 0x08, 0x20, 0x3D,
  0x14, 0x61, 0x86, 0x18, 0x61, 0x86, 0x28, 0xBC, 0x20, 0x81, 0x00, 0x3C,
  0x92, 0x49, 0x45, 0x27, 0x14, 0x52, 0x48, 0xA2, 0x3D, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x20, 0xBC, 0xF9, 0x08, 0x42, 0x21, 0x08, 0x44, 0x21,
  0x00, 0x42, 0x85, 0x12, 0x28, 0x50, 0xA2, 0x44, 0x89, 0x12, 0x47, 0x00,
  0x86, 0x18, 0xA2, 0x8A, 0x49, 0x28, 0xA3, 0x0C, 0x20, 0x84, 0x30, 0x8A,
  0x31, 0x46, 0x49, 0x49, 0x29, 0x29, 0x45, 0x28, 0xA6, 0x18, 0xC3, 0x10,
  0x42, 0x00, 0x13, 0x12, 0x14, 0x14, 0x08, 0x08, 0x10, 0x28, 0x28, 0x48,
  0x48, 0x88, 0x8E, 0x29, 0x14, 0x61, 0x84, 0x10, 0x42, 0x08, 0x20, 0x1E,
  0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x07, 0xC0, 0x3C, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x0E, 0x00, 0xAA, 0xA9,
  0x55, 0x1C, 0x10, 0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x8E,
  0x00, 0x10, 0x50, 0xA2, 0x24, 0x50, 0x40, 0xF0, 0x94, 0x1C, 0x94, 0x51,
  0x46, 0x28, 0xA2, 0x78, 0x10, 0x82, 0x08, 0x3C, 0x94, 0x51, 0x45, 0x18,
  0xA2, 0xF0, 0x19, 0x10, 0x88, 0x42, 0x10, 0x70, 0x02, 0x04, 0x08, 0x11,
  0xA4, 0x91, 0x22, 0x45, 0x12, 0x24, 0x47, 0x80, 0x39, 0x52, 0x97, 0x42,
  0x10, 0x70, 0x06, 0x08, 0x20, 0x41, 0xC1, 0x04, 0x08, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x08, 0x20, 0xC0, 0x1C, 0x94, 0x51, 0x46, 0x28, 0xA2, 0x78,
  0x21, 0x04, 0xE0, 0x10, 0x82, 0x08, 0x3C, 0x94, 0x51, 0x49, 0x28, 0xA2,
  0x88, 0x20, 0x14, 0x92, 0x52, 0x40, 0x08, 0x00, 0x10, 0x88, 0x42, 0x11,
  0x08, 0x42, 0x11, 0x18, 0x10, 0x82, 0x08, 0x25, 0x25, 0x18, 0x51, 0x49,
  0x24, 0x90, 0x24, 0x92, 0x92, 0x4A, 0x48, 0x3B, 0x92, 0x51, 0x29, 0x14,
  0x8A, 0x4A, 0x25, 0x12, 0x91, 0x00, 0x3C, 0x94, 0x51, 0x49, 0x28, 0xA2,
  0x88, 0x38, 0x94, 0x51, 0x46, 0x18, 0xA2, 0x70, 0x1E, 0x24, 0x89, 0x12,
  0x24, 0x51, 0x22, 0x78, 0x81, 0x04, 0x08, 0x00, 0x1C, 0x94, 0x51, 0x46,
  0x28, 0xA2, 0x78, 0x21, 0x04, 0x10, 0x39, 0x10, 0x84, 0x22, 0x10, 0x80,
  0x3A, 0x10, 0x82, 0x08, 0x42, 0xE0, 0x22, 0x74, 0x44, 0x44, 0x88, 0xE0,
  0x25, 0x14, 0x51, 0x49, 0x28, 0xA2, 0x78, 0x8C, 0xA5, 0x4A, 0x63, 0x10,
  0x80, 0x91, 0x92, 0x92, 0xAA, 0xAC, 0xCC, 0xD4, 0x88, 0x88, 0x26, 0x48,
  0x60, 0x81, 0x06, 0x0C, 0x24, 0x88, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x3C, 0x20, 0x84, 0x10, 0x84,
  0x10, 0xF0, 0x19, 0x08, 0x42, 0x21, 0x10, 0x42, 0x21, 0x08, 0x41, 0x00,
  0xFF, 0xFF, 0x80, 0x18, 0x20, 0x82, 0x08, 0x20, 0x83, 0x10, 0x42, 0x08,
  0x20, 0x8C, 0x00, 0xEC, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 3, 4, 5, 2, -12 },
  { 9, 7, 12, 6, 0, -12 },
  { 20, 6, 14, 6, 0, -13 },
  { 31, 7, 12, 9, 1, -12 },
  { 42, 6, 12, 6, 0, -12 },
  { 51, 1, 4, 3, 2, -12 },
  { 52, 5, 15, 4, 0, -12 },
  { 62, 5, 15, 4, -1, -12 },
  { 72, 4, 5, 6, 2, -13 },
  { 75, 5, 8, 7, 1, -10 },
  { 80, 3, 4, 3, -1, -2 },
  { 82, 4, 1, 4, 0, -5 },
  { 83, 1, 1, 3, 0, -1 },
  { 84, 7, 12, 5, -1, -12 },
  { 95, 6, 12, 6, 0, -12 },
  { 104, 3, 12, 6, 2, -12 },
  { 109, 7, 12, 6, -1, -12 },
  { 120, 6, 12, 6, 0, -12 },
  { 129, 6, 12, 6, 0, -12 },
  { 138, 6, 12, 6, 0, -12 },
  { 147, 6, 12, 6, 0, -12 },
  { 156, 6, 12, 6, 1, -12 },
  { 165, 6, 12, 6, 0, -12 },
  { 174, 6, 12, 6, 0, -12 },
  { 183, 3, 9, 3, 0, -9 },
  { 187, 4, 11, 3, -1, -9 },
  { 193, 5, 8, 7, 1, -10 },
  { 198, 5, 4, 7, 1, -8 },
  { 201, 5, 8, 7, 1, -10 },
  { 206, 5, 12, 4, 0, -12 },
  { 214, 9, 14, 9, 0, -12 },
  { 230, 6, 12, 6, -1, -12 },
  { 239, 7, 12, 7, 0, -12 },
  { 250, 6, 12, 6, 1, -12 },
  { 259, 7, 12, 7, 0, -12 },
  { 270, 7, 12, 6, 0, -12 },
  { 281, 7, 12, 5, 0, -12 },
  { 292, 7, 12, 8, 1, -12 },
  { 303, 8, 12, 8, 0, -12 },
  { 315, 5, 12, 3, -1, -12 },
  { 323, 5, 15, 3, -2, -12 },
  { 333, 7, 12, 6, 0, -12 },
  { 344, 4, 12, 5, 0, -12 },
  { 350, 10, 12, 10, 0, -12 },
  { 365, 8, 12, 8, 0, -12 },
  { 377, 6, 12, 8, 1, -12 },
  { 386, 6, 12, 6, 0, -12 },
  { 395, 6, 15, 8, 1, -12 },
  { 407, 6, 12, 6, 0, -12 },
  { 416, 6, 12, 6, 0, -12 },
  { 425, 5, 12, 5, 1, -12 },
  { 433, 7, 12, 7, 1, -12 },
  { 444, 6, 12, 6, 1, -12 },
  { 453, 11, 12, 10, 1, -12 },
  { 470, 8, 12, 5, -1, -12 },
  { 482, 6, 12, 5, 1, -12 },
  { 491, 7, 12, 5, -1, -12 },
  { 502, 6, 15, 5, 0, -12 },
  { 514, 2, 12, 5, 2, -12 },
  { 517, 6, 15, 5, -1, -12 },
  { 529, 7, 6, 7, 0, -12 },
  { 535, 4, 1, 5, -1, 1 },
  { 536, 2, 3, 4, 2, -13 },
  { 537, 6, 9, 7, 0, -9 },
  { 544, 6, 13, 6, 0, -13 },
  { 554, 5, 9, 5, 0, -9 },
  { 560, 7, 13, 7, 0, -13 },
  { 572, 5, 9, 6, 0, -9 },
  { 578, 7, 17, 3, -2, -13 },
  { 593, 6, 13, 7, 0, -9 },
  { 603, 6, 13, 6, 0, -13 },
  { 613, 3, 12, 3, 0, -12 },
  { 618, 5, 16, 3, -2, -12 },
  { 628, 6, 13, 5, 0, -13 },
  { 638, 3, 13, 3, 0, -13 },
  { 643, 9, 9, 10, 0, -9 },
  { 654, 6, 9, 6, 0, -9 },
  { 661, 6, 9, 6, 0, -9 },
  { 668, 7, 13, 7, -1, -9 },
  { 680, 6, 13, 7, 0, -9 },
  { 690, 5, 9, 4, 0, -9 },
  { 696, 5, 9, 5, 0, -9 },
  { 702, 4, 11, 3, 0, -11 },
  { 708, 6, 9, 6, 0, -9 },
  { 715, 5, 9, 5, 1, -9 },
  { 721, 8, 9, 8, 1, -9 },
  { 730, 7, 9, 5, -1, -9 },
  { 738, 8, 13, 5, -2, -9 },
  { 751, 6, 9, 4, -1, -9 },
  { 758, 5, 15, 5, 1, -12 },
  { 768, 1, 17, 6, 2, -13 },
  { 771, 6, 15, 5, -1, -12 },
  { 783, 5, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC17PT7B_H_
