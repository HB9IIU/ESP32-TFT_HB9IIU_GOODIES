#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x30, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18, 0x0C, 0x30, 0x18,
  0x60, 0x71, 0xC0, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x18, 0x60,
  0x30, 0xC0, 0x61, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x60,
  0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06,
  0x03, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x07, 0x01, 0x80, 0x00, 0x60, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xC3, 0x0E, 0x00, 0x70, 0x60, 0x20, 0x0E, 0x06, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x40, 0x00, 0x1C, 0x0C, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x1C,
  0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x0E, 0x18, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x18, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x1C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x03, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x02, 0x07, 0x00, 0x40, 0x61, 0xE0, 0x0F, 0xC6, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x02, 0x00,
  0x7F, 0x00, 0x06, 0x00, 0x73, 0xC0, 0x07, 0x00, 0x70, 0xE0, 0x03, 0x00,
  0x70, 0x30, 0x03, 0x80, 0x30, 0x18, 0x01, 0x80, 0x38, 0x0C, 0x01, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x0E, 0x01, 0x80, 0x60,
  0x06, 0x00, 0xC0, 0x70, 0x07, 0x00, 0x60, 0x30, 0x03, 0x80, 0x70, 0x38,
  0x01, 0x80, 0x38, 0x18, 0x01, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0x0C, 0x0C,
  0x00, 0x70, 0x06, 0x0E, 0x00, 0x30, 0x07, 0x06, 0x00, 0x18, 0x03, 0x87,
  0x00, 0x0C, 0x01, 0xC3, 0x00, 0x06, 0x00, 0xC3, 0x80, 0x07, 0x00, 0xE1,
  0x83, 0xF3, 0x80, 0x71, 0xC3, 0xFD, 0xC0, 0x30, 0xC3, 0x86, 0xE0, 0x38,
  0xE3, 0x83, 0xF0, 0x18, 0x61, 0x81, 0xF8, 0x1C, 0x71, 0xC0, 0xEC, 0x0C,
  0x30, 0xC0, 0x36, 0x0E, 0x38, 0xE0, 0x1B, 0x8E, 0x18, 0x60, 0x1C, 0xFE,
  0x1C, 0x70, 0x0E, 0x3E, 0x0C, 0x38, 0x07, 0x00, 0x0E, 0x18, 0x03, 0x80,
  0x06, 0x0C, 0x01, 0x80, 0x07, 0x0E, 0x00, 0xC0, 0x03, 0x07, 0x00, 0x60,
  0x03, 0x83, 0x00, 0x70, 0x01, 0x81, 0x80, 0x38, 0x01, 0xC0, 0xC0, 0x1C,
  0x00, 0xC0, 0xE0, 0x0C, 0x00, 0xE0, 0x70, 0x06, 0x00, 0x60, 0x38, 0x07,
  0x00, 0x70, 0x1C, 0x03, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x38, 0x06, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0xE0,
  0x60, 0x0E, 0x00, 0x70, 0x70, 0x06, 0x00, 0x18, 0x70, 0x07, 0x00, 0x0F,
  0xF0, 0x03, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x30,
  0x0E, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x39,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xCE,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x06, 0x03, 0x0E, 0x07, 0x07, 0x1C, 0x07,
  0x07, 0x1C, 0x03, 0x07, 0x38, 0x03, 0x06, 0x38, 0x03, 0x8E, 0x70, 0x03,
  0x8C, 0x70, 0x01, 0x9C, 0x70, 0x01, 0x9C, 0x60, 0x01, 0xD8, 0xE0, 0x01,
  0xF8, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xF0, 0x70, 0x07, 0x70, 0x70, 0x0E,
  0x30, 0x78, 0x1C, 0x38, 0x3F, 0xFC, 0x38, 0x1F, 0xF0, 0x38, 0x07, 0xC0,
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC7, 0x18, 0x61, 0x86,
  0x38, 0xC3, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x80, 0xC0, 0x18, 0x18, 0x07, 0xC3, 0x00, 0x1E, 0x60, 0xE0, 0xE9,
  0xFC, 0x07, 0xFC, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x0E, 0x60, 0x03, 0x8C,
  0x00, 0xE0, 0xC0, 0x38, 0x18, 0x0E, 0x01, 0x80, 0x80, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07,
  0x03, 0x03, 0x81, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x27,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x3E, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x03, 0x03,
  0x80, 0x03, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x18, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x60,
  0x00, 0x30, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x60,
  0x01, 0x80, 0x60, 0x03, 0x80, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x07, 0x70,
  0x73, 0x07, 0x38, 0xF1, 0xCF, 0x0E, 0xF0, 0x72, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC0, 0x1C, 0x00, 0x30, 0x01, 0xE0,
  0x02, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x70, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x18, 0x03, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x30,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00,
  0x30, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x08, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0xC0, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x01, 0xC3, 0xFC, 0x00, 0xE7, 0xFF, 0x00, 0x67, 0x83,
  0xC0, 0x37, 0x00, 0xF0, 0x3B, 0x00, 0x38, 0x1F, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38,
  0x18, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x0E,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x07,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x83, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0x01, 0xC0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x07, 0x00, 0x0C, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x83, 0x80, 0x0F, 0x80,
  0xE0, 0x0E, 0xC0, 0x78, 0x0E, 0xE0, 0x1F, 0x1E, 0x70, 0x07, 0xFE, 0x38,
  0x01, 0xFC, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x7C, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xC7, 0xE0, 0x30, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0xC0, 0x00, 0x00, 0x38, 0x38, 0x00, 0xFC, 0x07, 0x06, 0x00, 0x7F, 0xC0,
  0xE1, 0xC0, 0x1C, 0x38, 0x1C, 0x30, 0x07, 0x07, 0x03, 0x86, 0x01, 0xC0,
  0xC0, 0x61, 0xC0, 0x70, 0x18, 0x0C, 0x30, 0x0C, 0x07, 0x01, 0x86, 0x03,
  0x80, 0xE0, 0x31, 0xC0, 0x60, 0x18, 0x06, 0x38, 0x1C, 0x03, 0x01, 0xC6,
  0x03, 0x80, 0xE0, 0x38, 0xC0, 0x60, 0x1C, 0x06, 0x38, 0x1C, 0x03, 0x00,
  0xC7, 0x03, 0x80, 0x60, 0x18, 0xC0, 0x60, 0x1C, 0x07, 0x18, 0x0C, 0x03,
  0x80, 0xE3, 0x03, 0x80, 0x60, 0x18, 0xE0, 0x70, 0x1C, 0x03, 0x1C, 0x0E,
  0x03, 0x80, 0xE3, 0x81, 0xC0, 0x70, 0x18, 0x70, 0x30, 0x1C, 0x07, 0x0C,
  0x06, 0x03, 0x80, 0xC1, 0x80, 0xC0, 0x70, 0x18, 0x30, 0x18, 0x1E, 0x06,
  0x06, 0x03, 0x86, 0xC1, 0xC0, 0xC0, 0x70, 0xDC, 0x70, 0x18, 0x07, 0x71,
  0xFC, 0x03, 0x00, 0xFC, 0x3F, 0x00, 0x60, 0x07, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x0C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x0E, 0x00,
  0x03, 0x87, 0x00, 0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x06, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x38, 0x07, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x07, 0x00, 0x30, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x03, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x30,
  0x1F, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xF0, 0x07, 0x00, 0x3E, 0x00, 0x60, 0x7F, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xF0, 0x04, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x10,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0E, 0x03, 0xE0, 0x00,
  0x70, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xC0,
  0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80, 0x01,
  0xC0, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x00,
  0x60, 0x00, 0xF0, 0x03, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x0F, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x06, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xE0, 0xE0, 0x00, 0x7F, 0xE0, 0xE0, 0x00, 0x7F, 0xE0, 0xE0,
  0x00, 0x00, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xBF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x83, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x60, 0x78, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x03, 0x3E, 0x00, 0x00, 0x06, 0xDC, 0x00, 0x00, 0x1F, 0x98, 0x00, 0x00,
  0x3E, 0x38, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x01, 0x80, 0x07, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x03, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x36, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0,
  0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x66, 0x00, 0x00, 0x1D, 0xC0, 0x0E,
  0x60, 0x00, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x00, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x0C, 0x70, 0x00,
  0x06, 0x38, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x00, 0x0C,
  0x30, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x00, 0x18, 0x70, 0x00, 0x18, 0x70,
  0x01, 0x87, 0x00, 0x03, 0x87, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x03,
  0x87, 0x00, 0x07, 0x06, 0x00, 0x38, 0x30, 0x00, 0x60, 0xE0, 0x03, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x00,
  0x1C, 0x0E, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x38,
  0x1C, 0x00, 0x60, 0x30, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x30, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x00,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0x0C, 0x03, 0x80, 0xC0, 0x38, 0x01, 0xC0,
  0x38, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x81, 0x80, 0x30, 0x01, 0xC0, 0x38,
  0x38, 0x03, 0x00, 0x18, 0x03, 0x83, 0x00, 0x70, 0x01, 0x80, 0x38, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x86, 0x00, 0x70, 0x03, 0x80, 0x38, 0xE0, 0x06,
  0x00, 0x38, 0x03, 0x8C, 0x00, 0xE0, 0x03, 0x00, 0x19, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0x9C, 0x00, 0xE0, 0x07, 0x00, 0x1B, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xB8, 0x00, 0xC0, 0x06, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x0D, 0xC0, 0x00, 0x70, 0x03, 0xB8,
  0x00, 0x0C, 0x00, 0x77, 0x00, 0x01, 0x80, 0x0E, 0x60, 0x00, 0x70, 0x01,
  0x8C, 0x00, 0x0E, 0x00, 0x71, 0x80, 0x01, 0xC0, 0x0E, 0x38, 0x00, 0x30,
  0x01, 0xC7, 0x00, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x06, 0x0C, 0x00,
  0x38, 0x01, 0xC1, 0x80, 0x06, 0x00, 0x38, 0x38, 0x00, 0xC0, 0x07, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x07,
  0x01, 0x80, 0x18, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x1C, 0x07, 0x00, 0xE0,
  0x03, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0x80,
  0x60, 0x03, 0x80, 0x30, 0x1C, 0x00, 0x70, 0x07, 0x03, 0x80, 0x0C, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x03, 0x81, 0x80, 0x0E,
  0x00, 0x30, 0x70, 0x01, 0xC0, 0x06, 0x0E, 0x00, 0x30, 0x00, 0xE1, 0xC0,
  0x0E, 0x00, 0x1C, 0x30, 0x01, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x00, 0x31,
  0xC0, 0x06, 0x00, 0x06, 0x38, 0x00, 0xC0, 0x00, 0xE7, 0x00, 0x38, 0x00,
  0x1C, 0xC0, 0x07, 0x00, 0x03, 0x98, 0x00, 0xE0, 0x00, 0x77, 0x00, 0x18,
  0x00, 0x06, 0xE0, 0x03, 0x00, 0x00, 0xDC, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x60, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1E,
  0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x18, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0,
  0x60, 0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x01,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x7E, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x07,
  0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x0F, 0x00, 0x1C, 0x0F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x30, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x07, 0x03, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x7E, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x06, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0x60, 0x3F,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x00,
  0x70, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03,
  0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x01, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x80, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00,
  0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x80,
  0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0C,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x31, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x30, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x60, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC6, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x77, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x1F, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xB0, 0x00, 0x1C, 0x70,
  0x00, 0x1F, 0x00, 0x01, 0x87, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x70, 0x00,
  0x37, 0x00, 0x03, 0x87, 0x00, 0x03, 0x70, 0x00, 0x70, 0x70, 0x00, 0x77,
  0x00, 0x07, 0x07, 0x00, 0x06, 0x70, 0x00, 0x60, 0x60, 0x00, 0xE7, 0x00,
  0x0E, 0x06, 0x00, 0x0C, 0x70, 0x00, 0xE0, 0x60, 0x00, 0xC7, 0x00, 0x1C,
  0x06, 0x00, 0x1C, 0x70, 0x01, 0xC0, 0x60, 0x01, 0x86, 0x00, 0x18, 0x06,
  0x00, 0x38, 0x60, 0x03, 0x80, 0x60, 0x03, 0x06, 0x00, 0x38, 0x06, 0x00,
  0x30, 0x60, 0x07, 0x00, 0x60, 0x07, 0x06, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x60,
  0x0E, 0x00, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x60, 0x1C,
  0x00, 0x60, 0x18, 0x06, 0x01, 0x80, 0x06, 0x03, 0x80, 0x60, 0x38, 0x00,
  0x60, 0x38, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x60, 0x70, 0x00, 0x60,
  0x70, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0,
  0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x60, 0xE0, 0x00, 0x60, 0xC0, 0x0E,
  0x1C, 0x00, 0x06, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0xE1, 0xC0, 0x0E, 0x18,
  0x00, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00,
  0x0E, 0x30, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0xE6, 0x00, 0x00, 0xE6, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0xCE, 0x00, 0x00, 0xEC, 0x00, 0x0D, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xDC, 0x00, 0x00, 0xFC, 0x00, 0x0D, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0x70, 0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x06, 0x00, 0x0E,
  0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x80,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x60,
  0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x0C, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x30, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x18, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC1, 0xC3, 0x83, 0x87, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xF0, 0xC0, 0x1F, 0xFC, 0x60, 0x1E, 0x07, 0x30, 0x1E,
  0x01, 0xB8, 0x0E, 0x00, 0xD8, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0x07, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xC0,
  0x03, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xE0, 0x1C, 0x01, 0xB0, 0x0E,
  0x01, 0x98, 0x03, 0x81, 0xCC, 0x01, 0xFF, 0xCE, 0x00, 0x7F, 0x86, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0xFF, 0x80, 0x0E, 0x7F, 0xF0, 0x03, 0x38, 0x3C, 0x00, 0xDC, 0x07, 0x80,
  0x76, 0x00, 0xE0, 0x1F, 0x00, 0x38, 0x07, 0x80, 0x06, 0x01, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x07,
  0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x30, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0x80,
  0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x07, 0xC0, 0x0E,
  0x01, 0x98, 0x07, 0x00, 0x67, 0x03, 0xC0, 0x18, 0xFF, 0xC0, 0x0E, 0x1F,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0x01, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x08, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x81, 0x80, 0x00,
  0xFF, 0x0C, 0x00, 0x1F, 0xFC, 0xE0, 0x01, 0xE0, 0x77, 0x00, 0x1E, 0x01,
  0xB8, 0x00, 0xE0, 0x0D, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x07, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x30, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x30, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x07, 0x80, 0x1C,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x1C, 0x01,
  0xB0, 0x00, 0xE0, 0x19, 0x80, 0x03, 0x81, 0x8C, 0x00, 0x1F, 0xFC, 0xE0,
  0x00, 0x7F, 0x86, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xE0, 0xE0, 0x1E, 0x03, 0x81, 0xE0, 0x1C,
  0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x61, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86,
  0x00, 0x38, 0x70, 0x07, 0x83, 0x80, 0xF8, 0x1C, 0x7F, 0x80, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x02, 0x03, 0xC0, 0x60, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x11, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xC3, 0x00, 0x0F, 0xFE, 0x30, 0x01, 0xE0, 0x73, 0x00, 0x3C,
  0x03, 0x70, 0x03, 0x80, 0x36, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00,
  0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0,
  0x1C, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0xD8, 0x00, 0xE0,
  0x1B, 0x80, 0x07, 0x07, 0xB8, 0x00, 0x7F, 0xF3, 0x80, 0x03, 0xFC, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x80, 0x0E,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0xF0, 0x00, 0xE3, 0xFC, 0x00, 0xE7, 0xFE, 0x00, 0xCE, 0x0F,
  0x00, 0xD8, 0x07, 0x00, 0xF0, 0x03, 0x01, 0xF0, 0x03, 0x01, 0xE0, 0x03,
  0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x18,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x87, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x0C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0xE0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0x1E, 0x00, 0x01, 0x9B, 0x00, 0x01, 0xDD, 0x80, 0x00,
  0xFC, 0xE0, 0x00, 0x7C, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x1E, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x00, 0xE0,
  0x01, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x03, 0x8F, 0xF0, 0x7F, 0xC0, 0x0C, 0xFF, 0xE3, 0xFF, 0x80, 0x37, 0x03,
  0x9C, 0x0F, 0x00, 0xD8, 0x07, 0xE0, 0x1C, 0x07, 0xC0, 0x1F, 0x00, 0x70,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0xE0, 0x01, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x30, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x00, 0x0E, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0x07, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x03, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0xE0, 0x01, 0x80, 0x07, 0x03, 0x80, 0x06, 0x00, 0x18, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x70, 0x01,
  0xC0, 0x03, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0xE3, 0xFC, 0x00, 0xC7, 0xFE, 0x00, 0xCE,
  0x0F, 0x00, 0xD8, 0x07, 0x01, 0xF0, 0x03, 0x01, 0xE0, 0x03, 0x01, 0xE0,
  0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x0C, 0x00,
  0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0x83, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x0C,
  0x1C, 0x00, 0x18, 0x30, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7,
  0x00, 0x01, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x63, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x78, 0x03, 0x81, 0xE0, 0x07, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE3, 0xFC,
  0x00, 0x06, 0x3F, 0xF0, 0x00, 0x33, 0x81, 0xC0, 0x01, 0xB8, 0x07, 0x00,
  0x1D, 0x80, 0x38, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x3C,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x03, 0x80, 0x30,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x30, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0C, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00,
  0x1D, 0x80, 0x70, 0x00, 0xEE, 0x0F, 0x00, 0x06, 0x3F, 0xF0, 0x00, 0x30,
  0xFF, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0xC0, 0x1F, 0xFC, 0x60, 0x1E,
  0x07, 0x70, 0x1E, 0x01, 0xB8, 0x1E, 0x00, 0xD8, 0x0E, 0x00, 0x2C, 0x0E,
  0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xE0, 0x1C,
  0x01, 0xB0, 0x0E, 0x01, 0xB8, 0x07, 0x81, 0xDC, 0x01, 0xFF, 0xCE, 0x00,
  0x7F, 0x86, 0x00, 0x0F, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x06,
  0x1F, 0x80, 0x31, 0xFC, 0x01, 0x9C, 0x00, 0x0D, 0xC0, 0x00, 0xFC, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x78, 0x06, 0x01, 0xC0, 0x08, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x20, 0x03, 0x80, 0xE0, 0x3C, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0xF1, 0xFF,
  0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x1C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x30, 0x38,
  0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x30, 0x00, 0x60, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x60,
  0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0,
  0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x80, 0xE0,
  0x1B, 0x80, 0xF0, 0x3B, 0x00, 0x7F, 0xF3, 0x00, 0x3F, 0xC3, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03,
  0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01,
  0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xE0,
  0x70, 0x0E, 0x06, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xEE, 0x00, 0x1E,
  0x00, 0x3B, 0x80, 0x07, 0x80, 0x0C, 0xE0, 0x03, 0x60, 0x07, 0x38, 0x00,
  0xD8, 0x01, 0x8E, 0x00, 0x7E, 0x00, 0xE3, 0x80, 0x1B, 0x80, 0x38, 0xE0,
  0x06, 0xE0, 0x0C, 0x38, 0x03, 0xB8, 0x07, 0x0E, 0x00, 0xCE, 0x01, 0x83,
  0x80, 0x73, 0x80, 0x60, 0xE0, 0x18, 0xE0, 0x38, 0x38, 0x06, 0x38, 0x0C,
  0x0E, 0x03, 0x8E, 0x07, 0x03, 0x80, 0xC3, 0x81, 0x80, 0xE0, 0x70, 0xE0,
  0x60, 0x38, 0x18, 0x38, 0x38, 0x0E, 0x0E, 0x0E, 0x0C, 0x03, 0x83, 0x83,
  0x87, 0x00, 0xE0, 0xC0, 0xC1, 0xC0, 0x38, 0x70, 0x30, 0x60, 0x0E, 0x18,
  0x0C, 0x38, 0x03, 0x8E, 0x03, 0x0C, 0x00, 0xE3, 0x80, 0xC3, 0x00, 0x38,
  0xC0, 0x31, 0xC0, 0x0E, 0x70, 0x0C, 0x60, 0x03, 0x98, 0x03, 0x38, 0x00,
  0xEE, 0x00, 0xCC, 0x00, 0x3B, 0x80, 0x33, 0x00, 0x0E, 0xC0, 0x0D, 0xC0,
  0x03, 0xF0, 0x03, 0x60, 0x00, 0xF8, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x70,
  0x00, 0x60, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x07, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x03, 0x98, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x60, 0x70, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x0C, 0x1C, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0D, 0xC0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x08, 0x38, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x5F, 0xFE, 0x00, 0x7E, 0x07, 0xC0,
  0x7C, 0x00, 0xFF, 0xF4, 0x00, 0x1F, 0xF2, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 51, 15, 1, -51 },
  { 91, 15, 18, 20, 7, -51 },
  { 125, 28, 51, 27, 0, -51 },
  { 304, 28, 59, 25, -1, -55 },
  { 511, 33, 53, 39, 3, -52 },
  { 730, 24, 53, 25, -1, -52 },
  { 889, 6, 18, 11, 7, -51 },
  { 903, 20, 62, 18, 2, -51 },
  { 1058, 20, 62, 18, -5, -51 },
  { 1213, 19, 21, 23, 8, -55 },
  { 1263, 25, 33, 29, 2, -42 },
  { 1367, 9, 16, 12, -3, -7 },
  { 1385, 15, 3, 19, 2, -21 },
  { 1391, 4, 6, 12, 1, -6 },
  { 1394, 30, 51, 22, -3, -51 },
  { 1586, 24, 53, 25, 1, -52 },
  { 1745, 13, 51, 25, 8, -51 },
  { 1828, 28, 52, 25, -3, -52 },
  { 2010, 28, 53, 25, -2, -52 },
  { 2196, 27, 52, 25, -1, -52 },
  { 2372, 28, 52, 25, -2, -51 },
  { 2554, 25, 53, 25, 2, -52 },
  { 2720, 25, 51, 25, 3, -51 },
  { 2880, 27, 53, 25, -1, -52 },
  { 3059, 25, 53, 25, 0, -52 },
  { 3225, 11, 38, 12, 0, -38 },
  { 3278, 15, 47, 12, -3, -38 },
  { 3367, 25, 30, 29, 2, -40 },
  { 3461, 25, 18, 29, 2, -34 },
  { 3518, 25, 30, 29, 2, -40 },
  { 3612, 20, 52, 18, 1, -52 },
  { 3742, 35, 58, 38, 2, -52 },
  { 3996, 25, 52, 25, -5, -52 },
  { 4159, 28, 51, 28, 0, -51 },
  { 4338, 28, 53, 25, 3, -52 },
  { 4524, 29, 51, 30, 0, -51 },
  { 4709, 28, 51, 25, 0, -51 },
  { 4888, 28, 51, 23, 0, -51 },
  { 5067, 32, 53, 33, 3, -52 },
  { 5279, 33, 51, 32, 0, -51 },
  { 5490, 22, 51, 13, -4, -51 },
  { 5631, 24, 64, 12, -10, -51 },
  { 5823, 31, 51, 26, 0, -51 },
  { 6021, 17, 51, 22, 0, -51 },
  { 6130, 44, 51, 43, 0, -51 },
  { 6411, 35, 51, 34, 0, -51 },
  { 6635, 29, 53, 33, 2, -52 },
  { 6828, 27, 51, 26, 0, -51 },
  { 7001, 29, 64, 33, 2, -52 },
  { 7233, 27, 51, 27, 0, -51 },
  { 7406, 29, 53, 25, -2, -52 },
  { 7599, 22, 51, 22, 5, -51 },
  { 7740, 31, 52, 31, 2, -51 },
  { 7942, 25, 51, 26, 6, -51 },
  { 8102, 44, 51, 44, 5, -51 },
  { 8383, 32, 51, 23, -4, -51 },
  { 8587, 23, 51, 22, 5, -51 },
  { 8734, 30, 51, 22, -3, -51 },
  { 8926, 25, 62, 20, -1, -51 },
  { 9120, 10, 51, 23, 7, -51 },
  { 9184, 25, 62, 20, -4, -51 },
  { 9378, 26, 25, 28, 2, -51 },
  { 9460, 20, 3, 19, -6, 6 },
  { 9468, 7, 11, 15, 11, -55 },
  { 9478, 25, 40, 28, 2, -39 },
  { 9603, 26, 56, 27, 0, -55 },
  { 9785, 20, 40, 20, 2, -39 },
  { 9885, 29, 56, 28, 2, -55 },
  { 10088, 21, 40, 24, 2, -39 },
  { 10193, 31, 72, 14, -9, -55 },
  { 10472, 28, 56, 28, -1, -39 },
  { 10668, 24, 55, 27, 0, -55 },
  { 10833, 14, 52, 12, 0, -52 },
  { 10924, 24, 69, 12, -10, -52 },
  { 11131, 25, 55, 22, 0, -55 },
  { 11303, 15, 55, 11, 0, -55 },
  { 11407, 38, 39, 40, 0, -39 },
  { 11593, 24, 39, 27, 0, -39 },
  { 11710, 23, 40, 27, 2, -39 },
  { 11825, 29, 55, 28, -3, -39 },
  { 12025, 25, 56, 28, 2, -39 },
  { 12200, 21, 39, 17, 0, -39 },
  { 12303, 22, 40, 20, -1, -39 },
  { 12413, 14, 48, 14, 1, -47 },
  { 12497, 24, 39, 27, 2, -38 },
  { 12614, 20, 38, 20, 4, -38 },
  { 12709, 34, 38, 34, 4, -38 },
  { 12871, 27, 38, 21, -3, -38 },
  { 13000, 33, 56, 22, -8, -38 },
  { 13231, 22, 38, 17, -2, -38 },
  { 13336, 25, 62, 23, 2, -51 },
  { 13530, 3, 73, 25, 11, -55 },
  { 13558, 25, 62, 22, -5, -51 },
  { 13752, 25, 7, 29, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC72PT7B_H_
