#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC70PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x0C, 0x70, 0x71, 0x81, 0xCE, 0x07,
  0x38, 0x18, 0xE0, 0x63, 0x03, 0x8C, 0x0E, 0x70, 0x31, 0xC0, 0xC6, 0x03,
  0x18, 0x1C, 0x60, 0x61, 0x81, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x43, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x38,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x01,
  0xC0, 0x60, 0x00, 0x18, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x30, 0x1C, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0x06, 0x03, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x18, 0x06, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30,
  0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x3C, 0x61, 0xE0, 0x0E, 0x0C, 0x08, 0x03, 0x81, 0x80, 0x00, 0x70, 0x20,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x0C,
  0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x86, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x03, 0x98, 0x00, 0x00, 0x7B, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0C, 0x1C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x30, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x1C,
  0x00, 0x02, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x10, 0x18, 0x78, 0x07, 0xC3,
  0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0x18, 0x03, 0x86, 0x00,
  0x38, 0x07, 0x07, 0x00, 0x30, 0x06, 0x07, 0x00, 0x70, 0x0E, 0x07, 0x00,
  0x60, 0x0C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0x80, 0x38, 0x06, 0x03, 0x80, 0x30, 0x06, 0x03,
  0x00, 0x30, 0x06, 0x07, 0x00, 0x70, 0x06, 0x06, 0x00, 0x70, 0x0E, 0x0E,
  0x00, 0x60, 0x0E, 0x0C, 0x00, 0x60, 0x0C, 0x1C, 0x00, 0x60, 0x0C, 0x18,
  0x00, 0x60, 0x0C, 0x38, 0x00, 0xE0, 0x1C, 0x30, 0x10, 0xE0, 0x18, 0x70,
  0xFC, 0xE0, 0x18, 0x61, 0xFE, 0xE0, 0x38, 0xE3, 0x86, 0xE0, 0x30, 0xC7,
  0x07, 0xE0, 0x71, 0xC6, 0x07, 0xE0, 0x61, 0x8E, 0x03, 0x60, 0xE3, 0x8C,
  0x03, 0x61, 0xC3, 0x1C, 0x03, 0x7F, 0x87, 0x1C, 0x03, 0x3F, 0x06, 0x18,
  0x07, 0x0C, 0x0E, 0x38, 0x07, 0x00, 0x0C, 0x38, 0x07, 0x00, 0x1C, 0x30,
  0x06, 0x00, 0x18, 0x30, 0x06, 0x00, 0x38, 0x70, 0x06, 0x00, 0x30, 0x70,
  0x0E, 0x00, 0x70, 0x60, 0x0E, 0x00, 0x60, 0x60, 0x0C, 0x00, 0xE0, 0x60,
  0x0C, 0x00, 0xC0, 0x60, 0x1C, 0x01, 0xC0, 0x60, 0x1C, 0x01, 0x80, 0xE0,
  0x18, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x30, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x00, 0x60, 0xE0, 0x0C, 0x00, 0x70,
  0xC0, 0x1C, 0x00, 0x7B, 0xC0, 0x38, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x18, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x30, 0x00, 0x70, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x31,
  0xC0, 0x00, 0x33, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x06, 0x07, 0x0E, 0x06,
  0x06, 0x1C, 0x07, 0x0E, 0x38, 0x07, 0x0E, 0x38, 0x03, 0x0C, 0x30, 0x03,
  0x1C, 0x70, 0x03, 0x9C, 0x70, 0x03, 0x98, 0x60, 0x01, 0xB8, 0x60, 0x01,
  0xB0, 0xE0, 0x01, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0x70, 0x07, 0x60, 0x70, 0x0E,
  0x70, 0x78, 0x1C, 0x70, 0x3F, 0xF8, 0x30, 0x1F, 0xF0, 0x38, 0x03, 0xC0,
  0x00, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8C,
  0x30, 0xC3, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x18, 0x18, 0x0F, 0x0C, 0x00, 0xF3, 0x03, 0x0E,
  0xCF, 0xC0, 0xFF, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x60, 0x03, 0x8C,
  0x01, 0xC3, 0x01, 0xC0, 0x60, 0x60, 0x18, 0x08, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0C,
  0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0x06, 0x01, 0xC0, 0x06, 0x01,
  0x80, 0x06, 0x03, 0x80, 0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0x06, 0x07,
  0x00, 0x06, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C,
  0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x18,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x30, 0x60, 0x00, 0x70, 0x60,
  0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0,
  0x03, 0x80, 0x60, 0x03, 0x00, 0x60, 0x07, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x07, 0x80, 0x7C, 0x07, 0x60,
  0x77, 0x07, 0x38, 0xF1, 0x8F, 0x0C, 0xE0, 0xE2, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x40, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x04, 0x00,
  0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x0E, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x60, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3B, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x08, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x20, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x38, 0xFF,
  0x80, 0x31, 0xFF, 0xC0, 0x33, 0x81, 0xE0, 0x76, 0x00, 0xE0, 0x7C, 0x00,
  0x60, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0xF0, 0x00,
  0x70, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00,
  0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0x60, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xF0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x1C, 0x00,
  0x0C, 0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x1E,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC1, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x70, 0x60, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0,
  0x60, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x06, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x07,
  0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0C,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x0C, 0x00, 0x0F, 0x0C, 0x00, 0x0E, 0x0C,
  0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x3E, 0x0E, 0x00, 0x3E, 0x07,
  0x00, 0x6E, 0x07, 0x81, 0xCC, 0x03, 0xFF, 0x9C, 0x01, 0xFF, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x80, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x03, 0x80, 0xE0, 0x20, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x00,
  0x70, 0x60, 0x03, 0xF8, 0x1C, 0x18, 0x03, 0xFE, 0x07, 0x0E, 0x01, 0xE1,
  0x81, 0xC3, 0x00, 0xE0, 0xE0, 0x71, 0xC0, 0x30, 0x38, 0x18, 0x70, 0x18,
  0x0C, 0x06, 0x18, 0x0E, 0x03, 0x01, 0x8E, 0x03, 0x01, 0xC0, 0x63, 0x81,
  0xC0, 0x70, 0x18, 0xC0, 0x60, 0x18, 0x0E, 0x30, 0x18, 0x06, 0x03, 0x9C,
  0x0E, 0x03, 0x80, 0xC7, 0x03, 0x00, 0xE0, 0x31, 0x80, 0xC0, 0x30, 0x0C,
  0x60, 0x70, 0x0C, 0x07, 0x18, 0x1C, 0x07, 0x01, 0x8E, 0x06, 0x01, 0xC0,
  0x63, 0x81, 0x80, 0x60, 0x18, 0xE0, 0x60, 0x38, 0x0C, 0x30, 0x18, 0x0E,
  0x03, 0x0C, 0x06, 0x03, 0x81, 0xC3, 0x01, 0x81, 0xE0, 0x60, 0xC0, 0x60,
  0x58, 0x38, 0x30, 0x18, 0x36, 0x0C, 0x0C, 0x06, 0x1D, 0x87, 0x03, 0x01,
  0xC6, 0x63, 0x80, 0xC0, 0x3F, 0x1F, 0xC0, 0x30, 0x07, 0x83, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0xC3, 0x00, 0x01, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x03, 0x83, 0x00,
  0x03, 0x83, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00,
  0x0E, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x1C, 0x03, 0x00,
  0x18, 0x03, 0x00, 0x38, 0x03, 0x00, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x03, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x01,
  0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x03, 0x80, 0x03, 0x03,
  0x80, 0x03, 0x07, 0x00, 0x03, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03, 0x0E,
  0x00, 0x03, 0x0E, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x38, 0x00, 0x03, 0x70, 0x00, 0x03, 0x70,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xE0, 0xFE, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x60,
  0x0C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0xE0, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x60, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0x80, 0x00, 0xC0,
  0x70, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x1C, 0x06, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x00, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0x80, 0x60, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1E, 0x03, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x38, 0x7F,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x30, 0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x18, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01,
  0x80, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x03, 0x80, 0x30, 0x00, 0x70, 0x03, 0x00, 0x0F, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x0F, 0x80, 0x06, 0x1F,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x07, 0x00, 0x07, 0xFE, 0x0E,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x18, 0x00,
  0x00, 0xE0, 0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x18, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00, 0x30, 0x03, 0x80, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x02, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x61, 0xC0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0xCF, 0x00, 0x00, 0x03, 0x7E, 0x00, 0x00, 0x1D, 0xB8, 0x00, 0x00,
  0x7C, 0xE0, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x07, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0xEC, 0x00, 0x6E, 0x00, 0x00, 0x1D, 0x80, 0x0D,
  0xC0, 0x00, 0x07, 0x70, 0x03, 0x98, 0x00, 0x00, 0xEE, 0x00, 0x73, 0x00,
  0x00, 0x19, 0xC0, 0x0E, 0x60, 0x00, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x00, 0x06, 0x38,
  0x01, 0xC6, 0x00, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0x0E, 0x38, 0x00, 0xC3, 0x00, 0x01, 0x87, 0x00, 0x38, 0x60,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0xE1, 0xC0, 0x03,
  0x83, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x60, 0x03,
  0x03, 0x80, 0x1C, 0x0C, 0x00, 0x60, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0xE0, 0x70, 0x03, 0x80, 0xC0, 0x18, 0x0E, 0x00, 0x70, 0x18, 0x07,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x00, 0x70, 0x0C, 0x06, 0x01, 0xC0, 0x0E, 0x01, 0x81, 0xC0, 0x38, 0x01,
  0xC0, 0x30, 0x30, 0x06, 0x00, 0x30, 0x06, 0x0E, 0x01, 0xC0, 0x06, 0x00,
  0xC1, 0x80, 0x38, 0x01, 0xC0, 0x18, 0x70, 0x07, 0x00, 0x38, 0x03, 0x8C,
  0x00, 0xC0, 0x06, 0x00, 0x73, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x60, 0x07,
  0x00, 0x18, 0x01, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x3B, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x60, 0x03, 0x00,
  0x1F, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x01,
  0x80, 0x0F, 0x80, 0x00, 0xE0, 0x07, 0x60, 0x00, 0x38, 0x01, 0xD8, 0x00,
  0x0E, 0x00, 0x76, 0x00, 0x03, 0x00, 0x19, 0xC0, 0x01, 0xC0, 0x0E, 0x70,
  0x00, 0x70, 0x03, 0x8C, 0x00, 0x1C, 0x00, 0xE3, 0x00, 0x06, 0x00, 0x30,
  0xC0, 0x01, 0x80, 0x0C, 0x38, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x01,
  0xC3, 0x80, 0x0E, 0x00, 0x70, 0x60, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0,
  0x06, 0x06, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0xE0, 0x70, 0x07,
  0x00, 0x38, 0x1C, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x38, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x03, 0x00, 0x1C, 0x03,
  0x80, 0xC0, 0x06, 0x00, 0x60, 0x70, 0x03, 0x80, 0x18, 0x1C, 0x00, 0xE0,
  0x06, 0x07, 0x00, 0x38, 0x01, 0xC1, 0x80, 0x0C, 0x00, 0x70, 0x60, 0x03,
  0x00, 0x1C, 0x38, 0x01, 0xC0, 0x03, 0x0E, 0x00, 0x70, 0x00, 0xC3, 0x80,
  0x1C, 0x00, 0x38, 0xC0, 0x06, 0x00, 0x0E, 0x30, 0x01, 0x80, 0x03, 0x9C,
  0x00, 0xE0, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x19, 0x80, 0x0E, 0x00, 0x06,
  0x60, 0x03, 0x00, 0x01, 0xD8, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x00, 0xF0, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x30, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x60, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0x8F, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x30,
  0x03, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x03,
  0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x38, 0x06,
  0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x0C, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x3E, 0x00, 0x71, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x71, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38,
  0x60, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x30, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0x87, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00,
  0xF0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x18,
  0x00, 0x30, 0x0E, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x03,
  0x00, 0x78, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x06, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01,
  0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x20, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x08, 0x00, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18,
  0x03, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x30, 0x07, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x07,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x0E,
  0x06, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01,
  0xC0, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0C, 0x00,
  0x70, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x1C, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x0C,
  0x03, 0x00, 0x06, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x81, 0xC0, 0x00,
  0xC0, 0xE0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x38, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x30, 0x00, 0x0F, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x18, 0x00, 0x0D, 0x80, 0x01, 0xC3, 0x00,
  0x01, 0xB0, 0x00, 0x38, 0x60, 0x00, 0x76, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0xC0, 0x01, 0xC1, 0x80, 0x01, 0x98, 0x00, 0x38, 0x30, 0x00, 0x73, 0x00,
  0x0E, 0x06, 0x00, 0x0C, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x9C, 0x00, 0x30,
  0x18, 0x00, 0x63, 0x80, 0x0E, 0x03, 0x00, 0x0C, 0x70, 0x01, 0xC0, 0x60,
  0x03, 0x8E, 0x00, 0x70, 0x0C, 0x00, 0x61, 0xC0, 0x0E, 0x01, 0x80, 0x1C,
  0x38, 0x01, 0x80, 0x30, 0x03, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x1C, 0x03, 0x80, 0x18, 0x03, 0x03, 0x00, 0x70,
  0x03, 0x00, 0xE0, 0x60, 0x0C, 0x00, 0x60, 0x1C, 0x0C, 0x03, 0x80, 0x0C,
  0x03, 0x01, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x00, 0x70, 0x18,
  0x06, 0x03, 0x80, 0x0E, 0x07, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x18,
  0x1C, 0x00, 0x38, 0x18, 0x03, 0x03, 0x80, 0x07, 0x07, 0x00, 0x60, 0xE0,
  0x00, 0xE0, 0xC0, 0x0C, 0x1C, 0x00, 0x1C, 0x38, 0x01, 0x83, 0x00, 0x03,
  0x87, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0xC7, 0x00, 0x01, 0xC6, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xC0, 0x03,
  0x18, 0x00, 0x07, 0x38, 0x00, 0x67, 0x00, 0x00, 0xE6, 0x00, 0x0C, 0xE0,
  0x00, 0x1D, 0xC0, 0x01, 0x98, 0x00, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x00,
  0x76, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x60, 0x03, 0x80, 0x00, 0xC0,
  0x0E, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x18, 0x00, 0x70, 0x00, 0x30, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x67, 0x00, 0x03,
  0x9C, 0x00, 0x0C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x0C,
  0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x01,
  0xC0, 0x30, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x1C, 0x00, 0x18,
  0x60, 0x00, 0x63, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x70, 0x00, 0x19, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x30, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x63, 0x80, 0x00, 0x39, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0xE1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x06, 0x0C,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xE1, 0xC0, 0x1F, 0xF8, 0xC0, 0x1E,
  0x0E, 0x60, 0x1C, 0x03, 0x30, 0x1C, 0x00, 0xF8, 0x0E, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x83,
  0x80, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x06, 0xC0, 0x30, 0x03, 0xE0, 0x1C,
  0x03, 0x70, 0x0F, 0x07, 0x30, 0x03, 0xFF, 0x18, 0x00, 0xFF, 0x0C, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0xE3, 0xFC, 0x00, 0x63, 0xFF, 0x00,
  0x33, 0x83, 0x80, 0x3B, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x0D, 0x80, 0x1C,
  0x07, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x30, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0E,
  0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0x80, 0xF0, 0x01, 0xC0, 0xF8, 0x01, 0xC0, 0x7C, 0x00, 0xE0,
  0x37, 0x00, 0xE0, 0x19, 0xC1, 0xE0, 0x0C, 0x7F, 0xE0, 0x0E, 0x1F, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0x02, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x38, 0x00, 0x3F, 0xC3, 0x00, 0x07, 0xFE, 0x30, 0x00, 0xF0, 0x73,
  0x00, 0x1C, 0x03, 0x70, 0x03, 0x80, 0x1F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0x60, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0,
  0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0x60, 0x07, 0xC0, 0x07, 0x00, 0xDC,
  0x00, 0x78, 0x39, 0x80, 0x03, 0xFF, 0x18, 0x00, 0x1F, 0xE1, 0x80, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0E,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x07, 0x00, 0x30, 0x70, 0x03, 0x0E,
  0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x30, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x0F, 0x07, 0x03, 0xE0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xF4, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x02, 0x03, 0x80, 0x60, 0x3F, 0xFE, 0x00,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0x87,
  0x00, 0x0F, 0xFC, 0x60, 0x01, 0xE0, 0xE6, 0x00, 0x38, 0x06, 0x60, 0x07,
  0x00, 0x3E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xC0, 0x03,
  0xC0, 0x1C, 0x00, 0x3C, 0x01, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x03,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0xC0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0xD8,
  0x00, 0xC0, 0x1F, 0x80, 0x0E, 0x03, 0xB0, 0x00, 0xF0, 0x73, 0x00, 0x07,
  0xFE, 0x30, 0x00, 0x3F, 0xC7, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x80, 0x0E, 0x00, 0x0C, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0xE3, 0xFC, 0x00, 0xCF, 0xFE,
  0x00, 0xDC, 0x0E, 0x00, 0xD8, 0x07, 0x01, 0xF0, 0x07, 0x01, 0xE0, 0x07,
  0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x06, 0x03, 0x80, 0x06,
  0x03, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0C,
  0x07, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C,
  0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x60, 0x38, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0,
  0x60, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x60, 0x01,
  0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x03, 0x00, 0x03,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x06,
  0x3C, 0x00, 0x06, 0x7C, 0x00, 0x0E, 0xFC, 0x00, 0x0F, 0xCC, 0x00, 0x0D,
  0x8C, 0x00, 0x0F, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x38,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x30, 0x07, 0x00, 0x30, 0x03, 0x00, 0x70,
  0x03, 0x00, 0x70, 0x03, 0x00, 0x70, 0x03, 0x80, 0x60, 0x03, 0x80, 0x60,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x06, 0x3F, 0xC0, 0xFF, 0x00,
  0x33, 0xFF, 0x1F, 0xFC, 0x01, 0xB8, 0x3D, 0xC0, 0xE0, 0x1F, 0x00, 0xEC,
  0x03, 0x80, 0xD8, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x03, 0x03, 0x80, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0x03, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x80, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x80,
  0x0C, 0x06, 0x00, 0x18, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xC3, 0xFC, 0x00, 0xCF, 0xFE, 0x00, 0xDC, 0x0E, 0x01, 0xF8,
  0x06, 0x01, 0xB0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0,
  0x06, 0x03, 0xC0, 0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x06, 0x00,
  0x1C, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x30, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x38, 0x00,
  0x60, 0x38, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x01, 0x81,
  0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCC, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x60,
  0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0x80,
  0x1C, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x87, 0xF8, 0x00,
  0x18, 0xFF, 0xC0, 0x01, 0x9C, 0x1C, 0x00, 0x3B, 0x00, 0xE0, 0x03, 0xF0,
  0x0E, 0x00, 0x36, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70,
  0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x80, 0x03, 0x00, 0x70, 0x00,
  0x70, 0x07, 0x00, 0x06, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF8, 0x01, 0xC0, 0x0E, 0xC0, 0x38, 0x00, 0xCE, 0x0F, 0x00, 0x0C, 0x7F,
  0xE0, 0x00, 0xC3, 0xFC, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE1, 0xC0, 0x1F, 0xF8, 0xC0, 0x1E,
  0x0E, 0x60, 0x1C, 0x03, 0x30, 0x1C, 0x00, 0xF8, 0x0E, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x83,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x30, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0xC0, 0x30, 0x03, 0xE0, 0x1C,
  0x03, 0x70, 0x0F, 0x07, 0x30, 0x03, 0xFF, 0x18, 0x00, 0xFF, 0x1C, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x0C, 0x3F, 0x00, 0xCF, 0xF0, 0x0D, 0xE0,
  0x01, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0xA0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xC0, 0x70,
  0x38, 0x00, 0x81, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x20, 0x03, 0x81, 0x80, 0x78, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x7F, 0xF1, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x7F, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E, 0x06, 0x00,
  0x1C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0, 0x03,
  0x81, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x30, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x06, 0x07,
  0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x70, 0x00, 0xC0, 0xE0,
  0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x30, 0x01, 0xE0,
  0x60, 0x07, 0xC0, 0xE0, 0x0F, 0x01, 0xC0, 0x36, 0x03, 0xC1, 0xCC, 0x03,
  0xFF, 0x18, 0x03, 0xFC, 0x60, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x70,
  0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x30, 0x1C, 0x0E, 0x03, 0x81, 0x80, 0x70, 0x70, 0x0E, 0x0C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C,
  0x00, 0x73, 0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x03, 0xB8, 0x00, 0x70,
  0x01, 0xDC, 0x00, 0x78, 0x00, 0xCE, 0x00, 0x3C, 0x00, 0xE7, 0x00, 0x36,
  0x00, 0x63, 0x80, 0x1B, 0x00, 0x31, 0xC0, 0x1D, 0x80, 0x38, 0xE0, 0x0C,
  0xC0, 0x18, 0x70, 0x06, 0x60, 0x1C, 0x38, 0x07, 0x30, 0x0C, 0x1C, 0x03,
  0x18, 0x06, 0x0E, 0x03, 0x8C, 0x07, 0x07, 0x01, 0x86, 0x03, 0x03, 0x80,
  0xC3, 0x03, 0x81, 0xC0, 0xE1, 0x81, 0x80, 0xE0, 0x60, 0xC0, 0xC0, 0x70,
  0x70, 0x60, 0xE0, 0x38, 0x30, 0x30, 0x60, 0x1C, 0x18, 0x18, 0x30, 0x0E,
  0x1C, 0x0C, 0x38, 0x07, 0x0C, 0x06, 0x18, 0x03, 0x8E, 0x03, 0x1C, 0x01,
  0xC6, 0x01, 0x8C, 0x00, 0xE7, 0x00, 0xC6, 0x00, 0x73, 0x80, 0xE7, 0x00,
  0x31, 0x80, 0x73, 0x00, 0x19, 0xC0, 0x3B, 0x80, 0x0C, 0xC0, 0x1D, 0x80,
  0x06, 0x60, 0x0E, 0xC0, 0x03, 0x70, 0x06, 0xE0, 0x01, 0xB0, 0x03, 0x60,
  0x00, 0xF8, 0x01, 0xB0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x87, 0x00, 0x00, 0x63,
  0x80, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00,
  0xE0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0E,
  0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0D, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x3F,
  0xF0, 0x01, 0x7D, 0xFC, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x0F, 0xFE, 0x80,
  0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 50, 15, 1, -50 },
  { 89, 14, 18, 19, 7, -50 },
  { 121, 28, 50, 26, 0, -50 },
  { 296, 27, 57, 25, -1, -53 },
  { 489, 32, 52, 38, 3, -51 },
  { 697, 24, 52, 24, -1, -51 },
  { 853, 6, 18, 11, 7, -50 },
  { 867, 19, 61, 17, 2, -50 },
  { 1012, 19, 61, 17, -5, -50 },
  { 1157, 18, 20, 23, 8, -53 },
  { 1202, 24, 32, 28, 2, -41 },
  { 1298, 9, 16, 12, -3, -7 },
  { 1316, 15, 2, 18, 2, -20 },
  { 1320, 4, 5, 11, 1, -5 },
  { 1323, 29, 50, 21, -3, -50 },
  { 1505, 24, 52, 25, 1, -51 },
  { 1661, 13, 50, 25, 8, -50 },
  { 1743, 27, 51, 25, -2, -51 },
  { 1916, 27, 52, 25, -2, -51 },
  { 2092, 26, 51, 25, -1, -51 },
  { 2258, 27, 51, 25, -2, -50 },
  { 2431, 24, 52, 25, 2, -51 },
  { 2587, 24, 50, 25, 3, -50 },
  { 2737, 26, 52, 25, -1, -51 },
  { 2906, 24, 52, 25, 0, -51 },
  { 3062, 11, 37, 11, 0, -37 },
  { 3113, 14, 46, 12, -3, -37 },
  { 3194, 24, 29, 28, 2, -39 },
  { 3281, 24, 17, 28, 2, -33 },
  { 3332, 24, 29, 28, 2, -39 },
  { 3419, 19, 51, 18, 1, -51 },
  { 3541, 34, 56, 37, 2, -50 },
  { 3779, 24, 50, 24, -5, -50 },
  { 3929, 27, 50, 27, 0, -50 },
  { 4098, 27, 52, 24, 3, -51 },
  { 4274, 28, 50, 30, 0, -50 },
  { 4449, 27, 50, 24, 0, -50 },
  { 4618, 27, 50, 22, 0, -50 },
  { 4787, 31, 52, 32, 3, -51 },
  { 4989, 32, 50, 31, 0, -50 },
  { 5189, 22, 50, 13, -4, -50 },
  { 5327, 23, 62, 11, -10, -50 },
  { 5506, 30, 50, 25, 0, -50 },
  { 5694, 16, 50, 22, 0, -50 },
  { 5794, 43, 50, 42, 0, -50 },
  { 6063, 34, 50, 33, 0, -50 },
  { 6276, 29, 52, 32, 2, -51 },
  { 6465, 26, 50, 25, 0, -50 },
  { 6628, 29, 63, 32, 2, -51 },
  { 6857, 26, 50, 26, 0, -50 },
  { 7020, 28, 52, 24, -2, -51 },
  { 7202, 22, 50, 21, 5, -50 },
  { 7340, 30, 51, 30, 2, -50 },
  { 7532, 25, 50, 25, 6, -50 },
  { 7689, 43, 50, 43, 5, -50 },
  { 7958, 31, 50, 22, -4, -50 },
  { 8152, 22, 50, 21, 5, -50 },
  { 8290, 29, 50, 22, -3, -50 },
  { 8472, 25, 61, 19, -1, -50 },
  { 8663, 10, 50, 23, 7, -50 },
  { 8726, 25, 61, 19, -4, -50 },
  { 8917, 25, 25, 27, 2, -50 },
  { 8996, 18, 3, 19, -5, 6 },
  { 9003, 7, 11, 15, 10, -53 },
  { 9013, 25, 39, 27, 2, -38 },
  { 9135, 25, 54, 27, 0, -53 },
  { 9304, 20, 39, 20, 2, -38 },
  { 9402, 28, 54, 27, 2, -53 },
  { 9591, 20, 39, 24, 2, -38 },
  { 9689, 31, 71, 14, -9, -54 },
  { 9965, 28, 55, 27, -1, -38 },
  { 10158, 24, 53, 26, 0, -53 },
  { 10317, 14, 50, 11, 0, -50 },
  { 10405, 23, 67, 12, -9, -50 },
  { 10598, 24, 53, 22, 0, -53 },
  { 10757, 14, 53, 11, 0, -53 },
  { 10850, 37, 38, 39, 0, -38 },
  { 11026, 24, 38, 26, 0, -38 },
  { 11140, 22, 39, 26, 2, -38 },
  { 11248, 28, 54, 27, -3, -38 },
  { 11437, 25, 54, 27, 2, -38 },
  { 11606, 20, 38, 17, 0, -38 },
  { 11701, 21, 39, 20, -1, -38 },
  { 11804, 14, 47, 14, 1, -46 },
  { 11887, 23, 38, 26, 2, -37 },
  { 11997, 19, 37, 20, 4, -37 },
  { 12085, 33, 37, 33, 4, -37 },
  { 12238, 26, 37, 21, -3, -37 },
  { 12359, 33, 54, 21, -8, -37 },
  { 12582, 21, 37, 17, -2, -37 },
  { 12680, 24, 61, 22, 2, -50 },
  { 12863, 2, 70, 24, 11, -53 },
  { 12881, 24, 61, 22, -5, -50 },
  { 13064, 24, 6, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC70PT7B_H_
