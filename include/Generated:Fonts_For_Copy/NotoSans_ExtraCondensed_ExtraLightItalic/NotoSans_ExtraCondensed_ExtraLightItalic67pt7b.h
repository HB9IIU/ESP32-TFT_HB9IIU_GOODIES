#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x0C, 0x0E, 0x38, 0x18, 0x70,
  0x70, 0xE0, 0xE1, 0x81, 0xC3, 0x03, 0x0E, 0x06, 0x1C, 0x1C, 0x30, 0x38,
  0x60, 0x60, 0xC0, 0xC1, 0x81, 0x86, 0x03, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0xC0, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30,
  0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03,
  0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x30, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x06,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3C, 0xC3, 0xC0, 0x1C, 0x30, 0x20,
  0x0E, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60,
  0x40, 0x00, 0x18, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x23, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x1C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x10, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x80, 0x80, 0x61, 0xC0, 0x1C, 0x11, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xC0, 0x3F, 0xC0,
  0x07, 0x01, 0xC3, 0x00, 0x18, 0x06, 0x0E, 0x00, 0xE0, 0x38, 0x18, 0x03,
  0x00, 0xC0, 0x60, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x18, 0x0C, 0x03, 0x80, 0xE0, 0x70, 0x0C, 0x03, 0x81, 0x80, 0x30,
  0x0E, 0x0E, 0x01, 0xC0, 0x30, 0x30, 0x06, 0x00, 0xC1, 0xC0, 0x18, 0x03,
  0x06, 0x00, 0x60, 0x1C, 0x38, 0x01, 0x80, 0x70, 0xC0, 0x0E, 0x01, 0x87,
  0x00, 0x38, 0x06, 0x18, 0x00, 0xE0, 0x38, 0xE1, 0xF3, 0x00, 0xE3, 0x0F,
  0xEC, 0x03, 0x1C, 0x71, 0xF0, 0x1C, 0x63, 0x83, 0xC0, 0x63, 0x8C, 0x0F,
  0x03, 0x8C, 0x70, 0x3E, 0x0C, 0x71, 0x80, 0xD8, 0x71, 0x8E, 0x03, 0x7F,
  0x8E, 0x30, 0x0C, 0xFC, 0x30, 0xC0, 0x30, 0x81, 0xC7, 0x00, 0xC0, 0x06,
  0x1C, 0x03, 0x00, 0x38, 0x60, 0x0C, 0x00, 0xC1, 0x80, 0x70, 0x07, 0x0E,
  0x01, 0xC0, 0x18, 0x38, 0x06, 0x00, 0xE0, 0xC0, 0x18, 0x03, 0x03, 0x00,
  0x60, 0x1C, 0x0C, 0x03, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x38, 0x0E,
  0x00, 0xC0, 0xC0, 0x30, 0x03, 0x07, 0x01, 0xC0, 0x0E, 0x18, 0x06, 0x00,
  0x3D, 0xC0, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xE1, 0xC0, 0x01, 0x83,
  0x80, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18,
  0x00, 0xE0, 0x30, 0x01, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00,
  0x0C, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0xC6, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x70, 0xC0, 0xE1, 0xC1, 0xC1,
  0xC7, 0x03, 0x83, 0x0E, 0x03, 0x06, 0x38, 0x06, 0x1C, 0x60, 0x0E, 0x31,
  0xC0, 0x1C, 0x63, 0x80, 0x19, 0xC6, 0x00, 0x33, 0x0C, 0x00, 0x7E, 0x38,
  0x00, 0xF8, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x0F, 0x07, 0x00, 0x1E, 0x06, 0x00, 0x6E, 0x0E, 0x01, 0xDC, 0x1E, 0x07,
  0x18, 0x1F, 0xFC, 0x30, 0x1F, 0xF0, 0x70, 0x0E, 0x00, 0x00, 0x0C, 0x71,
  0xC7, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x06, 0x06, 0x03, 0xC3, 0x00,
  0x71, 0x03, 0x0E, 0x9F, 0x81, 0xFF, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xE4,
  0x00, 0xE3, 0x00, 0xE0, 0xC1, 0xC0, 0x60, 0x40, 0x38, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x1C, 0x01, 0xC0,
  0x70, 0x0E, 0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0x30,
  0x38, 0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x60,
  0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x71, 0xC0, 0x01,
  0xC7, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x80, 0x01, 0x8E,
  0x00, 0x06, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x9C, 0x00,
  0x0C, 0x70, 0x00, 0x31, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0x60, 0x18, 0x03, 0x80, 0x70, 0x1C, 0x01,
  0xC0, 0x60, 0x03, 0x87, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x7B, 0x07, 0x38,
  0x71, 0xC7, 0x0C, 0xF0, 0x62, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x30, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x02, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x02, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x04, 0x00, 0x38, 0x03,
  0x00, 0x78, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x71, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x70,
  0x00, 0x18, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x0E, 0x07, 0x00, 0x06, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0x80, 0x30, 0x01, 0xC0,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x60,
  0x03, 0x00, 0x70, 0x01, 0x80, 0x30, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x80, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x10, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x8F, 0xE0, 0x06,
  0x3F, 0xF0, 0x1C, 0xE0, 0xF0, 0x3B, 0x00, 0xE0, 0x7C, 0x00, 0xE0, 0xF0,
  0x01, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x03, 0x0F, 0x00, 0x06, 0x1C, 0x00,
  0x0C, 0x38, 0x00, 0x18, 0x70, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01,
  0xC3, 0x00, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x30, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x03,
  0x00, 0x0C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x1C,
  0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0x81, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x03,
  0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x0C, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x07, 0x00, 0x0C,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x0E, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xC1, 0xC0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x06, 0x06, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x60,
  0x00, 0x61, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0, 0x00,
  0xE1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x1E, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0xF8, 0x1C, 0x03, 0x70, 0x3C, 0x1C, 0xC0, 0x3F, 0xF1, 0x80,
  0x3F, 0xC7, 0x00, 0x08, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x20, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03,
  0x81, 0xE0, 0x40, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x03, 0x06, 0x00, 0x10, 0x03, 0x06, 0x00, 0xFF,
  0x03, 0x0C, 0x01, 0xFF, 0x03, 0x0C, 0x03, 0x87, 0x03, 0x1C, 0x07, 0x06,
  0x03, 0x18, 0x06, 0x06, 0x03, 0x18, 0x0C, 0x06, 0x03, 0x38, 0x1C, 0x0E,
  0x07, 0x30, 0x18, 0x0C, 0x06, 0x30, 0x18, 0x0C, 0x06, 0x30, 0x30, 0x0C,
  0x06, 0x70, 0x30, 0x1C, 0x06, 0x60, 0x70, 0x18, 0x0E, 0x60, 0x60, 0x18,
  0x0C, 0x60, 0x60, 0x18, 0x0C, 0x60, 0x60, 0x38, 0x0C, 0xE0, 0x60, 0x30,
  0x1C, 0xC0, 0xE0, 0x30, 0x18, 0xC0, 0xE0, 0x70, 0x18, 0xC0, 0xE0, 0x70,
  0x38, 0xC0, 0xC0, 0x70, 0x30, 0xC0, 0xC0, 0xF0, 0x30, 0xC0, 0xE0, 0xB0,
  0x60, 0xC0, 0xE1, 0xB0, 0xE0, 0xC0, 0x63, 0x31, 0xC0, 0xC0, 0x7F, 0x3F,
  0x80, 0xC0, 0x3E, 0x1F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x18, 0x0C, 0x00,
  0xE0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x00, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0x70,
  0x00, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x31, 0xC0, 0x00,
  0xC7, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xDC,
  0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x07, 0xF0, 0x00,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x06, 0x00, 0x1C,
  0x01, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x18, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xC0, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x01, 0xF0, 0x01, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C,
  0x07, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80,
  0x60, 0x03, 0xC0, 0x18, 0x07, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x3E, 0x03, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x18, 0x07, 0x80, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x18, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00,
  0x70, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x01, 0x80, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0, 0xC0,
  0x00, 0x30, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38,
  0x18, 0x00, 0x07, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x30,
  0x00, 0x70, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x06, 0x00, 0xF0, 0x00, 0xC1, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x08, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x01, 0xFF, 0x07, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x20, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x01, 0x80, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x60, 0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x30, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x01, 0x80,
  0x1C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0C,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x06, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x70, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x60, 0x07, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x03, 0x80, 0x18, 0x00, 0x07, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x60, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x03, 0x80, 0x00, 0xE0,
  0x06, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x38, 0x01, 0x80, 0x03, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x38,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0C,
  0xF0, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x07, 0xCC, 0x00, 0x00, 0x36, 0x60,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0xE0, 0x60, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x07,
  0x00, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x30, 0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x30, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x01, 0xB0,
  0x00, 0x00, 0xFC, 0x00, 0xD8, 0x00, 0x00, 0x6E, 0x00, 0xEC, 0x00, 0x00,
  0x76, 0x00, 0x76, 0x00, 0x00, 0x33, 0x00, 0x3B, 0x00, 0x00, 0x3B, 0x80,
  0x19, 0x80, 0x00, 0x19, 0xC0, 0x0C, 0xC0, 0x00, 0x1C, 0xE0, 0x0E, 0x60,
  0x00, 0x0E, 0x60, 0x07, 0x38, 0x00, 0x0E, 0x30, 0x03, 0x1C, 0x00, 0x07,
  0x38, 0x01, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x01, 0x86, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x00, 0x30, 0x60,
  0x00, 0xC3, 0x80, 0x18, 0x30, 0x00, 0xE1, 0xC0, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x0E, 0x0C, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x30, 0x30, 0x03,
  0x03, 0x00, 0x38, 0x38, 0x01, 0x81, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xC0,
  0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00, 0x70, 0x30, 0x0E, 0x07,
  0x00, 0x30, 0x18, 0x06, 0x03, 0x80, 0x18, 0x0C, 0x07, 0x01, 0xC0, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x83, 0x80, 0x60, 0x06, 0x01, 0xC1,
  0xC0, 0x70, 0x03, 0x00, 0xE0, 0xC0, 0x38, 0x01, 0x80, 0x70, 0xE0, 0x18,
  0x01, 0xC0, 0x38, 0x60, 0x0C, 0x00, 0xE0, 0x1C, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x30, 0x07, 0x00, 0x30, 0x07, 0x38, 0x03, 0x80, 0x18, 0x01, 0x98,
  0x01, 0x80, 0x1C, 0x00, 0xDC, 0x00, 0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xE0,
  0x06, 0x00, 0x3E, 0x00, 0x70, 0x03, 0x00, 0x1E, 0x00, 0x38, 0x03, 0x80,
  0x0F, 0x00, 0x18, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x00, 0xC0, 0x07, 0x80,
  0x00, 0xE0, 0x07, 0xC0, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x30, 0x01, 0xB0,
  0x00, 0x18, 0x00, 0xDC, 0x00, 0x0C, 0x00, 0xEE, 0x00, 0x0E, 0x00, 0x73,
  0x00, 0x07, 0x00, 0x39, 0x80, 0x03, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x0C,
  0x70, 0x00, 0xC0, 0x0E, 0x38, 0x00, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0x03,
  0x86, 0x00, 0x30, 0x01, 0x83, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x00,
  0xE0, 0xE0, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x00, 0x30, 0x18, 0x03, 0x00,
  0x18, 0x0C, 0x01, 0x80, 0x0C, 0x06, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0xE0,
  0x07, 0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x30, 0x18,
  0x01, 0xC0, 0x18, 0x1C, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0x70, 0x07, 0x06,
  0x00, 0x30, 0x03, 0x83, 0x00, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x00, 0x61,
  0xC0, 0x0E, 0x00, 0x30, 0xE0, 0x06, 0x00, 0x1C, 0x60, 0x03, 0x00, 0x0E,
  0x30, 0x01, 0x80, 0x07, 0x38, 0x01, 0xC0, 0x01, 0x9C, 0x00, 0xE0, 0x00,
  0xCC, 0x00, 0x60, 0x00, 0x66, 0x00, 0x30, 0x00, 0x3B, 0x00, 0x18, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x03, 0xC0, 0x06, 0x00,
  0x01, 0xE0, 0x03, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0x30, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xC7, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x38,
  0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x00, 0x1E, 0x00, 0x70,
  0x07, 0x80, 0x07, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xC0,
  0x38, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00,
  0xE0, 0x0C, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x07, 0x01, 0xF0, 0x03, 0x0F,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x30, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x30, 0x70, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x18, 0x70, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x03, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0x60, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x0C, 0x3F, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03, 0x00,
  0x70, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x38, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x04, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x01, 0x00,
  0x03, 0x80, 0x38, 0x01, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xC0, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x36, 0x00, 0x00, 0xEC, 0x00, 0x01, 0x98, 0x00,
  0x07, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x71, 0x80, 0x00,
  0xC3, 0x00, 0x03, 0x86, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38,
  0x30, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x70, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01,
  0xC0, 0x06, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x30,
  0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00,
  0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x60, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x00, 0x01,
  0x98, 0x00, 0x07, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x80, 0x00, 0xC6, 0x00,
  0x03, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0xE0, 0x00, 0x71, 0x80, 0x01, 0xB0,
  0x00, 0x30, 0xC0, 0x00, 0xD8, 0x00, 0x38, 0x60, 0x00, 0xEC, 0x00, 0x18,
  0x30, 0x00, 0x66, 0x00, 0x1C, 0x18, 0x00, 0x37, 0x00, 0x0E, 0x1C, 0x00,
  0x33, 0x80, 0x06, 0x0E, 0x00, 0x19, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0xE0,
  0x03, 0x03, 0x80, 0x0C, 0x70, 0x03, 0x81, 0xC0, 0x06, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x0C, 0x00, 0xE0, 0x38, 0x03,
  0x86, 0x00, 0x60, 0x1C, 0x01, 0x83, 0x00, 0x70, 0x0E, 0x00, 0xC1, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x60, 0x1C, 0x01,
  0xC0, 0x70, 0x30, 0x0C, 0x00, 0xE0, 0x30, 0x18, 0x0E, 0x00, 0x70, 0x18,
  0x0C, 0x07, 0x00, 0x38, 0x1C, 0x06, 0x03, 0x00, 0x1C, 0x0C, 0x03, 0x03,
  0x80, 0x0E, 0x0E, 0x01, 0x81, 0x80, 0x07, 0x06, 0x00, 0xC1, 0xC0, 0x03,
  0x83, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x30, 0x60, 0x00, 0xE1, 0x80,
  0x18, 0x70, 0x00, 0x71, 0xC0, 0x0C, 0x30, 0x00, 0x38, 0xE0, 0x06, 0x38,
  0x00, 0x18, 0x60, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x01, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0xCE, 0x00, 0x03, 0x18, 0x00, 0x66, 0x00, 0x01, 0x9C, 0x00,
  0x77, 0x00, 0x00, 0xCC, 0x00, 0x3B, 0x80, 0x00, 0x6E, 0x00, 0x1D, 0x80,
  0x00, 0x36, 0x00, 0x0F, 0xC0, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0x0F,
  0x80, 0x03, 0x60, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x06,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0,
  0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0, 0x01,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x01,
  0x80, 0x38, 0x06, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x38, 0x01, 0x80,
  0xE0, 0x06, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0x70, 0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x02,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x60, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x0E, 0x00,
  0x1C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x71, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x0C, 0x0C,
  0x0C, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x8C, 0x03, 0xE7, 0x98, 0x0E, 0x03,
  0x30, 0x38, 0x03, 0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x38, 0x00, 0x18, 0x70,
  0x00, 0x30, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0, 0x00,
  0xC1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x1E, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x70, 0x06, 0xC0, 0x70, 0x19, 0x80,
  0xF0, 0x76, 0x00, 0xFF, 0xCC, 0x00, 0xFF, 0x18, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC3, 0xF0,
  0x00, 0xC7, 0xF8, 0x01, 0xCE, 0x3C, 0x01, 0xD8, 0x0E, 0x01, 0xB0, 0x0E,
  0x01, 0xE0, 0x06, 0x01, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0E, 0x00, 0x06, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C,
  0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x38, 0x00, 0x60, 0x78, 0x00, 0xE0, 0x6C, 0x01, 0xC0, 0x6C, 0x03, 0x80,
  0x66, 0x07, 0x00, 0x67, 0xFE, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xC3, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x01, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x30, 0x00, 0x7F,
  0xC6, 0x00, 0x1F, 0x3C, 0xC0, 0x07, 0x01, 0xB8, 0x01, 0xC0, 0x1F, 0x00,
  0x30, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x60, 0x1C, 0x00, 0x0C,
  0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x01, 0x80,
  0x01, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00,
  0x38, 0x03, 0x00, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x03, 0x60, 0x03, 0x80, 0xDC, 0x00, 0x78, 0x3B,
  0x00, 0x07, 0xFE, 0x60, 0x00, 0x7F, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xC7, 0x80, 0xE0, 0x70, 0x38, 0x06,
  0x0E, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x63, 0x80, 0x0C,
  0x60, 0x03, 0x9C, 0x00, 0x63, 0x00, 0x1C, 0x60, 0x07, 0x1C, 0x01, 0xC3,
  0x80, 0xF0, 0x60, 0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x01, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x70, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x87, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFE, 0x30, 0x01,
  0xF3, 0xCC, 0x00, 0xE0, 0x33, 0x00, 0x70, 0x07, 0xC0, 0x18, 0x01, 0xE0,
  0x0E, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00,
  0x38, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x60, 0x01, 0xE0, 0x18,
  0x00, 0x78, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x06, 0xC0,
  0x0E, 0x03, 0x70, 0x03, 0x81, 0xD8, 0x00, 0x7F, 0xE6, 0x00, 0x0F, 0xE1,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x80, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x61, 0xF8, 0x00, 0xCF, 0xF8, 0x03, 0xBC, 0x78, 0x07, 0xE0, 0x30,
  0x0D, 0x80, 0x70, 0x1E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81,
  0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01,
  0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x02, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x0E, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x18, 0x07, 0x00, 0x30,
  0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x06, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x61, 0xC0, 0x00, 0xC7, 0x00,
  0x01, 0x9E, 0x00, 0x07, 0x7C, 0x00, 0x0E, 0xD8, 0x00, 0x1B, 0x38, 0x00,
  0x3E, 0x70, 0x00, 0x78, 0xE0, 0x01, 0xE0, 0xC0, 0x03, 0x81, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x30, 0x03, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x19, 0xFF, 0x0F, 0xF8, 0x07, 0x70, 0xE3, 0x87, 0x80, 0xD8, 0x0E, 0xC0,
  0x70, 0x1A, 0x00, 0xF0, 0x06, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x70, 0x03,
  0x80, 0x18, 0x1E, 0x00, 0x70, 0x03, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x70,
  0x03, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x03, 0x83, 0x80, 0x0C, 0x00, 0x70,
  0x70, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x01, 0x81, 0x80, 0x0E, 0x00,
  0x30, 0x30, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0x01, 0xC1, 0xC0, 0x06,
  0x00, 0x30, 0x30, 0x01, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x01, 0xC0, 0xC0,
  0x07, 0x00, 0x38, 0x38, 0x00, 0xC0, 0x06, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0xC0, 0x07, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x07, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0xE0, 0x03, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x03, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x60, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x60, 0x03, 0x83, 0x80,
  0x0C, 0x00, 0x60, 0x70, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x70, 0x01, 0x81,
  0x80, 0x0C, 0x00, 0x70, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF0,
  0x01, 0x9F, 0xF0, 0x06, 0x78, 0xF0, 0x0D, 0xC0, 0xE0, 0x1B, 0x00, 0xE0,
  0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3C,
  0x78, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x18, 0x18, 0x00, 0xE1,
  0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x33, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00,
  0x06, 0x30, 0x00, 0x71, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x70, 0x01, 0x83,
  0x80, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC1, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0x1F, 0xE0, 0x00, 0xE7, 0x1E, 0x00, 0x19, 0x80, 0xE0, 0x03, 0x60, 0x1C,
  0x00, 0x68, 0x01, 0x80, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x78,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x06, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x06, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x0F, 0x80, 0x70, 0x01, 0x98,
  0x1C, 0x00, 0x33, 0xFF, 0x00, 0x0E, 0x3F, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x8C, 0x03, 0xC7, 0x98, 0x0E, 0x03, 0x30,
  0x38, 0x03, 0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x0C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x18, 0x70, 0x00,
  0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xC1,
  0x80, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x3C, 0x1C,
  0x00, 0xF0, 0x38, 0x01, 0xE0, 0x70, 0x06, 0xC0, 0x70, 0x1B, 0x80, 0xE0,
  0x77, 0x00, 0xFF, 0xCC, 0x00, 0xFE, 0x18, 0x00, 0x70, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x19, 0xFC, 0x06,
  0x7C, 0x80, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x7C, 0x3C, 0x07, 0x80, 0x60, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x80, 0x1C, 0x06, 0x01,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0xFF, 0xC7, 0xFE, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x06,
  0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x0F, 0x03, 0x00, 0x3C, 0x0C, 0x01,
  0xF0, 0x38, 0x0D, 0x80, 0xE0, 0x76, 0x01, 0xFF, 0x98, 0x03, 0xFC, 0x60,
  0x03, 0x80, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x0E,
  0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x30,
  0x07, 0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0C, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x30, 0x38, 0x0C, 0x0C, 0x03, 0x07, 0x00,
  0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x1E, 0x00, 0x76, 0x00, 0x3C,
  0x00, 0xCC, 0x00, 0x78, 0x01, 0x98, 0x01, 0xB0, 0x07, 0x30, 0x03, 0x60,
  0x0C, 0x60, 0x0E, 0xC0, 0x18, 0xC0, 0x19, 0x80, 0x61, 0x80, 0x33, 0x00,
  0xC3, 0x00, 0xE6, 0x03, 0x86, 0x01, 0x8C, 0x06, 0x0C, 0x07, 0x18, 0x0C,
  0x18, 0x0C, 0x30, 0x38, 0x30, 0x18, 0x60, 0x60, 0x60, 0x60, 0xC1, 0xC0,
  0xC0, 0xC1, 0x83, 0x01, 0x83, 0x83, 0x06, 0x03, 0x06, 0x06, 0x1C, 0x06,
  0x0C, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x60, 0x31, 0x80, 0x31,
  0xC0, 0x63, 0x00, 0x63, 0x00, 0xCE, 0x00, 0xC6, 0x01, 0x98, 0x01, 0x98,
  0x03, 0x30, 0x03, 0x30, 0x06, 0xC0, 0x06, 0xE0, 0x0D, 0x80, 0x0D, 0x80,
  0x1F, 0x00, 0x1B, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x58, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xE0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x01, 0xC0, 0x06, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x87, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0xC0, 0x05, 0xFF, 0xE0, 0x0F, 0x01, 0xF0, 0x7C, 0x00, 0xFF, 0xD0, 0x00,
  0x7F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 48, 14, 1, -48 },
  { 79, 15, 17, 18, 6, -48 },
  { 111, 26, 48, 25, 0, -48 },
  { 267, 26, 55, 24, -1, -51 },
  { 446, 30, 50, 36, 3, -49 },
  { 634, 23, 50, 23, -1, -49 },
  { 778, 6, 17, 10, 6, -48 },
  { 791, 18, 59, 16, 2, -48 },
  { 924, 19, 59, 16, -5, -48 },
  { 1065, 17, 19, 22, 8, -51 },
  { 1106, 23, 31, 27, 2, -39 },
  { 1196, 9, 15, 11, -3, -6 },
  { 1213, 15, 2, 17, 1, -19 },
  { 1217, 4, 5, 11, 1, -5 },
  { 1220, 28, 48, 20, -3, -48 },
  { 1388, 22, 50, 24, 1, -49 },
  { 1526, 13, 48, 24, 7, -48 },
  { 1604, 26, 49, 24, -2, -49 },
  { 1764, 25, 50, 24, -1, -49 },
  { 1921, 25, 48, 24, -1, -48 },
  { 2071, 26, 49, 24, -2, -48 },
  { 2231, 23, 50, 24, 2, -49 },
  { 2375, 24, 48, 24, 2, -48 },
  { 2519, 25, 50, 24, -1, -49 },
  { 2676, 23, 50, 24, 0, -49 },
  { 2820, 11, 36, 11, 0, -36 },
  { 2870, 14, 45, 11, -3, -36 },
  { 2949, 23, 28, 27, 2, -38 },
  { 3030, 23, 17, 27, 2, -32 },
  { 3079, 23, 28, 27, 2, -38 },
  { 3160, 19, 49, 17, 1, -49 },
  { 3277, 32, 54, 35, 2, -48 },
  { 3493, 22, 48, 23, -4, -48 },
  { 3625, 26, 48, 26, 0, -48 },
  { 3781, 26, 50, 23, 2, -49 },
  { 3944, 27, 48, 28, 0, -48 },
  { 4106, 26, 48, 23, 0, -48 },
  { 4262, 26, 48, 21, 0, -48 },
  { 4418, 30, 50, 31, 2, -49 },
  { 4606, 31, 48, 30, 0, -48 },
  { 4792, 21, 48, 12, -4, -48 },
  { 4918, 23, 60, 11, -10, -48 },
  { 5091, 29, 48, 24, 0, -48 },
  { 5265, 15, 48, 21, 0, -48 },
  { 5355, 41, 48, 40, 0, -48 },
  { 5601, 33, 48, 32, 0, -48 },
  { 5799, 27, 50, 30, 2, -49 },
  { 5968, 25, 48, 24, 0, -48 },
  { 6118, 27, 60, 30, 2, -49 },
  { 6321, 25, 48, 25, 0, -48 },
  { 6471, 27, 50, 23, -2, -49 },
  { 6640, 22, 48, 20, 4, -48 },
  { 6772, 28, 49, 29, 2, -48 },
  { 6944, 23, 48, 24, 6, -48 },
  { 7082, 41, 48, 41, 5, -48 },
  { 7328, 30, 48, 21, -4, -48 },
  { 7508, 22, 48, 20, 4, -48 },
  { 7640, 28, 48, 21, -3, -48 },
  { 7808, 24, 59, 18, -1, -48 },
  { 7985, 9, 48, 22, 7, -48 },
  { 8039, 24, 59, 18, -4, -48 },
  { 8216, 25, 24, 26, 1, -48 },
  { 8291, 18, 2, 18, -5, 6 },
  { 8296, 7, 10, 14, 10, -51 },
  { 8305, 23, 37, 26, 2, -36 },
  { 8412, 24, 52, 26, 0, -51 },
  { 8568, 19, 37, 19, 2, -36 },
  { 8656, 27, 52, 26, 2, -51 },
  { 8832, 19, 37, 23, 2, -36 },
  { 8920, 30, 67, 13, -9, -51 },
  { 9172, 26, 52, 26, -1, -36 },
  { 9341, 23, 51, 25, 0, -51 },
  { 9488, 13, 48, 11, 0, -48 },
  { 9566, 22, 64, 11, -9, -48 },
  { 9742, 23, 51, 21, 0, -51 },
  { 9889, 14, 51, 11, 0, -51 },
  { 9979, 35, 36, 37, 0, -36 },
  { 10137, 23, 36, 25, 0, -36 },
  { 10241, 21, 37, 25, 2, -36 },
  { 10339, 27, 51, 26, -3, -36 },
  { 10512, 23, 52, 26, 2, -36 },
  { 10662, 19, 36, 16, 0, -36 },
  { 10748, 21, 37, 19, -1, -36 },
  { 10846, 13, 45, 13, 1, -44 },
  { 10920, 22, 36, 25, 2, -35 },
  { 11019, 18, 35, 19, 4, -35 },
  { 11098, 31, 35, 32, 4, -35 },
  { 11234, 25, 35, 20, -3, -35 },
  { 11344, 31, 51, 20, -7, -35 },
  { 11542, 20, 35, 16, -2, -35 },
  { 11630, 23, 59, 21, 2, -48 },
  { 11800, 3, 67, 23, 10, -51 },
  { 11826, 23, 59, 21, -4, -48 },
  { 11996, 23, 6, 27, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC67PT7B_H_
