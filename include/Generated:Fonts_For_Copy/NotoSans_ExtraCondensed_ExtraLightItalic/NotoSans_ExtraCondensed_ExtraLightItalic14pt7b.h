#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x92, 0x10, 0x76, 0xD0, 0x14, 0xA2, 0x9F, 0x51, 0x4F,
  0x98, 0xA2, 0x80, 0x11, 0xD4, 0xA6, 0x10, 0x86, 0x32, 0xB8, 0x80, 0x66,
  0xAA, 0xAC, 0xDF, 0xD3, 0x55, 0x56, 0x60, 0x32, 0x94, 0xA2, 0x32, 0xB2,
  0x97, 0x80, 0x6A, 0x12, 0x24, 0x48, 0x88, 0x88, 0x84, 0x11, 0x11, 0x11,
  0x11, 0x22, 0x48, 0x59, 0xF0, 0x21, 0x09, 0xF2, 0x10, 0x58, 0xE0, 0x80,
  0x04, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0x00, 0x3A, 0x52, 0x98, 0xC6,
  0x52, 0x97, 0x00, 0x75, 0xAA, 0xA0, 0x78, 0x42, 0x11, 0x08, 0x88, 0x87,
  0x00, 0x78, 0x42, 0x13, 0x08, 0x42, 0x17, 0x00, 0x08, 0xCA, 0x65, 0x2A,
  0x5E, 0x21, 0x00, 0x3A, 0x10, 0x87, 0x08, 0x42, 0x17, 0x00, 0x19, 0x10,
  0x8F, 0x46, 0x32, 0x93, 0x00, 0x78, 0x42, 0x21, 0x10, 0x88, 0x46, 0x00,
  0x3A, 0x52, 0x93, 0x2A, 0x52, 0x97, 0x00, 0x3A, 0x52, 0x94, 0xB8, 0x42,
  0x17, 0x00, 0x40, 0x08, 0x20, 0x00, 0x12, 0x80, 0x09, 0xB0, 0x83, 0x04,
  0xF8, 0x01, 0xF0, 0xC1, 0x06, 0x32, 0x60, 0x71, 0x11, 0x24, 0x48, 0x08,
  0x1C, 0x45, 0x0A, 0xF6, 0xB5, 0x6A, 0xDE, 0x81, 0x01, 0xC0, 0x08, 0x46,
  0x52, 0x9D, 0x29, 0x8C, 0x40, 0x39, 0x52, 0x97, 0x25, 0x31, 0x97, 0x00,
  0x3A, 0x21, 0x08, 0x42, 0x10, 0x87, 0x00, 0x38, 0x94, 0x51, 0x45, 0x14,
  0xA2, 0x93, 0x80, 0x39, 0x10, 0x87, 0x21, 0x10, 0x87, 0x00, 0x39, 0x10,
  0x84, 0x39, 0x10, 0x84, 0x00, 0x1E, 0x41, 0x02, 0x04, 0x11, 0xA1, 0x42,
  0x88, 0xF0, 0x22, 0x49, 0x12, 0x27, 0xC8, 0x92, 0x44, 0x89, 0x10, 0x38,
  0x88, 0x42, 0x10, 0x88, 0x47, 0x00, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21,
  0x09, 0x80, 0x24, 0xA5, 0x14, 0x61, 0x85, 0x24, 0x92, 0x40, 0x25, 0x24,
  0x94, 0x9C, 0x20, 0x90, 0x98, 0xCC, 0x66, 0x53, 0x29, 0xA9, 0x34, 0x92,
  0x49, 0x00, 0x22, 0x45, 0x8A, 0xA5, 0x4A, 0x95, 0x4C, 0x89, 0x10, 0x1C,
  0x94, 0x51, 0x46, 0x18, 0x62, 0x89, 0xC0, 0x39, 0x52, 0x94, 0xB9, 0x10,
  0x84, 0x00, 0x1C, 0x94, 0x51, 0x46, 0x18, 0x62, 0x89, 0x42, 0x04, 0x39,
  0x52, 0x94, 0xB9, 0x52, 0x94, 0x80, 0x3A, 0x10, 0x82, 0x10, 0x42, 0x17,
  0x00, 0xF4, 0x44, 0x44, 0x88, 0x88, 0x24, 0x94, 0x51, 0x45, 0x28, 0xA2,
  0x89, 0xC0, 0x8C, 0x65, 0x2A, 0x52, 0x98, 0x84, 0x00, 0x88, 0xC4, 0xA6,
  0x55, 0x4A, 0xA5, 0x53, 0x31, 0x98, 0x88, 0x44, 0x00, 0x24, 0x51, 0x86,
  0x10, 0x43, 0x14, 0x52, 0x40, 0x99, 0xAA, 0xC4, 0x88, 0x88, 0x1C, 0x10,
  0x82, 0x10, 0x42, 0x10, 0x43, 0xC0, 0x39, 0x08, 0x84, 0x21, 0x10, 0x84,
  0x21, 0x80, 0xA5, 0x55, 0x50, 0x18, 0x42, 0x11, 0x08, 0x42, 0x11, 0x09,
  0xC0, 0x11, 0x92, 0x98, 0x80, 0xF0, 0xE0, 0x32, 0x52, 0x98, 0xCA, 0x4E,
  0x21, 0x08, 0xA6, 0xA5, 0x29, 0x8C, 0xBC, 0x34, 0x48, 0x88, 0x86, 0x04,
  0x10, 0x4D, 0x49, 0x24, 0xA2, 0x92, 0x47, 0x00, 0x35, 0x59, 0xA8, 0x87,
  0x04, 0x20, 0x86, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x23, 0x00, 0x32,
  0x52, 0x98, 0xCA, 0x4E, 0x10, 0xB8, 0x21, 0x08, 0xA6, 0xA5, 0x2A, 0x94,
  0xA4, 0x20, 0x24, 0x94, 0x90, 0x08, 0x00, 0x21, 0x08, 0x44, 0x21, 0x08,
  0x4C, 0x00, 0x21, 0x08, 0x95, 0x29, 0x8C, 0xA5, 0x24, 0x24, 0xA4, 0x92,
  0x92, 0x00, 0x16, 0xD5, 0x2A, 0x55, 0x32, 0x64, 0xCA, 0x13, 0x52, 0x95,
  0x4A, 0x52, 0x32, 0x52, 0x98, 0xC6, 0x4C, 0x08, 0xD2, 0x49, 0x25, 0x14,
  0x9E, 0x41, 0x08, 0x00, 0x32, 0x52, 0x98, 0xCA, 0x4E, 0x10, 0x88, 0x16,
  0x44, 0x48, 0x88, 0x34, 0x44, 0x22, 0x2E, 0x2D, 0x25, 0x24, 0xC0, 0x4A,
  0x52, 0xA9, 0x4B, 0xC0, 0x9A, 0xAC, 0xC8, 0x80, 0xA6, 0x9D, 0xB6, 0x92,
  0x49, 0x00, 0x2C, 0xA1, 0x08, 0x31, 0x49, 0x00, 0x12, 0x28, 0x50, 0xC1,
  0x82, 0x04, 0x08, 0x21, 0xC0, 0x72, 0x24, 0x48, 0xC0, 0x18, 0x88, 0x42,
  0x13, 0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x10, 0x44, 0x21, 0x08, 0x64,
  0x21, 0x09, 0x80, 0x6C, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 3, 4, 4, 1, -10 },
  { 7, 6, 10, 5, 0, -10 },
  { 15, 5, 12, 5, 0, -11 },
  { 23, 6, 10, 8, 1, -10 },
  { 31, 5, 10, 5, 0, -10 },
  { 38, 2, 4, 2, 1, -10 },
  { 39, 4, 12, 3, 0, -10 },
  { 45, 4, 12, 3, -1, -10 },
  { 51, 3, 4, 5, 2, -11 },
  { 53, 5, 6, 6, 0, -8 },
  { 57, 2, 3, 2, -1, -1 },
  { 58, 3, 1, 4, 0, -4 },
  { 59, 1, 1, 2, 0, -1 },
  { 60, 6, 10, 4, -1, -10 },
  { 68, 5, 10, 5, 0, -10 },
  { 75, 2, 10, 5, 2, -10 },
  { 78, 5, 10, 5, 0, -10 },
  { 85, 5, 10, 5, 0, -10 },
  { 92, 5, 10, 5, 0, -10 },
  { 99, 5, 10, 5, 0, -10 },
  { 106, 5, 10, 5, 0, -10 },
  { 113, 5, 10, 5, 0, -10 },
  { 120, 5, 10, 5, 0, -10 },
  { 127, 5, 10, 5, 0, -10 },
  { 134, 2, 7, 2, 0, -7 },
  { 136, 3, 9, 2, -1, -7 },
  { 140, 5, 6, 6, 0, -8 },
  { 144, 5, 4, 6, 0, -7 },
  { 147, 5, 6, 6, 0, -8 },
  { 151, 4, 10, 4, 0, -10 },
  { 156, 7, 11, 7, 0, -10 },
  { 166, 5, 10, 5, -1, -10 },
  { 173, 5, 10, 5, 0, -10 },
  { 180, 5, 10, 5, 1, -10 },
  { 187, 6, 10, 6, 0, -10 },
  { 195, 5, 10, 5, 0, -10 },
  { 202, 5, 10, 4, 0, -10 },
  { 209, 7, 10, 6, 0, -10 },
  { 218, 7, 10, 6, 0, -10 },
  { 227, 5, 10, 3, -1, -10 },
  { 234, 5, 12, 2, -2, -10 },
  { 242, 6, 10, 5, 0, -10 },
  { 250, 3, 10, 4, 0, -10 },
  { 254, 9, 10, 8, 0, -10 },
  { 266, 7, 10, 7, 0, -10 },
  { 275, 6, 10, 6, 0, -10 },
  { 283, 5, 10, 5, 0, -10 },
  { 290, 6, 12, 6, 0, -10 },
  { 299, 5, 10, 5, 0, -10 },
  { 306, 5, 10, 5, 0, -10 },
  { 313, 4, 10, 4, 1, -10 },
  { 318, 6, 10, 6, 0, -10 },
  { 326, 5, 10, 5, 1, -10 },
  { 333, 9, 10, 9, 1, -10 },
  { 345, 6, 10, 4, -1, -10 },
  { 353, 4, 10, 4, 1, -10 },
  { 358, 6, 10, 4, -1, -10 },
  { 366, 5, 12, 4, 0, -10 },
  { 374, 2, 10, 5, 1, -10 },
  { 377, 5, 12, 4, -1, -10 },
  { 385, 5, 5, 5, 0, -10 },
  { 389, 4, 1, 4, -1, 1 },
  { 390, 1, 3, 3, 2, -11 },
  { 391, 5, 8, 5, 0, -8 },
  { 396, 5, 11, 5, 0, -11 },
  { 403, 4, 8, 4, 0, -8 },
  { 407, 6, 11, 5, 0, -11 },
  { 416, 4, 8, 5, 0, -8 },
  { 420, 6, 14, 3, -2, -11 },
  { 431, 5, 11, 5, 0, -8 },
  { 438, 5, 11, 5, 0, -11 },
  { 445, 3, 10, 2, 0, -10 },
  { 449, 5, 13, 2, -2, -10 },
  { 458, 5, 11, 4, 0, -11 },
  { 465, 3, 11, 2, 0, -11 },
  { 470, 7, 8, 8, 0, -8 },
  { 477, 5, 8, 5, 0, -8 },
  { 482, 5, 8, 5, 0, -8 },
  { 487, 6, 11, 5, -1, -8 },
  { 496, 5, 11, 5, 0, -8 },
  { 503, 4, 8, 3, 0, -8 },
  { 507, 4, 8, 4, 0, -8 },
  { 511, 3, 9, 3, 0, -9 },
  { 515, 5, 7, 5, 0, -7 },
  { 520, 4, 7, 4, 1, -7 },
  { 524, 6, 7, 7, 1, -7 },
  { 530, 6, 7, 4, -1, -7 },
  { 536, 7, 10, 4, -2, -7 },
  { 545, 4, 7, 3, 0, -7 },
  { 549, 5, 12, 4, 0, -10 },
  { 557, 1, 14, 5, 2, -11 },
  { 559, 5, 12, 4, -1, -10 },
  { 567, 5, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC14PT7B_H_
