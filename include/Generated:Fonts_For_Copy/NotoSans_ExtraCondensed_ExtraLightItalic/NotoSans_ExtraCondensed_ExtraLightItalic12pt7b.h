#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0xA0, 0x80, 0xB7, 0x60, 0x29, 0x4C, 0xB5, 0x32, 0xD4,
  0xC0, 0x17, 0x66, 0x22, 0x55, 0xE4, 0x4D, 0xB5, 0xCF, 0xF5, 0xB5, 0xB0,
  0x25, 0x56, 0x4B, 0xBA, 0xE0, 0xF0, 0x12, 0x44, 0x88, 0x88, 0x88, 0x40,
  0x24, 0x92, 0x49, 0x2A, 0x00, 0xAE, 0x80, 0x21, 0x3E, 0x42, 0x10, 0xE0,
  0xE0, 0x80, 0x08, 0x42, 0x21, 0x11, 0x08, 0x80, 0x35, 0x55, 0x99, 0x9A,
  0xE0, 0x39, 0x24, 0x94, 0x80, 0x71, 0x11, 0x12, 0x48, 0xE0, 0x71, 0x11,
  0x61, 0x12, 0xE0, 0x11, 0x35, 0x5A, 0xF2, 0x20, 0x34, 0x44, 0x21, 0x11,
  0xE0, 0x3A, 0x10, 0xC5, 0x4A, 0x52, 0xE0, 0x78, 0x44, 0x22, 0x11, 0x08,
  0x80, 0x35, 0x55, 0x6A, 0x99, 0xE0, 0x25, 0x59, 0x97, 0x12, 0xC0, 0x40,
  0x20, 0x20, 0x00, 0x94, 0x09, 0xB0, 0xC1, 0x80, 0xF8, 0x3E, 0x83, 0x06,
  0x6C, 0x00, 0x61, 0x12, 0x44, 0x80, 0x80, 0x18, 0x94, 0x5F, 0xAE, 0xDB,
  0x6A, 0x81, 0xC0, 0x11, 0x13, 0x33, 0x55, 0x90, 0x32, 0x52, 0x97, 0x4A,
  0x52, 0xE0, 0x19, 0x10, 0x88, 0x42, 0x10, 0x70, 0x32, 0x52, 0x94, 0xC6,
  0x52, 0xE0, 0x3A, 0x10, 0x87, 0x42, 0x10, 0xE0, 0x3A, 0x10, 0x87, 0x42,
  0x10, 0x80, 0x1C, 0x84, 0x10, 0x92, 0x28, 0xA2, 0x70, 0x25, 0x14, 0x92,
  0x7A, 0x28, 0xA4, 0x90, 0x32, 0x22, 0x22, 0x44, 0xC0, 0x11, 0x11, 0x12,
  0x22, 0x22, 0xC0, 0x2A, 0x54, 0xC4, 0x32, 0x94, 0x90, 0x29, 0x25, 0x24,
  0xE0, 0x22, 0x45, 0x8B, 0x36, 0xB5, 0x6B, 0x5A, 0xA4, 0x24, 0x96, 0x5A,
  0x6A, 0x69, 0xA4, 0x90, 0x11, 0x52, 0x98, 0xC6, 0x32, 0x70, 0x32, 0x52,
  0x95, 0x52, 0x10, 0x80, 0x11, 0x52, 0x98, 0xC6, 0x32, 0x51, 0x08, 0x32,
  0x52, 0x95, 0x52, 0x94, 0x90, 0x3A, 0x10, 0x82, 0x10, 0x42, 0xE0, 0xF4,
  0x44, 0x88, 0x88, 0x80, 0x4A, 0x52, 0x94, 0xC6, 0x52, 0xE0, 0x99, 0x9A,
  0xAC, 0xC8, 0x80, 0x93, 0x26, 0x4D, 0xAB, 0x5B, 0x26, 0x48, 0x90, 0x24,
  0xA2, 0x8C, 0x10, 0x85, 0x14, 0x90, 0x9A, 0xAC, 0xC8, 0x88, 0x80, 0x38,
  0x42, 0x21, 0x11, 0x08, 0xF0, 0x34, 0x44, 0x44, 0x88, 0x88, 0xC0, 0xAA,
  0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x21, 0x14, 0xA8,
  0x80, 0xE0, 0xC0, 0x7A, 0xA5, 0x29, 0x70, 0x24, 0x65, 0x59, 0x99, 0xE0,
  0x74, 0x88, 0x8E, 0x08, 0x4A, 0xA5, 0x4A, 0x52, 0xE0, 0x75, 0xE8, 0x8E,
  0x0C, 0x41, 0x84, 0x10, 0x42, 0x08, 0x20, 0x82, 0x30, 0x7A, 0xA5, 0x29,
  0x70, 0x84, 0xC0, 0x24, 0x65, 0x55, 0x99, 0xA0, 0x41, 0x5A, 0x80, 0x10,
  0x01, 0x11, 0x22, 0x22, 0x4C, 0x24, 0x45, 0x6C, 0xAA, 0xA0, 0x55, 0x5A,
  0x80, 0x7D, 0x55, 0x65, 0xA6, 0x90, 0x75, 0x59, 0x9A, 0x75, 0x99, 0x9E,
  0x39, 0x4A, 0x94, 0xB9, 0x10, 0x80, 0x7A, 0xA5, 0x29, 0x70, 0x84, 0x20,
  0x69, 0x49, 0x00, 0x78, 0x42, 0x2E, 0x4D, 0x29, 0x26, 0x55, 0x99, 0x9E,
  0xBB, 0x49, 0x00, 0xAD, 0x7D, 0x6A, 0x50, 0x29, 0x88, 0x45, 0x68, 0x29,
  0x4C, 0x62, 0x11, 0x08, 0x80, 0x65, 0x29, 0x80, 0x19, 0x08, 0x42, 0x61,
  0x08, 0x42, 0x10, 0xFF, 0xF0, 0x21, 0x11, 0x11, 0x22, 0x22, 0xC0, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 3, 1, -9 },
  { 7, 5, 9, 5, 0, -9 },
  { 13, 4, 10, 4, 0, -9 },
  { 18, 5, 9, 6, 1, -9 },
  { 24, 4, 9, 4, 0, -9 },
  { 29, 1, 4, 2, 1, -9 },
  { 30, 4, 11, 3, 0, -9 },
  { 36, 3, 11, 3, -1, -9 },
  { 41, 3, 3, 4, 1, -9 },
  { 43, 5, 6, 5, 0, -7 },
  { 47, 1, 3, 2, 0, -1 },
  { 48, 3, 1, 3, 0, -4 },
  { 49, 1, 1, 2, 0, -1 },
  { 50, 5, 9, 4, -1, -9 },
  { 56, 4, 9, 4, 0, -9 },
  { 61, 3, 9, 4, 1, -9 },
  { 65, 4, 9, 4, 0, -9 },
  { 70, 4, 9, 4, 0, -9 },
  { 75, 4, 9, 4, 0, -9 },
  { 80, 4, 9, 4, 0, -9 },
  { 85, 5, 9, 4, 0, -9 },
  { 91, 5, 9, 4, 0, -9 },
  { 97, 4, 9, 4, 0, -9 },
  { 102, 4, 9, 4, 0, -9 },
  { 107, 2, 6, 2, 0, -6 },
  { 109, 3, 8, 2, -1, -6 },
  { 112, 5, 5, 5, 0, -7 },
  { 116, 5, 3, 5, 0, -6 },
  { 118, 5, 5, 5, 0, -7 },
  { 122, 4, 9, 3, 0, -9 },
  { 127, 6, 10, 6, 0, -9 },
  { 135, 4, 9, 4, -1, -9 },
  { 140, 5, 9, 5, 0, -9 },
  { 146, 5, 9, 4, 0, -9 },
  { 152, 5, 9, 5, 0, -9 },
  { 158, 5, 9, 4, 0, -9 },
  { 164, 5, 9, 4, 0, -9 },
  { 170, 6, 9, 6, 0, -9 },
  { 177, 6, 9, 5, 0, -9 },
  { 184, 4, 9, 2, -1, -9 },
  { 189, 4, 11, 2, -2, -9 },
  { 195, 5, 9, 4, 0, -9 },
  { 201, 3, 9, 4, 0, -9 },
  { 205, 7, 9, 7, 0, -9 },
  { 213, 6, 9, 6, 0, -9 },
  { 220, 5, 9, 5, 0, -9 },
  { 226, 5, 9, 4, 0, -9 },
  { 232, 5, 11, 5, 0, -9 },
  { 239, 5, 9, 4, 0, -9 },
  { 245, 5, 9, 4, 0, -9 },
  { 251, 4, 9, 4, 1, -9 },
  { 256, 5, 9, 5, 0, -9 },
  { 262, 4, 9, 4, 1, -9 },
  { 267, 7, 9, 7, 1, -9 },
  { 275, 6, 9, 4, -1, -9 },
  { 282, 4, 9, 4, 1, -9 },
  { 287, 5, 9, 4, -1, -9 },
  { 293, 4, 11, 3, 0, -9 },
  { 299, 2, 9, 4, 1, -9 },
  { 302, 5, 11, 3, -1, -9 },
  { 309, 5, 5, 5, 0, -9 },
  { 313, 3, 1, 3, -1, 1 },
  { 314, 1, 2, 3, 2, -9 },
  { 315, 5, 6, 5, 0, -6 },
  { 319, 4, 9, 5, 0, -9 },
  { 324, 4, 6, 3, 0, -6 },
  { 327, 5, 9, 5, 0, -9 },
  { 333, 4, 6, 4, 0, -6 },
  { 336, 6, 12, 2, -2, -9 },
  { 345, 5, 9, 5, 0, -6 },
  { 351, 4, 9, 4, 0, -9 },
  { 356, 2, 9, 2, 0, -9 },
  { 359, 4, 12, 2, -2, -9 },
  { 365, 4, 9, 4, 0, -9 },
  { 370, 2, 9, 2, 0, -9 },
  { 373, 6, 6, 7, 0, -6 },
  { 378, 4, 6, 4, 0, -6 },
  { 381, 4, 6, 4, 0, -6 },
  { 384, 5, 9, 5, -1, -6 },
  { 390, 5, 9, 5, 0, -6 },
  { 396, 3, 6, 3, 0, -6 },
  { 399, 4, 6, 3, 0, -6 },
  { 402, 3, 8, 2, 0, -8 },
  { 405, 4, 6, 4, 0, -6 },
  { 408, 3, 6, 3, 1, -6 },
  { 411, 5, 6, 6, 1, -6 },
  { 415, 5, 6, 4, -1, -6 },
  { 419, 5, 9, 4, -1, -6 },
  { 425, 3, 6, 3, 0, -6 },
  { 428, 5, 11, 4, 0, -9 },
  { 435, 1, 12, 4, 2, -9 },
  { 437, 4, 11, 4, -1, -9 },
  { 443, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC12PT7B_H_
