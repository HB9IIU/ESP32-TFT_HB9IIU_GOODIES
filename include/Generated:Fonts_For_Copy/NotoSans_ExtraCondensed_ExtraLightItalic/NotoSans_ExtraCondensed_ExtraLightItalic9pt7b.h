#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xE0, 0x57, 0x6A, 0xCC, 0x2B, 0x24, 0xF4, 0x4B, 0xAB,
  0x77, 0x70, 0x2D, 0x2F, 0xB8, 0xC0, 0x6A, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0x7C, 0x5D, 0x20, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x2E, 0xDB, 0x70,
  0xDA, 0xA0, 0x64, 0x95, 0x30, 0x64, 0xA2, 0x70, 0x24, 0xBB, 0xD0, 0x73,
  0x13, 0x80, 0x2A, 0x7B, 0x78, 0x72, 0x24, 0x48, 0x2E, 0xAB, 0x78, 0x2E,
  0xD6, 0x70, 0x88, 0x8C, 0x39, 0x10, 0xFC, 0xC5, 0xC0, 0x44, 0xA8, 0x20,
  0x7B, 0xF5, 0xDF, 0x41, 0x80, 0x25, 0xB7, 0x40, 0x75, 0x6A, 0xAE, 0x34,
  0x88, 0x88, 0xC0, 0x75, 0x99, 0xAC, 0x69, 0xC9, 0x80, 0x6B, 0xC9, 0x00,
  0x34, 0x88, 0xB9, 0xE0, 0x55, 0x79, 0xAA, 0x25, 0x25, 0x80, 0x25, 0x24,
  0x94, 0x56, 0x4C, 0xAA, 0x5A, 0xB0, 0x4D, 0x2D, 0xB6, 0xEA, 0xA0, 0x55,
  0xBB, 0xAA, 0x25, 0x99, 0x99, 0xE0, 0x6E, 0xE9, 0x00, 0x25, 0x99, 0x99,
  0xA4, 0x20, 0x6E, 0xEB, 0x40, 0x72, 0x22, 0x70, 0xEA, 0xA0, 0x55, 0x99,
  0xAE, 0xBB, 0x49, 0x00, 0xAD, 0x7D, 0x6A, 0x50, 0x32, 0x22, 0x6A, 0xEA,
  0xA0, 0x65, 0x29, 0x80, 0x69, 0x49, 0x20, 0xFC, 0x31, 0x22, 0x22, 0xE0,
  0x6E, 0x80, 0xE0, 0xC0, 0x76, 0xDE, 0x49, 0xDB, 0x78, 0x72, 0x4C, 0x11,
  0x6A, 0xAA, 0xE0, 0x77, 0x4C, 0x32, 0x24, 0x44, 0x44, 0x80, 0x76, 0xDE,
  0x70, 0x49, 0xDB, 0x68, 0x5A, 0xA0, 0x25, 0x24, 0x94, 0x49, 0xE5, 0xB0,
  0x56, 0xA8, 0x7D, 0x6B, 0x5B, 0x00, 0x76, 0xDA, 0x76, 0xDE, 0x76, 0xDF,
  0x20, 0x76, 0xDE, 0x50, 0x72, 0x48, 0x71, 0x2C, 0x5A, 0xA0, 0x76, 0xDC,
  0xEA, 0x80, 0xDD, 0xEC, 0xC0, 0xA9, 0x2C, 0x55, 0x52, 0x24, 0xC0, 0x56,
  0xC0, 0x29, 0x45, 0x30, 0xFF, 0x80, 0x32, 0x21, 0x24, 0xC0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 2, 1, -6 },
  { 4, 4, 6, 3, 0, -6 },
  { 7, 3, 8, 3, 0, -7 },
  { 10, 4, 7, 5, 0, -7 },
  { 14, 3, 7, 3, 0, -7 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 2, 3, 3, 1, -7 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 1, 2, 1, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 1, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 7, 3, 0, -7 },
  { 36, 2, 6, 3, 1, -6 },
  { 38, 3, 7, 3, 0, -7 },
  { 41, 3, 7, 3, 0, -7 },
  { 44, 3, 7, 3, 0, -7 },
  { 47, 3, 6, 3, 0, -6 },
  { 50, 3, 7, 3, 0, -7 },
  { 53, 4, 6, 3, 0, -6 },
  { 56, 3, 7, 3, 0, -7 },
  { 59, 3, 7, 3, 0, -7 },
  { 62, 1, 5, 1, 0, -5 },
  { 63, 1, 6, 2, 0, -5 },
  { 64, 3, 4, 4, 0, -5 },
  { 66, 3, 2, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -5 },
  { 69, 3, 7, 2, 0, -7 },
  { 72, 5, 7, 5, 0, -6 },
  { 77, 3, 6, 3, -1, -6 },
  { 80, 4, 6, 3, 0, -6 },
  { 83, 4, 7, 3, 0, -7 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 3, 6, 3, 0, -6 },
  { 93, 3, 6, 3, 0, -6 },
  { 96, 4, 7, 4, 0, -7 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 3, 6, 2, -1, -6 },
  { 106, 3, 8, 1, -1, -6 },
  { 109, 4, 6, 3, 0, -6 },
  { 112, 2, 6, 3, 0, -6 },
  { 114, 6, 6, 5, 0, -6 },
  { 119, 4, 6, 4, 0, -6 },
  { 122, 4, 7, 4, 0, -7 },
  { 126, 3, 6, 3, 0, -6 },
  { 129, 4, 9, 4, 0, -7 },
  { 134, 3, 6, 3, 0, -6 },
  { 137, 3, 7, 3, 0, -7 },
  { 140, 2, 6, 3, 1, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 3, 6, 3, 1, -6 },
  { 148, 5, 6, 5, 1, -6 },
  { 152, 4, 6, 3, -1, -6 },
  { 155, 2, 6, 3, 1, -6 },
  { 157, 3, 6, 3, 0, -6 },
  { 160, 3, 7, 2, 0, -6 },
  { 163, 1, 6, 3, 1, -6 },
  { 164, 4, 7, 2, -1, -6 },
  { 168, 3, 3, 4, 0, -6 },
  { 170, 3, 1, 2, -1, 0 },
  { 171, 1, 2, 2, 1, -7 },
  { 172, 3, 5, 3, 0, -5 },
  { 174, 3, 7, 3, 0, -7 },
  { 177, 3, 5, 3, 0, -5 },
  { 179, 4, 7, 3, 0, -7 },
  { 183, 3, 5, 3, 0, -5 },
  { 185, 4, 9, 2, -1, -7 },
  { 190, 3, 7, 3, 0, -5 },
  { 193, 3, 7, 3, 0, -7 },
  { 196, 2, 6, 1, 0, -6 },
  { 198, 3, 8, 2, -1, -6 },
  { 201, 3, 7, 3, 0, -7 },
  { 204, 2, 7, 1, 0, -7 },
  { 206, 5, 5, 5, 0, -5 },
  { 210, 3, 5, 3, 0, -5 },
  { 212, 3, 5, 3, 0, -5 },
  { 214, 3, 7, 3, 0, -5 },
  { 217, 3, 7, 4, 0, -5 },
  { 220, 3, 5, 2, 0, -5 },
  { 222, 3, 5, 3, 0, -5 },
  { 224, 2, 6, 2, 0, -6 },
  { 226, 3, 5, 3, 0, -5 },
  { 228, 2, 5, 3, 1, -5 },
  { 230, 4, 5, 4, 1, -5 },
  { 233, 3, 5, 3, 0, -5 },
  { 235, 4, 7, 3, -1, -5 },
  { 239, 2, 5, 2, 0, -5 },
  { 241, 3, 7, 3, 0, -6 },
  { 244, 1, 9, 3, 1, -7 },
  { 246, 4, 7, 3, -1, -6 },
  { 250, 3, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC9PT7B_H_
