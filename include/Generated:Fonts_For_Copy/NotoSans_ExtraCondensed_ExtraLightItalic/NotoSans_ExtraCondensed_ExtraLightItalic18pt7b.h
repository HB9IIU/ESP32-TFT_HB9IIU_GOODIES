#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x44, 0x00, 0x80, 0x9A, 0xAA, 0xA0, 0x0A,
  0x24, 0x48, 0xA6, 0xE4, 0x8A, 0x14, 0xFC, 0xA1, 0x44, 0x8A, 0x00, 0x08,
  0x10, 0xF9, 0x45, 0x0A, 0x0C, 0x08, 0x18, 0x50, 0xA1, 0x4F, 0x04, 0x10,
  0x00, 0x32, 0x52, 0x94, 0x94, 0x98, 0xAB, 0xB5, 0xD9, 0x29, 0x29, 0x49,
  0x4A, 0x8E, 0x18, 0x92, 0x4A, 0x28, 0xC2, 0x15, 0x96, 0x68, 0xA6, 0xE8,
  0xF8, 0x08, 0x44, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x21, 0x08, 0x10,
  0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x42, 0x21, 0x10, 0x25, 0x1E, 0xC9,
  0x00, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x29, 0x40, 0xF0, 0x80,
  0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x1C, 0x92, 0x51, 0x45, 0x14, 0x61, 0x86, 0x28, 0xA4, 0x70, 0x2E,
  0x92, 0x92, 0x4A, 0x48, 0x1E, 0x04, 0x08, 0x10, 0x20, 0x41, 0x04, 0x10,
  0x20, 0x82, 0x0F, 0x80, 0x3C, 0x10, 0x41, 0x04, 0x23, 0x02, 0x08, 0x20,
  0x82, 0xF0, 0x04, 0x10, 0xC5, 0x14, 0xA4, 0x92, 0x8B, 0xF1, 0x04, 0x10,
  0x1C, 0x82, 0x10, 0x41, 0xC0, 0x82, 0x04, 0x20, 0x82, 0xF0, 0x0E, 0x20,
  0x81, 0x04, 0x0F, 0x11, 0x22, 0x85, 0x0A, 0x24, 0x47, 0x00, 0x7C, 0x10,
  0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x80, 0x1C, 0x45, 0x0A, 0x12,
  0x45, 0x0C, 0x24, 0x89, 0x12, 0x24, 0x47, 0x00, 0x1C, 0x94, 0x51, 0x45,
  0x14, 0x4F, 0x04, 0x20, 0x84, 0xE0, 0x24, 0x00, 0x00, 0x10, 0x11, 0x00,
  0x00, 0x00, 0x24, 0x48, 0x0C, 0xC4, 0x20, 0x40, 0xC0, 0xC0, 0xFC, 0x00,
  0x00, 0xFC, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x38, 0x42, 0x10, 0x88,
  0x88, 0x42, 0x00, 0x08, 0x00, 0x0F, 0x08, 0x48, 0x24, 0x14, 0xEA, 0x95,
  0x4A, 0xA9, 0x94, 0xCA, 0xA7, 0x90, 0x08, 0x02, 0x00, 0xE0, 0x04, 0x10,
  0xC3, 0x14, 0x52, 0x4F, 0x25, 0x14, 0x61, 0x84, 0x1C, 0x44, 0x89, 0x12,
  0x28, 0x9E, 0x22, 0x44, 0x8A, 0x14, 0x4F, 0x00, 0x1E, 0x41, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x00, 0x1C, 0x44, 0x89, 0x12,
  0x28, 0x50, 0xA1, 0x42, 0x8A, 0x14, 0x4F, 0x00, 0x1E, 0x40, 0x81, 0x02,
  0x08, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x0F, 0x00, 0x1E, 0x40, 0x81, 0x02,
  0x08, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x00, 0x1F, 0x20, 0x40, 0x40,
  0x80, 0x80, 0x8A, 0x84, 0x84, 0x84, 0x84, 0x84, 0x78, 0x11, 0x21, 0x21,
  0x21, 0x21, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x84, 0x84, 0x84, 0x1C, 0x41,
  0x04, 0x10, 0x42, 0x08, 0x20, 0x84, 0x10, 0xE0, 0x04, 0x10, 0x41, 0x04,
  0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x38, 0x11, 0x22, 0x24, 0x28,
  0x28, 0x50, 0x70, 0x50, 0x50, 0x48, 0x88, 0x88, 0x88, 0x12, 0x22, 0x24,
  0x44, 0x44, 0x88, 0xF0, 0x10, 0x26, 0x0C, 0xC1, 0x98, 0x53, 0x0C, 0xA2,
  0x94, 0x52, 0x92, 0x52, 0x8A, 0x92, 0x52, 0x4C, 0x48, 0x88, 0x10, 0x98,
  0x4C, 0x46, 0x22, 0x92, 0x49, 0x24, 0x94, 0x4A, 0x25, 0x21, 0x90, 0x88,
  0x40, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC2, 0x85, 0x0A, 0x24, 0x4F,
  0x00, 0x1C, 0x44, 0x89, 0x12, 0x28, 0x92, 0x38, 0x40, 0x82, 0x04, 0x08,
  0x00, 0x1C, 0x45, 0x0A, 0x18, 0x30, 0x60, 0xC2, 0x85, 0x0A, 0x24, 0x4F,
  0x04, 0x04, 0x08, 0x1C, 0x44, 0x89, 0x12, 0x28, 0x92, 0x38, 0x50, 0x92,
  0x24, 0x48, 0x80, 0x0F, 0x10, 0x20, 0x20, 0x20, 0x10, 0x08, 0x04, 0x04,
  0x04, 0x04, 0x04, 0xF8, 0x7C, 0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x04,
  0x20, 0x80, 0x42, 0x85, 0x0A, 0x14, 0x50, 0xA1, 0x42, 0x85, 0x12, 0x24,
  0x4F, 0x00, 0x86, 0x28, 0xA2, 0x92, 0x4A, 0x28, 0xC3, 0x08, 0x20, 0x80,
  0x84, 0x30, 0x86, 0x31, 0x46, 0x28, 0xC5, 0x29, 0x25, 0x24, 0xA8, 0xA5,
  0x14, 0xA3, 0x18, 0x63, 0x08, 0x40, 0x11, 0x12, 0x12, 0x14, 0x14, 0x08,
  0x08, 0x18, 0x28, 0x28, 0x48, 0x48, 0x88, 0x86, 0x24, 0x94, 0x51, 0x86,
  0x10, 0x41, 0x04, 0x20, 0x80, 0x1F, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xF8, 0x1C, 0x42, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x38, 0xAA, 0xA5, 0x55, 0x40, 0x1C, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x08, 0x41, 0x04, 0x10, 0x42, 0x38, 0x10, 0x30,
  0xA1, 0x24, 0x58, 0x40, 0xF0, 0xE0, 0x1A, 0x4D, 0x12, 0x24, 0x48, 0xA1,
  0x44, 0x88, 0xF0, 0x10, 0x42, 0x08, 0x28, 0xD2, 0x51, 0x45, 0x14, 0x61,
  0x8B, 0xC0, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x87, 0x00, 0x01, 0x01, 0x02,
  0x02, 0x1A, 0x26, 0x44, 0x44, 0x44, 0x44, 0x84, 0x88, 0x88, 0x78, 0x18,
  0x94, 0x51, 0x59, 0x88, 0x20, 0x81, 0xC0, 0x03, 0x04, 0x08, 0x08, 0x1C,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0x40,
  0xC0, 0x1A, 0x4D, 0x12, 0x24, 0x48, 0xA1, 0x44, 0x88, 0xF0, 0x20, 0x41,
  0x1C, 0x00, 0x10, 0x42, 0x08, 0x38, 0x92, 0x51, 0x45, 0x14, 0xA2, 0x8A,
  0x20, 0x12, 0x02, 0x24, 0x44, 0x44, 0x88, 0x80, 0x04, 0x00, 0x02, 0x08,
  0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x10, 0xC0, 0x10, 0x42, 0x08,
  0x24, 0x94, 0x94, 0x71, 0x45, 0x24, 0x92, 0x40, 0x11, 0x22, 0x22, 0x44,
  0x44, 0x48, 0x88, 0x39, 0x89, 0x92, 0x45, 0x12, 0x44, 0x92, 0x24, 0x8A,
  0x22, 0x89, 0x22, 0x40, 0x38, 0x92, 0x51, 0x45, 0x14, 0xA2, 0x8A, 0x20,
  0x18, 0x94, 0x51, 0x45, 0x18, 0x62, 0x89, 0xC0, 0x14, 0x34, 0x49, 0x12,
  0x24, 0x48, 0x91, 0x44, 0xF1, 0x02, 0x08, 0x10, 0x00, 0x1A, 0x4D, 0x12,
  0x24, 0x48, 0xA1, 0x44, 0x88, 0xF0, 0x20, 0x41, 0x02, 0x00, 0x39, 0x08,
  0x84, 0x21, 0x10, 0x84, 0x00, 0x3A, 0x10, 0x84, 0x10, 0x42, 0x17, 0x00,
  0x22, 0x72, 0x44, 0x44, 0x48, 0x8E, 0x24, 0x94, 0x51, 0x45, 0x14, 0xA2,
  0x89, 0xE0, 0x8C, 0x65, 0x2A, 0x52, 0x98, 0xC4, 0x00, 0x89, 0x89, 0x99,
  0x9A, 0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x88, 0x22, 0x48, 0x50, 0xC1, 0x02,
  0x0A, 0x14, 0x49, 0x10, 0x11, 0x11, 0x11, 0x12, 0x12, 0x14, 0x14, 0x18,
  0x08, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x1C, 0x10, 0x82, 0x10, 0x42, 0x10,
  0x43, 0xC0, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x10, 0xC1, 0x04, 0x20, 0x82,
  0x08, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0C,
  0x41, 0x04, 0x20, 0x82, 0x30, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 4, 5, 5, 2, -13 },
  { 11, 7, 13, 7, 0, -13 },
  { 23, 7, 15, 6, 0, -14 },
  { 37, 8, 13, 10, 1, -13 },
  { 50, 6, 13, 6, 0, -13 },
  { 60, 1, 5, 3, 2, -13 },
  { 61, 5, 16, 4, 0, -13 },
  { 71, 5, 16, 4, -1, -13 },
  { 81, 5, 5, 6, 2, -14 },
  { 85, 6, 9, 7, 1, -11 },
  { 92, 3, 4, 3, -1, -2 },
  { 94, 4, 1, 5, 0, -5 },
  { 95, 1, 1, 3, 0, -1 },
  { 96, 8, 13, 5, -1, -13 },
  { 109, 6, 13, 6, 0, -13 },
  { 119, 3, 13, 6, 2, -13 },
  { 124, 7, 13, 6, -1, -13 },
  { 136, 6, 13, 6, 0, -13 },
  { 146, 6, 13, 6, 0, -13 },
  { 156, 6, 13, 6, 0, -13 },
  { 166, 7, 13, 6, 0, -13 },
  { 178, 6, 13, 6, 1, -13 },
  { 188, 7, 13, 6, 0, -13 },
  { 200, 6, 13, 6, 0, -13 },
  { 210, 3, 10, 3, 0, -10 },
  { 214, 4, 12, 3, -1, -10 },
  { 220, 6, 7, 7, 1, -10 },
  { 226, 6, 5, 7, 1, -9 },
  { 230, 6, 7, 7, 1, -10 },
  { 236, 5, 13, 5, 0, -13 },
  { 245, 9, 15, 9, 0, -13 },
  { 262, 6, 13, 6, -1, -13 },
  { 272, 7, 13, 7, 0, -13 },
  { 284, 7, 13, 6, 1, -13 },
  { 296, 7, 13, 8, 0, -13 },
  { 308, 7, 13, 6, 0, -13 },
  { 320, 7, 13, 6, 0, -13 },
  { 332, 8, 13, 8, 1, -13 },
  { 345, 8, 13, 8, 0, -13 },
  { 358, 6, 13, 3, -1, -13 },
  { 368, 6, 16, 3, -3, -13 },
  { 380, 8, 13, 6, 0, -13 },
  { 393, 4, 13, 6, 0, -13 },
  { 400, 11, 13, 11, 0, -13 },
  { 418, 9, 13, 9, 0, -13 },
  { 433, 7, 13, 8, 1, -13 },
  { 445, 7, 13, 7, 0, -13 },
  { 457, 7, 16, 8, 1, -13 },
  { 471, 7, 13, 7, 0, -13 },
  { 483, 8, 13, 6, -1, -13 },
  { 496, 6, 13, 5, 1, -13 },
  { 506, 7, 13, 8, 1, -13 },
  { 518, 6, 13, 6, 2, -13 },
  { 528, 11, 13, 11, 1, -13 },
  { 546, 8, 13, 6, -1, -13 },
  { 559, 6, 13, 5, 1, -13 },
  { 569, 8, 13, 6, -1, -13 },
  { 582, 6, 16, 5, 0, -13 },
  { 594, 2, 13, 6, 2, -13 },
  { 598, 6, 16, 5, -1, -13 },
  { 610, 7, 6, 7, 0, -13 },
  { 616, 4, 1, 5, -1, 1 },
  { 617, 1, 3, 4, 3, -14 },
  { 618, 7, 10, 7, 0, -10 },
  { 627, 6, 14, 7, 0, -14 },
  { 638, 5, 10, 5, 1, -10 },
  { 645, 8, 14, 7, 0, -14 },
  { 659, 6, 10, 6, 0, -10 },
  { 667, 8, 18, 3, -2, -14 },
  { 685, 7, 14, 7, 0, -10 },
  { 698, 6, 14, 7, 0, -14 },
  { 709, 4, 13, 3, 0, -13 },
  { 716, 6, 17, 3, -2, -13 },
  { 729, 6, 14, 6, 0, -14 },
  { 740, 4, 14, 3, 0, -14 },
  { 747, 10, 10, 10, 0, -10 },
  { 760, 6, 10, 7, 0, -10 },
  { 768, 6, 10, 7, 0, -10 },
  { 776, 7, 14, 7, -1, -10 },
  { 789, 7, 14, 7, 0, -10 },
  { 802, 5, 10, 4, 0, -10 },
  { 809, 5, 10, 5, 0, -10 },
  { 816, 4, 12, 3, 0, -12 },
  { 822, 6, 10, 7, 0, -10 },
  { 830, 5, 10, 5, 1, -10 },
  { 837, 8, 10, 9, 1, -10 },
  { 847, 7, 10, 5, -1, -10 },
  { 856, 8, 14, 5, -2, -10 },
  { 870, 6, 10, 4, -1, -10 },
  { 878, 6, 16, 6, 1, -13 },
  { 890, 1, 18, 6, 3, -14 },
  { 893, 6, 16, 6, -1, -13 },
  { 905, 6, 1, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC18PT7B_H_
