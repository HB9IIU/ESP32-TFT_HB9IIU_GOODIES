#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x82, 0x04, 0x08, 0x30, 0x40, 0x81, 0x06, 0x00, 0x00, 0x00, 0x01, 0x83,
  0x04, 0x00, 0x23, 0x63, 0x62, 0x42, 0x42, 0x46, 0xC4, 0x84, 0x84, 0x8C,
  0x00, 0x42, 0x01, 0x84, 0x02, 0x18, 0x04, 0x20, 0x18, 0x40, 0x21, 0x80,
  0x42, 0x01, 0x84, 0x1F, 0xFE, 0x04, 0x20, 0x18, 0x40, 0x21, 0x80, 0x42,
  0x00, 0x84, 0x03, 0x08, 0x04, 0x30, 0x08, 0x40, 0x30, 0x83, 0xFF, 0xE0,
  0x84, 0x03, 0x08, 0x04, 0x30, 0x08, 0x40, 0x30, 0x80, 0x43, 0x00, 0x84,
  0x01, 0x08, 0x06, 0x30, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x3F, 0xE0, 0xC8, 0x83, 0x10, 0x04, 0x20, 0x18, 0x80, 0x31, 0x00,
  0x62, 0x00, 0xC4, 0x00, 0x98, 0x01, 0xA0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x05, 0x80, 0x09, 0x00, 0x13, 0x00, 0x22, 0x00, 0x44, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x20, 0x08, 0xC2, 0x13, 0x07, 0xFC, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x0F, 0x01, 0x0C, 0x81, 0x8C, 0x40, 0x84,
  0x20, 0xC6, 0x10, 0x42, 0x08, 0x61, 0x04, 0x21, 0x82, 0x30, 0xC1, 0x10,
  0x41, 0x98, 0x20, 0x88, 0x10, 0x4C, 0xE8, 0x64, 0xDC, 0x26, 0xC6, 0x32,
  0x43, 0x93, 0x61, 0x71, 0x20, 0x81, 0x90, 0x40, 0x88, 0x20, 0xCC, 0x10,
  0x46, 0x18, 0x62, 0x0C, 0x21, 0x04, 0x30, 0x82, 0x10, 0x43, 0x18, 0x21,
  0x08, 0x11, 0x0C, 0x07, 0x80, 0x01, 0xE0, 0x19, 0x81, 0x8C, 0x08, 0x60,
  0x43, 0x02, 0x18, 0x10, 0x80, 0x84, 0x04, 0x60, 0x22, 0x01, 0x20, 0x0B,
  0x00, 0x70, 0x03, 0x00, 0x28, 0x02, 0x60, 0x33, 0x1B, 0x08, 0x90, 0x45,
  0x83, 0x68, 0x1A, 0x40, 0x72, 0x03, 0x10, 0x18, 0x80, 0xC4, 0x0A, 0x30,
  0x98, 0xF8, 0xC0, 0x2D, 0xA4, 0xB4, 0x90, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06,
  0x01, 0x80, 0x20, 0x18, 0x00, 0x08, 0x01, 0x00, 0xC2, 0x20, 0xC8, 0x4F,
  0xE1, 0x80, 0xD0, 0x64, 0x30, 0x80, 0x30, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF,
  0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x10, 0xC0, 0xFF, 0xF8,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x19, 0x81,
  0x04, 0x18, 0x30, 0x81, 0x8C, 0x0C, 0x40, 0x66, 0x03, 0x30, 0x19, 0x00,
  0x98, 0x04, 0xC0, 0x24, 0x01, 0x20, 0x19, 0x00, 0xD8, 0x04, 0xC0, 0x26,
  0x03, 0x20, 0x19, 0x00, 0x88, 0x04, 0x40, 0x62, 0x02, 0x10, 0x30, 0x81,
  0x06, 0x18, 0x11, 0x80, 0xF8, 0x00, 0x03, 0x0E, 0x1A, 0x36, 0xE6, 0x44,
  0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x01, 0xF8,
  0x0E, 0x38, 0x08, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xF8, 0x0E, 0x18, 0x10, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x06, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x82, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xA0, 0x02, 0x40, 0x05, 0x80, 0x13, 0x00, 0x64, 0x00,
  0x88, 0x02, 0x30, 0x0C, 0x60, 0x10, 0xC0, 0x61, 0x00, 0x82, 0x02, 0x0C,
  0x0C, 0x18, 0x10, 0x20, 0x60, 0x40, 0x80, 0x82, 0x03, 0x0F, 0xFF, 0x9F,
  0xFF, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xD8, 0x01,
  0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x82, 0x06, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x0E, 0x10, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x19, 0xE0, 0x7C, 0xC1, 0x41, 0x86, 0x02, 0x30, 0x08, 0xC0, 0x23,
  0x00, 0x8C, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x88, 0x04, 0x20, 0x30,
  0xC0, 0xC3, 0x06, 0x06, 0x30, 0x0F, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x1C, 0x60,
  0xC0, 0xC2, 0x01, 0x08, 0x04, 0x60, 0x11, 0x80, 0x46, 0x03, 0x08, 0x08,
  0x20, 0x60, 0xC3, 0x01, 0x18, 0x06, 0xC0, 0x0C, 0x00, 0xD8, 0x06, 0x30,
  0x20, 0x41, 0x81, 0x8C, 0x02, 0x20, 0x08, 0x80, 0x32, 0x00, 0xC8, 0x02,
  0x20, 0x08, 0x80, 0x63, 0x01, 0x06, 0x1C, 0x0F, 0xC0, 0x01, 0xF0, 0x1C,
  0xC0, 0x41, 0x83, 0x02, 0x18, 0x08, 0x60, 0x31, 0x00, 0xC4, 0x03, 0x30,
  0x08, 0xC0, 0x23, 0x00, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x03, 0x86,
  0x34, 0x0F, 0x90, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x3F, 0x00, 0x04, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x30, 0xC0, 0x01, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x18, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x0F, 0xC3, 0x0C, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x00, 0x3E, 0x00,
  0x1C, 0x70, 0x06, 0x03, 0x01, 0x00, 0x20, 0x60, 0x04, 0x18, 0x00, 0xC2,
  0x00, 0x18, 0xC0, 0x01, 0x10, 0x3C, 0x26, 0x18, 0x84, 0x82, 0x31, 0x90,
  0x86, 0x36, 0x10, 0x84, 0x86, 0x10, 0x90, 0x86, 0x12, 0x30, 0xC2, 0xC6,
  0x10, 0xD8, 0x82, 0x13, 0x10, 0xC2, 0x42, 0x18, 0xC8, 0x45, 0x11, 0x08,
  0xA6, 0x21, 0xE7, 0x84, 0x08, 0x40, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x2C, 0x00, 0xB0, 0x06, 0xC0,
  0x13, 0x00, 0xCC, 0x02, 0x30, 0x08, 0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x30,
  0x20, 0xC0, 0x83, 0x07, 0xFC, 0x10, 0x30, 0xC0, 0xC2, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x00, 0xCC, 0x03, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03,
  0x03, 0xF0, 0x04, 0x78, 0x18, 0x18, 0x30, 0x30, 0x60, 0x20, 0x80, 0x41,
  0x00, 0x86, 0x03, 0x0C, 0x06, 0x10, 0x08, 0x20, 0x30, 0x40, 0xC1, 0x87,
  0x03, 0xF8, 0x04, 0x1C, 0x08, 0x08, 0x10, 0x18, 0x60, 0x30, 0xC0, 0x61,
  0x00, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x30, 0x18, 0x40, 0x20, 0x80,
  0xC3, 0x0F, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xC2, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x40, 0x1F,
  0x80, 0x03, 0xE0, 0x03, 0xF8, 0x06, 0x0C, 0x06, 0x06, 0x06, 0x02, 0x04,
  0x03, 0x04, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x08, 0x03, 0x08,
  0x03, 0x18, 0x02, 0x18, 0x02, 0x10, 0x02, 0x10, 0x06, 0x30, 0x06, 0x30,
  0x04, 0x30, 0x0C, 0x20, 0x0C, 0x20, 0x08, 0x60, 0x18, 0x60, 0x10, 0x40,
  0x30, 0x40, 0x60, 0x40, 0xC0, 0xC7, 0x80, 0xFE, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0xFE, 0x04,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x07, 0xFC, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x70, 0x70,
  0x30, 0x08, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x03, 0xE1, 0x00, 0x18, 0x40, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x43, 0x00, 0x10, 0xC0, 0x0C, 0x30, 0x03, 0x04, 0x00, 0x81, 0x00,
  0x20, 0x60, 0x08, 0x0C, 0x06, 0x03, 0x81, 0x80, 0x3F, 0xC0, 0x02, 0x00,
  0x40, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x06, 0x00, 0x81, 0x00, 0x20,
  0x40, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x02, 0x00, 0x40, 0x80, 0x30, 0x20,
  0x0C, 0x18, 0x02, 0x07, 0xFF, 0x81, 0x00, 0x20, 0x40, 0x18, 0x30, 0x06,
  0x0C, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x20, 0x0C, 0x18, 0x03, 0x06,
  0x00, 0x81, 0x00, 0x20, 0x40, 0x18, 0x10, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x40, 0x03, 0xF0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x02, 0xE0, 0x3C, 0x00, 0x02, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80, 0xC0,
  0x80, 0x60, 0xC0, 0x20, 0xC0, 0x10, 0x40, 0x18, 0x60, 0x0C, 0x60, 0x04,
  0x60, 0x02, 0x20, 0x01, 0x30, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x54, 0x00,
  0x33, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x20, 0x04, 0x10, 0x02, 0x0C,
  0x03, 0x06, 0x01, 0x81, 0x00, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x30,
  0x18, 0x18, 0x04, 0x00, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x18, 0x0C, 0x04, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x1F, 0xF0,
  0x03, 0x00, 0x03, 0x03, 0x00, 0x07, 0x07, 0x00, 0x06, 0x07, 0x00, 0x0E,
  0x05, 0x00, 0x0A, 0x05, 0x00, 0x1E, 0x05, 0x00, 0x16, 0x0D, 0x00, 0x34,
  0x0D, 0x00, 0x24, 0x09, 0x80, 0x64, 0x09, 0x80, 0x4C, 0x09, 0x80, 0xCC,
  0x19, 0x80, 0x88, 0x19, 0x81, 0x88, 0x11, 0x81, 0x18, 0x11, 0x83, 0x18,
  0x30, 0x82, 0x18, 0x30, 0x86, 0x10, 0x30, 0x86, 0x10, 0x20, 0x84, 0x30,
  0x20, 0x8C, 0x30, 0x60, 0x88, 0x20, 0x60, 0x98, 0x20, 0x40, 0x90, 0x20,
  0x40, 0xB0, 0x60, 0x40, 0xA0, 0x60, 0xC0, 0xE0, 0x40, 0xC0, 0xC0, 0x40,
  0x03, 0x00, 0x60, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x80, 0x20, 0x58, 0x04,
  0x0B, 0x01, 0x81, 0x20, 0x30, 0x64, 0x04, 0x0C, 0x80, 0x81, 0x10, 0x10,
  0x23, 0x06, 0x04, 0x60, 0xC1, 0x84, 0x10, 0x30, 0x82, 0x04, 0x10, 0x40,
  0x83, 0x18, 0x30, 0x63, 0x06, 0x0C, 0x40, 0xC0, 0x88, 0x10, 0x13, 0x02,
  0x02, 0x60, 0xC0, 0x68, 0x18, 0x0D, 0x02, 0x00, 0xA0, 0x40, 0x1C, 0x08,
  0x03, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x00, 0x00, 0xFC, 0x01, 0x8E, 0x03,
  0x02, 0x06, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x10, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x02, 0x40,
  0x02, 0x40, 0x06, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x40, 0x10, 0x40, 0x30, 0x60, 0x60, 0x30,
  0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x18, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x80, 0xC1, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x10, 0x08, 0x20, 0x30,
  0x40, 0x61, 0x81, 0x83, 0x06, 0x04, 0x18, 0x0F, 0xE0, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x8E,
  0x03, 0x02, 0x06, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x10, 0x03,
  0x30, 0x03, 0x30, 0x03, 0x20, 0x03, 0x20, 0x03, 0x60, 0x03, 0x60, 0x02,
  0x40, 0x02, 0x40, 0x06, 0x40, 0x06, 0xC0, 0x04, 0xC0, 0x04, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x18, 0x40, 0x10, 0x40, 0x30, 0x60, 0x60,
  0x30, 0xC0, 0x1F, 0x80, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xE0, 0x04, 0xF0, 0x18, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x80, 0xC1, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x10,
  0x08, 0x20, 0x30, 0x40, 0x41, 0x81, 0x83, 0x06, 0x07, 0xF8, 0x0F, 0xC0,
  0x31, 0x80, 0x61, 0x00, 0xC2, 0x01, 0x04, 0x02, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x20, 0x20, 0x40, 0x40, 0x80, 0x83, 0x01, 0x86, 0x03, 0x00, 0x00,
  0xFE, 0x03, 0x87, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0xC1, 0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x04, 0x01, 0x82, 0x00, 0x83, 0x00, 0x41, 0x80, 0x20, 0x80, 0x30,
  0x40, 0x18, 0x60, 0x08, 0x30, 0x04, 0x10, 0x06, 0x08, 0x03, 0x04, 0x01,
  0x06, 0x00, 0x83, 0x00, 0x41, 0x00, 0x60, 0x80, 0x30, 0x40, 0x10, 0x60,
  0x08, 0x30, 0x0C, 0x10, 0x06, 0x08, 0x02, 0x0C, 0x01, 0x06, 0x00, 0x83,
  0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x20, 0x20, 0x18, 0x30, 0x07, 0xE0,
  0x00, 0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x06, 0xC0, 0x13, 0x00, 0xCC,
  0x02, 0x30, 0x18, 0xC0, 0x43, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0xC1, 0x83,
  0x04, 0x0C, 0x30, 0x30, 0x80, 0xC2, 0x03, 0x18, 0x0C, 0x40, 0x33, 0x00,
  0xC8, 0x03, 0x60, 0x0D, 0x80, 0x34, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x02, 0xC0, 0x38, 0x06, 0xC0,
  0x38, 0x04, 0xC0, 0x38, 0x0C, 0xC0, 0x78, 0x0C, 0xC0, 0x58, 0x08, 0xC0,
  0xD0, 0x18, 0xC0, 0x90, 0x10, 0xC0, 0x90, 0x30, 0xC1, 0x90, 0x20, 0xC1,
  0x10, 0x20, 0xC3, 0x10, 0x60, 0x82, 0x10, 0x40, 0x82, 0x10, 0xC0, 0x86,
  0x10, 0x80, 0x84, 0x10, 0x80, 0x8C, 0x11, 0x80, 0x8C, 0x11, 0x00, 0x88,
  0x13, 0x00, 0x98, 0x12, 0x00, 0x90, 0x12, 0x00, 0x90, 0x16, 0x00, 0xB0,
  0x14, 0x00, 0xA0, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x38, 0x00, 0x01, 0x01, 0x80, 0x80, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x10,
  0x60, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x10, 0x00, 0x98, 0x00, 0x48, 0x00,
  0x28, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x02, 0x80,
  0x03, 0x40, 0x01, 0x20, 0x01, 0x90, 0x00, 0x88, 0x00, 0xC4, 0x00, 0xC3,
  0x00, 0x41, 0x80, 0x60, 0xC0, 0x20, 0x60, 0x30, 0x10, 0x10, 0x08, 0x18,
  0x04, 0x00, 0xC0, 0x3C, 0x02, 0xC0, 0x64, 0x04, 0x40, 0xC4, 0x08, 0x41,
  0x84, 0x10, 0x43, 0x04, 0x20, 0x66, 0x06, 0x40, 0x6C, 0x06, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x03, 0xF8, 0x00, 0x86, 0x31, 0x84, 0x21, 0x08, 0x63, 0x18, 0x42,
  0x10, 0x86, 0x31, 0x84, 0x21, 0x08, 0x63, 0x18, 0x42, 0x10, 0x01, 0xFC,
  0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x03, 0xF0, 0x00, 0x01, 0x00,
  0x0E, 0x00, 0x28, 0x01, 0xB0, 0x04, 0x40, 0x31, 0x80, 0x86, 0x06, 0x08,
  0x10, 0x30, 0xC0, 0x42, 0x01, 0x98, 0x02, 0x40, 0x0F, 0x00, 0x30, 0xFF,
  0xFF, 0xF0, 0x8C, 0x44, 0x23, 0x03, 0xC4, 0x1D, 0xB0, 0xC3, 0x86, 0x06,
  0x10, 0x18, 0xC0, 0x62, 0x01, 0x98, 0x04, 0x60, 0x11, 0x00, 0xC4, 0x03,
  0x30, 0x08, 0xC0, 0x23, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03,
  0x0C, 0x14, 0x18, 0xD0, 0x3E, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x33, 0xC0,
  0xDB, 0x82, 0x82, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x40, 0x31, 0x00, 0xCC, 0x02, 0x30, 0x08, 0x80, 0x62, 0x01, 0x88, 0x04,
  0x60, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x10, 0xD0, 0xC2, 0x7E, 0x00, 0x03,
  0xE0, 0xE4, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x83, 0xE0, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x03, 0xCC,
  0x07, 0x6C, 0x0C, 0x38, 0x18, 0x18, 0x10, 0x18, 0x30, 0x18, 0x20, 0x18,
  0x60, 0x10, 0x60, 0x10, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x20, 0xC0, 0x20,
  0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0x40,
  0x63, 0x40, 0x3E, 0xC0, 0x03, 0xC0, 0xCC, 0x30, 0x8C, 0x13, 0x02, 0x60,
  0x48, 0x1B, 0x02, 0x40, 0xC8, 0x73, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x83, 0xF0, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xF1, 0x01, 0xDB,
  0x03, 0x0E, 0x06, 0x06, 0x04, 0x06, 0x0C, 0x06, 0x08, 0x06, 0x18, 0x04,
  0x18, 0x04, 0x10, 0x0C, 0x10, 0x0C, 0x30, 0x08, 0x30, 0x08, 0x30, 0x18,
  0x30, 0x18, 0x30, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x50, 0x18, 0xF0,
  0x0F, 0xB0, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x81, 0x80, 0xFE, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x27,
  0x83, 0x66, 0x14, 0x10, 0xC0, 0x86, 0x04, 0x20, 0x23, 0x03, 0x18, 0x18,
  0x80, 0x84, 0x04, 0x60, 0x23, 0x03, 0x10, 0x18, 0x80, 0x84, 0x04, 0x60,
  0x63, 0x03, 0x10, 0x10, 0x80, 0x84, 0x04, 0x60, 0x60, 0x03, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x0F,
  0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x30, 0xC1, 0x83, 0x0C, 0x08,
  0x20, 0x21, 0x01, 0x8C, 0x06, 0x60, 0x11, 0x00, 0x4C, 0x01, 0x70, 0x0F,
  0xC0, 0x39, 0x00, 0xC4, 0x02, 0x10, 0x08, 0x40, 0x61, 0x81, 0x86, 0x04,
  0x08, 0x10, 0x20, 0xC0, 0x83, 0x03, 0x00, 0x03, 0x03, 0x02, 0x02, 0x02,
  0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0xC0,
  0xC0, 0x0C, 0xF1, 0xE0, 0x79, 0x99, 0x82, 0x87, 0x06, 0x18, 0x18, 0x30,
  0xC1, 0x81, 0x8C, 0x0C, 0x08, 0x60, 0x60, 0x43, 0x02, 0x02, 0x10, 0x10,
  0x30, 0x81, 0x81, 0x8C, 0x0C, 0x08, 0x60, 0x40, 0x42, 0x02, 0x06, 0x10,
  0x10, 0x30, 0x81, 0x81, 0x8C, 0x0C, 0x08, 0x60, 0x40, 0x42, 0x02, 0x06,
  0x10, 0x30, 0x31, 0x81, 0x81, 0x0C, 0x0C, 0x08, 0x00, 0x0C, 0xF0, 0x6C,
  0xC2, 0x82, 0x18, 0x10, 0xC0, 0x8C, 0x04, 0x60, 0x63, 0x03, 0x10, 0x10,
  0x80, 0x8C, 0x04, 0x60, 0x62, 0x03, 0x10, 0x10, 0x80, 0x8C, 0x0C, 0x60,
  0x62, 0x02, 0x10, 0x11, 0x80, 0x8C, 0x0C, 0x00, 0x03, 0xC0, 0x66, 0x0C,
  0x31, 0x81, 0x30, 0x13, 0x01, 0x20, 0x16, 0x01, 0x60, 0x14, 0x01, 0x40,
  0x3C, 0x03, 0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC1,
  0x86, 0x30, 0x3E, 0x00, 0x01, 0x3C, 0x03, 0x66, 0x02, 0x82, 0x03, 0x83,
  0x03, 0x03, 0x06, 0x03, 0x06, 0x03, 0x06, 0x03, 0x04, 0x03, 0x04, 0x03,
  0x0C, 0x02, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x18, 0x0C,
  0x18, 0x0C, 0x18, 0x18, 0x18, 0x10, 0x14, 0x30, 0x37, 0xC0, 0x30, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0x03, 0xC4, 0x19, 0xB0, 0xC3, 0x86, 0x06, 0x10,
  0x18, 0xC0, 0x62, 0x01, 0x98, 0x04, 0x60, 0x11, 0x00, 0xC4, 0x03, 0x30,
  0x08, 0xC0, 0x23, 0x00, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03, 0x0C,
  0x14, 0x18, 0xF0, 0x3E, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0xE1, 0x34,
  0x28, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0xE0, 0x67, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x8C, 0x30, 0xFE, 0x00, 0x04, 0x18,
  0x20, 0x40, 0x87, 0xDF, 0x88, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30,
  0x40, 0x81, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x81, 0xE0, 0x18, 0x08, 0xC0,
  0xC4, 0x06, 0x20, 0x21, 0x01, 0x18, 0x18, 0xC0, 0xC4, 0x06, 0x20, 0x21,
  0x01, 0x18, 0x18, 0xC0, 0xC4, 0x04, 0x20, 0x23, 0x03, 0x18, 0x18, 0xC0,
  0xC4, 0x0C, 0x30, 0x61, 0x85, 0x07, 0xC8, 0x00, 0xC0, 0x78, 0x0F, 0x01,
  0x60, 0x6C, 0x09, 0x83, 0x30, 0x46, 0x18, 0xC2, 0x18, 0x43, 0x18, 0x62,
  0x0C, 0xC1, 0x90, 0x36, 0x06, 0x80, 0xD0, 0x1E, 0x03, 0x80, 0x70, 0x0C,
  0x00, 0xC0, 0x40, 0x70, 0x30, 0x1C, 0x0C, 0x0F, 0x03, 0x02, 0xC1, 0x41,
  0xB0, 0x50, 0x4C, 0x34, 0x13, 0x09, 0x0C, 0xC2, 0x42, 0x31, 0x11, 0x8C,
  0x44, 0x43, 0x31, 0x10, 0xC8, 0x4C, 0x32, 0x12, 0x0D, 0x04, 0x83, 0x41,
  0x40, 0xF0, 0x50, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x00, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x10, 0xC0, 0x21, 0x00, 0x46,
  0x00, 0xC8, 0x01, 0xB0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x28, 0x00, 0x90, 0x03, 0x20, 0x04, 0x60, 0x18, 0xC0, 0x60, 0x80, 0x81,
  0x03, 0x02, 0x0C, 0x06, 0x00, 0x01, 0x00, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0xC0, 0x10, 0x20, 0x06, 0x18, 0x01,
  0x84, 0x00, 0x63, 0x00, 0x18, 0x80, 0x06, 0x60, 0x01, 0x90, 0x00, 0x64,
  0x00, 0x1B, 0x00, 0x06, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x78, 0x03, 0x80, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF0, 0x06, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x10, 0x01, 0xF8, 0x1C, 0x39, 0xE0, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 28, 8, 1, -28 },
  { 26, 8, 10, 11, 4, -28 },
  { 36, 15, 28, 15, 0, -28 },
  { 89, 15, 32, 14, 0, -30 },
  { 149, 17, 28, 21, 2, -28 },
  { 209, 13, 28, 13, 0, -28 },
  { 255, 3, 10, 6, 4, -28 },
  { 259, 11, 34, 10, 1, -28 },
  { 306, 11, 34, 10, -3, -28 },
  { 353, 10, 11, 13, 5, -30 },
  { 367, 14, 18, 16, 1, -23 },
  { 399, 6, 9, 6, -2, -4 },
  { 406, 8, 1, 10, 1, -11 },
  { 407, 2, 3, 6, 1, -3 },
  { 408, 16, 28, 12, -2, -28 },
  { 464, 13, 28, 14, 1, -28 },
  { 510, 8, 28, 14, 4, -28 },
  { 538, 15, 28, 14, -1, -28 },
  { 591, 15, 28, 14, -1, -28 },
  { 644, 15, 28, 14, -1, -28 },
  { 697, 15, 28, 14, -1, -28 },
  { 750, 14, 28, 14, 1, -28 },
  { 799, 14, 28, 14, 1, -28 },
  { 848, 14, 28, 14, 0, -28 },
  { 897, 14, 28, 14, 0, -28 },
  { 946, 6, 21, 6, 0, -21 },
  { 962, 8, 26, 6, -2, -21 },
  { 988, 14, 16, 16, 1, -22 },
  { 1016, 14, 10, 16, 1, -19 },
  { 1034, 14, 16, 16, 1, -22 },
  { 1062, 11, 28, 10, 0, -28 },
  { 1101, 19, 31, 20, 1, -28 },
  { 1175, 14, 28, 13, -3, -28 },
  { 1224, 15, 28, 15, 0, -28 },
  { 1277, 16, 28, 14, 1, -28 },
  { 1333, 16, 28, 16, 0, -28 },
  { 1389, 15, 28, 13, 0, -28 },
  { 1442, 15, 28, 12, 0, -28 },
  { 1495, 18, 28, 18, 1, -28 },
  { 1558, 18, 28, 18, 0, -28 },
  { 1621, 12, 28, 7, -2, -28 },
  { 1663, 13, 35, 6, -6, -28 },
  { 1720, 17, 28, 14, 0, -28 },
  { 1780, 9, 28, 12, 0, -28 },
  { 1812, 24, 28, 23, 0, -28 },
  { 1896, 19, 28, 18, 0, -28 },
  { 1963, 16, 28, 18, 1, -28 },
  { 2019, 15, 28, 14, 0, -28 },
  { 2072, 16, 35, 18, 1, -28 },
  { 2142, 15, 28, 14, 0, -28 },
  { 2195, 16, 28, 14, -1, -28 },
  { 2251, 12, 28, 12, 3, -28 },
  { 2293, 17, 28, 17, 1, -28 },
  { 2353, 14, 28, 14, 3, -28 },
  { 2402, 24, 28, 24, 3, -28 },
  { 2486, 17, 28, 12, -2, -28 },
  { 2546, 12, 28, 12, 3, -28 },
  { 2588, 16, 28, 12, -2, -28 },
  { 2644, 14, 34, 11, -1, -28 },
  { 2704, 5, 28, 13, 4, -28 },
  { 2722, 14, 34, 11, -2, -28 },
  { 2782, 14, 14, 15, 1, -28 },
  { 2807, 10, 2, 11, -3, 3 },
  { 2810, 4, 6, 8, 6, -30 },
  { 2813, 14, 21, 15, 1, -21 },
  { 2850, 14, 30, 15, 0, -30 },
  { 2903, 11, 21, 11, 1, -21 },
  { 2932, 16, 30, 15, 1, -30 },
  { 2992, 11, 21, 13, 1, -21 },
  { 3021, 17, 39, 8, -5, -30 },
  { 3104, 16, 30, 15, -1, -21 },
  { 3164, 13, 30, 14, 0, -30 },
  { 3213, 8, 28, 6, 0, -28 },
  { 3241, 13, 37, 7, -5, -28 },
  { 3302, 14, 30, 12, 0, -30 },
  { 3355, 8, 30, 6, 0, -30 },
  { 3385, 21, 21, 22, 0, -21 },
  { 3441, 13, 21, 14, 0, -21 },
  { 3476, 12, 21, 14, 1, -21 },
  { 3508, 16, 30, 15, -2, -21 },
  { 3568, 14, 30, 15, 1, -21 },
  { 3621, 11, 21, 9, 0, -21 },
  { 3650, 12, 21, 11, -1, -21 },
  { 3682, 7, 26, 8, 1, -26 },
  { 3705, 13, 21, 14, 1, -21 },
  { 3740, 11, 21, 11, 2, -21 },
  { 3769, 18, 21, 19, 2, -21 },
  { 3817, 15, 21, 12, -2, -21 },
  { 3857, 18, 30, 12, -4, -21 },
  { 3925, 12, 21, 9, -1, -21 },
  { 3957, 14, 34, 12, 1, -28 },
  { 4017, 1, 39, 14, 6, -30 },
  { 4022, 14, 34, 12, -3, -28 },
  { 4082, 14, 4, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHTITALIC39PT7B_H_
