#ifndef _UBUNTUMONO_ITALIC65PT7B_H_
#define _UBUNTUMONO_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F,
  0x03, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x87, 0x00, 0xE0, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0x00, 0xF0, 0x07, 0xF0, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0xFF, 0x80,
  0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x1E, 0x01, 0xF0, 0x00,
  0xF8, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF0,
  0x7C, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0xC3, 0xC0, 0x00,
  0x3C, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xFC,
  0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xE0, 0x00, 0x01, 0xFF, 0xCF, 0x80, 0x00,
  0x03, 0xFF, 0x9E, 0x00, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x1F, 0x3F, 0xE0,
  0x00, 0x00, 0x7C, 0xFF, 0xC0, 0x00, 0x01, 0xF3, 0xFF, 0xC0, 0x00, 0x03,
  0xC7, 0xFF, 0x80, 0x00, 0x0F, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3C, 0x1E,
  0x00, 0x00, 0xF8, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xE0, 0x78, 0x00, 0x0F,
  0x83, 0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0x1F,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x3C,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xF0, 0x3F,
  0xF0, 0x1F, 0x07, 0xFF, 0x81, 0xE0, 0xFC, 0xF8, 0x3E, 0x1F, 0x8F, 0xC3,
  0xE3, 0xF0, 0x7E, 0x7C, 0x3E, 0x07, 0xE7, 0xC7, 0xC0, 0x3F, 0xF8, 0x7C,
  0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xF0, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x3F, 0xF0, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xFD, 0xF0, 0x7F, 0xFF,
  0x9F, 0x83, 0xFF, 0xF0, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0x7F, 0x00, 0xFC,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x01, 0x80, 0xF8, 0x08, 0xF0, 0x7C, 0x1E, 0x7E,
  0x1C, 0x3F, 0x7F, 0xCE, 0x7F, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEF, 0x80,
  0x03, 0xF7, 0xE0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x3F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0x80, 0x02, 0x00,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFC, 0x03, 0x80, 0x00, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0x0F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0x83, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3, 0xE0,
  0xF0, 0x3F, 0x3F, 0x0F, 0xC1, 0xF9, 0xF8, 0xFF, 0x0F, 0xCF, 0x87, 0xF8,
  0x7C, 0x7C, 0x3F, 0xC3, 0xE7, 0xE1, 0xFE, 0x3F, 0x3F, 0x0F, 0xE1, 0xF9,
  0xF0, 0x3F, 0x0F, 0x8F, 0x80, 0xE0, 0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xC0, 0xF8, 0x01, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x1C, 0x00, 0x3F, 0x00,
  0x40, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0x03, 0xFC, 0x00, 0xE0, 0x07,
  0xE0, 0x04, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x81, 0x00,
  0x03, 0xFC, 0x1F, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x60, 0x00, 0x7F, 0x80, 0x78, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x1F, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xFE, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFE,
  0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x81, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0xF8, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xE0, 0x3F, 0xC1, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x7E,
  0x00, 0x7F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xFF,
  0x0F, 0x80, 0x3F, 0xFF, 0x1F, 0x80, 0xFF, 0xFE, 0x1F, 0x01, 0xFF, 0xFE,
  0x1F, 0x03, 0xFF, 0xFE, 0x3F, 0x07, 0xF8, 0x3E, 0x3E, 0x0F, 0xE0, 0x3C,
  0x3E, 0x0F, 0xC0, 0x7C, 0x7E, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x00, 0x7C,
  0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x01, 0xF0,
  0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0xC3, 0xE0,
  0x7C, 0x1F, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0xE0,
  0x7C, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xC0, 0x3E, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0xC1, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0x07, 0x01, 0xFC, 0x00,
  0x04, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0x00, 0xF8, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x0F,
  0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0xFF, 0x80, 0x7E, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x07, 0x00, 0xFE, 0x00, 0x04,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x38, 0x00,
  0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x3F, 0x80, 0x00,
  0x03, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0x78, 0x0F, 0x78,
  0x01, 0xEF, 0x83, 0xCF, 0x00, 0x3C, 0xF0, 0x79, 0xE0, 0x0F, 0x9E, 0x1E,
  0x7C, 0x01, 0xE3, 0xC3, 0xCF, 0x00, 0x3C, 0x78, 0xF1, 0xE0, 0x0F, 0x8F,
  0x1E, 0x3C, 0x01, 0xF1, 0xE7, 0x87, 0x80, 0x3C, 0x3C, 0xF1, 0xF0, 0x0F,
  0x87, 0xBC, 0x3E, 0x01, 0xF0, 0xF7, 0x07, 0x80, 0x3C, 0x1F, 0xE0, 0xF0,
  0x0F, 0x83, 0xF8, 0x3E, 0x01, 0xF0, 0x7F, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0xF8, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x7F, 0x80, 0x03, 0xE0, 0x0F, 0xF0, 0x00, 0x7C, 0x01, 0xFE, 0x00,
  0x1F, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x0F, 0x80, 0x3E, 0xF0, 0x03, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x80, 0x3E, 0x3C, 0x01, 0xF0, 0x07, 0xC7, 0x80, 0x3C,
  0x00, 0xF8, 0xF8, 0x0F, 0x80, 0x1E, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xE0,
  0x3E, 0x00, 0xF8, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0xC1, 0xF0, 0x03, 0xC0,
  0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0xF0, 0x03,
  0xE0, 0x3E, 0x3E, 0x00, 0x78, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x78, 0xF8,
  0x03, 0xE0, 0x0F, 0x1E, 0x00, 0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0x00, 0x3E,
  0xF8, 0x03, 0xE0, 0x03, 0xDF, 0x00, 0x7C, 0x00, 0x7B, 0xE0, 0x0F, 0x80,
  0x0F, 0xF8, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F,
  0x80, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x0F, 0x80, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x07,
  0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7C,
  0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0x80,
  0x3E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x3F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x3E,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x0F,
  0xE0, 0x3E, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0x80,
  0x02, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x20, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x78, 0x1F, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0xFC, 0x0F, 0x80, 0x7C, 0x1F, 0x81, 0xF0, 0x0F, 0x07, 0xF0, 0x3C, 0x01,
  0xE0, 0xFF, 0x0F, 0x80, 0x7C, 0x3D, 0xE1, 0xF0, 0x0F, 0x8F, 0x3C, 0x3C,
  0x01, 0xF1, 0xE7, 0x87, 0x80, 0x3C, 0x78, 0xF1, 0xF0, 0x07, 0x8F, 0x1E,
  0x3C, 0x00, 0xF3, 0xC3, 0xC7, 0x80, 0x3E, 0x78, 0x79, 0xF0, 0x07, 0x9E,
  0x07, 0x3C, 0x00, 0xF7, 0xC0, 0xE7, 0x80, 0x1E, 0xF0, 0x1C, 0xF0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x00, 0x0F, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0x7C, 0x01,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x3C, 0x20, 0x00, 0x04,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0x07, 0x01, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x3E, 0x07, 0xF8,
  0x03, 0xE0, 0xFF, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x03, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFD, 0xF0, 0x0F, 0xFF,
  0x1F, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC7, 0xF0, 0x00,
  0x3E, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8,
  0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0xC0, 0xF8,
  0x01, 0xFE, 0x0F, 0x80, 0x3F, 0xE0, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0C, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x7F,
  0xC0, 0x1E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0xFC, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0,
  0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0xC1, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFB, 0xE0, 0x00, 0xFF, 0xF1,
  0xF8, 0x00, 0x1F, 0xE0, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFE, 0x0F, 0xF0, 0x03, 0xF1, 0xFE, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x0F, 0xE7, 0xC0, 0x03, 0xFC, 0xFC, 0x03, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x20, 0x7F, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x07,
  0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1,
  0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x08, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x30, 0x01,
  0xF8, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x00, 0xFE, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x7C, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x80, 0x03, 0xE1, 0xFC, 0x00, 0x07,
  0xCF, 0xF0, 0x00, 0x0F, 0xBF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xEF,
  0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xE0, 0x1F,
  0x80, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0x7F, 0x07,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0x81, 0xF8, 0x01, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xFE, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0xFE,
  0x03, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x7E,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x3E, 0x1F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3E, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x7F,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8,
  0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0,
  0x0F, 0x80, 0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF8, 0x1F, 0x01, 0xFE, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xF0,
  0x00, 0x7F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC0, 0x0C, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x3C, 0x03, 0xF0, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x07,
  0xE0, 0x3C, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x70, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xDF, 0x00, 0xFF, 0xF1, 0xF0, 0x03, 0xFC, 0x1E, 0x00, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x78, 0x07, 0x80, 0xF8, 0x7C, 0x07,
  0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0x81,
  0xF8, 0x1E, 0x07, 0xC1, 0xFC, 0x1F, 0x03, 0xE0, 0xFE, 0x0F, 0x81, 0xF0,
  0xFF, 0x07, 0x80, 0xF8, 0xFF, 0x87, 0xC0, 0x78, 0x79, 0xE3, 0xE0, 0x3C,
  0x78, 0xF3, 0xE0, 0x1E, 0x3C, 0x79, 0xF0, 0x0F, 0x3C, 0x3C, 0xF0, 0x07,
  0x9E, 0x1E, 0xF8, 0x07, 0xDE, 0x0F, 0x78, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x06, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x40, 0x3F, 0xE0, 0x07, 0xC3, 0xFF, 0x80, 0x3C, 0x3F, 0xFE, 0x03,
  0xE3, 0xFF, 0xFC, 0x3E, 0x3F, 0x0F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF, 0x1F,
  0x00, 0xFF, 0xF0, 0xF0, 0x01, 0xFF, 0x01, 0x80, 0x07, 0xE0, 0x00,
};

const GFXglyph UbuntuMono_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 16, 40, 33, 11, -40 },
  { 81, 19, 16, 33, 14, -44 },
  { 119, 34, 40, 33, 3, -40 },
  { 289, 30, 51, 33, 5, -45 },
  { 481, 39, 40, 33, 0, -40 },
  { 676, 28, 40, 33, 4, -40 },
  { 816, 9, 17, 33, 19, -44 },
  { 836, 25, 57, 33, 9, -46 },
  { 1015, 24, 57, 33, 4, -46 },
  { 1186, 25, 24, 33, 9, -40 },
  { 1261, 27, 29, 33, 6, -31 },
  { 1359, 14, 18, 33, 7, -9 },
  { 1391, 16, 5, 33, 11, -19 },
  { 1401, 10, 9, 33, 11, -9 },
  { 1413, 37, 56, 33, -1, -45 },
  { 1672, 29, 40, 33, 5, -40 },
  { 1817, 24, 40, 33, 6, -40 },
  { 1937, 30, 40, 33, 4, -40 },
  { 2087, 29, 40, 33, 4, -40 },
  { 2232, 30, 40, 33, 3, -40 },
  { 2382, 32, 40, 33, 4, -40 },
  { 2542, 30, 40, 33, 6, -40 },
  { 2692, 29, 40, 33, 9, -40 },
  { 2837, 30, 40, 33, 5, -40 },
  { 2987, 30, 40, 33, 5, -40 },
  { 3137, 15, 30, 33, 11, -30 },
  { 3194, 19, 39, 33, 7, -30 },
  { 3287, 29, 26, 33, 5, -30 },
  { 3382, 30, 18, 33, 4, -26 },
  { 3450, 29, 26, 33, 4, -29 },
  { 3545, 23, 40, 33, 11, -40 },
  { 3660, 32, 50, 33, 4, -41 },
  { 3860, 31, 40, 33, -1, -40 },
  { 4015, 31, 40, 33, 3, -40 },
  { 4170, 31, 40, 33, 6, -40 },
  { 4325, 32, 40, 33, 2, -40 },
  { 4485, 32, 40, 33, 5, -40 },
  { 4645, 32, 40, 33, 5, -40 },
  { 4805, 31, 40, 33, 5, -40 },
  { 4960, 36, 40, 33, 2, -40 },
  { 5140, 30, 40, 33, 5, -40 },
  { 5290, 32, 40, 33, 4, -40 },
  { 5450, 35, 40, 33, 3, -40 },
  { 5625, 23, 40, 33, 4, -40 },
  { 5740, 35, 40, 33, 1, -40 },
  { 5915, 35, 40, 33, 3, -40 },
  { 6090, 30, 40, 33, 5, -40 },
  { 6240, 31, 40, 33, 4, -40 },
  { 6395, 30, 51, 33, 5, -40 },
  { 6587, 31, 40, 33, 3, -40 },
  { 6742, 31, 40, 33, 4, -40 },
  { 6897, 28, 40, 33, 10, -40 },
  { 7037, 32, 40, 33, 5, -40 },
  { 7197, 31, 40, 33, 9, -40 },
  { 7352, 35, 40, 33, 4, -40 },
  { 7527, 39, 40, 33, 1, -40 },
  { 7722, 30, 40, 33, 10, -40 },
  { 7872, 35, 40, 33, 2, -40 },
  { 8047, 30, 56, 33, 6, -45 },
  { 8257, 10, 56, 33, 14, -45 },
  { 8327, 29, 56, 33, 2, -45 },
  { 8530, 27, 22, 33, 7, -40 },
  { 8605, 30, 5, 33, -2, 6 },
  { 8624, 11, 12, 33, 17, -45 },
  { 8641, 28, 32, 33, 5, -31 },
  { 8753, 29, 46, 33, 4, -45 },
  { 8920, 28, 32, 33, 5, -31 },
  { 9032, 33, 46, 33, 5, -45 },
  { 9222, 28, 32, 33, 5, -31 },
  { 9334, 38, 56, 33, 1, -45 },
  { 9600, 34, 42, 33, 1, -31 },
  { 9779, 28, 45, 33, 3, -45 },
  { 9937, 19, 44, 33, 9, -44 },
  { 10042, 32, 55, 33, 1, -44 },
  { 10262, 31, 45, 33, 4, -45 },
  { 10437, 17, 46, 33, 12, -45 },
  { 10535, 32, 31, 33, 2, -31 },
  { 10659, 28, 31, 33, 4, -31 },
  { 10768, 28, 32, 33, 5, -31 },
  { 10880, 32, 42, 33, 1, -31 },
  { 11048, 29, 42, 33, 5, -31 },
  { 11201, 28, 31, 33, 6, -31 },
  { 11310, 28, 32, 33, 5, -31 },
  { 11422, 24, 40, 33, 9, -39 },
  { 11542, 28, 31, 33, 5, -30 },
  { 11651, 26, 30, 33, 9, -30 },
  { 11749, 33, 30, 33, 5, -30 },
  { 11873, 34, 30, 33, 1, -30 },
  { 12001, 36, 41, 33, -1, -30 },
  { 12186, 29, 30, 33, 4, -30 },
  { 12295, 31, 56, 33, 6, -45 },
  { 12512, 19, 56, 33, 10, -45 },
  { 12645, 31, 56, 33, 0, -45 },
  { 12862, 29, 10, 33, 5, -22 },
};

const GFXfont UbuntuMono_Italic65pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic65pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic65pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UBUNTUMONO_ITALIC65PT7B_H_
