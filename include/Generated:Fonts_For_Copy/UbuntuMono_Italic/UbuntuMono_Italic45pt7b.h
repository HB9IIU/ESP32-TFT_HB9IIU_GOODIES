#ifndef _UBUNTUMONO_ITALIC45PT7B_H_
#define _UBUNTUMONO_ITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xE0, 0x38, 0x00, 0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0F,
  0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xC6, 0x06, 0x30, 0x70, 0x00, 0x0E,
  0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38,
  0x3C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x78, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE1, 0xE0, 0x01, 0xC1, 0xE0, 0x03, 0xC1,
  0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x83, 0x80, 0x07, 0x07,
  0x80, 0x0F, 0x07, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x38,
  0x00, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xE0, 0x30, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC1, 0x00, 0x3C, 0x1E, 0x07, 0xE1, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x3F, 0x80,
  0x38, 0x0F, 0xF0, 0x0E, 0x01, 0xCF, 0x03, 0x80, 0x70, 0xE0, 0xE0, 0x0E,
  0x1C, 0x3C, 0x01, 0xC3, 0x8F, 0x00, 0x30, 0x61, 0xC0, 0x0E, 0x1C, 0x70,
  0x01, 0xC3, 0x9C, 0x00, 0x1C, 0xE7, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x7F,
  0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xEF, 0xE0,
  0x00, 0x39, 0xFE, 0x00, 0x0E, 0x71, 0xC0, 0x03, 0xCE, 0x38, 0x00, 0xF3,
  0x87, 0x00, 0x1C, 0x70, 0xE0, 0x07, 0x0E, 0x1C, 0x01, 0xC1, 0xC3, 0x00,
  0x70, 0x38, 0xE0, 0x1C, 0x07, 0x3C, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x1F,
  0xC0, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x07, 0x07, 0x80, 0xE1, 0xE0, 0x1E, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0x81, 0xC3, 0xF8, 0x79, 0xF7, 0x8E, 0x3C, 0xF1, 0xCF, 0x0F, 0x7B,
  0xC0, 0xFE, 0x78, 0x1F, 0xCE, 0x01, 0xF1, 0xC0, 0x3E, 0x38, 0x07, 0xC7,
  0x81, 0xF8, 0xF8, 0x7F, 0x8F, 0xFE, 0xF1, 0xFF, 0x9E, 0x0F, 0xC1, 0xC0,
  0x3C, 0xF3, 0xCF, 0x39, 0xE7, 0x9C, 0x71, 0xC6, 0x18, 0x00, 0x02, 0x00,
  0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x61, 0xC1, 0x9E, 0x31,
  0xE7, 0xED, 0xFB, 0xFF, 0xFE, 0x3F, 0xFF, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x0F, 0x3C, 0x07, 0xCF, 0x83, 0xE1, 0xE0, 0x78, 0x70, 0x04,
  0x08, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0x83, 0xE0, 0x78, 0x3C, 0x3E, 0x3F,
  0x0F, 0x83, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3C, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE1,
  0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x8F, 0x0E,
  0x79, 0xF1, 0xE7, 0x1F, 0x9E, 0xF1, 0xF1, 0xEF, 0x1F, 0x1C, 0xF0, 0xE3,
  0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF8, 0x7C, 0x07, 0xFF, 0x80, 0x3F,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0x78, 0x1E, 0x3C, 0x04, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0xFF, 0x9F,
  0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0x83, 0xE0, 0x30, 0x0F, 0x01, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3C, 0x1F, 0x01, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC4, 0x00, 0xF8, 0xF0, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0x80, 0x0F,
  0x1C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x83, 0x80,
  0x78, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0x80, 0x70, 0x3C, 0x07,
  0x83, 0xC0, 0x3C, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x40, 0x3F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x79, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xF8, 0x1F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x0E, 0x3C, 0x00,
  0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xC0, 0x1E, 0x0F,
  0x01, 0xF0, 0x7C, 0x3F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C,
  0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E,
  0x00, 0xF0, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0xF8, 0x7C, 0x07, 0xEF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xE3, 0xF0, 0x3C, 0x0F, 0x87, 0x80, 0x78,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07,
  0x8F, 0x00, 0xF8, 0xF8, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xC3, 0xE0,
  0x78, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x87,
  0x80, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFD, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F,
  0x00, 0x78, 0x07, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x08,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFF, 0x08, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x3C, 0x1E, 0x00, 0x70, 0xF8, 0x01, 0xC3,
  0xC0, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x1F, 0xF3, 0xC1, 0xFF, 0xCF, 0x0F,
  0xFE, 0x38, 0x7C, 0x39, 0xE3, 0xC1, 0xE7, 0x8F, 0x07, 0x9C, 0x78, 0x1C,
  0x71, 0xE0, 0x73, 0xC7, 0x03, 0xCF, 0x1C, 0x0F, 0x3C, 0x70, 0x38, 0xF1,
  0xC0, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3F, 0xF0, 0xF0, 0x7F,
  0xC3, 0xC0, 0x7E, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x8E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00,
  0xF0, 0x38, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0,
  0x3C, 0x0E, 0x00, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xE0, 0x3E, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0,
  0x78, 0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x0F, 0x03, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xFC,
  0x07, 0x80, 0xF8, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0xF0, 0x70, 0x1F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFC, 0x1E, 0x07,
  0xC0, 0x10, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x40, 0x7E, 0x07, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xE0, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x70, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7,
  0x80, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1C, 0x03, 0xE0, 0xF0,
  0x7F, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFE,
  0x07, 0xC0, 0xE0, 0x78, 0x01, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xE0, 0x03,
  0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F,
  0x03, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E,
  0x07, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x08,
  0x07, 0xC0, 0x78, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x01, 0xC0, 0x1F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x03, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x87,
  0x80, 0x07, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1C, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xE0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xB0, 0x36, 0x03, 0xB0, 0x7E, 0x03, 0xB8,
  0xEE, 0x03, 0x38, 0xEE, 0x07, 0x39, 0xCE, 0x07, 0x39, 0xCE, 0x07, 0x3B,
  0x9C, 0x0E, 0x3B, 0x1C, 0x0E, 0x3F, 0x1C, 0x0E, 0x3E, 0x1C, 0x1E, 0x3E,
  0x1C, 0x1C, 0x3C, 0x3C, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x3C, 0x00,
  0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00,
  0x70, 0x70, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0E, 0x03, 0xE0,
  0x0E, 0x07, 0xE0, 0x0E, 0x07, 0x70, 0x1E, 0x07, 0x70, 0x1E, 0x07, 0x70,
  0x1C, 0x0F, 0x78, 0x1C, 0x0F, 0x38, 0x3C, 0x0E, 0x38, 0x3C, 0x0E, 0x38,
  0x38, 0x1E, 0x1C, 0x38, 0x1E, 0x1C, 0x78, 0x1C, 0x1C, 0x78, 0x1C, 0x1C,
  0x70, 0x1C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x38, 0x0E, 0xF0, 0x38, 0x0E,
  0xE0, 0x38, 0x0E, 0xE0, 0x78, 0x06, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07,
  0xC0, 0x70, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xE0, 0x03,
  0x80, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E, 0x0F,
  0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x07, 0x3C, 0x00, 0x73,
  0x80, 0x07, 0x78, 0x00, 0x77, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01,
  0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0x78, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xF0, 0x3F, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0xF0, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x1C,
  0x1E, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0xC0, 0x0E, 0x0F, 0x00, 0x78, 0x3C,
  0x03, 0xC0, 0xE0, 0x3E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7C, 0x1E, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x07,
  0x3C, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77, 0x80, 0x0F, 0x70, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEE, 0x00,
  0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0x8F, 0x00, 0x78, 0xF0,
  0x0F, 0x0F, 0x01, 0xF0, 0x78, 0x3E, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xF0, 0x3E, 0x03, 0x80, 0x78, 0x1E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x78, 0x1F, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xE0,
  0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xE0, 0x78, 0x03, 0x81, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x80,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x10, 0x01, 0xE0, 0x78, 0x0F,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0x80, 0x0E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00,
  0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x38,
  0x38, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x0F, 0x00, 0xF0, 0x3C,
  0x07, 0xC0, 0x78, 0x3E, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0x83, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x70, 0x1E,
  0x01, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x79, 0xE0, 0x01, 0xE7,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38,
  0x3C, 0x00, 0x38, 0x38, 0x38, 0x78, 0x38, 0x78, 0x70, 0x38, 0xF8, 0x70,
  0x38, 0xF8, 0x70, 0x79, 0xD8, 0xE0, 0x71, 0xD8, 0xE0, 0x73, 0x9C, 0xE0,
  0x73, 0x1C, 0xC0, 0x77, 0x1D, 0xC0, 0x6E, 0x1D, 0xC0, 0xEE, 0x1D, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xE7, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x1F, 0x00, 0x70, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xBC, 0x00,
  0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x38, 0x03, 0xC1, 0xC0, 0x1E, 0x0F,
  0x01, 0xE0, 0x78, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x0F, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x00, 0x0E, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xE3, 0xC0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1E, 0x1C, 0x0F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x39, 0xE0, 0x0F, 0x78,
  0x03, 0xFC, 0x00, 0x72, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0x20, 0x70, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x04, 0x00, 0x1F,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x0F, 0x0F, 0x80, 0xE1, 0xF0,
  0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x1C, 0x78,
  0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x0F, 0x07, 0xC3, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0x78, 0x0F, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x73, 0xF0, 0x07, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xE1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00,
  0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80,
  0x78, 0x70, 0x0F, 0x87, 0x01, 0xF0, 0xF0, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7E, 0x06, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x10, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xC3, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x70, 0x78, 0x03,
  0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x83,
  0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x3F, 0x01, 0xFF, 0xFC,
  0x03, 0xFE, 0x70, 0x07, 0xF1, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0xFC, 0x1E, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3,
  0xC0, 0x0E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x70, 0x1F, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x30, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xF8, 0x20, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xE0,
  0xE0, 0x3F, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1C,
  0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0x81,
  0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x1E,
  0x01, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F,
  0x9C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x40, 0x0F,
  0x80, 0xE0, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC3, 0xC0,
  0x38, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x07, 0x8E, 0x00,
  0xF1, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03,
  0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x0F,
  0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xF1, 0xFF, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1F,
  0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xC1,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x0F, 0x81, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x38, 0x3F,
  0x00, 0xE1, 0xF0, 0x03, 0x9F, 0x80, 0x1E, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xCF,
  0x80, 0x0E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x00,
  0x7F, 0xCF, 0xFC, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x37, 0xFF, 0x3F, 0xF0, 0xFC,
  0x01, 0xF8, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x38, 0xF9, 0xE0,
  0xF0, 0xE1, 0xC1, 0xE1, 0xC3, 0x83, 0x87, 0x87, 0x07, 0x0E, 0x0E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xF0, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3,
  0x87, 0x87, 0x87, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0x81, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x38, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x70,
  0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xCF,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xEF, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x3C, 0xE0,
  0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x78, 0x7C, 0x3F, 0x07, 0xFF, 0xC0, 0x7F,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xF0, 0x3E, 0x03, 0x80, 0x78, 0x1E, 0x00, 0xE0, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3C,
  0x1E, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x07, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x1E, 0x1F, 0x01,
  0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x00,
  0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00, 0x78, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F,
  0x83, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0x9C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x07, 0xC0, 0x40, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE1, 0x00, 0x38, 0x78, 0x1F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x0C, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x1E, 0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0,
  0x3C, 0x70, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00,
  0xF1, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x00, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xE1, 0xFC, 0x3F, 0xFF,
  0x87, 0xFE, 0xF0, 0x3F, 0x0E, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78,
  0x70, 0x1C, 0x1C, 0x0F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E,
  0x38, 0x07, 0x9E, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x71, 0xC1, 0xC1, 0xCF, 0x0F,
  0x0F, 0x3C, 0x3C, 0x38, 0xF1, 0xF0, 0xE3, 0x87, 0xC7, 0x8E, 0x3F, 0x1C,
  0x38, 0xCC, 0x70, 0xE7, 0x33, 0x83, 0xB8, 0xCE, 0x0E, 0xE3, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF9, 0xE0, 0x03,
  0xE3, 0xC0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xE0,
  0x0F, 0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0xF0,
  0x03, 0xC0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1C,
  0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0x73, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x41, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x71, 0xFE, 0x07, 0x3F, 0xF8, 0xE7, 0x8F, 0xFE, 0x70, 0x3F, 0xC6, 0x01,
  0xF0,
};

const GFXglyph UbuntuMono_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 11, 28, 23, 8, -28 },
  { 40, 13, 11, 23, 10, -31 },
  { 58, 24, 28, 23, 2, -28 },
  { 142, 21, 35, 23, 3, -31 },
  { 234, 27, 28, 23, 0, -28 },
  { 329, 19, 28, 23, 3, -28 },
  { 396, 6, 12, 23, 13, -31 },
  { 405, 17, 40, 23, 7, -32 },
  { 490, 17, 40, 23, 3, -32 },
  { 575, 18, 17, 23, 6, -28 },
  { 614, 19, 19, 23, 4, -21 },
  { 660, 10, 12, 23, 5, -6 },
  { 675, 11, 4, 23, 8, -14 },
  { 681, 6, 6, 23, 8, -6 },
  { 686, 26, 38, 23, -1, -31 },
  { 810, 20, 28, 23, 4, -28 },
  { 880, 17, 28, 23, 4, -28 },
  { 940, 21, 28, 23, 3, -28 },
  { 1014, 20, 28, 23, 3, -28 },
  { 1084, 21, 28, 23, 2, -28 },
  { 1158, 22, 28, 23, 3, -28 },
  { 1235, 21, 28, 23, 4, -28 },
  { 1309, 21, 28, 23, 6, -28 },
  { 1383, 20, 28, 23, 4, -28 },
  { 1453, 21, 28, 23, 3, -28 },
  { 1527, 10, 20, 23, 8, -20 },
  { 1552, 13, 26, 23, 5, -20 },
  { 1595, 19, 18, 23, 4, -21 },
  { 1638, 21, 11, 23, 3, -17 },
  { 1667, 20, 18, 23, 3, -20 },
  { 1712, 16, 28, 23, 7, -28 },
  { 1768, 22, 34, 23, 3, -28 },
  { 1862, 22, 28, 23, -1, -28 },
  { 1939, 22, 28, 23, 2, -28 },
  { 2016, 22, 28, 23, 4, -28 },
  { 2093, 22, 28, 23, 2, -28 },
  { 2170, 23, 28, 23, 3, -28 },
  { 2251, 23, 28, 23, 3, -28 },
  { 2332, 21, 28, 23, 4, -28 },
  { 2406, 24, 28, 23, 2, -28 },
  { 2490, 21, 28, 23, 3, -28 },
  { 2564, 22, 28, 23, 3, -28 },
  { 2641, 24, 28, 23, 2, -28 },
  { 2725, 17, 28, 23, 2, -28 },
  { 2785, 24, 28, 23, 1, -28 },
  { 2869, 24, 28, 23, 2, -28 },
  { 2953, 20, 28, 23, 4, -28 },
  { 3023, 22, 28, 23, 2, -28 },
  { 3100, 20, 35, 23, 4, -28 },
  { 3188, 22, 28, 23, 2, -28 },
  { 3265, 23, 28, 23, 2, -28 },
  { 3346, 20, 28, 23, 7, -28 },
  { 3416, 22, 28, 23, 4, -28 },
  { 3493, 22, 28, 23, 6, -28 },
  { 3570, 24, 28, 23, 3, -28 },
  { 3654, 27, 28, 23, 0, -28 },
  { 3749, 21, 28, 23, 7, -28 },
  { 3823, 24, 28, 23, 2, -28 },
  { 3907, 21, 38, 23, 4, -31 },
  { 4007, 7, 38, 23, 10, -31 },
  { 4041, 20, 38, 23, 1, -31 },
  { 4136, 18, 15, 23, 5, -28 },
  { 4170, 21, 3, 23, -1, 4 },
  { 4178, 8, 8, 23, 12, -31 },
  { 4186, 20, 23, 23, 3, -22 },
  { 4244, 20, 32, 23, 3, -31 },
  { 4324, 20, 23, 23, 3, -22 },
  { 4382, 22, 32, 23, 4, -31 },
  { 4470, 20, 23, 23, 3, -22 },
  { 4528, 27, 38, 23, 0, -31 },
  { 4657, 23, 29, 23, 1, -22 },
  { 4741, 19, 31, 23, 2, -31 },
  { 4815, 13, 30, 23, 6, -30 },
  { 4864, 22, 37, 23, 1, -30 },
  { 4966, 22, 31, 23, 3, -31 },
  { 5052, 12, 32, 23, 8, -31 },
  { 5100, 23, 22, 23, 1, -22 },
  { 5164, 19, 22, 23, 3, -22 },
  { 5217, 19, 23, 23, 4, -22 },
  { 5272, 22, 29, 23, 1, -22 },
  { 5352, 20, 29, 23, 4, -22 },
  { 5425, 19, 22, 23, 4, -22 },
  { 5478, 19, 23, 23, 4, -22 },
  { 5533, 17, 28, 23, 6, -27 },
  { 5593, 19, 22, 23, 4, -21 },
  { 5646, 18, 21, 23, 6, -21 },
  { 5694, 22, 21, 23, 4, -21 },
  { 5752, 23, 21, 23, 1, -21 },
  { 5813, 25, 28, 23, -1, -21 },
  { 5901, 20, 21, 23, 3, -21 },
  { 5954, 22, 38, 23, 4, -31 },
  { 6059, 13, 38, 23, 7, -31 },
  { 6121, 22, 38, 23, 0, -31 },
  { 6226, 20, 6, 23, 3, -15 },
};

const GFXfont UbuntuMono_Italic45pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic45pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic45pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _UBUNTUMONO_ITALIC45PT7B_H_
