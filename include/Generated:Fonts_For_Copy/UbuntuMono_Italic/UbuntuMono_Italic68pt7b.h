#ifndef _UBUNTUMONO_ITALIC68PT7B_H_
#define _UBUNTUMONO_ITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x3C, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x03,
  0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x01, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x08, 0x00, 0x03, 0xF0,
  0x1C, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFE,
  0x00, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0x01,
  0xE0, 0x78, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x1E,
  0x03, 0xE0, 0x00, 0x78, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x83, 0xE0,
  0x00, 0x1E, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x03, 0xC3, 0xE0, 0x00, 0x07,
  0x83, 0xE1, 0xF0, 0x00, 0x03, 0xE3, 0xE1, 0xF0, 0x00, 0x01, 0xFF, 0xF1,
  0xF0, 0x00, 0x00, 0xFF, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0xF1, 0xF0, 0x00,
  0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x7F, 0xF8, 0x00, 0x00,
  0x7C, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x3E,
  0x03, 0xC0, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x03, 0xE0, 0xFD, 0xF8, 0x1F,
  0x0F, 0xC7, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x8F, 0xC0, 0xFC, 0x78, 0x7C,
  0x07, 0xE7, 0xC7, 0xE0, 0x1F, 0xBE, 0x3E, 0x00, 0x7F, 0xE1, 0xF0, 0x03,
  0xFF, 0x1F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0x87, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xF8, 0x7F,
  0x00, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF,
  0xC7, 0xC1, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F,
  0x1F, 0x8F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x07, 0xC0, 0x21, 0xE0, 0xF8,
  0x3C, 0x7F, 0x0E, 0x1F, 0xCF, 0xF9, 0xCF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x01, 0xF0, 0x1F, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x7F,
  0x03, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xC0, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x1E, 0x03, 0xE3, 0xE0, 0xFC, 0x0F, 0x9F, 0x87, 0xF8, 0x7E, 0x7E,
  0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0x87, 0xE7, 0xC1, 0xFE, 0x1F, 0x3F, 0x07,
  0xF0, 0xFC, 0xFC, 0x1F, 0xC3, 0xF3, 0xF0, 0x3C, 0x0F, 0xCF, 0xC0, 0x00,
  0x3E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xBF,
  0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1E, 0x0F, 0xC0, 0x0C, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x30, 0x00, 0x7E,
  0x00, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x7F, 0x80, 0x07, 0x00, 0x3F, 0x80, 0x08, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x04, 0x00, 0x07, 0xF8, 0x1F, 0x00, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x02,
  0x00, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x00, 0xFD, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0xFF, 0x01,
  0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x7F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFB, 0xF0, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x80, 0xFF, 0x04, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x7E, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0xFE, 0x3F, 0x00, 0x7F, 0xFE, 0x1F, 0x00,
  0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0xFF, 0xC7, 0xC0,
  0xFF, 0x07, 0xC7, 0xE0, 0xFE, 0x03, 0xE3, 0xF0, 0x7E, 0x01, 0xF1, 0xF0,
  0x7E, 0x01, 0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0xFC, 0x1F, 0x00, 0x7C, 0x7E,
  0x1F, 0x80, 0x3E, 0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0x83, 0xE0, 0x0F, 0x87, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0xF8, 0x07, 0xE1,
  0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x1F, 0x80, 0xF8,
  0x3E, 0x07, 0xF0, 0xFC, 0x1F, 0x03, 0xFF, 0xFE, 0x0F, 0x80, 0xFF, 0xFE,
  0x07, 0xC0, 0x3F, 0xFF, 0x03, 0xF0, 0x0F, 0xFF, 0x81, 0xF8, 0x01, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xF0,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xF0,
  0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x01, 0xFC, 0x0F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x01,
  0xFE, 0x07, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x04,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x20, 0x03, 0xFE, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x07,
  0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F,
  0xE0, 0x1F, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x38, 0x01,
  0xFC, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x08,
  0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0xFE,
  0x00, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0x0F,
  0x78, 0x0F, 0x7C, 0x00, 0xFB, 0xC0, 0xF3, 0xC0, 0x07, 0x9F, 0x07, 0x9E,
  0x00, 0x3C, 0xF8, 0x78, 0xF0, 0x03, 0xE3, 0xC3, 0xCF, 0x80, 0x1F, 0x1E,
  0x3C, 0x7C, 0x00, 0xF0, 0xF1, 0xE3, 0xE0, 0x0F, 0x87, 0x9E, 0x1E, 0x00,
  0x7C, 0x3D, 0xF0, 0xF0, 0x03, 0xE1, 0xEF, 0x0F, 0x80, 0x3E, 0x0F, 0xF0,
  0x7C, 0x01, 0xF0, 0x7F, 0x83, 0xE0, 0x0F, 0x83, 0xF8, 0x1F, 0x00, 0x78,
  0x1F, 0xC0, 0xF0, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x7C,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x03, 0xE0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x0F,
  0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0x7C,
  0x01, 0xF3, 0xC0, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8,
  0x3E, 0x00, 0x7C, 0x07, 0x83, 0xE0, 0x0F, 0x80, 0x78, 0x3E, 0x00, 0xF8,
  0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x7C, 0x7C, 0x00, 0xF8, 0x03, 0xC7, 0xC0,
  0x1F, 0x80, 0x3C, 0x7C, 0x01, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x00, 0x3E,
  0xFC, 0x01, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0x1E, 0xF8, 0x03, 0xE0,
  0x01, 0xEF, 0x80, 0x3E, 0x00, 0x1E, 0xF8, 0x03, 0xE0, 0x01, 0xFF, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x0F,
  0xF0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F,
  0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7C,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0x08, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x08, 0x00, 0x03, 0xF8, 0x0F, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0xF8, 0x03, 0xC0, 0xFC, 0x07, 0x80, 0x3E, 0x0F, 0xF0, 0x7C,
  0x01, 0xF0, 0x7F, 0x83, 0xE0, 0x0F, 0x87, 0xFC, 0x1E, 0x00, 0x78, 0x3D,
  0xE1, 0xF0, 0x03, 0xC3, 0xEF, 0x0F, 0x80, 0x3E, 0x1E, 0x78, 0x7C, 0x01,
  0xF1, 0xE3, 0xC3, 0xC0, 0x0F, 0x8F, 0x1E, 0x3E, 0x00, 0x78, 0xF0, 0xF1,
  0xF0, 0x03, 0xCF, 0x87, 0x8F, 0x00, 0x1E, 0x78, 0x3C, 0xF8, 0x01, 0xF7,
  0xC0, 0xE7, 0xC0, 0x0F, 0x3C, 0x07, 0xBC, 0x00, 0x7B, 0xE0, 0x3D, 0xE0,
  0x03, 0xDE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0xFC,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x08,
  0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x10,
  0x03, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xC0, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x81, 0xFE, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xF0, 0x7F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF, 0x8F, 0x80, 0x0F, 0xF0, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x3E, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x80, 0xF8,
  0x03, 0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xC0,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x40, 0x3F, 0xE0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x03, 0xF0, 0x03, 0xFE,
  0x00, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFB, 0xF0,
  0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x07, 0xF8, 0x1E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xE1, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x7F, 0xCF, 0x80, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x02, 0x03, 0xFE, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x41, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0x80, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x7F,
  0x80, 0x0F, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE7, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x10, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x1F, 0x01, 0xFE,
  0x00, 0x1F, 0x83, 0xFE, 0x00, 0x0F, 0x83, 0xFE, 0x00, 0x07, 0xC7, 0xFC,
  0x00, 0x03, 0xE7, 0xFC, 0x00, 0x03, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x9F,
  0xC0, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07,
  0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x13, 0xF8,
  0x1C, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x3F,
  0xC7, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFC,
  0x03, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xFE,
  0x00, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0x80, 0xFF, 0x80, 0x3F, 0x03, 0xFC,
  0x00, 0x7C, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xBE, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xC0, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x08, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x08, 0x07, 0xF0, 0x1E, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0xFC, 0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x7F, 0xC1, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x7C, 0x03, 0xFF, 0xE3, 0xE0, 0x07, 0xF8,
  0x1E, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x7C,
  0x3E, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x1F, 0x03, 0xF8,
  0x1F, 0x07, 0xC1, 0xFE, 0x0F, 0x81, 0xF0, 0x7F, 0x83, 0xE0, 0x7C, 0x3F,
  0xE0, 0xF0, 0x1F, 0x0F, 0x7C, 0x7C, 0x07, 0xC7, 0x8F, 0x1F, 0x01, 0xF1,
  0xE3, 0xCF, 0x80, 0x7C, 0xF0, 0xF3, 0xE0, 0x1F, 0x7C, 0x3C, 0xF0, 0x07,
  0x9E, 0x0F, 0x7C, 0x01, 0xEF, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0xFF, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x1F, 0xF8, 0x00,
  0xF0, 0xFF, 0xF0, 0x07, 0xC7, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0xE1, 0xF8,
  0xF8, 0x7F, 0xFF, 0xC7, 0xC0, 0x7F, 0xFE, 0x1E, 0x00, 0xFF, 0xF0, 0xF8,
  0x00, 0xFF, 0x80, 0xC0, 0x01, 0xF8, 0x00,
};

const GFXglyph UbuntuMono_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 16, 43, 34, 12, -42 },
  { 87, 19, 17, 34, 15, -46 },
  { 128, 36, 42, 34, 3, -42 },
  { 317, 31, 54, 34, 5, -47 },
  { 527, 41, 44, 34, 0, -43 },
  { 753, 29, 44, 34, 4, -43 },
  { 913, 9, 18, 34, 20, -46 },
  { 934, 26, 59, 34, 10, -48 },
  { 1126, 26, 59, 34, 4, -48 },
  { 1318, 27, 25, 34, 9, -42 },
  { 1403, 28, 31, 34, 6, -33 },
  { 1512, 15, 18, 34, 7, -8 },
  { 1546, 16, 5, 34, 12, -20 },
  { 1556, 10, 9, 34, 12, -8 },
  { 1568, 39, 59, 34, -1, -48 },
  { 1856, 30, 44, 34, 6, -43 },
  { 2021, 25, 42, 34, 6, -42 },
  { 2153, 31, 43, 34, 5, -43 },
  { 2320, 31, 44, 34, 4, -43 },
  { 2491, 32, 42, 34, 3, -42 },
  { 2659, 33, 43, 34, 4, -42 },
  { 2837, 30, 43, 34, 7, -42 },
  { 2999, 31, 42, 34, 9, -42 },
  { 3162, 32, 44, 34, 5, -43 },
  { 3338, 31, 43, 34, 5, -43 },
  { 3505, 15, 31, 34, 12, -30 },
  { 3564, 20, 40, 34, 7, -30 },
  { 3664, 30, 27, 34, 5, -31 },
  { 3766, 32, 18, 34, 4, -27 },
  { 3838, 30, 27, 34, 4, -32 },
  { 3940, 24, 44, 34, 11, -43 },
  { 4072, 33, 52, 34, 5, -43 },
  { 4287, 33, 42, 34, -1, -42 },
  { 4461, 33, 42, 34, 3, -42 },
  { 4635, 33, 42, 34, 6, -42 },
  { 4809, 34, 42, 34, 2, -42 },
  { 4988, 34, 42, 34, 5, -42 },
  { 5167, 34, 42, 34, 5, -42 },
  { 5346, 33, 42, 34, 5, -42 },
  { 5520, 37, 42, 34, 2, -42 },
  { 5715, 32, 42, 34, 5, -42 },
  { 5883, 33, 42, 34, 5, -42 },
  { 6057, 37, 42, 34, 3, -42 },
  { 6252, 25, 42, 34, 4, -42 },
  { 6384, 37, 42, 34, 1, -42 },
  { 6579, 36, 42, 34, 3, -42 },
  { 6768, 32, 42, 34, 5, -42 },
  { 6936, 33, 42, 34, 4, -42 },
  { 7110, 32, 53, 34, 5, -42 },
  { 7322, 33, 42, 34, 3, -42 },
  { 7496, 33, 42, 34, 4, -42 },
  { 7670, 30, 42, 34, 10, -42 },
  { 7828, 33, 42, 34, 6, -42 },
  { 8002, 33, 42, 34, 9, -42 },
  { 8176, 37, 42, 34, 4, -42 },
  { 8371, 40, 42, 34, 1, -42 },
  { 8581, 32, 42, 34, 10, -42 },
  { 8749, 37, 42, 34, 2, -42 },
  { 8944, 30, 59, 34, 7, -48 },
  { 9166, 10, 59, 34, 15, -48 },
  { 9240, 30, 59, 34, 2, -48 },
  { 9462, 28, 23, 34, 7, -42 },
  { 9543, 32, 5, 34, -2, 6 },
  { 9563, 12, 12, 34, 18, -47 },
  { 9581, 30, 34, 34, 5, -33 },
  { 9709, 30, 48, 34, 4, -47 },
  { 9889, 30, 34, 34, 5, -33 },
  { 10017, 34, 48, 34, 5, -47 },
  { 10221, 29, 34, 34, 5, -33 },
  { 10345, 40, 58, 34, 1, -47 },
  { 10635, 35, 44, 34, 1, -33 },
  { 10828, 29, 47, 34, 3, -47 },
  { 10999, 20, 46, 34, 9, -46 },
  { 11114, 33, 57, 34, 1, -46 },
  { 11350, 33, 47, 34, 4, -47 },
  { 11544, 18, 48, 34, 12, -47 },
  { 11652, 34, 33, 34, 2, -33 },
  { 11793, 30, 33, 34, 4, -33 },
  { 11917, 29, 34, 34, 5, -33 },
  { 12041, 33, 44, 34, 1, -33 },
  { 12223, 31, 44, 34, 5, -33 },
  { 12394, 30, 33, 34, 6, -33 },
  { 12518, 29, 34, 34, 5, -33 },
  { 12642, 26, 43, 34, 9, -42 },
  { 12782, 29, 33, 34, 6, -32 },
  { 12902, 27, 32, 34, 9, -32 },
  { 13010, 34, 32, 34, 5, -32 },
  { 13146, 36, 32, 34, 1, -32 },
  { 13290, 37, 43, 34, -1, -32 },
  { 13489, 31, 32, 34, 4, -32 },
  { 13613, 33, 59, 34, 6, -48 },
  { 13857, 20, 59, 34, 10, -48 },
  { 14005, 33, 59, 34, 0, -48 },
  { 14249, 30, 10, 34, 5, -23 },
};

const GFXfont UbuntuMono_Italic68pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic68pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic68pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _UBUNTUMONO_ITALIC68PT7B_H_
