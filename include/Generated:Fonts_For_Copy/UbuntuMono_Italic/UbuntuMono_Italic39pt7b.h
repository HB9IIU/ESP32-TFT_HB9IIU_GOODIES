#ifndef _UBUNTUMONO_ITALIC39PT7B_H_
#define _UBUNTUMONO_ITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0x87, 0xC3, 0xE1, 0xE0, 0x70, 0xEE, 0x39, 0xC7, 0x30, 0xEE, 0x1D, 0xC3,
  0x38, 0xE6, 0x1C, 0xC3, 0x10, 0x60, 0x00, 0x38, 0x70, 0x07, 0x06, 0x00,
  0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0,
  0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1E, 0x06,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE1, 0x80, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xF8,
  0x18, 0x07, 0x38, 0x38, 0x0E, 0x38, 0x70, 0x0E, 0x38, 0xE0, 0x0C, 0x31,
  0xC0, 0x0C, 0x33, 0x80, 0x0E, 0x77, 0x00, 0x0F, 0xE6, 0x00, 0x0F, 0xEE,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0xE0, 0x00, 0xEF,
  0xF0, 0x01, 0xCE, 0x70, 0x01, 0x8C, 0x70, 0x03, 0x9C, 0x70, 0x07, 0x1C,
  0x70, 0x0E, 0x18, 0x60, 0x1C, 0x1C, 0xE0, 0x38, 0x1F, 0xE0, 0x70, 0x0F,
  0xC0, 0x60, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x3C, 0x03,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x71, 0xFC, 0x39, 0xE7, 0x18, 0xE3, 0xDC,
  0xE0, 0xEE, 0x70, 0x3E, 0x78, 0x1E, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x0F,
  0xE3, 0xFF, 0x70, 0xFF, 0x38, 0x3E, 0x1E, 0x7B, 0x9C, 0xEF, 0x73, 0x9C,
  0xC6, 0x00, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x10, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x03,
  0x0C, 0x37, 0x99, 0xEF, 0xFF, 0xCF, 0xFF, 0x01, 0xE0, 0x07, 0xE0, 0x1D,
  0xE0, 0x79, 0xE0, 0xF3, 0xC1, 0xC3, 0x81, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x80, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x0F,
  0x87, 0xE3, 0xF0, 0xF0, 0x38, 0x79, 0xF8, 0xF8, 0x70, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7B, 0xEF, 0xFE, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0xF0, 0xF0, 0xF0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03,
  0x9C, 0x71, 0xDE, 0x78, 0xEE, 0x3C, 0x77, 0x1E, 0x7B, 0x8E, 0x3B, 0xC0,
  0x1D, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x87,
  0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x0F, 0x80, 0x7E, 0x0F, 0xF8, 0x7F, 0xC1, 0xE7, 0x02, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xE0, 0xE0, 0xF0, 0x40,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0xFF,
  0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x0E, 0x0F, 0x02, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x60, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x3D,
  0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x03, 0x87, 0x01, 0xC3, 0xC0, 0xE0, 0xE0,
  0x70, 0x38, 0x3C, 0x0E, 0x0E, 0x07, 0x87, 0x01, 0xC3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x06, 0x07, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3D, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0xCF, 0x81, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x8F, 0x07, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1E, 0x0F, 0x0F, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0xC3, 0xC0, 0xFD, 0xE0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0x8F, 0x83, 0x81, 0xE1, 0xC0, 0x3C, 0xF0,
  0x0F, 0x38, 0x03, 0xCE, 0x00, 0xE3, 0xC0, 0x78, 0xF8, 0x3E, 0x1F, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3E, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x1C, 0xF0, 0x07, 0x3C,
  0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x1E, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x0F,
  0x0F, 0x87, 0xE3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC3, 0xE1, 0xF8, 0xF8, 0x38, 0x00, 0x01, 0xE0, 0x3E, 0x03,
  0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF0, 0x07,
  0x01, 0xE0, 0xFC, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01,
  0xE0, 0x00, 0x30, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x03, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0E,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x3E,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xE1, 0xFF, 0xC6, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xE0, 0xE0, 0xF0, 0x1E, 0x1C, 0x01,
  0xC7, 0x00, 0x39, 0xE0, 0x07, 0x38, 0x1F, 0xEF, 0x0F, 0xF9, 0xC3, 0xFF,
  0x38, 0xF0, 0xEF, 0x3C, 0x1D, 0xC7, 0x07, 0x38, 0xE0, 0xE7, 0x1C, 0x1C,
  0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x71, 0xFF, 0x8E, 0x1F, 0xE1,
  0xC0, 0xF8, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x03, 0x8E, 0x00, 0x70, 0xC0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x70, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x07, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x3C,
  0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x1E, 0x03,
  0x87, 0x03, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0x0E, 0x03, 0xC3,
  0x80, 0x78, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x01, 0xE7, 0x00, 0x79, 0xC0,
  0x3C, 0x70, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x70, 0xF8, 0x04, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x03, 0xC3, 0xE0, 0x70, 0x1E, 0x0E, 0x03, 0xC1, 0xC0, 0x38,
  0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7,
  0x00, 0xF0, 0xE0, 0x3E, 0x38, 0x0F, 0x87, 0x07, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xE0, 0xE0, 0xF0, 0x04, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78,
  0xE0, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x3C, 0x0F, 0x07, 0xC1, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x38, 0x0E, 0x00,
  0xE0, 0x38, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x70, 0x07, 0x03, 0xC0, 0x3C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C,
  0x0F, 0x00, 0x70, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1E,
  0x00, 0xE0, 0x70, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x20, 0x1C, 0x0F, 0x0F, 0x81, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0x80, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x78,
  0x0E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01, 0xCF,
  0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x38, 0x78,
  0x03, 0xC1, 0xC0, 0x1C, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x78,
  0x07, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0,
  0x3E, 0x1F, 0x03, 0xF0, 0xD8, 0x1B, 0x8F, 0xC0, 0xDC, 0x6E, 0x0E, 0x66,
  0x70, 0x73, 0x33, 0x03, 0x1B, 0x18, 0x38, 0xF9, 0xC1, 0xC7, 0x8E, 0x0E,
  0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x30, 0x3C, 0x03, 0x81, 0xE0, 0x1C,
  0x0F, 0x80, 0xE0, 0xFC, 0x06, 0x07, 0xE0, 0x70, 0x3B, 0x03, 0x81, 0x9C,
  0x1C, 0x1C, 0xE0, 0xE0, 0xE3, 0x0E, 0x07, 0x1C, 0x70, 0x30, 0xE3, 0x83,
  0x87, 0x1C, 0x1C, 0x19, 0xC0, 0xE0, 0xCE, 0x07, 0x07, 0x70, 0x70, 0x3B,
  0x83, 0x81, 0xF8, 0x1C, 0x07, 0xC0, 0xE0, 0x3E, 0x0E, 0x01, 0xF0, 0x70,
  0x0F, 0x03, 0x80, 0x78, 0x1C, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0,
  0x07, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x03,
  0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCF,
  0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x7C, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xF0, 0x70,
  0x1E, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0,
  0x38, 0x70, 0x0F, 0x0E, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0x71,
  0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x0F, 0x70, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07,
  0x38, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x7C, 0x1F, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0x81, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70,
  0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E, 0x07, 0xC1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xC3, 0xC0, 0x38, 0x38, 0x0F, 0x07,
  0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xE1, 0xE0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xE0,
  0x20, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x20, 0x07, 0x87, 0x03, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00,
  0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03,
  0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x0E,
  0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x78,
  0x78, 0x1E, 0x07, 0x87, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00,
  0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xCF, 0x00, 0x79,
  0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xC3, 0x87, 0x0E,
  0x3C, 0x30, 0x71, 0xE3, 0x83, 0x9F, 0x1C, 0x18, 0xD8, 0xC0, 0xCE, 0xCE,
  0x0E, 0x66, 0x70, 0x76, 0x3B, 0x03, 0xF1, 0xD8, 0x1B, 0x0F, 0xC0, 0xF8,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE7, 0x00,
  0x03, 0xC7, 0x00, 0x03, 0x87, 0x80, 0x07, 0x83, 0x80, 0x0F, 0x03, 0x80,
  0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0,
  0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x3C, 0x70, 0x0E, 0x1C,
  0x07, 0x87, 0x03, 0xC1, 0xC0, 0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x9E,
  0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3D, 0xEF, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0x9C, 0x07, 0x9C, 0x0F, 0x1C, 0x0E, 0x0E, 0x1C, 0x0E, 0x38, 0x0E,
  0x78, 0x07, 0xF0, 0x07, 0x20, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x20, 0xE1, 0xE1, 0xC1, 0xC1, 0xC1, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xE3, 0xF0, 0xE3, 0xE0, 0x71, 0xC0, 0x39, 0xE0, 0x3C, 0xE0,
  0x1C, 0xF0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xE3, 0xC1, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xCE, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xDF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0x87, 0x83, 0x80, 0xF1, 0xE0, 0x3C, 0x70, 0x0F, 0x1C,
  0x03, 0xC7, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x03,
  0xC7, 0x01, 0xE1, 0xC1, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xF0, 0x23, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x30, 0xFF, 0xF8, 0x3F, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0x83, 0x81,
  0xE0, 0x70, 0x3C, 0x07, 0x07, 0x80, 0x70, 0x70, 0x0F, 0x07, 0x00, 0xE0,
  0xF0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xF0, 0x1C,
  0x07, 0x87, 0xC0, 0x7F, 0xFC, 0x03, 0xFE, 0xE0, 0x1F, 0x8E, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D,
  0xC0, 0x3D, 0xE0, 0x7E, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x30, 0xFF, 0xF8, 0x3F, 0xFC, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x0E, 0x07,
  0x80, 0xE0, 0xF0, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1,
  0xC0, 0x38, 0x3C, 0x03, 0x83, 0xC0, 0x38, 0x3C, 0x03, 0x81, 0xE0, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x60, 0x7C, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x7E, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xE0, 0xF0, 0xE0, 0x38, 0x70, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xE3, 0x80, 0x71,
  0xC0, 0x38, 0xE0, 0x3C, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x87, 0xF8, 0xFF, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0x0F,
  0xF0, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x06, 0x0F, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x03, 0xC0, 0xE1,
  0xE0, 0x1C, 0x78, 0x07, 0x9E, 0x00, 0xEF, 0x80, 0x1F, 0xE0, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0x8F, 0x00, 0x70, 0xF0, 0x0E, 0x0E,
  0x03, 0xC1, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x3C, 0x00, 0x7F,
  0xBF, 0xEF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xE1, 0x7F, 0xCF, 0xF1, 0xF8, 0x03, 0xE3, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x1C, 0x70, 0xE3, 0x8E, 0x38, 0x71, 0xC7,
  0x0C, 0x38, 0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x0E, 0x38, 0xE3, 0x87, 0x1C,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60,
  0x07, 0x1C, 0x00, 0xE0, 0x01, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xC0,
  0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E,
  0x03, 0xCF, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x79, 0xE0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xE1, 0xE3, 0xC0, 0x79, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F,
  0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xEE, 0x01, 0xE7, 0x81,
  0xF1, 0xE1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xE0, 0x70, 0x1E, 0x1E, 0x03,
  0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07,
  0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x70, 0x1E, 0x0E, 0x0F, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xE0,
  0x7F, 0xF8, 0x7E, 0x0E, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0x71, 0xC0,
  0x1C, 0x70, 0x0F, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E,
  0x3C, 0x07, 0x07, 0x87, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xEE, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xE0,
  0x60, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE1, 0x80, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC1, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xF0, 0x1C, 0x03, 0x8E, 0x03, 0xCF, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x79, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x0F, 0x3C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xE1, 0xC1, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xCF, 0x00, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x1C, 0xF0, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0x70, 0xE0, 0x71, 0xC0, 0x7B, 0x80, 0x3B, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x71, 0xE3,
  0x87, 0x1E, 0x38, 0x63, 0x63, 0x0E, 0x76, 0x70, 0xE6, 0x67, 0x0E, 0xE6,
  0xE0, 0xEC, 0x6E, 0x0F, 0xC6, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0,
  0x78, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x78, 0x1E, 0x03, 0x83, 0xC0,
  0x3C, 0x38, 0x01, 0xC7, 0x00, 0x1E, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0x9C,
  0x00, 0xF1, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x0F, 0x00,
  0x70, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x1E,
  0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01,
  0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xF7,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x43, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x01, 0x9F, 0xC1, 0xDF, 0xF1, 0xCE, 0x3F, 0xEE, 0x0F, 0xE2, 0x01,
  0xE0,
};

const GFXglyph UbuntuMono_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 24, 20, 7, -24 },
  { 28, 11, 10, 20, 9, -24 },
  { 42, 20, 24, 20, 2, -24 },
  { 102, 18, 31, 20, 3, -27 },
  { 172, 24, 24, 20, 0, -24 },
  { 244, 17, 24, 20, 2, -24 },
  { 295, 5, 10, 20, 12, -26 },
  { 302, 14, 34, 20, 6, -27 },
  { 362, 15, 34, 20, 2, -27 },
  { 426, 15, 14, 20, 5, -24 },
  { 453, 17, 17, 20, 3, -19 },
  { 490, 9, 10, 20, 4, -5 },
  { 502, 9, 3, 20, 7, -11 },
  { 506, 6, 5, 20, 7, -5 },
  { 510, 23, 33, 20, -1, -27 },
  { 605, 17, 24, 20, 3, -24 },
  { 656, 14, 24, 20, 4, -24 },
  { 698, 17, 24, 20, 3, -24 },
  { 749, 18, 24, 20, 2, -24 },
  { 803, 18, 24, 20, 2, -24 },
  { 857, 19, 24, 20, 2, -24 },
  { 914, 17, 24, 20, 4, -24 },
  { 965, 18, 24, 20, 5, -24 },
  { 1019, 18, 24, 20, 3, -24 },
  { 1073, 18, 24, 20, 3, -24 },
  { 1127, 9, 18, 20, 7, -18 },
  { 1148, 12, 23, 20, 4, -18 },
  { 1183, 17, 15, 20, 3, -17 },
  { 1215, 19, 11, 20, 2, -16 },
  { 1242, 18, 15, 20, 2, -18 },
  { 1276, 14, 24, 20, 6, -24 },
  { 1318, 19, 29, 20, 3, -24 },
  { 1387, 19, 24, 20, -1, -24 },
  { 1444, 18, 24, 20, 2, -24 },
  { 1498, 19, 24, 20, 3, -24 },
  { 1555, 19, 24, 20, 1, -24 },
  { 1612, 19, 24, 20, 3, -24 },
  { 1669, 19, 24, 20, 3, -24 },
  { 1726, 19, 24, 20, 3, -24 },
  { 1783, 22, 24, 20, 1, -24 },
  { 1849, 18, 24, 20, 3, -24 },
  { 1903, 19, 24, 20, 3, -24 },
  { 1960, 21, 24, 20, 2, -24 },
  { 2023, 14, 24, 20, 2, -24 },
  { 2065, 21, 24, 20, 1, -24 },
  { 2128, 21, 24, 20, 2, -24 },
  { 2191, 18, 24, 20, 3, -24 },
  { 2245, 19, 24, 20, 2, -24 },
  { 2302, 18, 30, 20, 3, -24 },
  { 2370, 19, 24, 20, 2, -24 },
  { 2427, 19, 24, 20, 2, -24 },
  { 2484, 17, 24, 20, 6, -24 },
  { 2535, 19, 24, 20, 3, -24 },
  { 2592, 19, 24, 20, 5, -24 },
  { 2649, 21, 24, 20, 2, -24 },
  { 2712, 24, 24, 20, 0, -24 },
  { 2784, 18, 24, 20, 6, -24 },
  { 2838, 21, 24, 20, 1, -24 },
  { 2901, 17, 33, 20, 4, -27 },
  { 2972, 5, 33, 20, 9, -27 },
  { 2993, 17, 33, 20, 1, -27 },
  { 3064, 16, 13, 20, 4, -24 },
  { 3090, 18, 3, 20, -1, 4 },
  { 3097, 7, 7, 20, 10, -27 },
  { 3104, 17, 18, 20, 3, -18 },
  { 3143, 18, 27, 20, 2, -27 },
  { 3204, 17, 18, 20, 3, -18 },
  { 3243, 20, 27, 20, 3, -27 },
  { 3311, 17, 18, 20, 3, -18 },
  { 3350, 23, 33, 20, 0, -27 },
  { 3445, 20, 24, 20, 1, -18 },
  { 3505, 17, 27, 20, 2, -27 },
  { 3563, 12, 26, 20, 5, -26 },
  { 3602, 19, 32, 20, 1, -26 },
  { 3678, 19, 27, 20, 2, -27 },
  { 3743, 10, 27, 20, 7, -27 },
  { 3777, 19, 18, 20, 1, -18 },
  { 3820, 17, 18, 20, 2, -18 },
  { 3859, 17, 18, 20, 3, -18 },
  { 3898, 19, 24, 20, 1, -18 },
  { 3955, 18, 24, 20, 3, -18 },
  { 4009, 17, 18, 20, 3, -18 },
  { 4048, 17, 18, 20, 3, -18 },
  { 4087, 15, 24, 20, 5, -24 },
  { 4132, 17, 18, 20, 3, -18 },
  { 4171, 16, 18, 20, 5, -18 },
  { 4207, 20, 18, 20, 3, -18 },
  { 4252, 20, 18, 20, 1, -18 },
  { 4297, 22, 24, 20, -1, -18 },
  { 4363, 18, 18, 20, 2, -18 },
  { 4404, 19, 33, 20, 3, -27 },
  { 4483, 11, 33, 20, 6, -27 },
  { 4529, 19, 33, 20, 0, -27 },
  { 4608, 17, 6, 20, 3, -16 },
};

const GFXfont UbuntuMono_Italic39pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic39pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic39pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _UBUNTUMONO_ITALIC39PT7B_H_
