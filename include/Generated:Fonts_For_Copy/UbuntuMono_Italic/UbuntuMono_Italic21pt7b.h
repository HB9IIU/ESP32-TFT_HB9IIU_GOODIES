#ifndef _UBUNTUMONO_ITALIC21PT7B_H_
#define _UBUNTUMONO_ITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0x8C, 0x63, 0x11, 0x8C, 0x00, 0x31, 0x8C, 0x00, 0xCB, 0x29,
  0xA6, 0x90, 0x06, 0x60, 0x88, 0x33, 0x3F, 0xF7, 0xFE, 0x33, 0x04, 0x41,
  0x98, 0xFF, 0xDF, 0xF1, 0x98, 0x26, 0x0C, 0xC0, 0x01, 0x00, 0xC0, 0x78,
  0x7F, 0x18, 0x44, 0x01, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x18, 0x06, 0x43,
  0x9F, 0xC3, 0xE0, 0x60, 0x10, 0x00, 0x0C, 0x10, 0xF1, 0x0D, 0x98, 0x4D,
  0x82, 0x78, 0x1F, 0x80, 0x6F, 0x00, 0xBC, 0x0B, 0x60, 0xD3, 0x0C, 0x90,
  0xC7, 0x84, 0x38, 0x00, 0x0F, 0x0F, 0xC6, 0x62, 0x21, 0x30, 0xF0, 0xE2,
  0xDB, 0x47, 0x61, 0xB1, 0xDF, 0xA7, 0x98, 0x6D, 0x2D, 0x80, 0x01, 0x07,
  0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x30, 0x20, 0x04, 0x0C, 0x06, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0xE0, 0x40,
  0x18, 0x18, 0xDB, 0xFF, 0x3C, 0x3C, 0x66, 0x24, 0x0C, 0x06, 0x03, 0x01,
  0x0F, 0xF0, 0xC0, 0x40, 0x20, 0x30, 0x00, 0x31, 0xCE, 0x23, 0x60, 0xFF,
  0x80, 0xDF, 0x00, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x0F, 0xCC, 0x6C, 0x36, 0x1E,
  0x4F, 0x77, 0xB2, 0xC3, 0x61, 0xB1, 0x9F, 0x87, 0x80, 0x02, 0x06, 0x1E,
  0x36, 0x24, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0xFE, 0xFE, 0x0F, 0x87,
  0xF1, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0x87, 0xF1, 0x0C, 0x03, 0x01, 0x83, 0xC0, 0xF0,
  0x06, 0x01, 0x80, 0x64, 0x3B, 0xFC, 0x7C, 0x00, 0x01, 0xC0, 0xE0, 0x78,
  0x36, 0x19, 0x8C, 0x42, 0x31, 0x0C, 0xFF, 0xBF, 0xE0, 0x20, 0x18, 0x06,
  0x00, 0x0F, 0xC1, 0xF8, 0x30, 0x04, 0x01, 0x80, 0x3C, 0x07, 0xC0, 0x1C,
  0x01, 0x80, 0x31, 0x0C, 0x7F, 0x87, 0xC0, 0x03, 0x83, 0xE1, 0xC0, 0xC0,
  0x60, 0x1F, 0x8F, 0xF3, 0x0C, 0xC1, 0x30, 0xCC, 0x71, 0xF8, 0x7C, 0x00,
  0x7F, 0xBF, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x00, 0x0F, 0x1F, 0xCC, 0x64, 0x12, 0x19, 0xF8, 0x78, 0xCE,
  0xC3, 0x41, 0xB1, 0xDF, 0xC7, 0xC0, 0x1F, 0x1F, 0xDC, 0x6C, 0x16, 0x1B,
  0x0D, 0xFE, 0x7F, 0x03, 0x03, 0x07, 0x9F, 0x0E, 0x00, 0x37, 0x30, 0x00,
  0x0C, 0xEC, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x0C, 0x38, 0xE1, 0x0C, 0xC0,
  0x00, 0x83, 0xC7, 0x9F, 0x0C, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x20, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0x81, 0xE3, 0xC3, 0xC0, 0xC0, 0x00, 0x1E, 0x3F, 0x23, 0x03, 0x06, 0x0C,
  0x10, 0x20, 0x00, 0x00, 0x60, 0xE0, 0x60, 0x07, 0x81, 0xF8, 0x71, 0x98,
  0x33, 0x06, 0xC7, 0xD9, 0xF2, 0x66, 0x48, 0xD9, 0x13, 0x3E, 0x23, 0xC4,
  0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0xE0, 0x68, 0x12, 0x0C, 0x82,
  0x21, 0x8C, 0x43, 0x3F, 0xCF, 0xF6, 0x0F, 0x03, 0xC0, 0xC0, 0x1F, 0x87,
  0xF3, 0x0C, 0xC3, 0x31, 0x8F, 0xC7, 0xF1, 0x86, 0x61, 0x90, 0x64, 0x3B,
  0xFC, 0xFC, 0x00, 0x0F, 0x87, 0xF3, 0x85, 0x80, 0x60, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0E, 0x21, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0xE3, 0x1C,
  0xC3, 0x30, 0xC8, 0x36, 0x0D, 0x83, 0x41, 0x90, 0xEC, 0x73, 0xF8, 0xF8,
  0x00, 0x0F, 0xE3, 0xFC, 0x60, 0x0C, 0x01, 0x00, 0x7F, 0x0F, 0xE1, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xE3, 0xFC, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0F, 0xE1, 0xFC, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x0F, 0x87, 0xF3, 0x09, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x04, 0x83,
  0x30, 0xCC, 0x33, 0xF8, 0x3E, 0x00, 0x10, 0x62, 0x0C, 0xC1, 0x98, 0x62,
  0x0C, 0x7F, 0x9F, 0xF3, 0x04, 0x61, 0x88, 0x33, 0x06, 0x60, 0x8C, 0x30,
  0x0F, 0xC7, 0xF0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02,
  0x01, 0x81, 0xFC, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x03, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x61, 0x1C, 0x7F, 0x03, 0xC0, 0x18,
  0x62, 0x18, 0xC6, 0x19, 0x83, 0x60, 0x78, 0x1E, 0x03, 0x60, 0x66, 0x0C,
  0xC1, 0x0C, 0x61, 0x8C, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x40, 0x7F, 0xFF, 0x0C, 0x30, 0xC7, 0x0C, 0x61, 0xCA,
  0x14, 0xA1, 0x52, 0x37, 0x62, 0x66, 0x20, 0x46, 0x04, 0x60, 0xC4, 0x0C,
  0x40, 0xC0, 0x18, 0x63, 0x0C, 0xE1, 0x9E, 0x22, 0xC4, 0x49, 0x99, 0x33,
  0x34, 0x46, 0x88, 0x73, 0x0E, 0x61, 0x8C, 0x30, 0x0F, 0x1F, 0xCC, 0x6C,
  0x14, 0x0E, 0x07, 0x07, 0x83, 0x81, 0x41, 0xB1, 0x9F, 0xC7, 0x80, 0x1F,
  0x87, 0xF1, 0x8C, 0xC1, 0x30, 0x4C, 0x32, 0x1D, 0xFE, 0x7E, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x00, 0x0F, 0x1F, 0xCC, 0x6C, 0x14, 0x0E, 0x07, 0x07,
  0x83, 0x81, 0x41, 0xB1, 0x9F, 0xC7, 0x81, 0x80, 0xF0, 0x18, 0x1F, 0x87,
  0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0x36, 0x19, 0xFE, 0x6E, 0x19, 0x84, 0x33,
  0x0C, 0xC1, 0x00, 0x07, 0x87, 0xF1, 0x84, 0x40, 0x18, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0x80, 0x64, 0x3B, 0xFC, 0x7E, 0x00, 0xFF, 0xFF, 0xC2, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x00, 0x20,
  0xD8, 0x36, 0x09, 0x86, 0x41, 0xB0, 0x6C, 0x13, 0x0C, 0x83, 0x20, 0xCC,
  0x63, 0xF8, 0x78, 0x00, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31, 0x8C,
  0x63, 0x30, 0xC8, 0x36, 0x0D, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x23, 0x02,
  0x30, 0x62, 0x06, 0x20, 0x46, 0x6C, 0x6E, 0xC4, 0xE8, 0x52, 0x87, 0x38,
  0x63, 0x0E, 0x30, 0xC3, 0x00, 0x0C, 0x30, 0x61, 0x81, 0x18, 0x0D, 0x80,
  0x78, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0xCC, 0x0C, 0x20, 0xC1,
  0x86, 0x0C, 0x00, 0xC0, 0xF0, 0x64, 0x11, 0x0C, 0x66, 0x1B, 0x02, 0x80,
  0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x00, 0x1F, 0xE3, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0x87, 0xC3, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0xF8, 0x7C, 0x00, 0x93,
  0x6D, 0xB6, 0xDB, 0x24, 0x9B, 0x6C, 0x0F, 0x87, 0xC0, 0x40, 0x20, 0x30,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0xF8, 0x7C, 0x00, 0x06, 0x07, 0x06, 0xC6, 0x63, 0x13, 0x0D, 0x06, 0x7F,
  0xC0, 0x46, 0x31, 0x0F, 0xC7, 0xE3, 0x89, 0x86, 0x61, 0x90, 0x4C, 0x11,
  0x8C, 0x7F, 0x0F, 0x40, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0F, 0xC3,
  0xF8, 0xC7, 0x30, 0xC8, 0x36, 0x19, 0x86, 0x47, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE3, 0x81, 0x80, 0x60, 0x10, 0x0C, 0x01, 0x84, 0x7F, 0x0F, 0x80,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x83, 0xE3, 0xF9, 0xC6, 0xC1, 0xB0,
  0xE8, 0x32, 0x0C, 0xC7, 0x3F, 0xC7, 0xB0, 0x0F, 0x8F, 0xE3, 0x0D, 0x86,
  0x7F, 0x9F, 0x8C, 0x01, 0x84, 0x7F, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80,
  0xE0, 0x06, 0x00, 0x30, 0x07, 0xF0, 0x7F, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x03, 0xE1, 0xFC, 0x71, 0x8C, 0x23, 0x04, 0x61, 0x8C, 0x31,
  0x86, 0x3F, 0x83, 0xF0, 0x06, 0x3F, 0x87, 0xE0, 0x18, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0xF8, 0xFE, 0x63, 0x61, 0xB0, 0xD8, 0x6C, 0x24, 0x36, 0x1B,
  0x0C, 0x18, 0x61, 0x80, 0x03, 0xEF, 0x0C, 0x30, 0xC2, 0x18, 0x60, 0xF3,
  0xC0, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x7E,
  0x0F, 0x00, 0x08, 0x06, 0x01, 0x80, 0x60, 0x10, 0x04, 0x33, 0x18, 0xDC,
  0x2C, 0x0E, 0x06, 0xC1, 0x98, 0x66, 0x10, 0xCC, 0x30, 0xFF, 0x8C, 0x63,
  0x11, 0x8C, 0x62, 0x31, 0x8C, 0xFD, 0xE0, 0x3F, 0x8F, 0xF6, 0x4D, 0x93,
  0x6C, 0xD3, 0x2C, 0x1B, 0x06, 0xC1, 0xA0, 0x40, 0x1F, 0x1F, 0xCC, 0x66,
  0x12, 0x0B, 0x0D, 0x86, 0xC3, 0x41, 0x61, 0x80, 0x1E, 0x1F, 0x98, 0xF8,
  0x3C, 0x1C, 0x0A, 0x0D, 0x8C, 0xFE, 0x3C, 0x00, 0x0F, 0x83, 0xF8, 0x63,
  0x8C, 0x33, 0x06, 0x60, 0x8C, 0x31, 0x0C, 0x7F, 0x0F, 0xC1, 0x80, 0x20,
  0x0C, 0x00, 0x0F, 0x9F, 0xDC, 0x78, 0x2C, 0x34, 0x1A, 0x0D, 0x8C, 0xFE,
  0x3F, 0x01, 0x01, 0x80, 0xC0, 0x1F, 0x9F, 0xC8, 0x0C, 0x06, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x00, 0x1F, 0x1F, 0x88, 0x46, 0x03, 0xC0, 0xF0,
  0x19, 0x0C, 0xFE, 0x3E, 0x00, 0x18, 0x10, 0x30, 0xFF, 0xFF, 0x30, 0x60,
  0x60, 0x60, 0x40, 0x60, 0x7C, 0x3C, 0x61, 0xB0, 0x90, 0xD8, 0x6C, 0x36,
  0x12, 0x19, 0x8C, 0xFE, 0x3D, 0x00, 0xC3, 0xC3, 0xC6, 0xC6, 0xC4, 0xCC,
  0xD8, 0x50, 0x70, 0x60, 0xC0, 0xF0, 0x3C, 0x8B, 0x66, 0x9D, 0xAF, 0x4A,
  0xF3, 0x98, 0xC6, 0x21, 0x80, 0x18, 0x61, 0x18, 0x32, 0x02, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0xC8, 0x31, 0x8C, 0x30, 0x18, 0x63, 0x0C, 0x61, 0x0C,
  0x61, 0x88, 0x13, 0x03, 0x40, 0x78, 0x0E, 0x01, 0x80, 0x70, 0x7C, 0x0E,
  0x00, 0x1F, 0xC7, 0xE0, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF,
  0x3F, 0xC0, 0x03, 0xC1, 0xF0, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60,
  0xF0, 0x38, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x7C, 0x0F,
  0x00, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x08, 0x21, 0x86,
  0x10, 0x43, 0x00, 0x0F, 0x03, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x03, 0xC0, 0x70, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0xF8,
  0x3C, 0x00, 0x71, 0xFC, 0xF7, 0xD0, 0xC0,
};

const GFXglyph UbuntuMono_Italic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 4, -13 },
  { 10, 6, 5, 11, 5, -13 },
  { 14, 11, 13, 11, 1, -13 },
  { 32, 10, 17, 11, 1, -15 },
  { 54, 13, 13, 11, 0, -13 },
  { 76, 9, 13, 11, 1, -13 },
  { 91, 3, 6, 11, 6, -14 },
  { 94, 8, 19, 11, 3, -15 },
  { 113, 8, 19, 11, 1, -15 },
  { 132, 8, 8, 11, 3, -13 },
  { 140, 9, 9, 11, 2, -10 },
  { 151, 5, 6, 11, 2, -3 },
  { 155, 5, 2, 11, 4, -7 },
  { 157, 3, 3, 11, 4, -3 },
  { 159, 12, 18, 11, 0, -15 },
  { 186, 9, 13, 11, 2, -13 },
  { 201, 8, 13, 11, 2, -13 },
  { 214, 10, 13, 11, 1, -13 },
  { 231, 10, 13, 11, 1, -13 },
  { 248, 10, 13, 11, 1, -13 },
  { 265, 11, 13, 11, 1, -13 },
  { 283, 10, 13, 11, 2, -13 },
  { 300, 9, 13, 11, 3, -13 },
  { 315, 9, 13, 11, 2, -13 },
  { 330, 9, 13, 11, 2, -13 },
  { 345, 4, 10, 11, 4, -10 },
  { 350, 6, 13, 11, 2, -10 },
  { 360, 9, 9, 11, 2, -10 },
  { 371, 10, 5, 11, 1, -8 },
  { 378, 10, 9, 11, 1, -10 },
  { 390, 8, 13, 11, 3, -13 },
  { 403, 11, 16, 11, 1, -13 },
  { 425, 10, 13, 11, 0, -13 },
  { 442, 10, 13, 11, 1, -13 },
  { 459, 10, 13, 11, 2, -13 },
  { 476, 10, 13, 11, 1, -13 },
  { 493, 11, 13, 11, 1, -13 },
  { 511, 11, 13, 11, 1, -13 },
  { 529, 10, 13, 11, 2, -13 },
  { 546, 11, 13, 11, 1, -13 },
  { 564, 10, 13, 11, 1, -13 },
  { 581, 11, 13, 11, 1, -13 },
  { 599, 11, 13, 11, 1, -13 },
  { 617, 8, 13, 11, 1, -13 },
  { 630, 12, 13, 11, 0, -13 },
  { 650, 11, 13, 11, 1, -13 },
  { 668, 9, 13, 11, 2, -13 },
  { 683, 10, 13, 11, 1, -13 },
  { 700, 9, 16, 11, 2, -13 },
  { 718, 10, 13, 11, 1, -13 },
  { 735, 10, 13, 11, 1, -13 },
  { 752, 9, 13, 11, 3, -13 },
  { 767, 10, 13, 11, 2, -13 },
  { 784, 10, 13, 11, 3, -13 },
  { 801, 12, 13, 11, 1, -13 },
  { 821, 13, 13, 11, 0, -13 },
  { 843, 10, 13, 11, 3, -13 },
  { 860, 11, 13, 11, 1, -13 },
  { 878, 9, 18, 11, 2, -15 },
  { 899, 3, 18, 11, 5, -15 },
  { 906, 9, 18, 11, 1, -15 },
  { 927, 9, 7, 11, 2, -13 },
  { 935, 10, 1, 11, -1, 2 },
  { 937, 4, 4, 11, 5, -15 },
  { 939, 10, 10, 11, 1, -10 },
  { 952, 10, 15, 11, 1, -15 },
  { 971, 10, 10, 11, 1, -10 },
  { 984, 10, 15, 11, 2, -15 },
  { 1003, 10, 10, 11, 1, -10 },
  { 1016, 13, 18, 11, 0, -15 },
  { 1046, 11, 13, 11, 0, -10 },
  { 1064, 9, 15, 11, 1, -15 },
  { 1081, 6, 15, 11, 3, -15 },
  { 1093, 11, 18, 11, 0, -15 },
  { 1118, 10, 15, 11, 1, -15 },
  { 1137, 5, 15, 11, 4, -15 },
  { 1147, 10, 10, 11, 1, -10 },
  { 1160, 9, 10, 11, 1, -10 },
  { 1172, 9, 10, 11, 2, -10 },
  { 1184, 11, 13, 11, 0, -10 },
  { 1202, 9, 13, 11, 2, -10 },
  { 1217, 9, 10, 11, 2, -10 },
  { 1229, 9, 10, 11, 2, -10 },
  { 1241, 8, 13, 11, 3, -13 },
  { 1254, 9, 10, 11, 2, -10 },
  { 1266, 8, 10, 11, 3, -10 },
  { 1276, 10, 10, 11, 2, -10 },
  { 1289, 11, 10, 11, 0, -10 },
  { 1303, 11, 13, 11, 0, -10 },
  { 1321, 10, 10, 11, 1, -10 },
  { 1334, 10, 18, 11, 2, -15 },
  { 1357, 6, 18, 11, 3, -15 },
  { 1371, 10, 18, 11, 0, -15 },
  { 1394, 9, 4, 11, 2, -9 },
};

const GFXfont UbuntuMono_Italic21pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic21pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic21pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _UBUNTUMONO_ITALIC21PT7B_H_
