#ifndef _UBUNTUMONO_ITALIC25PT7B_H_
#define _UBUNTUMONO_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x8C, 0x30, 0xC0, 0x00, 0x63, 0xC6,
  0x00, 0xC7, 0x9B, 0x36, 0x68, 0x91, 0x00, 0x03, 0x18, 0x18, 0xC0, 0x8C,
  0x0C, 0x63, 0xFF, 0x9F, 0xFC, 0x31, 0x03, 0x18, 0x19, 0x87, 0xFF, 0xBF,
  0xF8, 0x46, 0x06, 0x30, 0x33, 0x03, 0x18, 0x00, 0x01, 0x80, 0x30, 0x06,
  0x03, 0xE1, 0xFE, 0x30, 0x4C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x0D, 0x83, 0x3F, 0xE3, 0xF0, 0x18, 0x03, 0x00, 0x40, 0x00, 0x0E,
  0x06, 0x3E, 0x18, 0x6C, 0x60, 0x89, 0x83, 0x36, 0x06, 0x78, 0x07, 0xA0,
  0x0E, 0xF8, 0x03, 0xF8, 0x0D, 0x30, 0x36, 0x60, 0xCC, 0xC3, 0x1B, 0x0C,
  0x3E, 0x10, 0x38, 0x00, 0x03, 0xC1, 0xF8, 0x31, 0x8C, 0x21, 0x8C, 0x33,
  0x03, 0xC0, 0xF3, 0x36, 0x6C, 0x79, 0x87, 0x70, 0xCE, 0x3C, 0xFD, 0x8F,
  0x30, 0x36, 0x66, 0x64, 0x40, 0x01, 0x81, 0xC1, 0xC1, 0xC1, 0xC1, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0x80, 0x02, 0x01, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0xE0, 0x10, 0x00, 0x0C, 0x03,
  0x04, 0xCD, 0xDF, 0x3F, 0x03, 0x81, 0xB0, 0xCE, 0x11, 0x00, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xBF, 0xF0, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x00, 0x3B, 0xCE, 0x7F, 0x60, 0x7D, 0xF0, 0x7F, 0x60, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x07, 0x81, 0xF8, 0x73, 0x9C, 0x33, 0x06, 0xC0, 0xD9, 0x9F, 0x73, 0xCE,
  0xD8, 0x1B, 0x07, 0x60, 0xCE, 0x30, 0xFE, 0x0F, 0x00, 0x01, 0x81, 0xC3,
  0xE3, 0xF1, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC3,
  0xFF, 0xFE, 0x0F, 0x83, 0xFC, 0x43, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x06, 0x01, 0xFF, 0x3F, 0xE0, 0x07,
  0xC0, 0xFE, 0x08, 0x70, 0x03, 0x00, 0x70, 0x0E, 0x07, 0xC0, 0x7C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x0E, 0x41, 0xC7, 0xF8, 0x7F, 0x00, 0x00, 0x70,
  0x0E, 0x01, 0xE0, 0x36, 0x06, 0x60, 0xCC, 0x18, 0xC3, 0x0C, 0x30, 0xC6,
  0x0C, 0x7F, 0xEF, 0xFE, 0x01, 0x80, 0x18, 0x03, 0x00, 0x07, 0xF8, 0x3F,
  0x81, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x01, 0x84, 0x1C, 0x3F, 0xC1, 0xF8, 0x00, 0x00, 0xF0,
  0x3F, 0x0F, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x7F, 0x87, 0xFC, 0x60, 0xCE,
  0x0C, 0xC0, 0xCE, 0x0C, 0x61, 0xC7, 0xF8, 0x3E, 0x00, 0x3F, 0xF3, 0xFE,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x00, 0x07, 0xC1, 0xFC, 0x61,
  0x98, 0x33, 0x06, 0x71, 0xC7, 0x70, 0xF8, 0x33, 0x8C, 0x1B, 0x03, 0x60,
  0x6E, 0x19, 0xFF, 0x0F, 0x80, 0x07, 0x83, 0xFC, 0xE1, 0x98, 0x37, 0x06,
  0xC0, 0xDC, 0x19, 0xFF, 0x1F, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0xF1, 0xF8,
  0x3C, 0x00, 0x1C, 0xF1, 0x80, 0x00, 0x00, 0x00, 0x73, 0xC6, 0x00, 0x0E,
  0x3C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0xF0, 0xE1, 0xCF, 0x18, 0x00,
  0x00, 0x20, 0x3C, 0x1F, 0x0F, 0x0F, 0x81, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0x80, 0x30, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x10, 0x03, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x60, 0x1E, 0x0F, 0x83, 0xC0,
  0x70, 0x04, 0x00, 0x1E, 0x1F, 0xC8, 0x60, 0x30, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x18, 0x00, 0x00, 0x06, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xFE, 0x1C,
  0x33, 0x83, 0x30, 0x36, 0x1F, 0x67, 0xFC, 0xE6, 0xCC, 0x6C, 0xC6, 0xD8,
  0x6D, 0x8C, 0xCC, 0xCC, 0xFC, 0xC7, 0xCE, 0x00, 0x70, 0x07, 0xE0, 0x1E,
  0x00, 0x00, 0xE0, 0x1E, 0x01, 0x60, 0x36, 0x06, 0x60, 0x66, 0x0C, 0x60,
  0x86, 0x18, 0x61, 0xFE, 0x3F, 0xF2, 0x03, 0x60, 0x3C, 0x03, 0xC0, 0x30,
  0x0F, 0xC1, 0xFF, 0x18, 0x71, 0x83, 0x18, 0x33, 0x06, 0x3F, 0xC3, 0xFC,
  0x30, 0xE6, 0x06, 0x60, 0x66, 0x06, 0x61, 0xCF, 0xF8, 0xFF, 0x00, 0x03,
  0xE0, 0xFF, 0x1C, 0x13, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x87, 0xF8, 0x1F, 0x00, 0x1F, 0x81,
  0xFE, 0x18, 0x61, 0x83, 0x38, 0x33, 0x03, 0x30, 0x33, 0x03, 0x60, 0x36,
  0x06, 0x60, 0xE6, 0x0C, 0xC3, 0xCF, 0xF0, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x3F, 0xC3, 0xF8, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x3F, 0xC3, 0xFC, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0x1C, 0x23,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x1C, 0xE1, 0x87, 0xF8, 0x3F, 0x00, 0x1C, 0x18, 0xC0, 0xC6, 0x06, 0x30,
  0x73, 0x83, 0x18, 0x18, 0xFF, 0xC7, 0xFE, 0x70, 0x63, 0x03, 0x18, 0x18,
  0xC0, 0xC6, 0x0C, 0x60, 0x63, 0x03, 0x00, 0x1F, 0xE1, 0xFE, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0xC3, 0x0F, 0xF0, 0x7C, 0x00, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x06, 0x30,
  0x19, 0x80, 0xEC, 0x03, 0x60, 0x0F, 0x00, 0x3E, 0x01, 0xDC, 0x06, 0x30,
  0x18, 0x60, 0x61, 0xC3, 0x83, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x1F, 0xEF, 0xF8, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x8E, 0x0B, 0x68,
  0x6D, 0x21, 0xBD, 0x84, 0xE6, 0x33, 0x98, 0xC0, 0x43, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x80, 0xC6, 0x06, 0x00, 0x0C, 0x18, 0xE0, 0xC7, 0x86, 0x3C,
  0x31, 0x63, 0x19, 0x18, 0xCC, 0xC6, 0x66, 0x23, 0x63, 0x0B, 0x18, 0x58,
  0xC3, 0xC4, 0x1C, 0x60, 0xE3, 0x03, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x63,
  0x06, 0x70, 0x76, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC,
  0x1C, 0xE3, 0x87, 0xF0, 0x3C, 0x00, 0x0F, 0xC0, 0x7F, 0x87, 0x0C, 0x30,
  0x71, 0x83, 0x8C, 0x18, 0xE0, 0xC6, 0x1C, 0x3F, 0xC1, 0xFC, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x00, 0x07, 0xC0, 0xFE, 0x18, 0x63,
  0x06, 0x70, 0x76, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC,
  0x1C, 0xE3, 0x87, 0xF0, 0x3C, 0x01, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x00,
  0x0F, 0xC1, 0xFE, 0x18, 0x71, 0x83, 0x18, 0x33, 0x83, 0x30, 0x73, 0x0E,
  0x3F, 0xC7, 0xF0, 0x63, 0x86, 0x18, 0x61, 0xCE, 0x0C, 0xC0, 0xC0, 0x03,
  0xE0, 0x7F, 0x83, 0x04, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x01, 0xC4, 0x1C, 0x3F, 0xC0, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x38, 0x33, 0x03,
  0x30, 0x33, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC1, 0xCC, 0x18, 0xE3, 0x87, 0xF0, 0x3E, 0x00, 0xE0, 0x3E, 0x07, 0xE0,
  0x66, 0x0E, 0x60, 0xC6, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60, 0x66,
  0x06, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x00, 0x18, 0x0C, 0x60, 0x31, 0x81,
  0x8C, 0x06, 0x30, 0x18, 0xC0, 0x43, 0x33, 0x09, 0xCC, 0x65, 0x21, 0xB5,
  0x87, 0x96, 0x16, 0x50, 0x71, 0xC1, 0x87, 0x0E, 0x18, 0x00, 0x06, 0x0E,
  0x0C, 0x18, 0x1C, 0x60, 0x19, 0x80, 0x36, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xE3, 0x03, 0x86, 0x0E, 0x0C,
  0x18, 0x0C, 0x00, 0xC0, 0x6C, 0x0E, 0xC0, 0xCC, 0x18, 0x63, 0x06, 0x60,
  0x6E, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x03, 0xF0, 0x7E, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x07, 0xE0, 0x7E, 0x00, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x67, 0x73, 0x33, 0x33, 0x33, 0x30, 0x07, 0xE0,
  0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30,
  0x7E, 0x0F, 0xC0, 0x07, 0x03, 0xC0, 0xF0, 0x66, 0x31, 0x98, 0x6E, 0x0F,
  0x02, 0x7F, 0xFF, 0xFF, 0x8C, 0x67, 0x20, 0x07, 0xC3, 0xFC, 0xE3, 0x38,
  0x6E, 0x0D, 0x81, 0xB0, 0x66, 0x0C, 0xC1, 0x98, 0x73, 0xFE, 0x3E, 0xC0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x6F, 0x0F, 0xF1, 0x86, 0x30,
  0xEC, 0x0D, 0x83, 0xB0, 0x66, 0x0D, 0x83, 0x31, 0xE7, 0xF8, 0xFC, 0x00,
  0x07, 0xC3, 0xFC, 0xE1, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x11, 0xFE, 0x1F, 0x80, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x03, 0xF0, 0x7F, 0x87, 0x0C, 0x70, 0xC3, 0x06, 0x30, 0x31, 0x83,
  0x8C, 0x18, 0x60, 0xC3, 0x8E, 0x0F, 0xF0, 0x3D, 0x80, 0x0F, 0x83, 0xF9,
  0xE3, 0xB0, 0x7E, 0x0D, 0x83, 0xBF, 0xE7, 0xF0, 0xC0, 0x1C, 0x11, 0xFE,
  0x1F, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x01,
  0xFF, 0x83, 0xFE, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0x1C, 0x33, 0x87,
  0x30, 0x63, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC7, 0x1C, 0x3F, 0xC1, 0xEC,
  0x01, 0x88, 0x38, 0xFF, 0x0F, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x3F, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0C, 0xC1, 0xB8, 0x66, 0x0C,
  0xC1, 0x98, 0x37, 0x0C, 0xC1, 0x80, 0x0E, 0x0E, 0x0E, 0x00, 0x00, 0x7C,
  0xFC, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x38, 0x1F, 0x0F, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x86, 0x0F, 0xE0, 0xF8, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x06, 0x31, 0xC3, 0x38, 0x37, 0x06, 0xE0, 0x78, 0x06,
  0xC0, 0x6E, 0x0C, 0x70, 0xC3, 0x0C, 0x38, 0xC1, 0x80, 0x7C, 0xF8, 0x30,
  0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0xBF, 0x3E,
  0x1E, 0xE3, 0xFF, 0x33, 0x33, 0x33, 0x23, 0x36, 0x62, 0x66, 0x66, 0x66,
  0x60, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0x1F, 0x8F, 0xF3, 0x0C, 0xC3, 0x60,
  0xD8, 0x36, 0x0D, 0x83, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0x0F, 0x83, 0xF8,
  0xE3, 0x30, 0x76, 0x07, 0x81, 0xF0, 0x36, 0x06, 0xC1, 0xDC, 0x71, 0xFC,
  0x1F, 0x00, 0x07, 0xE0, 0x7F, 0x83, 0x0C, 0x38, 0x71, 0x81, 0x8C, 0x1C,
  0x60, 0xC7, 0x06, 0x30, 0x61, 0x8F, 0x0F, 0xF0, 0x7E, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x07, 0xE3, 0xFC, 0xE1, 0xB8, 0x66, 0x0D, 0x81,
  0xB0, 0x36, 0x0C, 0xC1, 0x9C, 0x71, 0xFE, 0x1F, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x0F, 0xE3, 0xFC, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x0F, 0xC3, 0xF8, 0xE1, 0x18,
  0x03, 0x80, 0x3C, 0x03, 0xE0, 0x1C, 0x01, 0x88, 0x73, 0xFC, 0x3F, 0x00,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x7F, 0xDF, 0xF1, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x1C, 0x43, 0xF0, 0x78, 0x30, 0x6E, 0x1D, 0x83,
  0x30, 0x66, 0x0D, 0xC3, 0xB0, 0x66, 0x0C, 0xC1, 0x9C, 0x71, 0xFE, 0x1E,
  0xC0, 0xC0, 0xF8, 0x3E, 0x19, 0x86, 0x63, 0x18, 0xC6, 0x61, 0x98, 0x6C,
  0x1F, 0x07, 0x80, 0xC0, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x66, 0xC6, 0x6C,
  0xE6, 0xDA, 0xCD, 0x2C, 0xF2, 0x8E, 0x38, 0xE3, 0x8C, 0x30, 0x0C, 0x18,
  0x30, 0xC0, 0x67, 0x01, 0x98, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x0C, 0xC0, 0x63, 0x03, 0x0E, 0x18, 0x18, 0x1C, 0x18, 0x60, 0xC3, 0x0E,
  0x18, 0x60, 0xC3, 0x06, 0x30, 0x31, 0x81, 0xD8, 0x06, 0xC0, 0x3C, 0x01,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x70, 0x0F, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xE0, 0x1E, 0x00, 0x06,
  0x0C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x18,
  0x30, 0x60, 0xC3, 0x06, 0x0C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x0C, 0x00, 0xF0, 0x1F,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x0F, 0xC0,
  0xF8, 0x00, 0x38, 0x6F, 0x8F, 0x3F, 0x61, 0xC0,
};

const GFXglyph UbuntuMono_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 15, 13, 4, -15 },
  { 13, 7, 6, 13, 6, -16 },
  { 19, 13, 15, 13, 1, -15 },
  { 44, 11, 19, 13, 2, -17 },
  { 71, 15, 15, 13, 0, -15 },
  { 100, 11, 15, 13, 1, -15 },
  { 121, 4, 7, 13, 7, -17 },
  { 125, 9, 22, 13, 4, -18 },
  { 150, 10, 22, 13, 1, -18 },
  { 178, 10, 9, 13, 3, -15 },
  { 190, 11, 12, 13, 2, -12 },
  { 207, 5, 6, 13, 3, -3 },
  { 211, 6, 2, 13, 4, -7 },
  { 213, 4, 3, 13, 4, -3 },
  { 215, 14, 21, 13, 0, -17 },
  { 252, 11, 15, 13, 2, -15 },
  { 273, 9, 15, 13, 2, -15 },
  { 290, 11, 15, 13, 2, -15 },
  { 311, 12, 15, 13, 1, -15 },
  { 334, 12, 15, 13, 1, -15 },
  { 357, 13, 15, 13, 1, -15 },
  { 382, 12, 15, 13, 2, -15 },
  { 405, 12, 15, 13, 3, -15 },
  { 428, 11, 15, 13, 2, -15 },
  { 449, 11, 15, 13, 2, -15 },
  { 470, 6, 11, 13, 4, -11 },
  { 479, 7, 14, 13, 3, -11 },
  { 492, 11, 10, 13, 2, -13 },
  { 506, 11, 7, 13, 2, -10 },
  { 516, 12, 10, 13, 1, -12 },
  { 531, 9, 15, 13, 4, -15 },
  { 548, 12, 19, 13, 2, -16 },
  { 577, 12, 15, 13, 0, -15 },
  { 600, 12, 15, 13, 1, -15 },
  { 623, 12, 15, 13, 2, -15 },
  { 646, 12, 15, 13, 1, -15 },
  { 669, 12, 15, 13, 2, -15 },
  { 692, 12, 15, 13, 2, -15 },
  { 715, 12, 15, 13, 2, -15 },
  { 738, 13, 15, 13, 1, -15 },
  { 763, 12, 15, 13, 2, -15 },
  { 786, 12, 15, 13, 2, -15 },
  { 809, 14, 15, 13, 1, -15 },
  { 836, 10, 15, 13, 1, -15 },
  { 855, 14, 15, 13, 0, -15 },
  { 882, 13, 15, 13, 1, -15 },
  { 907, 12, 15, 13, 2, -15 },
  { 930, 13, 15, 13, 1, -15 },
  { 955, 12, 19, 13, 2, -15 },
  { 984, 12, 15, 13, 1, -15 },
  { 1007, 13, 15, 13, 1, -15 },
  { 1032, 11, 15, 13, 4, -15 },
  { 1053, 12, 15, 13, 2, -15 },
  { 1076, 12, 15, 13, 3, -15 },
  { 1099, 14, 15, 13, 1, -15 },
  { 1126, 15, 15, 13, 0, -15 },
  { 1155, 12, 15, 13, 4, -15 },
  { 1178, 13, 15, 13, 1, -15 },
  { 1203, 12, 21, 13, 2, -17 },
  { 1235, 4, 21, 13, 5, -17 },
  { 1246, 11, 21, 13, 1, -17 },
  { 1275, 10, 8, 13, 3, -15 },
  { 1285, 12, 2, 13, -1, 2 },
  { 1288, 4, 5, 13, 7, -18 },
  { 1291, 11, 12, 13, 2, -12 },
  { 1308, 11, 17, 13, 2, -17 },
  { 1332, 11, 12, 13, 2, -12 },
  { 1349, 13, 17, 13, 2, -17 },
  { 1377, 11, 12, 13, 2, -12 },
  { 1394, 15, 21, 13, 0, -17 },
  { 1434, 12, 16, 13, 1, -12 },
  { 1458, 11, 17, 13, 1, -17 },
  { 1482, 8, 17, 13, 3, -17 },
  { 1499, 12, 21, 13, 1, -17 },
  { 1531, 12, 17, 13, 2, -17 },
  { 1557, 7, 17, 13, 4, -17 },
  { 1572, 12, 12, 13, 1, -12 },
  { 1590, 10, 12, 13, 2, -12 },
  { 1605, 11, 12, 13, 2, -12 },
  { 1622, 13, 16, 13, 0, -12 },
  { 1648, 11, 16, 13, 2, -12 },
  { 1670, 11, 12, 13, 2, -12 },
  { 1687, 11, 12, 13, 2, -12 },
  { 1704, 10, 16, 13, 3, -16 },
  { 1724, 11, 12, 13, 2, -12 },
  { 1741, 10, 12, 13, 3, -12 },
  { 1756, 12, 12, 13, 2, -12 },
  { 1774, 14, 12, 13, 0, -12 },
  { 1795, 13, 16, 13, 0, -12 },
  { 1821, 12, 12, 13, 1, -12 },
  { 1839, 12, 21, 13, 2, -17 },
  { 1871, 7, 21, 13, 4, -17 },
  { 1890, 12, 21, 13, 0, -17 },
  { 1922, 11, 4, 13, 2, -11 },
};

const GFXfont UbuntuMono_Italic25pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic25pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic25pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUMONO_ITALIC25PT7B_H_
