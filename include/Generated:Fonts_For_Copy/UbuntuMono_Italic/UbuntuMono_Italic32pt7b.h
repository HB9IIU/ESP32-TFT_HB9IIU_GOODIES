#ifndef _UBUNTUMONO_ITALIC32PT7B_H_
#define _UBUNTUMONO_ITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x83,
  0x00, 0x00, 0x00, 0xE1, 0xE3, 0xC7, 0x00, 0x71, 0xB9, 0xD8, 0xEC, 0x66,
  0x36, 0x1B, 0x09, 0x8C, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x30, 0xC0, 0x38,
  0xE0, 0x18, 0x60, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0x1C, 0x03,
  0x0C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xC3, 0x03, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFC, 0x38, 0xE0, 0x18, 0x60, 0x1C, 0x60, 0x0C, 0x70, 0x00, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xC3, 0x81,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0xC0, 0xF1, 0xFF, 0xC7, 0xFF,
  0x03, 0xF8, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x60, 0xF8, 0x18, 0x3F, 0x06, 0x06, 0x61, 0x81, 0x8C, 0x70, 0x31, 0x9C,
  0x06, 0x73, 0x00, 0xFE, 0xC0, 0x1F, 0xB0, 0x01, 0xEC, 0x00, 0x03, 0x38,
  0x00, 0xEF, 0x80, 0x3B, 0xF0, 0x06, 0x66, 0x01, 0x98, 0xC0, 0x63, 0x18,
  0x18, 0x67, 0x07, 0x0F, 0xC1, 0xC1, 0xF8, 0x30, 0x1E, 0x00, 0x01, 0xE0,
  0x1F, 0xC0, 0xFF, 0x83, 0x8E, 0x0C, 0x38, 0x70, 0xC0, 0xC7, 0x03, 0x78,
  0x0F, 0x80, 0x7C, 0x73, 0xB1, 0x9C, 0xE6, 0x61, 0xF3, 0x83, 0xCE, 0x0E,
  0x38, 0x38, 0xE1, 0xF3, 0xFF, 0xC7, 0xF3, 0x0F, 0x0E, 0x76, 0x6E, 0xEC,
  0xCC, 0x80, 0x00, 0x20, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x00, 0x01, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x0E, 0x00, 0x40, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x86, 0x27, 0xA7, 0x3F, 0xFC, 0xFF, 0x80,
  0xE0, 0x0D, 0xC0, 0xEF, 0x0E, 0x38, 0x30, 0x80, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x1E, 0x3C, 0x78, 0xF0, 0xE3,
  0xBE, 0x30, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x3C, 0x1C, 0xE0, 0x77, 0x01,
  0xDC, 0xC7, 0x67, 0x9F, 0x9E, 0x6E, 0x73, 0xB8, 0x0E, 0xC0, 0x3B, 0x01,
  0xCC, 0x07, 0x38, 0x38, 0xE1, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0x80, 0x00,
  0x70, 0x0E, 0x03, 0xE0, 0xFE, 0x1E, 0xE1, 0xCC, 0x11, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x70,
  0xF0, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC1, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x1E, 0x03, 0xF0, 0x0F,
  0x00, 0x7F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x40,
  0xF3, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0,
  0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0x73, 0x83, 0x8E, 0x1C, 0x30, 0x60, 0xC3,
  0x07, 0x1C, 0x1C, 0x60, 0x63, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x1F,
  0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x40, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1B, 0xE0,
  0x7F, 0xF0, 0xFF, 0xE1, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x38, 0xF0, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0xF8, 0x00, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x18, 0x0C, 0xE0, 0x73,
  0x81, 0xCF, 0x0E, 0x1F, 0xF0, 0x7F, 0x01, 0xFE, 0x0E, 0x7C, 0x60, 0x73,
  0x80, 0xCC, 0x03, 0x30, 0x1C, 0xE0, 0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0,
  0x01, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE3, 0x01, 0xCE,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0xFF, 0xE0, 0x7D,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x07, 0xE0, 0xFF, 0x81, 0xFC, 0x07,
  0xC0, 0x00, 0x1C, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC7,
  0x8F, 0x1C, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0xF8,
  0x18, 0x00, 0x00, 0x04, 0x00, 0x3C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x1C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0x80, 0x03, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x10, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xC0, 0x3C, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFE, 0x1F, 0xE1, 0x0F, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x01, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x87, 0x1E, 0x07, 0x1C, 0x07, 0x38,
  0x07, 0x38, 0x7F, 0x70, 0xFE, 0x71, 0xFE, 0x63, 0x86, 0x67, 0x0E, 0xE7,
  0x0C, 0xE7, 0x0C, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0xF8, 0xE3, 0xF8, 0x61,
  0xF0, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0x63,
  0x01, 0xC6, 0x03, 0x0C, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0, 0xE3,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x70, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0E, 0x0F, 0x0E, 0x07, 0x0C,
  0x07, 0x0C, 0x06, 0x1C, 0x1E, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xFC, 0x38,
  0x1C, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x1C, 0x70, 0x7C, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xF8, 0x07, 0xFC, 0x3F, 0xF8, 0xF8,
  0x23, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x20, 0xFF, 0xC0, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0E, 0x1E, 0x0E, 0x0E, 0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x18,
  0x07, 0x18, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x1C, 0x70,
  0x1C, 0x70, 0x78, 0x60, 0xF8, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0xF8, 0x23, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0xE6, 0x01, 0xCC, 0x03, 0x18, 0x0E, 0x30, 0x1C, 0x70,
  0x38, 0xF0, 0x60, 0xFF, 0xC1, 0xFF, 0x80, 0xFC, 0x00, 0x06, 0x01, 0x83,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x30, 0x60, 0x38, 0x70, 0x1C,
  0x38, 0x0E, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0x01, 0xC3, 0x80,
  0xC1, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x30, 0x0C, 0x18,
  0x0E, 0x1C, 0x07, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x40, 0x70, 0x61, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0x00, 0x07, 0x03,
  0x81, 0x81, 0xC0, 0x60, 0xE0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x1C, 0x00,
  0xCE, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xB8, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x0E, 0x38, 0x03, 0x06, 0x01, 0xC1, 0xC0, 0x70, 0x30,
  0x1C, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x03, 0x83, 0x81, 0xC1, 0xC1, 0xE0, 0xE1, 0xE0, 0xD8, 0xF0, 0x6C, 0xD8,
  0x36, 0x6C, 0x33, 0x66, 0x19, 0xB7, 0x0C, 0xF3, 0x8E, 0x71, 0x86, 0x38,
  0xC3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x70,
  0x0E, 0x30, 0x07, 0x18, 0x03, 0x80, 0x07, 0x01, 0x81, 0xC0, 0x60, 0xF0,
  0x18, 0x3E, 0x0E, 0x0D, 0x83, 0x03, 0x60, 0xC1, 0xDC, 0x30, 0x73, 0x1C,
  0x18, 0xC7, 0x06, 0x31, 0x81, 0x8C, 0x60, 0xE1, 0xB8, 0x30, 0x6E, 0x0C,
  0x1B, 0x03, 0x06, 0xC1, 0xC1, 0xF0, 0x70, 0x3C, 0x18, 0x0E, 0x06, 0x03,
  0x83, 0x80, 0xE0, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0x38, 0x1C,
  0xE0, 0x37, 0x00, 0xD8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x06,
  0xC0, 0x3B, 0x00, 0xEC, 0x07, 0x38, 0x3C, 0xE1, 0xE3, 0xFF, 0x07, 0xF8,
  0x0F, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0xF1, 0xC0, 0xE3,
  0x80, 0xC7, 0x01, 0x8C, 0x07, 0x38, 0x1E, 0x70, 0x78, 0xFF, 0xE1, 0xFF,
  0x83, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0x38,
  0x1C, 0xE0, 0x37, 0x00, 0xD8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x06, 0xC0, 0x3B, 0x00, 0xEC, 0x07, 0x38, 0x3C, 0xE1, 0xE3, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x1C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0x80,
  0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x0E, 0x0F, 0x0E, 0x07, 0x0E, 0x07,
  0x0C, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x1E, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE0, 0x38, 0xE0, 0x30, 0x70, 0x70, 0x70, 0x70, 0x30, 0x70, 0x38,
  0x60, 0x38, 0x60, 0x18, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x78, 0x21,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x40, 0xF1,
  0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x18, 0x06, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0x73, 0x00, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x19, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x1C, 0x70, 0x70, 0xE1,
  0xE1, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0xE0, 0x06, 0xE0, 0x0E, 0xE0,
  0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x70, 0x60,
  0x60, 0x60, 0xE0, 0x60, 0xC0, 0x61, 0xC0, 0x71, 0x80, 0x73, 0x80, 0x73,
  0x00, 0x77, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38,
  0xC0, 0x18, 0x60, 0x0C, 0x31, 0x8E, 0x39, 0xE6, 0x18, 0xF3, 0x0C, 0xD9,
  0x86, 0x6D, 0xC3, 0x66, 0xC1, 0xE3, 0x61, 0xB1, 0xB0, 0xF0, 0xF0, 0x78,
  0x78, 0x38, 0x38, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0x3B, 0x00, 0x07,
  0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3B,
  0x80, 0x07, 0x30, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x1C, 0x0C, 0x07, 0x01,
  0xC1, 0xE0, 0x38, 0x38, 0x07, 0x00, 0xC0, 0x0F, 0xC0, 0x3B, 0x80, 0xE7,
  0x01, 0xC6, 0x07, 0x0C, 0x0C, 0x1C, 0x38, 0x38, 0xE0, 0x31, 0x80, 0x66,
  0x00, 0xFC, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x63,
  0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x63, 0x18, 0xE7, 0x39, 0xCE, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xD8, 0x06, 0x70, 0x38, 0xC1, 0xC3, 0x0E,
  0x0E, 0x70, 0x19, 0xC0, 0x62, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x23,
  0x87, 0x0E, 0x1C, 0x20, 0x01, 0xF8, 0x1F, 0xF1, 0xFF, 0xCF, 0x87, 0x38,
  0x19, 0xC0, 0x67, 0x03, 0x98, 0x0C, 0xE0, 0x33, 0x81, 0xCE, 0x07, 0x3C,
  0x3C, 0x7F, 0xF1, 0xFF, 0xC1, 0xF3, 0x00, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x7C, 0x1F, 0xF8, 0x7F,
  0xF1, 0xC1, 0xCE, 0x07, 0x38, 0x0C, 0xE0, 0x73, 0x01, 0xCC, 0x07, 0x70,
  0x39, 0x81, 0xE6, 0x1F, 0x1F, 0xF8, 0xFF, 0xC3, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0xF1, 0xFF, 0xCF, 0x83, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x04, 0x7F, 0xF0, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x03, 0xFC, 0x0F, 0xFC, 0x1E, 0x18, 0x38, 0x38, 0x70,
  0x38, 0xE0, 0x38, 0xE0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x70, 0xC0,
  0x60, 0xC0, 0xE0, 0xE1, 0xE0, 0x7F, 0xE0, 0x3E, 0x70, 0x03, 0xF0, 0x3F,
  0xE1, 0xFF, 0xCF, 0x87, 0x38, 0x1D, 0xC0, 0x76, 0x07, 0xFF, 0xFE, 0xFF,
  0xE3, 0xFE, 0x0E, 0x00, 0x1C, 0x0C, 0x7F, 0xF0, 0xFF, 0xC0, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0x87, 0x0E,
  0x06, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x30, 0x1C, 0x30,
  0x1C, 0x38, 0x18, 0x38, 0x78, 0x1F, 0xF8, 0x0F, 0xB8, 0x00, 0x30, 0x00,
  0x70, 0xC0, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x7F, 0xF1, 0xC1, 0xC7, 0x07, 0x1C, 0x0C, 0xE0, 0x73, 0x81, 0xCE,
  0x07, 0x30, 0x18, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x60, 0x31, 0x81, 0xC0,
  0x07, 0x01, 0xE0, 0x78, 0x1C, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0xFE, 0x03,
  0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x07, 0x01, 0xFC,
  0x3F, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x30, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x07, 0x1C, 0x3C, 0x30, 0xF0, 0x67,
  0x80, 0xDE, 0x03, 0xF8, 0x07, 0xC0, 0x0D, 0xC0, 0x19, 0xC0, 0x71, 0xC0,
  0xE3, 0x81, 0x83, 0x83, 0x03, 0x8E, 0x07, 0x1C, 0x06, 0x00, 0xFE, 0xFE,
  0xFE, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0xE1, 0x7F, 0x7F, 0x3E, 0x0F, 0x9E, 0x1F, 0xFE,
  0x18, 0xE7, 0x18, 0xC7, 0x18, 0xC6, 0x39, 0xC6, 0x31, 0xC6, 0x31, 0x8E,
  0x31, 0x8E, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0xE0, 0x18,
  0xE0, 0x18, 0x07, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x0F, 0x18, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x30, 0x19, 0xC0, 0xE7, 0x03, 0x9C, 0x0C, 0x60,
  0x33, 0x81, 0xCE, 0x07, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0xF8, 0x77,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xB0, 0x3D, 0xC3,
  0xCF, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8,
  0x60, 0xF1, 0xC0, 0xE3, 0x80, 0xC7, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0x70,
  0x38, 0xC0, 0xF1, 0x87, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xF1,
  0xE1, 0x8E, 0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0x30, 0x1C, 0xC0, 0x73,
  0x01, 0xCC, 0x06, 0x38, 0x38, 0xE1, 0xE1, 0xFF, 0x83, 0xEC, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0xFC, 0x7F, 0xE1, 0xFF,
  0x86, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF0,
  0x7F, 0xC7, 0xFE, 0x38, 0x23, 0x80, 0x1E, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0x00, 0x19, 0x81, 0xCF, 0xFE, 0x7F, 0xE1, 0xFC, 0x00, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x43, 0xFC, 0x3F, 0xC1, 0xF8, 0x30, 0x19, 0x81, 0xDC, 0x0E, 0xE0, 0x76,
  0x03, 0x70, 0x3B, 0x81, 0xDC, 0x0C, 0xC0, 0x66, 0x07, 0x30, 0x39, 0xC3,
  0xCF, 0xFE, 0x3F, 0xB0, 0xF9, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xC0,
  0xE6, 0x06, 0x30, 0x71, 0x83, 0x0C, 0x38, 0x73, 0x83, 0x98, 0x1D, 0xC0,
  0xEC, 0x03, 0xE0, 0x1E, 0x00, 0xE0, 0x00, 0x60, 0x06, 0xE0, 0x06, 0xE0,
  0x0E, 0xE0, 0x0C, 0xE3, 0x0C, 0xC3, 0x1C, 0xC7, 0x18, 0xCF, 0x18, 0xCD,
  0xB0, 0xD9, 0xB0, 0xD9, 0xF0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xC1,
  0xC0, 0x0E, 0x07, 0x0E, 0x0E, 0x06, 0x1C, 0x07, 0x18, 0x03, 0x38, 0x03,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x1C,
  0x70, 0x38, 0x30, 0x70, 0x38, 0xE0, 0x38, 0x07, 0x01, 0xC1, 0xC0, 0x70,
  0x30, 0x18, 0x0C, 0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E,
  0x38, 0x01, 0x8E, 0x00, 0x67, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1F, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0xE0, 0x70, 0x38, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x80, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1E, 0x0E, 0x7F, 0x19,
  0x8F, 0xE7, 0x07, 0x80,
};

const GFXglyph UbuntuMono_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 20, 16, 6, -20 },
  { 19, 9, 8, 16, 7, -20 },
  { 28, 17, 20, 16, 1, -20 },
  { 71, 15, 25, 16, 2, -22 },
  { 118, 19, 20, 16, 0, -20 },
  { 166, 14, 20, 16, 2, -20 },
  { 201, 4, 9, 16, 10, -22 },
  { 206, 12, 27, 16, 5, -22 },
  { 247, 12, 27, 16, 2, -22 },
  { 288, 13, 12, 16, 4, -20 },
  { 308, 13, 14, 16, 3, -16 },
  { 331, 7, 8, 16, 3, -4 },
  { 338, 7, 3, 16, 6, -10 },
  { 341, 4, 4, 16, 6, -4 },
  { 343, 19, 27, 16, -1, -22 },
  { 408, 14, 20, 16, 3, -20 },
  { 443, 12, 20, 16, 3, -20 },
  { 473, 15, 20, 16, 2, -20 },
  { 511, 14, 20, 16, 2, -20 },
  { 546, 14, 20, 16, 2, -20 },
  { 581, 16, 20, 16, 2, -20 },
  { 621, 15, 20, 16, 3, -20 },
  { 659, 15, 20, 16, 4, -20 },
  { 697, 14, 20, 16, 3, -20 },
  { 732, 15, 20, 16, 2, -20 },
  { 770, 7, 14, 16, 6, -14 },
  { 783, 10, 18, 16, 3, -14 },
  { 806, 15, 13, 16, 2, -15 },
  { 831, 15, 8, 16, 2, -13 },
  { 846, 14, 13, 16, 2, -15 },
  { 869, 12, 20, 16, 5, -20 },
  { 899, 16, 24, 16, 2, -20 },
  { 947, 15, 20, 16, 0, -20 },
  { 985, 16, 20, 16, 1, -20 },
  { 1025, 15, 20, 16, 3, -20 },
  { 1063, 16, 20, 16, 1, -20 },
  { 1103, 16, 20, 16, 2, -20 },
  { 1143, 16, 20, 16, 2, -20 },
  { 1183, 15, 20, 16, 3, -20 },
  { 1221, 17, 20, 16, 1, -20 },
  { 1264, 15, 20, 16, 2, -20 },
  { 1302, 16, 20, 16, 2, -20 },
  { 1342, 18, 20, 16, 1, -20 },
  { 1387, 11, 20, 16, 2, -20 },
  { 1415, 17, 20, 16, 1, -20 },
  { 1458, 18, 20, 16, 1, -20 },
  { 1503, 14, 20, 16, 3, -20 },
  { 1538, 15, 20, 16, 2, -20 },
  { 1576, 14, 25, 16, 3, -20 },
  { 1620, 16, 20, 16, 1, -20 },
  { 1660, 15, 20, 16, 2, -20 },
  { 1698, 14, 20, 16, 5, -20 },
  { 1733, 15, 20, 16, 3, -20 },
  { 1771, 16, 20, 16, 4, -20 },
  { 1811, 17, 20, 16, 2, -20 },
  { 1854, 19, 20, 16, 0, -20 },
  { 1902, 15, 20, 16, 5, -20 },
  { 1940, 17, 20, 16, 1, -20 },
  { 1983, 15, 27, 16, 3, -22 },
  { 2034, 5, 27, 16, 7, -22 },
  { 2051, 14, 27, 16, 1, -22 },
  { 2099, 14, 11, 16, 3, -20 },
  { 2119, 15, 2, 16, -1, 3 },
  { 2123, 6, 6, 16, 8, -22 },
  { 2128, 14, 15, 16, 2, -15 },
  { 2155, 14, 22, 16, 2, -22 },
  { 2194, 14, 15, 16, 2, -15 },
  { 2221, 16, 22, 16, 3, -22 },
  { 2265, 14, 15, 16, 2, -15 },
  { 2292, 19, 27, 16, 0, -22 },
  { 2357, 16, 20, 16, 1, -15 },
  { 2397, 14, 22, 16, 1, -22 },
  { 2436, 10, 21, 16, 4, -21 },
  { 2463, 15, 26, 16, 1, -21 },
  { 2512, 15, 22, 16, 2, -22 },
  { 2554, 8, 22, 16, 6, -22 },
  { 2576, 16, 15, 16, 1, -15 },
  { 2606, 14, 15, 16, 2, -15 },
  { 2633, 13, 15, 16, 3, -15 },
  { 2658, 15, 20, 16, 1, -15 },
  { 2696, 14, 20, 16, 3, -15 },
  { 2731, 14, 15, 16, 3, -15 },
  { 2758, 13, 15, 16, 3, -15 },
  { 2783, 12, 20, 16, 4, -20 },
  { 2813, 13, 15, 16, 3, -15 },
  { 2838, 13, 15, 16, 4, -15 },
  { 2863, 16, 15, 16, 3, -15 },
  { 2893, 16, 15, 16, 1, -15 },
  { 2923, 18, 20, 16, -1, -15 },
  { 2968, 14, 15, 16, 2, -15 },
  { 2995, 15, 27, 16, 3, -22 },
  { 3046, 9, 27, 16, 5, -22 },
  { 3077, 15, 27, 16, 0, -22 },
  { 3128, 15, 4, 16, 2, -12 },
};

const GFXfont UbuntuMono_Italic32pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic32pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic32pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUMONO_ITALIC32PT7B_H_
