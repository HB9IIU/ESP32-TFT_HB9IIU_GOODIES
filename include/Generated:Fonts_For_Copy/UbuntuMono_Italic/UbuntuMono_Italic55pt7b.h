#ifndef _UBUNTUMONO_ITALIC55PT7B_H_
#define _UBUNTUMONO_ITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x3E, 0x1F, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0,
  0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x78, 0x1E, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7E, 0x01, 0xC0, 0x7E, 0x00, 0x20, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x40, 0x03, 0xF0, 0x78, 0x07, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x3F, 0xC0, 0x07, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x3F, 0xF8, 0x07,
  0x80, 0x1E, 0x3C, 0x07, 0x80, 0x1E, 0x1E, 0x03, 0xC0, 0x0F, 0x07, 0x03,
  0xC0, 0x07, 0x07, 0x83, 0xC0, 0x03, 0x83, 0xC3, 0xC0, 0x01, 0xC1, 0xE3,
  0xC0, 0x01, 0xE0, 0xE3, 0xC0, 0x00, 0xF0, 0xF3, 0xC0, 0x00, 0x78, 0xF9,
  0xE0, 0x00, 0x1F, 0xF9, 0xE0, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x03, 0xF9,
  0xE0, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x01,
  0xE7, 0xF8, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x00, 0xF3, 0xFF, 0x00, 0x00,
  0xF3, 0xC7, 0x80, 0x00, 0xF1, 0xC1, 0xC0, 0x00, 0xF1, 0xE0, 0xE0, 0x00,
  0xF0, 0xE0, 0x70, 0x00, 0x78, 0x70, 0x78, 0x00, 0x78, 0x38, 0x3C, 0x00,
  0x78, 0x1C, 0x1C, 0x00, 0x78, 0x0E, 0x1E, 0x00, 0x78, 0x07, 0x9F, 0x00,
  0x78, 0x03, 0xFF, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x7F, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x7C, 0x01, 0xF0, 0x3E, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xE3, 0xE0, 0x01, 0xF7, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0x07, 0xFC, 0x0F, 0x0F,
  0xFE, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x1F, 0x3E, 0x3C, 0x0F, 0xBC, 0x7C,
  0x07, 0xFC, 0x78, 0x07, 0xF8, 0xF8, 0x03, 0xF8, 0xF8, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0x7C, 0x1F, 0xF8, 0x7F,
  0xFF, 0x78, 0x3F, 0xFE, 0x78, 0x1F, 0xF8, 0x7C, 0x0F, 0xE0, 0x7C, 0x1F,
  0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x70,
  0x70, 0x70, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x20, 0x78, 0x11, 0xC1, 0xC3, 0xDF, 0xCE, 0x7E, 0xFF,
  0x7F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xEF, 0x00, 0x1E, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8,
  0x3E, 0x03, 0x81, 0xE0, 0x08, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x07, 0xE0, 0x3E, 0x07, 0xC1, 0xFC, 0xFF, 0x8F, 0xE0, 0xFC, 0x0E,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x3C, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x3C, 0x1F,
  0x7C, 0x7E, 0x1E, 0x7C, 0x7E, 0x1E, 0x78, 0x7E, 0x3E, 0xF8, 0x7E, 0x3E,
  0xF8, 0x7E, 0x3E, 0xF8, 0x38, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0,
  0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x80,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xBC, 0x07, 0xE3, 0xC0, 0x78,
  0x7C, 0x02, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0x03, 0xF0, 0x0E, 0x00, 0xFC, 0x04, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0x81, 0xF8, 0x02, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x82, 0x00, 0x1F, 0xC3, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80,
  0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x1E, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x1F, 0x80,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF1, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80,
  0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC7, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0x03,
  0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFC, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x8F, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0x00,
  0x3E, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xF3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0xFF, 0x80,
  0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x20,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xC0, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF0, 0x07, 0x80, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x3F, 0xE1,
  0xE0, 0x3F, 0xFC, 0x7C, 0x1F, 0xFF, 0x8F, 0x07, 0xFF, 0xF3, 0xE0, 0xFC,
  0x3C, 0x7C, 0x3E, 0x07, 0x8F, 0x0F, 0x80, 0xF1, 0xE1, 0xE0, 0x3E, 0x7C,
  0x3C, 0x07, 0x8F, 0x8F, 0x80, 0xF1, 0xE1, 0xE0, 0x1E, 0x3C, 0x3C, 0x07,
  0xC7, 0x87, 0x80, 0xF8, 0xF0, 0xF0, 0x1E, 0x1E, 0x1F, 0x03, 0xC3, 0xC3,
  0xE0, 0xF8, 0x78, 0x3E, 0x1F, 0x0F, 0x07, 0xFF, 0xC1, 0xE0, 0x7F, 0xF8,
  0x3E, 0x07, 0xFF, 0x07, 0xC0, 0x3F, 0x80, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x08, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3C, 0x01,
  0xFC, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0, 0xF8,
  0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE0, 0x78, 0x07, 0xE0, 0x01,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x02, 0x00, 0x7F, 0x03, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x1E, 0x03, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x3F,
  0x80, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x38, 0x03, 0xF0, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x01,
  0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0x03,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x0F, 0x80, 0x70, 0x07, 0xE0,
  0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF1,
  0xF8, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x0F, 0x1F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3B, 0x80, 0x3B, 0x81, 0xFE, 0x00, 0xEF, 0x07, 0x78,
  0x07, 0xBC, 0x3D, 0xC0, 0x1E, 0xF0, 0xE7, 0x00, 0x73, 0xC7, 0x1C, 0x03,
  0xCF, 0x3C, 0xF0, 0x0F, 0x1C, 0xE3, 0xC0, 0x38, 0x77, 0x8F, 0x01, 0xE1,
  0xDC, 0x38, 0x07, 0x87, 0xF1, 0xE0, 0x1E, 0x1F, 0x87, 0x80, 0xF0, 0x7C,
  0x1E, 0x03, 0xC1, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x7C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x3F, 0x00,
  0x1E, 0x01, 0xFC, 0x00, 0x78, 0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0x0F,
  0x00, 0x7F, 0x80, 0x3C, 0x03, 0xDE, 0x00, 0xF0, 0x0F, 0x3C, 0x07, 0xC0,
  0x3C, 0xF0, 0x1E, 0x00, 0xF3, 0xC0, 0x78, 0x07, 0x87, 0x01, 0xE0, 0x1E,
  0x1E, 0x0F, 0x80, 0x78, 0x78, 0x3C, 0x01, 0xE1, 0xE0, 0xF0, 0x0F, 0x03,
  0x83, 0xC0, 0x3C, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x78, 0x03, 0xC0, 0xF1,
  0xE0, 0x1F, 0x01, 0xC7, 0x80, 0x78, 0x07, 0x1E, 0x01, 0xE0, 0x1E, 0xF0,
  0x07, 0x80, 0x7B, 0xC0, 0x3E, 0x01, 0xEF, 0x00, 0xF0, 0x03, 0xBC, 0x03,
  0xC0, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0xFE, 0x01, 0xE0,
  0x03, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07,
  0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0x01, 0xFC, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9F,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x3C, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C,
  0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8,
  0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x03, 0xF0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x7F, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3C,
  0x03, 0xE0, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x0F, 0xC0, 0xF8, 0x07, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x7C,
  0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x3E, 0x0F, 0x01, 0xE0, 0xF8, 0x3C, 0x07, 0x87,
  0xE0, 0xE0, 0x1E, 0x1F, 0x87, 0x80, 0x70, 0xFE, 0x1E, 0x03, 0xC3, 0xB8,
  0x78, 0x0F, 0x1E, 0xE3, 0xC0, 0x3C, 0x73, 0x8F, 0x00, 0xF3, 0x8E, 0x3C,
  0x03, 0x9E, 0x38, 0xE0, 0x0E, 0x70, 0xE7, 0x80, 0x7B, 0xC3, 0xDE, 0x01,
  0xEE, 0x0F, 0x70, 0x07, 0x78, 0x1F, 0xC0, 0x1D, 0xC0, 0x7F, 0x00, 0x7F,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0xFC, 0x1E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x0F, 0x0F, 0x0F, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80,
  0x0F, 0x9E, 0x00, 0x7C, 0x78, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C,
  0x0F, 0x03, 0xE0, 0x1E, 0x1F, 0x00, 0x78, 0xF8, 0x01, 0xE7, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x10, 0x0E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x80, 0x40, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFC, 0x1E, 0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFC, 0xF0, 0x07, 0xF0, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0xC3,
  0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x78, 0x01, 0xF8, 0x3C, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x07, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xF8, 0x06, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x7F, 0x00,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xF0, 0x07, 0xF0, 0x1F,
  0x00, 0xFC, 0x01, 0xF0, 0x1F, 0x80, 0x1E, 0x01, 0xF0, 0x01, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xC7, 0x80, 0x07, 0xF0, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0x1F,
  0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0xFC, 0x78, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x10, 0x7F, 0x00, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x10,
  0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0x81, 0xE0, 0x0F, 0xE0, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x78,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x07,
  0x80, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x01, 0xF0, 0x07, 0x80, 0x7F, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03,
  0xE0, 0x7F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1E,
  0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3C,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0x78, 0x7C,
  0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x0F, 0x03, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0x80, 0x3F, 0x00, 0xF0, 0x0F,
  0xC0, 0x1E, 0x07, 0xF0, 0x03, 0xC1, 0xFC, 0x00, 0xF0, 0xFF, 0x00, 0x1E,
  0x3F, 0x80, 0x03, 0xDF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x3C, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07,
  0x80, 0x0F, 0xC0, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0xDF, 0xFF, 0x3F, 0xFC,
  0x7F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0x00, 0x7F, 0xEF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x7E, 0x3E, 0x0F, 0x0F, 0x87,
  0xC3, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x7C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x03, 0xC0, 0x7F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x3E,
  0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C,
  0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0x7E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x1F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xC0, 0xF0, 0x3F, 0x80, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3C,
  0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x07,
  0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xFE,
  0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFE, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x04, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xF0, 0x0C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x20, 0x01, 0xF0, 0x7C, 0x07,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x78,
  0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80,
  0x1F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF0, 0x03,
  0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x7C,
  0x78, 0x00, 0xF8, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xFC, 0x3F, 0x07, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF3, 0xC0, 0x3F, 0x87, 0x80, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0x78, 0x00,
  0xF9, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE1,
  0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xF0,
  0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x0E, 0x07, 0xC7,
  0xC1, 0xE0, 0x78, 0x78, 0x1E, 0x07, 0x87, 0x83, 0xF0, 0xF8, 0x78, 0x3F,
  0x0F, 0x07, 0x87, 0xF0, 0xF0, 0x78, 0x7F, 0x1E, 0x07, 0x8F, 0xF1, 0xE0,
  0x78, 0xE7, 0x1E, 0x07, 0x9C, 0x73, 0xC0, 0x79, 0xC7, 0x3C, 0x07, 0xB8,
  0x73, 0x80, 0x77, 0x87, 0x78, 0x07, 0x70, 0x77, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x7E, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xF0, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x04, 0x0F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x06, 0x0F, 0xF0, 0x07, 0x1F, 0xFC, 0x0F, 0x3F, 0xFE,
  0x1E, 0x7C, 0x7F, 0xFE, 0x78, 0x1F, 0xFC, 0xF0, 0x0F, 0xF8, 0x30, 0x03,
  0xE0,
};

const GFXglyph UbuntuMono_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 34, 28, 10, -34 },
  { 57, 16, 14, 28, 12, -37 },
  { 85, 29, 34, 28, 2, -34 },
  { 209, 25, 43, 28, 4, -38 },
  { 344, 33, 34, 28, 0, -34 },
  { 485, 24, 34, 28, 3, -34 },
  { 587, 8, 15, 28, 16, -37 },
  { 602, 21, 48, 28, 8, -39 },
  { 728, 21, 48, 28, 3, -39 },
  { 854, 21, 20, 28, 8, -34 },
  { 907, 23, 24, 28, 5, -26 },
  { 976, 12, 14, 28, 6, -7 },
  { 997, 13, 4, 28, 10, -16 },
  { 1004, 8, 7, 28, 10, -7 },
  { 1011, 31, 47, 28, -1, -38 },
  { 1194, 24, 34, 28, 5, -34 },
  { 1296, 20, 34, 28, 5, -34 },
  { 1381, 25, 34, 28, 4, -34 },
  { 1488, 25, 34, 28, 3, -34 },
  { 1595, 25, 34, 28, 3, -34 },
  { 1702, 27, 34, 28, 3, -34 },
  { 1817, 25, 34, 28, 5, -34 },
  { 1924, 24, 34, 28, 8, -34 },
  { 2026, 26, 34, 28, 4, -34 },
  { 2137, 25, 34, 28, 4, -34 },
  { 2244, 12, 25, 28, 10, -25 },
  { 2282, 16, 32, 28, 6, -25 },
  { 2346, 24, 22, 28, 4, -25 },
  { 2412, 26, 15, 28, 3, -22 },
  { 2461, 25, 22, 28, 3, -25 },
  { 2530, 19, 34, 28, 9, -34 },
  { 2611, 27, 41, 28, 4, -34 },
  { 2750, 27, 34, 28, -1, -34 },
  { 2865, 27, 34, 28, 2, -34 },
  { 2980, 27, 34, 28, 5, -34 },
  { 3095, 27, 34, 28, 2, -34 },
  { 3210, 27, 34, 28, 4, -34 },
  { 3325, 27, 34, 28, 4, -34 },
  { 3440, 27, 34, 28, 4, -34 },
  { 3555, 30, 34, 28, 2, -34 },
  { 3683, 26, 34, 28, 4, -34 },
  { 3794, 26, 34, 28, 4, -34 },
  { 3905, 30, 34, 28, 2, -34 },
  { 4033, 20, 34, 28, 3, -34 },
  { 4118, 30, 34, 28, 1, -34 },
  { 4246, 30, 34, 28, 2, -34 },
  { 4374, 26, 34, 28, 4, -34 },
  { 4485, 27, 34, 28, 3, -34 },
  { 4600, 26, 43, 28, 4, -34 },
  { 4740, 27, 34, 28, 2, -34 },
  { 4855, 27, 34, 28, 3, -34 },
  { 4970, 24, 34, 28, 8, -34 },
  { 5072, 28, 34, 28, 4, -34 },
  { 5191, 27, 34, 28, 7, -34 },
  { 5306, 30, 34, 28, 3, -34 },
  { 5434, 33, 34, 28, 0, -34 },
  { 5575, 26, 34, 28, 8, -34 },
  { 5686, 29, 34, 28, 2, -34 },
  { 5810, 25, 47, 28, 5, -38 },
  { 5957, 8, 47, 28, 12, -38 },
  { 6004, 25, 47, 28, 1, -38 },
  { 6151, 22, 18, 28, 6, -34 },
  { 6201, 25, 4, 28, -1, 5 },
  { 6214, 10, 10, 28, 14, -38 },
  { 6227, 24, 28, 28, 4, -27 },
  { 6311, 25, 39, 28, 3, -38 },
  { 6433, 24, 28, 28, 4, -27 },
  { 6517, 28, 39, 28, 4, -38 },
  { 6654, 24, 28, 28, 4, -27 },
  { 6738, 33, 47, 28, 0, -38 },
  { 6932, 28, 36, 28, 1, -27 },
  { 7058, 24, 38, 28, 2, -38 },
  { 7172, 16, 37, 28, 7, -37 },
  { 7246, 27, 46, 28, 1, -37 },
  { 7402, 27, 38, 28, 3, -38 },
  { 7531, 14, 39, 28, 10, -38 },
  { 7600, 27, 27, 28, 2, -27 },
  { 7692, 24, 27, 28, 3, -27 },
  { 7773, 24, 28, 28, 4, -27 },
  { 7857, 27, 36, 28, 1, -27 },
  { 7979, 25, 36, 28, 4, -27 },
  { 8092, 24, 27, 28, 5, -27 },
  { 8173, 24, 28, 28, 4, -27 },
  { 8257, 20, 35, 28, 8, -34 },
  { 8345, 23, 27, 28, 5, -26 },
  { 8423, 22, 26, 28, 7, -26 },
  { 8495, 28, 26, 28, 4, -26 },
  { 8586, 29, 26, 28, 1, -26 },
  { 8681, 30, 35, 28, -1, -26 },
  { 8813, 25, 26, 28, 3, -26 },
  { 8895, 26, 47, 28, 5, -38 },
  { 9048, 16, 47, 28, 8, -38 },
  { 9142, 27, 47, 28, 0, -38 },
  { 9301, 24, 8, 28, 4, -18 },
};

const GFXfont UbuntuMono_Italic55pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic55pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic55pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUMONO_ITALIC55PT7B_H_
