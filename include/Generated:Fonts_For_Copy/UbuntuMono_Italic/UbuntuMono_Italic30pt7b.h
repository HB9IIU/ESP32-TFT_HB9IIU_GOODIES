#ifndef _UBUNTUMONO_ITALIC30PT7B_H_
#define _UBUNTUMONO_ITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0x80,
  0x00, 0x00, 0x38, 0xF1, 0xE1, 0x80, 0x63, 0x67, 0xE7, 0xC6, 0xC6, 0xC4,
  0x84, 0x00, 0xC3, 0x00, 0xC6, 0x01, 0x86, 0x01, 0x8E, 0x03, 0x8C, 0x3F,
  0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C,
  0x60, 0x7F, 0xFC, 0xFF, 0xFC, 0x30, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x63,
  0x80, 0xE3, 0x00, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x7E, 0x07, 0xFC,
  0x38, 0x21, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC4, 0x0E,
  0x3F, 0xF0, 0x3F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x07, 0x80, 0xC3,
  0xF0, 0x60, 0xCC, 0x30, 0x63, 0x18, 0x18, 0xCC, 0x06, 0x67, 0x01, 0x99,
  0x80, 0x7C, 0xC0, 0x0E, 0x60, 0x00, 0x30, 0x00, 0x19, 0xC0, 0x0E, 0xF8,
  0x03, 0x66, 0x01, 0x99, 0x80, 0xC4, 0x60, 0x63, 0x18, 0x30, 0xEE, 0x1C,
  0x1F, 0x06, 0x07, 0x80, 0x03, 0xE0, 0x3F, 0x83, 0x9C, 0x38, 0x61, 0xC7,
  0x0C, 0x30, 0x73, 0x83, 0xB8, 0x0F, 0x00, 0xF1, 0xCF, 0xCC, 0xE6, 0x6E,
  0x3F, 0x60, 0xF3, 0x03, 0x18, 0x3C, 0xE3, 0xE7, 0xFB, 0x0F, 0x1C, 0x77,
  0x66, 0xEC, 0xCC, 0x00, 0x20, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0x80, 0x02, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x10, 0x00, 0x06, 0x00, 0x60, 0x06, 0x04, 0x62,
  0xF6, 0xE3, 0xFC, 0x0F, 0x01, 0xF8, 0x39, 0xC3, 0x9C, 0x10, 0x80, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x7C, 0xF8, 0xF0,
  0xC7, 0x3C, 0x60, 0x7F, 0xFC, 0x77, 0xFE, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x1C,
  0x70, 0x73, 0x83, 0xB8, 0x1D, 0x80, 0xEC, 0xE7, 0xEF, 0x37, 0x79, 0xB1,
  0x9D, 0x80, 0xEC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x38, 0xE3, 0x87, 0xF8,
  0x0F, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0x07, 0xE1, 0xDC, 0x23, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x1F, 0xFB, 0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xE0, 0xC3, 0x82, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x03, 0xE0, 0x7F, 0xC3, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x3F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0xC1, 0xE7, 0xFE, 0x1F, 0xC0, 0x00, 0x1C,
  0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xD8, 0x0E, 0x60, 0x73, 0x83, 0x8E,
  0x0C, 0x30, 0x60, 0xC3, 0x07, 0x1C, 0x1C, 0x7F, 0xFD, 0xFF, 0xE0, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0F, 0x80, 0x1F,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0xC1, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xE0,
  0x7C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1F, 0xF0, 0x7F, 0xE3,
  0xC3, 0x8E, 0x07, 0x38, 0x1C, 0xC0, 0x73, 0x01, 0xCC, 0x06, 0x38, 0x38,
  0xE1, 0xC1, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x03, 0x1C,
  0x0C, 0x60, 0x71, 0xC1, 0xC7, 0x0E, 0x0F, 0xF0, 0x3F, 0x03, 0xCE, 0x0C,
  0x1C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x38, 0x1C, 0x70, 0xE1, 0xFF, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xE3, 0x87, 0x07, 0x18, 0x0C, 0xE0,
  0x33, 0x80, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF1, 0xFF, 0x83, 0xFE, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xF8, 0x0F, 0x80, 0x00,
  0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x8E,
  0x00, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x07, 0xC3, 0xE0, 0xF0, 0x30, 0x70, 0xF0, 0x60, 0x00, 0x00, 0x08,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x06, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x18, 0x3F, 0xFD, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x10, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1C, 0x03, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x3C, 0x01, 0x00, 0x00, 0x1F, 0x87, 0xF8, 0x87, 0x00, 0x70, 0x0C,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xF8,
  0x1C, 0x30, 0x60, 0x71, 0xC0, 0xE7, 0x01, 0xCC, 0x1F, 0xB8, 0xFE, 0x63,
  0x8C, 0xCE, 0x3B, 0x98, 0x77, 0x30, 0xCC, 0x61, 0x98, 0xC3, 0x31, 0x8E,
  0x63, 0x98, 0xE3, 0xF1, 0xC3, 0xE1, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x36, 0x01,
  0xD8, 0x06, 0x60, 0x31, 0x81, 0xC7, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0xC7,
  0x07, 0x1F, 0xFC, 0xFF, 0xF3, 0x01, 0xDC, 0x07, 0x60, 0x1F, 0x80, 0x7C,
  0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x38, 0x70, 0x60, 0x70, 0xC0, 0xE3,
  0x81, 0x87, 0x07, 0x0C, 0x1C, 0x1F, 0xF0, 0x7F, 0xE0, 0xE0, 0xE1, 0x80,
  0xC3, 0x01, 0xC6, 0x03, 0x9C, 0x06, 0x38, 0x1C, 0x60, 0xF0, 0xFF, 0xC3,
  0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0, 0x87, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x41, 0xFF, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x1F, 0xF0, 0x30, 0xF0, 0x60, 0xE1, 0xC0, 0xC3, 0x81, 0xC6,
  0x03, 0x8C, 0x07, 0x38, 0x0E, 0x70, 0x18, 0xC0, 0x31, 0x80, 0xE3, 0x01,
  0xCE, 0x07, 0x1C, 0x0E, 0x30, 0x38, 0x61, 0xE1, 0xFF, 0x83, 0xF8, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xFF, 0xE3, 0xFF, 0x80,
  0x0F, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0xF8, 0x07, 0xFC, 0x3C, 0x10, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x1C, 0x06, 0x18, 0x1C, 0x38, 0x38, 0x78, 0x60, 0x7F, 0xC0, 0x7F, 0x00,
  0x0E, 0x03, 0x0E, 0x07, 0x0C, 0x07, 0x0C, 0x06, 0x1C, 0x06, 0x1C, 0x06,
  0x18, 0x0E, 0x18, 0x0E, 0x1F, 0xFC, 0x3F, 0xFC, 0x38, 0x1C, 0x30, 0x1C,
  0x30, 0x18, 0x70, 0x18, 0x70, 0x38, 0x60, 0x38, 0x60, 0x30, 0xE0, 0x30,
  0xE0, 0x70, 0x0F, 0xFC, 0x3F, 0xF0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x20, 0x70, 0xE1, 0xC1, 0xFF, 0x00, 0xFC, 0x00,
  0x06, 0x07, 0x07, 0x07, 0x03, 0x87, 0x01, 0x87, 0x00, 0xC7, 0x00, 0x63,
  0x80, 0x73, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0x70, 0x03, 0x1C, 0x01, 0x86, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x38, 0x0E, 0x00, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x1B, 0x16, 0x1B, 0x36, 0x1B, 0x66,
  0x3B, 0x6E, 0x31, 0xCC, 0x31, 0xCC, 0x31, 0x8C, 0x70, 0x0C, 0x60, 0x1C,
  0x60, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0x06, 0x03,
  0x0F, 0x03, 0x0F, 0x03, 0x0F, 0x07, 0x0F, 0x06, 0x1D, 0x86, 0x19, 0x86,
  0x19, 0x8E, 0x19, 0x8C, 0x38, 0xCC, 0x30, 0xCC, 0x30, 0xDC, 0x30, 0xD8,
  0x70, 0xD8, 0x70, 0x78, 0x60, 0x78, 0x60, 0x78, 0x60, 0x70, 0xE0, 0x70,
  0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0xC7, 0x07, 0x18, 0x0C, 0xE0, 0x33, 0x00,
  0xDC, 0x03, 0x70, 0x0D, 0x80, 0x76, 0x01, 0xF8, 0x06, 0xE0, 0x3B, 0x80,
  0xCE, 0x07, 0x18, 0x18, 0x71, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xE1, 0xC3, 0xC7, 0x07, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x07,
  0x38, 0x38, 0xC1, 0xC3, 0xFE, 0x1F, 0xE0, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0,
  0xE1, 0xC7, 0x07, 0x18, 0x0C, 0xE0, 0x33, 0x00, 0xDC, 0x03, 0x70, 0x0D,
  0x80, 0x76, 0x01, 0xF8, 0x06, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0x18, 0x18,
  0x71, 0xE0, 0xFF, 0x01, 0xF0, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x70, 0x07, 0xF0, 0x1F, 0xF8, 0x38, 0x70, 0x60, 0x70, 0xC0, 0xE1,
  0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18, 0x1C, 0x30, 0x70, 0xFF, 0xC1, 0xFE,
  0x03, 0x0C, 0x06, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x60, 0x70, 0xC0, 0x63,
  0x80, 0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0xE0, 0x87, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0xC0, 0xE3, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x81, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x06, 0x38, 0x1C, 0x60,
  0x38, 0xC0, 0x63, 0x80, 0xC7, 0x03, 0x8C, 0x07, 0x18, 0x0E, 0x30, 0x18,
  0xE0, 0x31, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x1C, 0x06, 0x38, 0x1C, 0x30,
  0x30, 0x70, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xCE, 0x06, 0x38, 0x38, 0xE0, 0xC3, 0x87,
  0x06, 0x18, 0x18, 0xE0, 0x63, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x18, 0x07, 0x18, 0x07, 0x38, 0x06, 0x38,
  0x06, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x73, 0x8C, 0x63, 0x9C, 0x67,
  0x98, 0x67, 0x98, 0x6D, 0x98, 0x6D, 0xB0, 0xD9, 0xB0, 0xD0, 0xB0, 0xF0,
  0xA0, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0x07, 0x01, 0xC0, 0xC0, 0xE0,
  0x38, 0x38, 0x0E, 0x1C, 0x01, 0x8E, 0x00, 0x73, 0x00, 0x1D, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x07, 0x30,
  0x01, 0xCE, 0x00, 0xE3, 0x80, 0x70, 0x60, 0x38, 0x1C, 0x1C, 0x07, 0x07,
  0x00, 0xC0, 0xE0, 0x0C, 0xC0, 0x39, 0x80, 0xE3, 0x01, 0x87, 0x07, 0x0E,
  0x1C, 0x0C, 0x70, 0x1C, 0xE0, 0x3B, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xCC,
  0xCC, 0xCE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x77, 0x77, 0x77, 0x73,
  0x03, 0xF8, 0x1F, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0xC0,
  0x6E, 0x0E, 0x61, 0xC6, 0x38, 0x77, 0x03, 0x60, 0x36, 0x03, 0x7F, 0xFF,
  0xFF, 0xF0, 0x47, 0x1C, 0x71, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0x86, 0x70,
  0x77, 0x03, 0xB8, 0x1B, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x03, 0x38, 0x18,
  0xE3, 0xC7, 0xFE, 0x1F, 0x30, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFC, 0x1F, 0xF0, 0xE1, 0xCE, 0x0E, 0x70,
  0x33, 0x01, 0x98, 0x0D, 0xC0, 0xEE, 0x06, 0x60, 0x73, 0x07, 0x38, 0xF1,
  0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0xC7, 0x82, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x43,
  0xFE, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0x3C, 0x30, 0xE0, 0x61,
  0x81, 0xC7, 0x03, 0x0C, 0x06, 0x18, 0x1C, 0x70, 0x38, 0xE0, 0x70, 0xC0,
  0xC1, 0xC7, 0x83, 0xFF, 0x01, 0xE7, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x0E,
  0x70, 0x37, 0x03, 0xB0, 0x1F, 0x83, 0xDF, 0xFC, 0xFF, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x43, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x07, 0xFC, 0x3C, 0x30, 0xF0,
  0x61, 0xC1, 0xC7, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x38, 0x60, 0x70,
  0xE1, 0xC1, 0xFF, 0x80, 0xF7, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0xC1,
  0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0xFC, 0x1F, 0xF0, 0xE1, 0xC6, 0x06, 0x30,
  0x33, 0x81, 0x9C, 0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x33, 0x81, 0x98, 0x1C,
  0xC0, 0xEE, 0x06, 0x00, 0x07, 0x07, 0x83, 0xC0, 0xC0, 0x00, 0x03, 0xF9,
  0xFC, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x07, 0xE1, 0xF0, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x0C, 0x38, 0x3F, 0xC0, 0x7E, 0x00, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x07, 0x18, 0x38, 0x61, 0xC3, 0x8C, 0x0E, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xF0, 0x1C, 0xE0, 0x63, 0x81, 0x87, 0x0E, 0x0C, 0x38, 0x38, 0xC0, 0x60,
  0x7E, 0xFE, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x71, 0x7F, 0x3F, 0x0F, 0xBC, 0x3F,
  0xF8, 0x67, 0x39, 0xCE, 0x73, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xCE,
  0x73, 0x98, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xCE, 0x03, 0x18, 0x06, 0x00,
  0x0F, 0xE0, 0xFF, 0x86, 0x1E, 0x70, 0x73, 0x83, 0x98, 0x1C, 0xC0, 0xEE,
  0x06, 0x70, 0x33, 0x03, 0x98, 0x1D, 0xC0, 0xCE, 0x06, 0x60, 0x70, 0x03,
  0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x77, 0x01, 0xB8, 0x0D, 0x80, 0xEC, 0x07,
  0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xE3, 0xC7, 0xFC, 0x0F, 0x80, 0x07, 0xF0,
  0x3F, 0xE0, 0xC1, 0xC7, 0x07, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x07,
  0x38, 0x18, 0xC0, 0xE3, 0x07, 0x1C, 0x38, 0x7F, 0xC1, 0xFC, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xF1,
  0xE1, 0x8E, 0x06, 0x30, 0x39, 0xC0, 0xE6, 0x03, 0x18, 0x1C, 0xE0, 0x73,
  0x81, 0xC6, 0x06, 0x1C, 0x38, 0x7F, 0xE0, 0x7B, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x07, 0xF8, 0xFF, 0x8E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0x04, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x81,
  0xC7, 0xFC, 0x1F, 0x80, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x0F, 0xFF, 0xFF,
  0xC6, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x84, 0x3F, 0x83, 0xE0, 0x70, 0x37, 0x03, 0x70, 0x76, 0x07, 0x60,
  0x6E, 0x06, 0xE0, 0xEC, 0x0E, 0xC0, 0xCC, 0x0C, 0xC1, 0xCE, 0x3C, 0xFF,
  0xC7, 0xCC, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1,
  0x86, 0x38, 0x67, 0x06, 0x60, 0x6E, 0x07, 0xC0, 0x78, 0x03, 0x00, 0x70,
  0x06, 0xE0, 0x0D, 0x80, 0x33, 0x0C, 0x66, 0x38, 0xCC, 0x73, 0x19, 0xE6,
  0x36, 0xDC, 0x6D, 0xB0, 0xF3, 0x63, 0xE7, 0x87, 0x8F, 0x0E, 0x0E, 0x1C,
  0x18, 0x00, 0x1C, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x39, 0x80, 0x76, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x73, 0x81, 0xC3,
  0x87, 0x07, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xC0,
  0xE0, 0xE0, 0x70, 0x70, 0x18, 0x30, 0x0C, 0x38, 0x07, 0x18, 0x03, 0x9C,
  0x01, 0xCC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x03, 0x07, 0x07, 0x06, 0x06,
  0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0x03, 0xE0, 0x0F,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xF0, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x1C, 0x0D, 0xFC, 0x66, 0x3F,
  0x30, 0x78,
};

const GFXglyph UbuntuMono_Italic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 19, 15, 5, -19 },
  { 18, 8, 7, 15, 7, -19 },
  { 25, 16, 19, 15, 1, -19 },
  { 63, 14, 24, 15, 2, -21 },
  { 105, 18, 19, 15, 0, -19 },
  { 148, 13, 19, 15, 2, -19 },
  { 179, 4, 8, 15, 9, -20 },
  { 183, 12, 26, 15, 4, -21 },
  { 222, 11, 26, 15, 2, -21 },
  { 258, 12, 11, 15, 4, -19 },
  { 275, 12, 14, 15, 3, -15 },
  { 296, 7, 8, 15, 3, -4 },
  { 303, 7, 2, 15, 5, -8 },
  { 305, 5, 4, 15, 5, -4 },
  { 308, 18, 26, 15, -1, -21 },
  { 367, 13, 19, 15, 3, -19 },
  { 398, 11, 19, 15, 3, -19 },
  { 425, 14, 19, 15, 2, -19 },
  { 459, 13, 19, 15, 2, -19 },
  { 490, 14, 19, 15, 1, -19 },
  { 524, 15, 19, 15, 2, -19 },
  { 560, 14, 19, 15, 3, -19 },
  { 594, 14, 19, 15, 4, -19 },
  { 628, 14, 19, 15, 2, -19 },
  { 662, 14, 19, 15, 2, -19 },
  { 696, 7, 14, 15, 5, -14 },
  { 709, 9, 18, 15, 3, -14 },
  { 730, 14, 12, 15, 2, -14 },
  { 751, 14, 8, 15, 2, -12 },
  { 765, 13, 12, 15, 2, -14 },
  { 785, 11, 19, 15, 5, -19 },
  { 812, 15, 23, 15, 2, -19 },
  { 856, 14, 19, 15, 0, -19 },
  { 890, 15, 19, 15, 1, -19 },
  { 926, 14, 19, 15, 3, -19 },
  { 960, 15, 19, 15, 1, -19 },
  { 996, 15, 19, 15, 2, -19 },
  { 1032, 15, 19, 15, 2, -19 },
  { 1068, 15, 19, 15, 2, -19 },
  { 1104, 16, 19, 15, 1, -19 },
  { 1142, 14, 19, 15, 2, -19 },
  { 1176, 15, 19, 15, 2, -19 },
  { 1212, 17, 19, 15, 1, -19 },
  { 1253, 11, 19, 15, 2, -19 },
  { 1280, 16, 19, 15, 1, -19 },
  { 1318, 16, 19, 15, 1, -19 },
  { 1356, 14, 19, 15, 2, -19 },
  { 1390, 14, 19, 15, 2, -19 },
  { 1424, 14, 24, 15, 2, -19 },
  { 1466, 15, 19, 15, 1, -19 },
  { 1502, 14, 19, 15, 2, -19 },
  { 1536, 13, 19, 15, 5, -19 },
  { 1567, 15, 19, 15, 2, -19 },
  { 1603, 14, 19, 15, 4, -19 },
  { 1637, 16, 19, 15, 2, -19 },
  { 1675, 18, 19, 15, 0, -19 },
  { 1718, 15, 19, 15, 4, -19 },
  { 1754, 16, 19, 15, 1, -19 },
  { 1792, 13, 26, 15, 3, -21 },
  { 1835, 4, 26, 15, 7, -21 },
  { 1848, 13, 26, 15, 1, -21 },
  { 1891, 12, 10, 15, 3, -19 },
  { 1906, 14, 2, 15, -1, 3 },
  { 1910, 5, 5, 15, 8, -20 },
  { 1914, 13, 14, 15, 2, -14 },
  { 1937, 13, 21, 15, 2, -21 },
  { 1972, 13, 14, 15, 2, -14 },
  { 1995, 15, 21, 15, 2, -21 },
  { 2035, 13, 14, 15, 2, -14 },
  { 2058, 18, 26, 15, 0, -21 },
  { 2117, 15, 19, 15, 1, -14 },
  { 2153, 13, 21, 15, 1, -21 },
  { 2188, 9, 20, 15, 4, -20 },
  { 2211, 14, 25, 15, 1, -20 },
  { 2255, 14, 21, 15, 2, -21 },
  { 2292, 8, 21, 15, 5, -21 },
  { 2313, 15, 14, 15, 1, -14 },
  { 2340, 13, 14, 15, 2, -14 },
  { 2363, 13, 14, 15, 2, -14 },
  { 2386, 14, 19, 15, 1, -14 },
  { 2420, 14, 19, 15, 2, -14 },
  { 2454, 13, 14, 15, 3, -14 },
  { 2477, 13, 14, 15, 2, -14 },
  { 2500, 11, 18, 15, 4, -18 },
  { 2525, 12, 14, 15, 3, -14 },
  { 2546, 12, 14, 15, 4, -14 },
  { 2567, 15, 14, 15, 2, -14 },
  { 2594, 15, 14, 15, 1, -14 },
  { 2621, 17, 19, 15, -1, -14 },
  { 2662, 13, 14, 15, 2, -14 },
  { 2685, 14, 26, 15, 3, -21 },
  { 2731, 8, 26, 15, 5, -21 },
  { 2757, 14, 26, 15, 0, -21 },
  { 2803, 14, 4, 15, 2, -12 },
};

const GFXfont UbuntuMono_Italic30pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic30pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic30pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUMONO_ITALIC30PT7B_H_
