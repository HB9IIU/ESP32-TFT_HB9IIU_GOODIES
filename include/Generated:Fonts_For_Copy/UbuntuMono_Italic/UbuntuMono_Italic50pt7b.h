#ifndef _UBUNTUMONO_ITALIC50PT7B_H_
#define _UBUNTUMONO_ITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x70, 0x00,
  0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xDE, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x07,
  0x1C, 0x1C, 0xF0, 0x73, 0x81, 0x8E, 0x0E, 0x30, 0x38, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03,
  0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x01, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x0C, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x20, 0x01, 0xF0, 0x3C, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xF0,
  0x0F, 0x00, 0x7F, 0xC0, 0x38, 0x03, 0xC7, 0x01, 0xC0, 0x0E, 0x1C, 0x0F,
  0x00, 0x78, 0x70, 0x78, 0x01, 0xC1, 0xC3, 0xC0, 0x07, 0x07, 0x1E, 0x00,
  0x1C, 0x1C, 0x70, 0x00, 0x70, 0xF3, 0x80, 0x01, 0xE7, 0x9C, 0x00, 0x07,
  0xFE, 0xF0, 0x00, 0x1F, 0xF7, 0x80, 0x00, 0x3F, 0xBC, 0x00, 0x00, 0x7D,
  0xE7, 0x80, 0x00, 0x07, 0x7F, 0x80, 0x00, 0x39, 0xFE, 0x00, 0x01, 0xCF,
  0xF8, 0x00, 0x0F, 0x78, 0xE0, 0x00, 0x79, 0xC3, 0xC0, 0x03, 0xC7, 0x0E,
  0x00, 0x1E, 0x3C, 0x38, 0x00, 0x70, 0xE0, 0xE0, 0x03, 0x83, 0x83, 0x80,
  0x1E, 0x0E, 0x1E, 0x00, 0xF0, 0x3C, 0xF0, 0x07, 0x80, 0xFF, 0xC0, 0x3C,
  0x01, 0xFE, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xF0,
  0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x81, 0xE0,
  0x0E, 0x07, 0x80, 0x3C, 0x7C, 0x00, 0xF3, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x03, 0xC1, 0xFE, 0x0E, 0x1F, 0x78, 0x78, 0xF9, 0xF1,
  0xE3, 0xC3, 0xEF, 0x1E, 0x07, 0xBC, 0x78, 0x1F, 0xE3, 0xC0, 0x3F, 0x8F,
  0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC3,
  0xFE, 0x1F, 0xFF, 0x78, 0x7F, 0xF9, 0xE0, 0xFF, 0xC7, 0xC0, 0xF8, 0x1F,
  0x00, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0x87, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x04, 0x0E, 0x04, 0xF1, 0xC7, 0xBF, 0xBB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x1E, 0x3C,
  0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x0E, 0x0E, 0x00, 0x80, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x7C, 0x7F,
  0x0F, 0xC0, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x3D, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF0, 0x7C, 0x03,
  0xC3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xCF,
  0x80, 0x0F, 0x3C, 0x38, 0x3C, 0xF1, 0xF0, 0xF7, 0x8F, 0xC7, 0xDE, 0x3F,
  0x1E, 0x78, 0xFC, 0x79, 0xE1, 0xF1, 0xEF, 0x87, 0x8F, 0xBC, 0x00, 0x3C,
  0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x00, 0xF0, 0xF8,
  0x07, 0xC1, 0xE0, 0x3E, 0x07, 0xC3, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0x3C, 0x0F, 0x0F, 0x01, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0x07, 0xE0, 0x38, 0x07, 0xC0, 0x40,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0E,
  0x07, 0xC0, 0x10, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x80,
  0x07, 0xE1, 0xC0, 0x3F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xBC, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x20, 0x01, 0xF0, 0x1C,
  0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE3,
  0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x01,
  0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF0,
  0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF0, 0x7E, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0x7C, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0x1F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F,
  0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF8,
  0xF0, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x3F, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0xE0, 0x3F, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x07, 0xF3, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x1E, 0x00, 0x00,
  0x78, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x0C, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE3,
  0xC0, 0x3F, 0xF1, 0xE0, 0x7F, 0xF1, 0xE0, 0x7F, 0xF8, 0xF0, 0x7F, 0xFC,
  0x78, 0x7E, 0x1E, 0x78, 0x7C, 0x0E, 0x3C, 0x3C, 0x0F, 0x1E, 0x3C, 0x07,
  0x8F, 0x1E, 0x03, 0xC7, 0x8F, 0x03, 0xC3, 0x87, 0x81, 0xE3, 0xC3, 0xC0,
  0xF1, 0xE1, 0xE0, 0xF8, 0xF0, 0xF8, 0x78, 0x78, 0x3F, 0xFC, 0x1C, 0x1F,
  0xFE, 0x0F, 0x07, 0xFE, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xDE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xE0, 0x3F,
  0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0x00, 0xFC, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C,
  0x78, 0x01, 0xF8, 0x78, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC0, 0xF0, 0x1F, 0x80,
  0x10, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x20, 0x0F, 0xC0, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xC0, 0xFE, 0x03, 0xC0,
  0x3E, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x78, 0x03, 0xF0, 0x78, 0x07,
  0xE0, 0x78, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xF8, 0x1E, 0x07, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF8,
  0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7F, 0x03, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x3E,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3C,
  0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x20, 0x03, 0xC0, 0x18, 0x03, 0xE0, 0x1F,
  0x07, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00,
  0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x1E, 0x7E, 0x00, 0x03, 0xDF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x77, 0x07, 0xF0, 0x0E, 0xE0,
  0xEE, 0x01, 0xDC, 0x39, 0xC0, 0x73, 0x87, 0x78, 0x0E, 0x71, 0xCE, 0x01,
  0xCE, 0x39, 0xC0, 0x79, 0xCE, 0x38, 0x0E, 0x3B, 0xC7, 0x01, 0xC3, 0x71,
  0xE0, 0x78, 0x7C, 0x3C, 0x0F, 0x0F, 0x87, 0x01, 0xC1, 0xE0, 0xE0, 0x78,
  0x3C, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x3E,
  0x00, 0x3C, 0x07, 0xC0, 0x07, 0x00, 0xFC, 0x01, 0xE0, 0x3F, 0x80, 0x3C,
  0x07, 0xF0, 0x07, 0x80, 0xFE, 0x00, 0xE0, 0x1D, 0xE0, 0x3C, 0x07, 0xBC,
  0x07, 0x80, 0xF3, 0x80, 0xF0, 0x1E, 0x78, 0x1C, 0x03, 0x8F, 0x07, 0x80,
  0xF0, 0xE0, 0xF0, 0x1E, 0x1C, 0x1E, 0x03, 0xC3, 0xC3, 0x80, 0x70, 0x78,
  0x70, 0x1E, 0x07, 0x1E, 0x03, 0xC0, 0xE3, 0xC0, 0x78, 0x1C, 0x78, 0x0E,
  0x03, 0xCE, 0x01, 0xC0, 0x7B, 0xC0, 0x78, 0x07, 0x78, 0x0F, 0x00, 0xEF,
  0x01, 0xE0, 0x1D, 0xC0, 0x38, 0x03, 0xF8, 0x0F, 0x00, 0x7F, 0x01, 0xE0,
  0x07, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0,
  0x3C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC,
  0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78, 0x00,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF8, 0x7E, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xC0,
  0x7E, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x01, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xC0, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x0F, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0,
  0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00,
  0x7C, 0x78, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF8, 0x7E,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F,
  0x03, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x7E, 0x0F, 0x01, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1E, 0x7F, 0x00,
  0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xF0,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x0E,
  0x03, 0xE0, 0x02, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x60, 0x03, 0xF0, 0x78, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC1, 0xE0, 0xE0, 0x38, 0x7C,
  0x3C, 0x0F, 0x0F, 0x87, 0x81, 0xE3, 0xF0, 0xE0, 0x38, 0x7E, 0x1C, 0x07,
  0x1D, 0xC7, 0x80, 0xE3, 0x98, 0xF0, 0x1C, 0xE3, 0x1C, 0x07, 0xBC, 0x73,
  0x80, 0xE7, 0x0E, 0xF0, 0x1D, 0xE1, 0xDC, 0x03, 0xB8, 0x3B, 0x80, 0x7E,
  0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0,
  0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78,
  0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xB8, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x03, 0xC1, 0xE0,
  0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00,
  0x79, 0xE0, 0x01, 0xCF, 0x00, 0x0F, 0x10, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x20, 0x38, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0E, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x78, 0x7E, 0x01,
  0xE3, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFE, 0xF0, 0x0F, 0xE1, 0xC0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF3, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF8,
  0x3F, 0x0F, 0x80, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E,
  0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x01,
  0xF1, 0xE0, 0x0F, 0x87, 0x80, 0x7E, 0x1E, 0x0F, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xE0, 0x30, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x10, 0x7E, 0x03, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xC1, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0xC0,
  0x1F, 0xFE, 0xE0, 0x07, 0xFE, 0x78, 0x00, 0xFC, 0x3C, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFE, 0x0F, 0x8F,
  0xC0, 0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x07,
  0xFE, 0x00, 0x7D, 0xE0, 0x3F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x87, 0xE0, 0x3C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x04, 0x3F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x3E, 0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xCF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x01, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF7, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E,
  0x1E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE1, 0xE0, 0x0F, 0x8F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x70, 0x3F,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x7E, 0x07, 0x80, 0xFC, 0x07, 0x81,
  0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x0F, 0xC0, 0x0F, 0x1F, 0x80, 0x0F, 0x7E,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x7F, 0xE7,
  0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x83, 0x7F, 0xF9, 0xFF, 0xCF, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7C,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0x0F, 0x8F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x0F, 0x1E, 0x0E, 0x0F, 0x1E, 0x1E, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x1E, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x3C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0xF8, 0x1E,
  0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3C, 0x01,
  0xF1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3,
  0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x3C, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0x7C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F,
  0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xF7,
  0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xF0, 0x0F, 0x87, 0xC1, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F,
  0x07, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x1E, 0x01, 0xF8, 0x1E, 0x07, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x1F, 0x07, 0xC0, 0x78, 0x3E,
  0x01, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0xF9, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x7E, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xE0, 0x08, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x03, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x80, 0x0F, 0x87,
  0x80, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x18, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0x0F, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0xF1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x80, 0xFC, 0x1F, 0x07, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xBC, 0x03, 0xF8, 0x78, 0xF0, 0x01, 0xFF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF8, 0x1E,
  0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F,
  0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xE3, 0xC0,
  0x00, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x38, 0x70, 0x7C, 0x3C, 0x38,
  0x3E, 0x1C, 0x1C, 0x3F, 0x1E, 0x0E, 0x1F, 0x8F, 0x0F, 0x1D, 0xC7, 0x07,
  0x9E, 0xE7, 0x83, 0xCE, 0x73, 0x81, 0xEE, 0x3B, 0xC0, 0xFF, 0x1D, 0xE0,
  0x7F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x78,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xC0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x40, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x18, 0x7F, 0x80,
  0xF3, 0xFF, 0x03, 0x9F, 0xFF, 0x1E, 0x78, 0xFF, 0xF3, 0xC0, 0xFF, 0xCE,
  0x01, 0xFE, 0x18, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 12, 31, 25, 9, -31 },
  { 48, 14, 12, 25, 11, -34 },
  { 69, 26, 31, 25, 2, -31 },
  { 170, 24, 40, 25, 3, -35 },
  { 290, 30, 31, 25, 0, -31 },
  { 407, 22, 31, 25, 3, -31 },
  { 493, 7, 13, 25, 15, -34 },
  { 505, 19, 43, 25, 7, -35 },
  { 608, 19, 43, 25, 3, -35 },
  { 711, 19, 18, 25, 7, -31 },
  { 754, 21, 22, 25, 4, -24 },
  { 812, 11, 14, 25, 5, -7 },
  { 832, 12, 4, 25, 9, -15 },
  { 838, 7, 7, 25, 9, -7 },
  { 845, 29, 43, 25, -1, -35 },
  { 1001, 22, 31, 25, 4, -31 },
  { 1087, 18, 31, 25, 5, -31 },
  { 1157, 23, 31, 25, 3, -31 },
  { 1247, 23, 31, 25, 3, -31 },
  { 1337, 24, 31, 25, 2, -31 },
  { 1430, 25, 31, 25, 3, -31 },
  { 1527, 23, 31, 25, 5, -31 },
  { 1617, 23, 31, 25, 7, -31 },
  { 1707, 23, 31, 25, 4, -31 },
  { 1797, 23, 31, 25, 4, -31 },
  { 1887, 11, 23, 25, 9, -23 },
  { 1919, 15, 30, 25, 5, -23 },
  { 1976, 22, 20, 25, 4, -23 },
  { 2031, 23, 14, 25, 3, -20 },
  { 2072, 22, 20, 25, 3, -23 },
  { 2127, 18, 31, 25, 8, -31 },
  { 2197, 25, 38, 25, 3, -31 },
  { 2316, 24, 31, 25, -1, -31 },
  { 2409, 24, 31, 25, 2, -31 },
  { 2502, 25, 31, 25, 4, -31 },
  { 2599, 24, 31, 25, 2, -31 },
  { 2692, 24, 31, 25, 4, -31 },
  { 2785, 25, 31, 25, 4, -31 },
  { 2882, 24, 31, 25, 4, -31 },
  { 2975, 27, 31, 25, 2, -31 },
  { 3080, 23, 31, 25, 4, -31 },
  { 3170, 25, 31, 25, 3, -31 },
  { 3267, 27, 31, 25, 2, -31 },
  { 3372, 18, 31, 25, 3, -31 },
  { 3442, 27, 31, 25, 1, -31 },
  { 3547, 27, 31, 25, 2, -31 },
  { 3652, 23, 31, 25, 4, -31 },
  { 3742, 24, 31, 25, 3, -31 },
  { 3835, 23, 39, 25, 4, -31 },
  { 3948, 24, 31, 25, 2, -31 },
  { 4041, 24, 31, 25, 3, -31 },
  { 4134, 21, 31, 25, 8, -31 },
  { 4216, 25, 31, 25, 4, -31 },
  { 4313, 24, 31, 25, 7, -31 },
  { 4406, 27, 31, 25, 3, -31 },
  { 4511, 30, 31, 25, 0, -31 },
  { 4628, 24, 31, 25, 7, -31 },
  { 4721, 27, 31, 25, 2, -31 },
  { 4826, 22, 43, 25, 5, -35 },
  { 4945, 8, 43, 25, 11, -35 },
  { 4988, 23, 43, 25, 1, -35 },
  { 5112, 21, 17, 25, 5, -31 },
  { 5157, 23, 4, 25, -1, 5 },
  { 5169, 9, 9, 25, 13, -34 },
  { 5180, 22, 25, 25, 4, -24 },
  { 5249, 22, 36, 25, 3, -35 },
  { 5348, 22, 25, 25, 4, -24 },
  { 5417, 25, 36, 25, 4, -35 },
  { 5530, 21, 25, 25, 4, -24 },
  { 5596, 30, 43, 25, 0, -35 },
  { 5758, 26, 32, 25, 1, -24 },
  { 5862, 22, 35, 25, 2, -35 },
  { 5959, 14, 34, 25, 7, -34 },
  { 6019, 24, 42, 25, 1, -34 },
  { 6145, 24, 35, 25, 3, -35 },
  { 6250, 13, 36, 25, 9, -35 },
  { 6309, 24, 24, 25, 2, -24 },
  { 6381, 22, 24, 25, 3, -24 },
  { 6447, 21, 25, 25, 4, -24 },
  { 6513, 24, 32, 25, 1, -24 },
  { 6609, 22, 32, 25, 4, -24 },
  { 6697, 22, 24, 25, 4, -24 },
  { 6763, 21, 25, 25, 4, -24 },
  { 6829, 19, 31, 25, 7, -30 },
  { 6903, 22, 24, 25, 4, -23 },
  { 6969, 20, 23, 25, 7, -23 },
  { 7027, 25, 23, 25, 4, -23 },
  { 7099, 26, 23, 25, 1, -23 },
  { 7174, 28, 31, 25, -1, -23 },
  { 7283, 22, 23, 25, 3, -23 },
  { 7347, 25, 43, 25, 4, -35 },
  { 7482, 14, 43, 25, 8, -35 },
  { 7558, 24, 43, 25, 0, -35 },
  { 7687, 22, 8, 25, 4, -17 },
};

const GFXfont UbuntuMono_Italic50pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic50pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic50pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUMONO_ITALIC50PT7B_H_
