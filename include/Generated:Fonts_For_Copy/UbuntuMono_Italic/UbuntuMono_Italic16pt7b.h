#ifndef _UBUNTUMONO_ITALIC16PT7B_H_
#define _UBUNTUMONO_ITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x64, 0x40, 0xCC, 0x99, 0xAA, 0x09, 0x1B, 0x12, 0x7F,
  0x24, 0x6C, 0xFE, 0x48, 0x90, 0x90, 0x04, 0x04, 0x1E, 0x20, 0x20, 0x30,
  0x18, 0x04, 0x04, 0x84, 0x78, 0x20, 0x20, 0x18, 0x8A, 0x42, 0xB0, 0xA8,
  0x34, 0x02, 0xC1, 0x50, 0x94, 0x45, 0x31, 0x80, 0x1C, 0x48, 0x91, 0x63,
  0x8E, 0x77, 0x46, 0x8C, 0xE8, 0xFA, 0x04, 0x31, 0x8C, 0x61, 0x04, 0x30,
  0xC3, 0x04, 0x10, 0x60, 0x80, 0x10, 0x60, 0x83, 0x04, 0x10, 0x43, 0x08,
  0x61, 0x08, 0x42, 0x00, 0x13, 0x53, 0x8E, 0x69, 0x20, 0x08, 0x10, 0x63,
  0xF1, 0x02, 0x0C, 0x00, 0x6D, 0xE0, 0xE0, 0xF0, 0x01, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x08, 0x04, 0x04, 0x00,
  0x1E, 0x64, 0x8A, 0x15, 0xBB, 0x71, 0xE2, 0x4C, 0xE0, 0x04, 0x73, 0xC2,
  0x08, 0x21, 0x86, 0x11, 0xF0, 0x1E, 0x44, 0x08, 0x10, 0x61, 0x0C, 0x30,
  0x41, 0xF8, 0x1E, 0x44, 0x08, 0x31, 0x80, 0x81, 0x82, 0x8D, 0xF0, 0x06,
  0x1C, 0x79, 0x26, 0x58, 0xBF, 0x84, 0x08, 0x10, 0x1F, 0x10, 0x30, 0x20,
  0x38, 0x0C, 0x04, 0x04, 0x8C, 0xF8, 0x0E, 0x61, 0x86, 0x0F, 0x91, 0xA1,
  0x46, 0x89, 0xE0, 0x7E, 0x0C, 0x30, 0x41, 0x06, 0x08, 0x30, 0x41, 0x80,
  0x1E, 0x33, 0x23, 0x22, 0x34, 0x6C, 0x46, 0xC6, 0xC4, 0x78, 0x1E, 0x22,
  0x63, 0x43, 0x62, 0x3E, 0x06, 0x0C, 0x18, 0xE0, 0x6C, 0x01, 0xB0, 0x33,
  0x00, 0x06, 0x66, 0xC0, 0x02, 0x19, 0xC6, 0x07, 0x03, 0x01, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x40, 0x60, 0x30, 0x31, 0xCE, 0x20, 0x00, 0x78, 0x42,
  0x33, 0x31, 0x00, 0xC6, 0x00, 0x0E, 0x31, 0x21, 0x4F, 0x5B, 0xD2, 0x92,
  0x92, 0x9E, 0xC0, 0x40, 0x38, 0x06, 0x0E, 0x0A, 0x12, 0x12, 0x22, 0x3E,
  0x42, 0x42, 0x82, 0x3E, 0x45, 0x8A, 0x37, 0xC8, 0xD1, 0xE3, 0x8D, 0xF0,
  0x0F, 0x31, 0x20, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x44, 0x3C, 0x3C, 0x4D,
  0x8A, 0x14, 0x28, 0x71, 0xC2, 0x8D, 0xE0, 0x3F, 0x20, 0x20, 0x20, 0x7C,
  0x40, 0x40, 0x40, 0xC0, 0xFC, 0x3F, 0x20, 0x20, 0x20, 0x7C, 0x40, 0x40,
  0x40, 0xC0, 0xC0, 0x0F, 0x31, 0x60, 0x40, 0x40, 0xC2, 0xC6, 0xC4, 0x44,
  0x3C, 0x21, 0x21, 0x63, 0x42, 0x7E, 0x42, 0xC6, 0x84, 0x84, 0x84, 0x3F,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30, 0xF8, 0x1F, 0x03, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x04, 0x8C, 0x78, 0x23, 0x26, 0x6C, 0x58, 0x70,
  0x50, 0x58, 0xC8, 0x8C, 0x84, 0x20, 0x82, 0x18, 0x61, 0x04, 0x30, 0xC3,
  0xF0, 0x19, 0x8C, 0xC6, 0xA5, 0x62, 0xD1, 0x69, 0x04, 0x82, 0x43, 0x61,
  0x00, 0x21, 0x31, 0x73, 0x52, 0x5A, 0x4A, 0xCA, 0x8C, 0x8C, 0x8C, 0x1E,
  0x32, 0x63, 0x43, 0x43, 0xC2, 0xC2, 0xC6, 0x4C, 0x78, 0x3E, 0x23, 0x23,
  0x62, 0x46, 0x7C, 0x40, 0xC0, 0x80, 0x80, 0x1E, 0x32, 0x63, 0x43, 0x43,
  0xC2, 0xC2, 0xC6, 0x4C, 0x78, 0x20, 0x30, 0x18, 0x3E, 0x44, 0x8B, 0x14,
  0x6F, 0x92, 0x66, 0x85, 0x08, 0x1F, 0x20, 0x20, 0x20, 0x38, 0x0C, 0x04,
  0x04, 0x84, 0xF8, 0x7E, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10, 0x60, 0x80,
  0x21, 0x21, 0x63, 0x42, 0x42, 0x42, 0xC6, 0xC4, 0xCC, 0x78, 0xC3, 0xC2,
  0xC6, 0xC4, 0xCC, 0xC8, 0xD0, 0x50, 0x60, 0x60, 0x21, 0x30, 0x90, 0x48,
  0x65, 0xA2, 0xD2, 0xA9, 0x58, 0xCC, 0x46, 0x00, 0x10, 0x86, 0x60, 0xB0,
  0x28, 0x0C, 0x03, 0x01, 0xE0, 0xC8, 0x62, 0x10, 0x80, 0xC3, 0x42, 0x44,
  0x48, 0x78, 0x30, 0x20, 0x20, 0x60, 0x60, 0x3F, 0x02, 0x06, 0x0C, 0x18,
  0x10, 0x20, 0x40, 0xC0, 0xFC, 0x1E, 0x20, 0xC1, 0x02, 0x04, 0x18, 0x20,
  0x40, 0x83, 0x04, 0x08, 0x1E, 0x00, 0x49, 0x24, 0x92, 0x6D, 0xB6, 0x40,
  0x0E, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08,
  0x18, 0x70, 0x18, 0xE6, 0xD1, 0x84, 0xFE, 0x48, 0x80, 0x1E, 0xC5, 0x1E,
  0x28, 0x59, 0x9D, 0x00, 0x30, 0x60, 0x81, 0x03, 0xCC, 0x50, 0xA1, 0x47,
  0x9B, 0xC0, 0x1E, 0xC1, 0x06, 0x08, 0x18, 0x9F, 0x00, 0x01, 0x01, 0x03,
  0x03, 0x1E, 0x22, 0x46, 0xC6, 0xC6, 0xCE, 0x74, 0x1E, 0xC5, 0x1F, 0xE8,
  0x18, 0x9F, 0x00, 0x03, 0x81, 0x80, 0x40, 0x30, 0x1F, 0x82, 0x00, 0x80,
  0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x38, 0x00, 0x0F, 0x08, 0x88,
  0x44, 0x66, 0x23, 0x10, 0xF8, 0x0C, 0x04, 0x7C, 0x00, 0x30, 0x40, 0x81,
  0x07, 0xC8, 0xD1, 0xA2, 0xC5, 0x0A, 0x30, 0x31, 0x81, 0xE2, 0x10, 0x8C,
  0x61, 0xC0, 0x03, 0x03, 0x00, 0x1F, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04,
  0x04, 0x08, 0xF0, 0x10, 0x30, 0x20, 0x20, 0x22, 0x64, 0x68, 0x70, 0x58,
  0xC8, 0x84, 0xE2, 0x26, 0x64, 0x4C, 0xCC, 0x70, 0x3F, 0x2D, 0x29, 0x69,
  0x43, 0x42, 0x42, 0x3C, 0xCD, 0x0A, 0x34, 0x58, 0xA1, 0x00, 0x1C, 0xC5,
  0x0E, 0x1C, 0x79, 0x9E, 0x00, 0x1E, 0x33, 0x21, 0x21, 0x23, 0x66, 0x7C,
  0x40, 0x40, 0xC0, 0x1E, 0x45, 0x1E, 0x3C, 0x58, 0x9F, 0x06, 0x08, 0x10,
  0x3E, 0x40, 0x83, 0x04, 0x08, 0x10, 0x00, 0x1E, 0x40, 0x80, 0xC0, 0x50,
  0x9E, 0x00, 0x30, 0xCF, 0xC8, 0x61, 0x04, 0x10, 0x78, 0x62, 0x85, 0x1A,
  0x2C, 0x59, 0x9D, 0x00, 0xC5, 0x8B, 0x26, 0xC5, 0x0E, 0x18, 0x00, 0x41,
  0x43, 0x5A, 0xDA, 0xEC, 0xEC, 0xCC, 0x31, 0x09, 0x03, 0x01, 0x81, 0x41,
  0x31, 0x08, 0x31, 0x18, 0x8C, 0xC2, 0x41, 0x60, 0xA0, 0x70, 0x10, 0x10,
  0x70, 0x00, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x00, 0x07, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x20, 0x60, 0x20, 0x20, 0x20, 0x60, 0x60, 0x38, 0x08,
  0xC4, 0x21, 0x18, 0x84, 0x21, 0x18, 0x84, 0x20, 0x1C, 0x02, 0x06, 0x04,
  0x04, 0x04, 0x04, 0x0F, 0x08, 0x08, 0x08, 0x18, 0x10, 0xF0, 0x73, 0x18,
};

const GFXglyph UbuntuMono_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 10, 8, 3, -10 },
  { 6, 4, 4, 8, 4, -10 },
  { 8, 8, 10, 8, 1, -10 },
  { 18, 8, 13, 8, 1, -11 },
  { 31, 10, 10, 8, 0, -10 },
  { 44, 7, 10, 8, 1, -10 },
  { 53, 2, 4, 8, 5, -11 },
  { 54, 6, 14, 8, 2, -11 },
  { 65, 6, 14, 8, 1, -11 },
  { 76, 6, 6, 8, 2, -10 },
  { 81, 7, 7, 8, 1, -8 },
  { 88, 3, 4, 8, 2, -2 },
  { 90, 4, 1, 8, 3, -4 },
  { 91, 2, 2, 8, 3, -2 },
  { 92, 9, 14, 8, 0, -11 },
  { 108, 7, 10, 8, 1, -10 },
  { 117, 6, 10, 8, 1, -10 },
  { 125, 7, 10, 8, 1, -10 },
  { 134, 7, 10, 8, 1, -10 },
  { 143, 7, 10, 8, 1, -10 },
  { 152, 8, 10, 8, 1, -10 },
  { 162, 7, 10, 8, 2, -10 },
  { 171, 7, 10, 8, 2, -10 },
  { 180, 8, 10, 8, 1, -10 },
  { 190, 8, 10, 8, 1, -10 },
  { 200, 3, 7, 8, 3, -7 },
  { 203, 4, 9, 8, 2, -7 },
  { 208, 7, 7, 8, 1, -8 },
  { 215, 7, 4, 8, 1, -6 },
  { 219, 7, 7, 8, 1, -8 },
  { 226, 5, 10, 8, 3, -10 },
  { 233, 8, 12, 8, 1, -10 },
  { 245, 8, 10, 8, 0, -10 },
  { 255, 7, 10, 8, 1, -10 },
  { 264, 8, 10, 8, 1, -10 },
  { 274, 7, 10, 8, 1, -10 },
  { 283, 8, 10, 8, 1, -10 },
  { 293, 8, 10, 8, 1, -10 },
  { 303, 8, 10, 8, 1, -10 },
  { 313, 8, 10, 8, 1, -10 },
  { 323, 8, 10, 8, 1, -10 },
  { 333, 8, 10, 8, 1, -10 },
  { 343, 8, 10, 8, 1, -10 },
  { 353, 6, 10, 8, 1, -10 },
  { 361, 9, 10, 8, 0, -10 },
  { 373, 8, 10, 8, 1, -10 },
  { 383, 8, 10, 8, 1, -10 },
  { 393, 8, 10, 8, 1, -10 },
  { 403, 8, 13, 8, 1, -10 },
  { 416, 7, 10, 8, 1, -10 },
  { 425, 8, 10, 8, 1, -10 },
  { 435, 7, 10, 8, 2, -10 },
  { 444, 8, 10, 8, 1, -10 },
  { 454, 8, 10, 8, 2, -10 },
  { 464, 9, 10, 8, 1, -10 },
  { 476, 10, 10, 8, 0, -10 },
  { 489, 8, 10, 8, 2, -10 },
  { 499, 8, 10, 8, 1, -10 },
  { 509, 7, 14, 8, 2, -11 },
  { 522, 3, 14, 8, 3, -11 },
  { 528, 8, 14, 8, 0, -11 },
  { 542, 6, 5, 8, 2, -10 },
  { 546, 7, 1, 8, 0, 2 },
  { 547, 3, 3, 8, 4, -11 },
  { 549, 7, 7, 8, 1, -7 },
  { 556, 7, 11, 8, 1, -11 },
  { 566, 7, 7, 8, 1, -7 },
  { 573, 8, 11, 8, 1, -11 },
  { 584, 7, 7, 8, 1, -7 },
  { 591, 10, 14, 8, 0, -11 },
  { 609, 9, 10, 8, 0, -7 },
  { 621, 7, 11, 8, 1, -11 },
  { 631, 5, 10, 8, 2, -10 },
  { 638, 8, 13, 8, 0, -10 },
  { 651, 8, 11, 8, 1, -11 },
  { 662, 4, 11, 8, 3, -11 },
  { 668, 8, 7, 8, 0, -7 },
  { 675, 7, 7, 8, 1, -7 },
  { 682, 7, 7, 8, 1, -7 },
  { 689, 8, 10, 8, 0, -7 },
  { 699, 7, 10, 8, 1, -7 },
  { 708, 7, 7, 8, 1, -7 },
  { 715, 7, 7, 8, 1, -7 },
  { 722, 6, 9, 8, 2, -9 },
  { 729, 7, 7, 8, 1, -7 },
  { 736, 7, 7, 8, 2, -7 },
  { 743, 8, 7, 8, 1, -7 },
  { 750, 9, 7, 8, 0, -7 },
  { 758, 9, 10, 8, 0, -7 },
  { 770, 7, 7, 8, 1, -7 },
  { 777, 8, 14, 8, 1, -11 },
  { 791, 5, 14, 8, 2, -11 },
  { 800, 8, 14, 8, 0, -11 },
  { 814, 7, 2, 8, 1, -6 },
};

const GFXfont UbuntuMono_Italic16pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic16pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic16pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUMONO_ITALIC16PT7B_H_
