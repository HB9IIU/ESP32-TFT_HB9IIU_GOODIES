#ifndef _UBUNTUMONO_ITALIC41PT7B_H_
#define _UBUNTUMONO_ITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x70, 0x00, 0x38, 0xF7, 0x8E,
  0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x1C, 0xE1, 0xCE, 0x1C, 0xC1, 0x8C, 0x18,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x83, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x87,
  0x80, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF0, 0x70, 0x70, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC3, 0xC0,
  0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3E,
  0x06, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x10, 0x03,
  0xC3, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x07, 0x01, 0xFC, 0x03, 0x00, 0xFE, 0x03, 0x80, 0xE7, 0x03, 0x80, 0x61,
  0x83, 0x80, 0x70, 0xC3, 0x80, 0x38, 0x63, 0x80, 0x1C, 0x73, 0x80, 0x0E,
  0x3B, 0x80, 0x07, 0x39, 0xC0, 0x03, 0xFD, 0xC0, 0x00, 0xFD, 0xC0, 0x00,
  0x3D, 0xDE, 0x00, 0x01, 0xDF, 0x80, 0x01, 0xDF, 0xE0, 0x01, 0xCE, 0x70,
  0x00, 0xEE, 0x38, 0x00, 0xE7, 0x1C, 0x00, 0xE3, 0x0E, 0x00, 0xE1, 0x87,
  0x00, 0xE0, 0xC7, 0x00, 0xE0, 0x73, 0x80, 0xE0, 0x3F, 0x80, 0xE0, 0x1F,
  0xC0, 0x70, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x0F, 0x1E, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x07,
  0x0E, 0x01, 0xE7, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC1, 0xC3, 0xF8,
  0x71, 0xCF, 0x38, 0xE1, 0xCE, 0x70, 0x7F, 0x1C, 0x0F, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x3E, 0x1E, 0x1F, 0xC7, 0xFF, 0x70, 0xFF, 0x9C, 0x1F,
  0x87, 0x80, 0x3C, 0xE3, 0x9E, 0x79, 0xC7, 0x1C, 0x63, 0x8E, 0x00, 0x00,
  0x04, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x40, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x04, 0x38, 0x7E, 0x73, 0xFF, 0x7F, 0xBF, 0xFE, 0x03, 0x80,
  0x0D, 0x80, 0x3B, 0xC0, 0xF3, 0x83, 0xC7, 0x87, 0x07, 0x02, 0x08, 0x00,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C,
  0x1E, 0x1E, 0x1E, 0x7E, 0x3E, 0x0C, 0x00, 0x7F, 0xDF, 0xFF, 0xF8, 0x39,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0x0F, 0x07, 0x81, 0xC3, 0xC0, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x01,
  0xCE, 0x38, 0x73, 0x9F, 0x1D, 0xE7, 0xC7, 0x79, 0xF3, 0xDC, 0x38, 0xF7,
  0x00, 0x39, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF1, 0xC0,
  0x78, 0x70, 0x3C, 0x1E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xF7,
  0x03, 0xCE, 0x04, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF8,
  0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1E, 0x0F, 0x04, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xE1, 0xF0, 0x10, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xC0,
  0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0xF7, 0x80,
  0x3C, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0xF0, 0x1C, 0x1C, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x30, 0x1F, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x3F, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x80, 0xF1, 0xE0, 0x0E,
  0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C,
  0x78, 0x07, 0x0F, 0x01, 0xE0, 0xF0, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xF0, 0x70, 0x1E,
  0x1E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F, 0x0E, 0x01, 0xC1, 0xE0, 0x78,
  0x1E, 0x3E, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xFC, 0x0F, 0x87, 0xC1,
  0xC0, 0x38, 0x70, 0x07, 0x8E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8F,
  0x00, 0xF0, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE0, 0xF0, 0x1E,
  0x3C, 0x03, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C,
  0x70, 0x07, 0x8F, 0x01, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFC, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC1, 0xF1, 0xF8, 0xFC, 0x7E, 0x1E, 0x00, 0x00, 0xE0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0xE1, 0xFF, 0xC4, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC,
  0x01, 0xFF, 0xE0, 0x3E, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x1E, 0x00,
  0x71, 0xC0, 0x07, 0x3C, 0x0F, 0xF3, 0x83, 0xFE, 0x78, 0x7F, 0xE7, 0x0F,
  0x0E, 0x71, 0xE0, 0xE7, 0x1C, 0x1C, 0xF3, 0xC1, 0xCE, 0x38, 0x1C, 0xE3,
  0x81, 0xCE, 0x38, 0x3C, 0xE3, 0x83, 0x8E, 0x3C, 0x38, 0xE3, 0xC3, 0x8E,
  0x1F, 0xF8, 0xE0, 0xFF, 0x0F, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x01, 0xC0, 0xF0, 0x3C, 0x07,
  0x03, 0x80, 0x70, 0x78, 0x07, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x77, 0x80,
  0x07, 0x70, 0x00, 0x70, 0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x83,
  0x81, 0xF0, 0x70, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x0E,
  0x01, 0xE3, 0xC0, 0x38, 0x78, 0x1E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0,
  0x0F, 0x38, 0x01, 0xE7, 0x00, 0x78, 0xE0, 0x3E, 0x3F, 0xFF, 0x87, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7C, 0x0E, 0x0F, 0x00, 0x41, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x38, 0x3E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x1E, 0x00, 0x71, 0xE0, 0x0F, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x38, 0x03, 0xC3, 0x80, 0x78, 0x78, 0x0F, 0x87,
  0x03, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x3E, 0x0E, 0x07, 0x80, 0x20, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0x70, 0xF0, 0x07, 0x07, 0x00, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0xE0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0x80, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0x80, 0xF0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x0F, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x3F,
  0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x40, 0x3C, 0x07,
  0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80,
  0x7C, 0x0E, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xC0, 0xF8, 0x07, 0x07, 0x80,
  0x1C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x3B,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x80,
  0x03, 0xCF, 0x00, 0x0E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE0, 0xF0, 0x07,
  0x81, 0xC0, 0x1E, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x00,
  0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0x60, 0xF8, 0x0D, 0x83, 0x60, 0x76,
  0x1F, 0x81, 0xD8, 0x6E, 0x06, 0x63, 0xB8, 0x39, 0x8C, 0xE0, 0xE7, 0x63,
  0x03, 0x9F, 0x9C, 0x1C, 0x7C, 0x70, 0x71, 0xF1, 0xC1, 0xC7, 0x87, 0x0F,
  0x1E, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00,
  0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x1F, 0x00, 0xE0, 0x7C, 0x03, 0x81,
  0xF0, 0x0E, 0x07, 0xC0, 0x38, 0x3B, 0x81, 0xC0, 0xEE, 0x07, 0x03, 0xB8,
  0x1C, 0x0E, 0x70, 0x70, 0x71, 0xC3, 0x81, 0xC7, 0x0E, 0x07, 0x1C, 0x38,
  0x1C, 0x38, 0xE0, 0xE0, 0xE7, 0x03, 0x83, 0x9C, 0x0E, 0x0E, 0x70, 0x38,
  0x19, 0xC1, 0xE0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F,
  0x83, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0xF0, 0x1E,
  0x1C, 0x03, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1D,
  0xE0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xBC, 0x00, 0x77,
  0x80, 0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x07, 0x87,
  0x01, 0xE0, 0xF0, 0x78, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x78, 0x1F, 0x07, 0x80,
  0xF0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0,
  0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x1E, 0x1E, 0x07, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xE1,
  0xE0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x3C, 0x00,
  0xE7, 0x00, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03,
  0xBC, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C,
  0x78, 0x07, 0x87, 0x01, 0xE0, 0xF0, 0x78, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0x78, 0x3E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x01, 0xE1, 0xE0,
  0x3C, 0x1C, 0x0F, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xDF, 0x80, 0x38,
  0x3C, 0x03, 0x83, 0xC0, 0x78, 0x1C, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x07,
  0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3E, 0x06, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x20, 0x07, 0x87, 0x01, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x70, 0x78, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xE1, 0xE0, 0x0E, 0x0F,
  0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x3C, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x70, 0x07, 0x87, 0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x80, 0x38, 0x3C, 0x03, 0xC1,
  0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70,
  0x01, 0xCE, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0,
  0x1E, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xC0, 0x0E, 0x78, 0x01, 0xCE,
  0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0xF0, 0xE0, 0x71, 0xE1, 0xC1,
  0xC7, 0xC7, 0x03, 0x8D, 0x8E, 0x07, 0x3B, 0x1C, 0x0E, 0x66, 0x70, 0x19,
  0xCC, 0xE0, 0x33, 0x19, 0xC0, 0xEE, 0x33, 0x01, 0xD8, 0x6E, 0x03, 0xF0,
  0xDC, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x38, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC3, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x00, 0xF0, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0x87, 0x80,
  0x3C, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xE3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x9E, 0x79, 0xE7, 0x9E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x1E, 0x70, 0x1E, 0x38, 0x1E,
  0x1E, 0x0E, 0x07, 0x0E, 0x03, 0x8F, 0x01, 0xCF, 0x00, 0x77, 0x00, 0x39,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x21, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3E, 0x0E, 0x1E, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0xF0,
  0x07, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8F, 0x01, 0xE3, 0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFB, 0x81, 0xF8, 0xE0,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x9F, 0x00, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x3C, 0x70, 0x0F,
  0x3C, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x07, 0x9C,
  0x03, 0xC7, 0x00, 0xF1, 0xC0, 0xF8, 0xE0, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x7E, 0x06,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x18, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFC, 0x1C, 0x0F, 0x81, 0xC0, 0xF0,
  0x0E, 0x07, 0x80, 0x70, 0x78, 0x07, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x38, 0x1E, 0x03,
  0xC0, 0x78, 0x3E, 0x03, 0xFF, 0xF0, 0x0F, 0xFB, 0x80, 0x1F, 0x0E, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x1E, 0x3E, 0x03, 0xCF,
  0x00, 0xF7, 0x80, 0x39, 0xC0, 0x1E, 0xF0, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFF, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x18,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0x78, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x0E, 0x01, 0xC0, 0x78, 0x3E,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xB8, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x01, 0x81, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x07, 0x87,
  0x80, 0xE1, 0xE0, 0x38, 0x70, 0x0F, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0xC0,
  0x38, 0xE0, 0x1E, 0x38, 0x07, 0x9E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x3C,
  0x70, 0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x78, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x7F, 0xC7, 0xF8, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xFF,
  0x07, 0xF0, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x06, 0x0F, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x38, 0x0F, 0x07, 0x07, 0xC1,
  0xE1, 0xE0, 0x38, 0x78, 0x07, 0x3E, 0x00, 0xEF, 0x80, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1C, 0xF0, 0x07, 0x9F, 0x00, 0xE1, 0xE0, 0x1C,
  0x1E, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0x70,
  0x07, 0x80, 0x7F, 0xCF, 0xFB, 0xFE, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x27, 0xFC, 0xFF, 0x8F, 0xE0, 0x03, 0xF1, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0x71, 0xC3,
  0x87, 0x1C, 0x38, 0xF1, 0xC7, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38,
  0x01, 0xE3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7,
  0x00, 0x38, 0xE0, 0x03, 0x80, 0x01, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC3,
  0xC1, 0xF1, 0xE0, 0x78, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x3C, 0x03,
  0x9C, 0x03, 0xCE, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x79, 0xC0,
  0x39, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E, 0x03, 0xCF, 0x00, 0xF3,
  0x80, 0x3D, 0xE0, 0x0F, 0x70, 0x03, 0xDC, 0x00, 0xEF, 0x00, 0x3B, 0xC0,
  0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x78, 0x3E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xE0, 0x1E, 0x1C,
  0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x0F, 0x83, 0x83, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0xE1, 0xF0, 0x3C, 0x78, 0x07,
  0x0F, 0x00, 0xE3, 0xC0, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x1C,
  0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x83, 0xC1, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3E, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3E, 0x04, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0x84, 0x00, 0xE1, 0xC0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x02, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xC0, 0x1E,
  0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0x8E, 0x01,
  0xE3, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1,
  0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0x87, 0x01, 0xE1, 0xE1, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFB, 0x81, 0xF8, 0xE0, 0x70, 0x07, 0xB8, 0x03, 0x9C, 0x01,
  0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xE0, 0x78, 0x70,
  0x38, 0x3C, 0x38, 0x1E, 0x1C, 0x0F, 0x1C, 0x03, 0x9E, 0x01, 0xCE, 0x00,
  0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x79, 0xC0, 0x03, 0x9E, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x30, 0x71, 0xC3, 0x87, 0x0E, 0x1E, 0x38, 0x71, 0xF1, 0xC3, 0x9F,
  0x9C, 0x1C, 0xFC, 0xE0, 0xCE, 0xE6, 0x0E, 0x67, 0x70, 0x77, 0x1B, 0x83,
  0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x38, 0x0E,
  0x00, 0x07, 0x80, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0x80,
  0x1E, 0x38, 0x00, 0xF3, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xE0, 0x03,
  0xC7, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x3C,
  0x3C, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x3C, 0x07, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x10, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0xCF, 0xF0, 0x77, 0xFE,
  0x39, 0xC7, 0xFE, 0xE0, 0x7F, 0x18, 0x0F, 0x80,
};

const GFXglyph UbuntuMono_Italic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 10, 25, 21, 7, -25 },
  { 33, 12, 10, 21, 9, -26 },
  { 48, 21, 25, 21, 2, -25 },
  { 114, 19, 32, 21, 3, -28 },
  { 190, 25, 25, 21, 0, -25 },
  { 269, 18, 25, 21, 2, -25 },
  { 326, 6, 11, 21, 12, -28 },
  { 335, 15, 36, 21, 6, -29 },
  { 403, 16, 36, 21, 2, -29 },
  { 475, 15, 15, 21, 6, -25 },
  { 504, 17, 19, 21, 4, -20 },
  { 545, 9, 12, 21, 4, -6 },
  { 559, 10, 3, 21, 7, -12 },
  { 563, 6, 6, 21, 7, -6 },
  { 568, 24, 36, 21, -1, -29 },
  { 676, 18, 25, 21, 3, -25 },
  { 733, 15, 25, 21, 4, -25 },
  { 780, 18, 25, 21, 3, -25 },
  { 837, 19, 25, 21, 2, -25 },
  { 897, 19, 25, 21, 2, -25 },
  { 957, 21, 25, 21, 2, -25 },
  { 1023, 19, 25, 21, 4, -25 },
  { 1083, 18, 25, 21, 6, -25 },
  { 1140, 19, 25, 21, 3, -25 },
  { 1200, 19, 25, 21, 3, -25 },
  { 1260, 9, 19, 21, 7, -19 },
  { 1282, 12, 25, 21, 4, -19 },
  { 1320, 18, 17, 21, 3, -19 },
  { 1359, 19, 11, 21, 3, -16 },
  { 1386, 19, 17, 21, 2, -19 },
  { 1427, 14, 25, 21, 7, -25 },
  { 1471, 20, 31, 21, 3, -26 },
  { 1549, 20, 25, 21, -1, -25 },
  { 1612, 19, 25, 21, 2, -25 },
  { 1672, 20, 25, 21, 4, -25 },
  { 1735, 20, 25, 21, 1, -25 },
  { 1798, 20, 25, 21, 3, -25 },
  { 1861, 20, 25, 21, 3, -25 },
  { 1924, 20, 25, 21, 3, -25 },
  { 1987, 23, 25, 21, 1, -25 },
  { 2059, 19, 25, 21, 3, -25 },
  { 2119, 20, 25, 21, 3, -25 },
  { 2182, 22, 25, 21, 2, -25 },
  { 2251, 15, 25, 21, 2, -25 },
  { 2298, 22, 25, 21, 1, -25 },
  { 2367, 22, 25, 21, 2, -25 },
  { 2436, 19, 25, 21, 3, -25 },
  { 2496, 20, 25, 21, 2, -25 },
  { 2559, 19, 32, 21, 3, -25 },
  { 2635, 20, 25, 21, 2, -25 },
  { 2698, 20, 25, 21, 2, -25 },
  { 2761, 18, 25, 21, 6, -25 },
  { 2818, 21, 25, 21, 3, -25 },
  { 2884, 19, 25, 21, 6, -25 },
  { 2944, 23, 25, 21, 2, -25 },
  { 3016, 25, 25, 21, 0, -25 },
  { 3095, 20, 25, 21, 6, -25 },
  { 3158, 22, 25, 21, 1, -25 },
  { 3227, 18, 36, 21, 4, -29 },
  { 3308, 6, 36, 21, 9, -29 },
  { 3335, 18, 36, 21, 1, -29 },
  { 3416, 17, 14, 21, 4, -25 },
  { 3446, 19, 3, 21, -1, 4 },
  { 3454, 7, 7, 21, 11, -28 },
  { 3461, 18, 19, 21, 3, -19 },
  { 3504, 18, 28, 21, 3, -28 },
  { 3567, 18, 19, 21, 3, -19 },
  { 3610, 21, 28, 21, 3, -28 },
  { 3684, 18, 19, 21, 3, -19 },
  { 3727, 25, 35, 21, 0, -28 },
  { 3837, 21, 26, 21, 1, -19 },
  { 3906, 18, 28, 21, 2, -28 },
  { 3969, 12, 28, 21, 5, -28 },
  { 4011, 20, 35, 21, 1, -28 },
  { 4099, 19, 28, 21, 3, -28 },
  { 4166, 11, 28, 21, 7, -28 },
  { 4205, 20, 19, 21, 1, -19 },
  { 4253, 17, 19, 21, 3, -19 },
  { 4294, 18, 19, 21, 3, -19 },
  { 4337, 20, 26, 21, 1, -19 },
  { 4402, 19, 26, 21, 3, -19 },
  { 4464, 17, 19, 21, 4, -19 },
  { 4505, 18, 19, 21, 3, -19 },
  { 4548, 15, 25, 21, 6, -25 },
  { 4595, 18, 19, 21, 3, -19 },
  { 4638, 17, 19, 21, 5, -19 },
  { 4679, 21, 19, 21, 3, -19 },
  { 4729, 21, 19, 21, 1, -19 },
  { 4779, 23, 26, 21, -1, -19 },
  { 4854, 19, 19, 21, 2, -19 },
  { 4900, 19, 36, 21, 4, -29 },
  { 4986, 12, 36, 21, 6, -29 },
  { 5040, 20, 36, 21, 0, -29 },
  { 5130, 18, 6, 21, 3, -16 },
};

const GFXfont UbuntuMono_Italic41pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic41pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic41pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUMONO_ITALIC41PT7B_H_
