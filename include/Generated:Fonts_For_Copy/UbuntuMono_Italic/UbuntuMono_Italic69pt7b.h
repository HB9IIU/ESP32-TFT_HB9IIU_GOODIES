#ifndef _UBUNTUMONO_ITALIC69PT7B_H_
#define _UBUNTUMONO_ITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0x1F,
  0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x07, 0xE3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78,
  0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F,
  0x0F, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3C,
  0x00, 0xFE, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x20, 0x00, 0x0F, 0xC0,
  0x38, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x0F,
  0x80, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x00,
  0x7C, 0x0F, 0x01, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80,
  0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x0F,
  0x80, 0x00, 0x1E, 0x0F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xE3, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x00, 0x00, 0x0F,
  0xFE, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0x87, 0xFF, 0x80, 0x00, 0x07, 0xC3, 0xFF, 0xE0, 0x00, 0x01, 0xF1, 0xF8,
  0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x1E, 0x07, 0x80,
  0x00, 0x3E, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x80, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0xF0, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF3, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0xFF, 0xF0, 0x3E, 0x07, 0xFF, 0xC0, 0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF8,
  0x3E, 0x1F, 0x0F, 0xC0, 0xFC, 0x7C, 0x3E, 0x01, 0xFB, 0xE1, 0xF8, 0x07,
  0xEF, 0x87, 0xC0, 0x0F, 0xFE, 0x1F, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x7F,
  0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFF, 0xE7, 0xE0, 0xFF, 0xFF, 0x1F, 0x81, 0xFF,
  0xF8, 0x7E, 0x03, 0xFF, 0x80, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x8F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F,
  0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x06, 0x03, 0xE0, 0x11,
  0xE0, 0x78, 0x1E, 0x7E, 0x1E, 0x1F, 0xBF, 0xE7, 0x9F, 0xEF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xF8, 0x0F, 0xC0, 0x1E, 0x01, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF,
  0xE0, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0xFC, 0xFC, 0x1E, 0x03, 0xF3, 0xF0, 0xFE, 0x0F,
  0xCF, 0x87, 0xF8, 0x3F, 0x7E, 0x1F, 0xE0, 0xF9, 0xF8, 0x7F, 0x83, 0xE7,
  0xE1, 0xFE, 0x1F, 0x9F, 0x07, 0xF8, 0x7E, 0xFC, 0x0F, 0xC1, 0xFB, 0xF0,
  0x1E, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xCF, 0x80, 0x1F,
  0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x60, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3E, 0x00,
  0x3F, 0x80, 0x38, 0x00, 0x3F, 0x00, 0x40, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x3F,
  0xC0, 0x07, 0x00, 0x3F, 0x80, 0x08, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x08, 0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFD, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0xFF,
  0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3E, 0x03, 0xF8, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xF8, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x7F, 0xF8, 0x3E,
  0x00, 0xFF, 0xFE, 0x1F, 0x80, 0x7F, 0xFF, 0x87, 0xC0, 0x7F, 0xFF, 0xC3,
  0xF0, 0x3F, 0xFF, 0xF0, 0xFC, 0x1F, 0xE0, 0x7C, 0x3E, 0x07, 0xF0, 0x3F,
  0x1F, 0x83, 0xF0, 0x0F, 0xC7, 0xE0, 0xFC, 0x03, 0xE1, 0xF0, 0x7E, 0x00,
  0xF8, 0x7C, 0x1F, 0x00, 0x7E, 0x3F, 0x07, 0xC0, 0x1F, 0x8F, 0xC3, 0xF0,
  0x07, 0xC3, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x0F,
  0x80, 0x3F, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x3F, 0x01, 0xF8, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x03,
  0xE0, 0x7F, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xF0, 0x3E, 0x03, 0xFF, 0xFC,
  0x0F, 0xC0, 0x7F, 0xFF, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x7F,
  0x80, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x20, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFF, 0x03, 0xE0, 0x00, 0xFF, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x70, 0x03, 0xF8, 0x00, 0x08, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0x00, 0x0F, 0xF8, 0x03, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x3E, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x01, 0xF0, 0x03, 0xFC, 0x00, 0x38, 0x03, 0xF8, 0x00, 0x08, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03,
  0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x08, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xE0,
  0x00, 0x00, 0x7C, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x7F, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0xF7, 0xC0, 0x7B, 0xC0, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0x0F,
  0x7C, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x7D, 0xF0, 0x01, 0xE3, 0xC1, 0xE7,
  0xC0, 0x07, 0x8F, 0x0F, 0x1F, 0x00, 0x3E, 0x3C, 0x3C, 0x78, 0x00, 0xF8,
  0xF1, 0xE1, 0xE0, 0x03, 0xC3, 0xC7, 0x8F, 0x80, 0x1F, 0x0F, 0x3C, 0x3E,
  0x00, 0x7C, 0x3C, 0xF0, 0xF8, 0x01, 0xF0, 0xF7, 0x83, 0xE0, 0x0F, 0x83,
  0xDE, 0x1F, 0x00, 0x3E, 0x0F, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0xC1, 0xF0,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x03,
  0xE0, 0x07, 0xDE, 0x00, 0x1F, 0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE0,
  0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x03, 0xE1, 0xF0,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0x0F,
  0x81, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x0F, 0x87, 0xC0, 0x0F, 0x80,
  0x3C, 0x3E, 0x00, 0x7C, 0x01, 0xE1, 0xF0, 0x03, 0xE0, 0x0F, 0x8F, 0x80,
  0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x80, 0x0F,
  0x3E, 0x00, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE0, 0x03, 0xDF, 0x00, 0x3E,
  0x00, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x03, 0xFE,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0x80, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x3F, 0xC0, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0,
  0x7C, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF3, 0xFF, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x20, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x00, 0x3F, 0x80,
  0x38, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x0F,
  0x80, 0x7C, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0xFE, 0x07, 0xC0, 0x1E, 0x07,
  0xF0, 0x3E, 0x01, 0xF0, 0x7F, 0x81, 0xE0, 0x0F, 0x83, 0xFC, 0x1F, 0x00,
  0x7C, 0x3D, 0xE0, 0xF8, 0x03, 0xE1, 0xEF, 0x07, 0xC0, 0x1E, 0x1E, 0x78,
  0x7C, 0x01, 0xF0, 0xF3, 0xC3, 0xE0, 0x0F, 0x8F, 0x0E, 0x1F, 0x00, 0x7C,
  0xF8, 0x70, 0xF0, 0x03, 0xC7, 0x83, 0xCF, 0x80, 0x1E, 0x7C, 0x1E, 0x7C,
  0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x07, 0xBE, 0x07, 0x9E, 0x00, 0x7D, 0xE0,
  0x3D, 0xF0, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x0F, 0x78, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x7C, 0x00,
  0x00, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07,
  0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3C, 0x10, 0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x08, 0x03, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0E, 0x00, 0x40,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x3F,
  0xE0, 0x0F, 0x81, 0xFE, 0x00, 0x7E, 0x0F, 0xF0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8,
  0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xE0, 0x7F, 0x81, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFB, 0xF0,
  0x0F, 0xFF, 0x8F, 0xC0, 0x0F, 0xF8, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x00, 0xFB,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7E, 0x07,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x1F, 0xE0, 0x7C,
  0x00, 0x7F, 0x80, 0xF8, 0x03, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFE, 0x01, 0xE0, 0x7F, 0xC0, 0x01, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x20, 0x3F, 0xE0, 0x0F, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x01, 0xF0,
  0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFB, 0xE0, 0x01, 0xFF, 0xFC, 0xF8, 0x00, 0x3F, 0xFC,
  0x3E, 0x00, 0x03, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xE7,
  0xE0, 0x01, 0xFF, 0x1F, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x60, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x04, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x41, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0x00, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x80, 0x3E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x01, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x07, 0xFC, 0x00,
  0x3F, 0x03, 0xFC, 0x00, 0x0F, 0x83, 0xFE, 0x00, 0x03, 0xE1, 0xFF, 0x00,
  0x00, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xE3,
  0xF8, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0x1F, 0xC0, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0xFE, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x1F, 0xC3,
  0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x9F,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xC0,
  0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x7E, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x03, 0xC0, 0x1F,
  0xC0, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x02, 0x00, 0x01, 0xF8, 0x0E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x01, 0x01, 0xFE, 0x07, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7C,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xF0, 0x03, 0xFF, 0xC7, 0xE0, 0x03,
  0xF8, 0x0F, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x03, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0x1F, 0x87, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x01, 0xF0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x3F, 0x07, 0xF8, 0x3E, 0x0F, 0x81, 0xFE, 0x0F, 0x83, 0xE0,
  0xFF, 0x87, 0xC0, 0xF8, 0x7D, 0xE1, 0xF0, 0x3E, 0x1E, 0x78, 0x78, 0x0F,
  0x8F, 0x9E, 0x3E, 0x03, 0xE3, 0xC7, 0x8F, 0x80, 0xF9, 0xF1, 0xE7, 0xC0,
  0x3E, 0x78, 0x79, 0xF0, 0x0F, 0xBC, 0x1E, 0x78, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0xF7, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x10, 0x0F, 0xFC, 0x00, 0x7C, 0x3F, 0xFC, 0x01, 0xF0, 0xFF, 0xFE, 0x03,
  0xE3, 0xFF, 0xFE, 0x1F, 0x87, 0xC1, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0xFC,
  0x3C, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x20, 0x00, 0x7E, 0x00,
};

const GFXglyph UbuntuMono_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 17, 44, 35, 12, -43 },
  { 95, 20, 17, 35, 15, -47 },
  { 138, 36, 43, 35, 3, -43 },
  { 332, 32, 55, 35, 5, -48 },
  { 552, 42, 45, 35, 0, -44 },
  { 789, 30, 45, 35, 4, -44 },
  { 958, 9, 18, 35, 21, -47 },
  { 979, 26, 60, 35, 10, -48 },
  { 1174, 26, 60, 35, 4, -48 },
  { 1369, 26, 25, 35, 10, -43 },
  { 1451, 29, 31, 35, 6, -34 },
  { 1564, 15, 18, 35, 7, -8 },
  { 1598, 17, 5, 35, 12, -20 },
  { 1609, 10, 9, 35, 12, -8 },
  { 1621, 39, 59, 35, -1, -48 },
  { 1909, 30, 45, 35, 6, -44 },
  { 2078, 26, 43, 35, 6, -43 },
  { 2218, 31, 44, 35, 5, -44 },
  { 2389, 31, 45, 35, 4, -44 },
  { 2564, 32, 43, 35, 3, -43 },
  { 2736, 34, 44, 35, 4, -43 },
  { 2923, 31, 44, 35, 7, -43 },
  { 3094, 31, 43, 35, 10, -43 },
  { 3261, 32, 45, 35, 5, -44 },
  { 3441, 32, 44, 35, 5, -44 },
  { 3617, 15, 31, 35, 12, -30 },
  { 3676, 20, 40, 35, 7, -30 },
  { 3776, 31, 28, 35, 5, -32 },
  { 3885, 32, 18, 35, 4, -27 },
  { 3957, 31, 28, 35, 4, -32 },
  { 4066, 25, 45, 35, 11, -44 },
  { 4207, 34, 53, 35, 5, -44 },
  { 4433, 33, 43, 35, -1, -43 },
  { 4611, 33, 43, 35, 3, -43 },
  { 4789, 34, 43, 35, 6, -43 },
  { 4972, 34, 43, 35, 2, -43 },
  { 5155, 34, 43, 35, 5, -43 },
  { 5338, 34, 43, 35, 5, -43 },
  { 5521, 33, 43, 35, 6, -43 },
  { 5699, 38, 43, 35, 2, -43 },
  { 5904, 32, 43, 35, 5, -43 },
  { 6076, 33, 43, 35, 5, -43 },
  { 6254, 38, 43, 35, 3, -43 },
  { 6459, 25, 43, 35, 4, -43 },
  { 6594, 38, 43, 35, 1, -43 },
  { 6799, 37, 43, 35, 3, -43 },
  { 6998, 31, 43, 35, 6, -43 },
  { 7165, 33, 43, 35, 4, -43 },
  { 7343, 31, 54, 35, 6, -43 },
  { 7553, 33, 43, 35, 3, -43 },
  { 7731, 34, 43, 35, 4, -43 },
  { 7914, 31, 43, 35, 10, -43 },
  { 8081, 34, 43, 35, 6, -43 },
  { 8264, 33, 43, 35, 9, -43 },
  { 8442, 37, 43, 35, 4, -43 },
  { 8641, 41, 43, 35, 1, -43 },
  { 8862, 33, 43, 35, 10, -43 },
  { 9040, 37, 43, 35, 2, -43 },
  { 9239, 31, 59, 35, 7, -48 },
  { 9468, 11, 59, 35, 15, -48 },
  { 9550, 31, 59, 35, 2, -48 },
  { 9779, 28, 23, 35, 8, -43 },
  { 9860, 32, 5, 35, -2, 7 },
  { 9880, 12, 13, 35, 18, -48 },
  { 9900, 30, 34, 35, 5, -33 },
  { 10028, 31, 49, 35, 4, -48 },
  { 10218, 30, 34, 35, 5, -33 },
  { 10346, 34, 49, 35, 6, -48 },
  { 10555, 30, 34, 35, 5, -33 },
  { 10683, 40, 59, 35, 1, -48 },
  { 10978, 36, 44, 35, 1, -33 },
  { 11176, 30, 48, 35, 3, -48 },
  { 11356, 20, 46, 35, 9, -46 },
  { 11471, 34, 57, 35, 1, -46 },
  { 11714, 34, 48, 35, 4, -48 },
  { 11918, 19, 49, 35, 12, -48 },
  { 12035, 34, 33, 35, 2, -33 },
  { 12176, 30, 33, 35, 4, -33 },
  { 12300, 29, 34, 35, 6, -33 },
  { 12424, 34, 44, 35, 1, -33 },
  { 12611, 30, 44, 35, 6, -33 },
  { 12776, 30, 33, 35, 6, -33 },
  { 12900, 30, 34, 35, 5, -33 },
  { 13028, 25, 43, 35, 10, -42 },
  { 13163, 30, 33, 35, 6, -32 },
  { 13287, 28, 32, 35, 9, -32 },
  { 13399, 34, 32, 35, 6, -32 },
  { 13535, 36, 32, 35, 1, -32 },
  { 13679, 38, 43, 35, -1, -32 },
  { 13884, 31, 32, 35, 4, -32 },
  { 14008, 33, 59, 35, 6, -48 },
  { 14252, 19, 59, 35, 11, -48 },
  { 14393, 33, 59, 35, 0, -48 },
  { 14637, 31, 10, 35, 5, -23 },
};

const GFXfont UbuntuMono_Italic69pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic69pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic69pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _UBUNTUMONO_ITALIC69PT7B_H_
