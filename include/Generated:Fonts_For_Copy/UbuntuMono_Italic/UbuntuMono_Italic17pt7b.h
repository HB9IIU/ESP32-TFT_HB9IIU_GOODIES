#ifndef _UBUNTUMONO_ITALIC17PT7B_H_
#define _UBUNTUMONO_ITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x64, 0x0C, 0xC0, 0xD4, 0xA5, 0x20, 0x09, 0x04,
  0x86, 0xCF, 0xE3, 0x61, 0x20, 0x91, 0xFE, 0x48, 0x6C, 0x24, 0x00, 0x04,
  0x04, 0x1F, 0x30, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x46, 0x78, 0x30,
  0x20, 0x18, 0x4B, 0x22, 0x90, 0xA8, 0x36, 0x01, 0x00, 0xB0, 0x52, 0x24,
  0x99, 0x4C, 0x70, 0x1C, 0x64, 0x99, 0x23, 0x86, 0x56, 0xE7, 0x8D, 0x99,
  0xD8, 0x5E, 0x80, 0x02, 0x18, 0x60, 0x82, 0x0C, 0x10, 0x20, 0x41, 0x81,
  0x02, 0x06, 0x04, 0x08, 0x00, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x0C,
  0x21, 0x84, 0x31, 0x88, 0x00, 0x10, 0xAC, 0xE1, 0xC6, 0xC4, 0x80, 0x08,
  0x08, 0x08, 0x7E, 0x10, 0x10, 0x10, 0x6D, 0xE0, 0xF0, 0xF0, 0x00, 0x80,
  0xC0, 0x40, 0x40, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0x02, 0x00, 0x0E, 0x13, 0x23, 0x63, 0x5B, 0x5B, 0x42, 0xC2, 0xC6,
  0x4C, 0x78, 0x0C, 0xE6, 0x82, 0x18, 0x61, 0x04, 0x30, 0xCF, 0x80, 0x1E,
  0x23, 0x03, 0x03, 0x02, 0x04, 0x18, 0x30, 0x60, 0x40, 0xFC, 0x1E, 0x23,
  0x03, 0x03, 0x06, 0x1C, 0x06, 0x02, 0x06, 0x84, 0xF8, 0x03, 0x06, 0x0A,
  0x12, 0x26, 0x64, 0xC4, 0xFE, 0x0C, 0x08, 0x08, 0x1F, 0x10, 0x10, 0x30,
  0x38, 0x0E, 0x06, 0x02, 0x06, 0x8C, 0xF8, 0x0E, 0x30, 0x82, 0x0F, 0x90,
  0xA1, 0x42, 0x85, 0x19, 0xC0, 0x7F, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x30,
  0x20, 0x60, 0x40, 0x40, 0x1E, 0x33, 0x21, 0x23, 0x32, 0x3C, 0x66, 0x42,
  0xC2, 0x46, 0x78, 0x1E, 0x33, 0x21, 0x61, 0x61, 0x23, 0x3E, 0x02, 0x04,
  0x18, 0xF0, 0x77, 0x00, 0x0C, 0xC0, 0x39, 0xC0, 0x00, 0x31, 0x8C, 0xC0,
  0x03, 0x0E, 0x70, 0xC0, 0x70, 0x1C, 0x04, 0x7F, 0x00, 0x00, 0xFE, 0x60,
  0x38, 0x0E, 0x02, 0x1C, 0x70, 0x80, 0x78, 0x30, 0xC3, 0x18, 0xC6, 0x10,
  0x03, 0x0C, 0x00, 0x0F, 0x08, 0x88, 0x4C, 0xE5, 0x92, 0x8B, 0x4D, 0xA4,
  0x92, 0x67, 0x10, 0x0C, 0x03, 0x80, 0x06, 0x06, 0x0B, 0x0B, 0x13, 0x13,
  0x23, 0x3F, 0x41, 0x41, 0x81, 0x3E, 0x23, 0x23, 0x63, 0x62, 0x7C, 0x42,
  0x42, 0xC2, 0x86, 0xF8, 0x1E, 0x22, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC4, 0x78, 0x3C, 0x22, 0x23, 0x63, 0x43, 0x43, 0x43, 0xC2, 0xC6,
  0x8C, 0xF0, 0x1F, 0x18, 0x0C, 0x04, 0x02, 0x03, 0xF1, 0x80, 0x80, 0x40,
  0x20, 0x3F, 0x80, 0x1F, 0x98, 0x0C, 0x04, 0x02, 0x03, 0xF1, 0x80, 0x80,
  0x40, 0x20, 0x30, 0x00, 0x0F, 0x11, 0x20, 0x60, 0x40, 0x40, 0xC2, 0xC2,
  0xC6, 0x66, 0x3C, 0x21, 0x90, 0x88, 0x4C, 0x26, 0x33, 0xF9, 0x09, 0x84,
  0xC6, 0x43, 0x21, 0x00, 0x1F, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x18, 0x10,
  0x10, 0x10, 0xFC, 0x1F, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x8C, 0x78, 0x31, 0x91, 0x89, 0x8D, 0x87, 0x83, 0x81, 0x60, 0x90, 0xCC,
  0x62, 0x21, 0x80, 0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x0F, 0xC0,
  0x18, 0x8C, 0xC6, 0x67, 0x52, 0xA9, 0x64, 0xB6, 0xC2, 0x41, 0x20, 0xB0,
  0xC0, 0x31, 0x98, 0x8C, 0x4F, 0x24, 0x92, 0x59, 0x29, 0x94, 0xC6, 0x43,
  0x21, 0x00, 0x0E, 0x33, 0x21, 0x61, 0x41, 0x41, 0xC3, 0xC2, 0xC6, 0x44,
  0x78, 0x3E, 0x23, 0x21, 0x21, 0x63, 0x62, 0x7C, 0x40, 0xC0, 0xC0, 0x80,
  0x0E, 0x33, 0x21, 0x61, 0x41, 0x41, 0xC3, 0xC2, 0xC6, 0x44, 0x78, 0x30,
  0x18, 0x0C, 0x3E, 0x23, 0x21, 0x61, 0x63, 0x66, 0x7C, 0x4C, 0xC4, 0x84,
  0x86, 0x1F, 0x31, 0x20, 0x20, 0x30, 0x1C, 0x06, 0x02, 0x06, 0x84, 0xF8,
  0xFE, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x00, 0x21, 0x90,
  0x88, 0x4C, 0x26, 0x32, 0x19, 0x09, 0x84, 0xC6, 0x22, 0x1E, 0x00, 0xC1,
  0xC3, 0xC2, 0xC6, 0xC4, 0x4C, 0x48, 0x58, 0x50, 0x70, 0x60, 0x20, 0xB0,
  0xD8, 0x68, 0x24, 0x92, 0xD9, 0x69, 0xD4, 0xAA, 0x66, 0x31, 0x00, 0x18,
  0xC6, 0x20, 0x98, 0x3C, 0x0E, 0x03, 0x00, 0xE0, 0x68, 0x32, 0x18, 0xC4,
  0x30, 0x41, 0x21, 0x90, 0x8C, 0x86, 0xC1, 0xC0, 0xC0, 0x60, 0x20, 0x10,
  0x18, 0x00, 0x3F, 0x81, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60,
  0x60, 0x3F, 0x80, 0x1E, 0x20, 0x41, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81,
  0x06, 0x0C, 0x10, 0x3C, 0x00, 0xAA, 0xBF, 0xF5, 0x54, 0x0F, 0x03, 0x02,
  0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x78,
  0x08, 0x38, 0x93, 0x24, 0x50, 0xC0, 0xFE, 0x4C, 0x80, 0x1F, 0x32, 0x42,
  0xC2, 0xC6, 0xC4, 0xC4, 0x7E, 0x10, 0x30, 0x30, 0x20, 0x3E, 0x22, 0x63,
  0x43, 0x42, 0x46, 0xCC, 0xF8, 0x1F, 0x30, 0x40, 0xC0, 0xC0, 0xC0, 0x44,
  0x3C, 0x01, 0x80, 0xC0, 0x40, 0x21, 0xF1, 0x99, 0x8C, 0x86, 0xC6, 0x63,
  0x11, 0x8F, 0xC0, 0x1E, 0x22, 0x43, 0xC6, 0xFC, 0xC0, 0x44, 0x7C, 0x03,
  0xC1, 0x80, 0x40, 0x10, 0x1F, 0x83, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x0E, 0x00, 0x0F, 0x8C, 0xCC, 0x64, 0x22, 0x13,
  0x18, 0x8C, 0x7C, 0x02, 0x03, 0x3E, 0x00, 0x30, 0x60, 0x81, 0x03, 0xCC,
  0xD0, 0xA1, 0x47, 0x8A, 0x14, 0x20, 0x18, 0xC1, 0xE3, 0x18, 0x84, 0x21,
  0x0E, 0x03, 0x01, 0x80, 0x03, 0xE0, 0x30, 0x18, 0x08, 0x04, 0x06, 0x03,
  0x01, 0x00, 0x80, 0xC7, 0xC0, 0x10, 0x10, 0x30, 0x30, 0x23, 0x26, 0x68,
  0x70, 0x58, 0x48, 0xC4, 0xC6, 0xF1, 0x88, 0x42, 0x31, 0x08, 0x46, 0x30,
  0xE0, 0x7F, 0x49, 0x4B, 0x5A, 0xD2, 0x82, 0x86, 0x86, 0x3E, 0x45, 0x8B,
  0x14, 0x28, 0xF1, 0xE2, 0x1E, 0x22, 0x43, 0x43, 0xC2, 0xC6, 0x44, 0x78,
  0x1F, 0x08, 0x8C, 0x64, 0x32, 0x11, 0x19, 0x98, 0xF8, 0x40, 0x20, 0x30,
  0x00, 0x1F, 0x33, 0x62, 0x42, 0xC6, 0xC6, 0x44, 0x7C, 0x0C, 0x0C, 0x08,
  0x3E, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x1E, 0x20, 0x20, 0x38, 0x0C,
  0x06, 0x44, 0x78, 0x10, 0x63, 0xF9, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x70,
  0x23, 0x62, 0x42, 0x42, 0x46, 0xC4, 0x44, 0x7E, 0xC7, 0x8B, 0x12, 0x64,
  0x8A, 0x1C, 0x30, 0x41, 0xA0, 0x92, 0x4B, 0x65, 0xA7, 0x53, 0x31, 0x98,
  0x11, 0x8D, 0x82, 0x81, 0x80, 0xC0, 0xB0, 0x88, 0x84, 0x30, 0x98, 0xC4,
  0x42, 0x61, 0x20, 0x90, 0x70, 0x18, 0x08, 0x08, 0x38, 0x00, 0x3E, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x40, 0xFC, 0x0F, 0x18, 0x10, 0x10, 0x30, 0x20,
  0x20, 0xC0, 0x60, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x70, 0x11, 0x13, 0x22,
  0x26, 0x44, 0x4C, 0xC8, 0x80, 0x1E, 0x02, 0x02, 0x02, 0x06, 0x04, 0x06,
  0x03, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x18, 0xF0, 0x71, 0xCE,
};

const GFXglyph UbuntuMono_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 5, 4, 9, 4, -11 },
  { 10, 9, 11, 9, 1, -11 },
  { 23, 8, 14, 9, 1, -12 },
  { 37, 10, 11, 9, 0, -11 },
  { 51, 7, 11, 9, 1, -11 },
  { 61, 2, 5, 9, 5, -12 },
  { 63, 7, 15, 9, 2, -12 },
  { 77, 6, 15, 9, 1, -12 },
  { 89, 7, 6, 9, 2, -11 },
  { 95, 8, 7, 9, 1, -8 },
  { 102, 3, 4, 9, 2, -2 },
  { 104, 4, 1, 9, 3, -5 },
  { 105, 2, 2, 9, 3, -2 },
  { 106, 9, 15, 9, 0, -12 },
  { 123, 8, 11, 9, 1, -11 },
  { 134, 6, 11, 9, 2, -11 },
  { 143, 8, 11, 9, 1, -11 },
  { 154, 8, 11, 9, 1, -11 },
  { 165, 8, 11, 9, 1, -11 },
  { 176, 8, 11, 9, 1, -11 },
  { 187, 7, 11, 9, 2, -11 },
  { 197, 8, 11, 9, 2, -11 },
  { 208, 8, 11, 9, 1, -11 },
  { 219, 8, 11, 9, 1, -11 },
  { 230, 4, 7, 9, 3, -7 },
  { 234, 5, 9, 9, 2, -7 },
  { 240, 8, 7, 9, 1, -9 },
  { 247, 8, 4, 9, 1, -6 },
  { 251, 8, 7, 9, 1, -9 },
  { 258, 6, 11, 9, 3, -11 },
  { 267, 9, 13, 9, 1, -11 },
  { 282, 8, 11, 9, 0, -11 },
  { 293, 8, 11, 9, 1, -11 },
  { 304, 8, 11, 9, 2, -11 },
  { 315, 8, 11, 9, 1, -11 },
  { 326, 9, 11, 9, 1, -11 },
  { 339, 9, 11, 9, 1, -11 },
  { 352, 8, 11, 9, 1, -11 },
  { 363, 9, 11, 9, 1, -11 },
  { 376, 8, 11, 9, 1, -11 },
  { 387, 8, 11, 9, 1, -11 },
  { 398, 9, 11, 9, 1, -11 },
  { 411, 6, 11, 9, 1, -11 },
  { 420, 9, 11, 9, 0, -11 },
  { 433, 9, 11, 9, 1, -11 },
  { 446, 8, 11, 9, 1, -11 },
  { 457, 8, 11, 9, 1, -11 },
  { 468, 8, 14, 9, 1, -11 },
  { 482, 8, 11, 9, 1, -11 },
  { 493, 8, 11, 9, 1, -11 },
  { 504, 7, 11, 9, 3, -11 },
  { 514, 9, 11, 9, 1, -11 },
  { 527, 8, 11, 9, 2, -11 },
  { 538, 9, 11, 9, 1, -11 },
  { 551, 10, 11, 9, 0, -11 },
  { 565, 9, 11, 9, 2, -11 },
  { 578, 9, 11, 9, 1, -11 },
  { 591, 7, 15, 9, 2, -12 },
  { 605, 2, 15, 9, 4, -12 },
  { 609, 8, 15, 9, 0, -12 },
  { 624, 7, 6, 9, 2, -11 },
  { 630, 7, 1, 9, 0, 2 },
  { 631, 3, 3, 9, 4, -12 },
  { 633, 8, 8, 9, 1, -8 },
  { 641, 8, 12, 9, 1, -12 },
  { 653, 8, 8, 9, 1, -8 },
  { 661, 9, 12, 9, 1, -12 },
  { 675, 8, 8, 9, 1, -8 },
  { 683, 10, 15, 9, 0, -12 },
  { 702, 9, 11, 9, 0, -8 },
  { 715, 7, 12, 9, 1, -12 },
  { 726, 5, 11, 9, 2, -11 },
  { 733, 9, 14, 9, 0, -11 },
  { 749, 8, 12, 9, 1, -12 },
  { 761, 5, 12, 9, 3, -12 },
  { 769, 8, 8, 9, 1, -8 },
  { 777, 7, 8, 9, 1, -8 },
  { 784, 8, 8, 9, 1, -8 },
  { 792, 9, 11, 9, 0, -8 },
  { 805, 8, 11, 9, 1, -8 },
  { 816, 7, 8, 9, 2, -8 },
  { 823, 8, 8, 9, 1, -8 },
  { 831, 7, 10, 9, 2, -10 },
  { 840, 8, 8, 9, 1, -8 },
  { 848, 7, 8, 9, 2, -8 },
  { 855, 9, 8, 9, 1, -8 },
  { 864, 9, 8, 9, 0, -8 },
  { 873, 9, 11, 9, 0, -8 },
  { 886, 8, 8, 9, 1, -8 },
  { 894, 8, 15, 9, 2, -12 },
  { 909, 4, 15, 9, 3, -12 },
  { 917, 8, 15, 9, 0, -12 },
  { 932, 8, 2, 9, 1, -7 },
};

const GFXfont UbuntuMono_Italic17pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic17pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic17pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUMONO_ITALIC17PT7B_H_
