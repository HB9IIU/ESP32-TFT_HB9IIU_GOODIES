#ifndef _UBUNTUMONO_ITALIC43PT7B_H_
#define _UBUNTUMONO_ITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x01,
  0xC1, 0xC0, 0x0F, 0x0F, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x1C, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0x80, 0x1E, 0x1E, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x01, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0xC3, 0xC0, 0x0E, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x06, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x40, 0x0F, 0x87, 0x01, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x7E, 0x00, 0xE0, 0x3F, 0xC0, 0x70, 0x1E,
  0x70, 0x38, 0x07, 0x1C, 0x1C, 0x01, 0x87, 0x0E, 0x00, 0xE1, 0xC7, 0x80,
  0x38, 0x71, 0xC0, 0x0E, 0x38, 0xE0, 0x03, 0x8E, 0x70, 0x00, 0xFF, 0x38,
  0x00, 0x1F, 0xDC, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0xE7, 0xE0, 0x00, 0x73, 0xFC, 0x00, 0x39, 0xE7, 0x00,
  0x1C, 0x71, 0xC0, 0x0F, 0x18, 0x70, 0x03, 0x8E, 0x1C, 0x01, 0xC3, 0x87,
  0x00, 0xE0, 0xE3, 0x80, 0x70, 0x38, 0xE0, 0x38, 0x0F, 0xF0, 0x1E, 0x01,
  0xF8, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0x00, 0xF1, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x1C,
  0x07, 0x87, 0x80, 0xF1, 0xE0, 0x0E, 0x78, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xC1, 0xC3, 0xFC, 0x38, 0xF7, 0x8E, 0x3C, 0x79, 0xC7, 0x07, 0xF9,
  0xE0, 0xFE, 0x38, 0x0F, 0xC7, 0x00, 0xF1, 0xE0, 0x1E, 0x1C, 0x07, 0xC3,
  0xC3, 0xFC, 0x7F, 0xFF, 0x87, 0xFC, 0x70, 0x3E, 0x0F, 0x00, 0x38, 0xE7,
  0x9E, 0x71, 0xCF, 0x38, 0xE3, 0x8C, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x41, 0xC3, 0x71, 0x8F, 0xFD, 0xBF, 0xFF, 0xFF, 0x3F, 0xFE, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0x70, 0x1E, 0x78, 0x3E, 0x3C, 0x1C, 0x3C, 0x08, 0x10,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x0F, 0x87, 0xE7, 0xF1,
  0xF8, 0x7C, 0x1C, 0x1E, 0x3E, 0x7E, 0x3E, 0x18, 0x00, 0xFF, 0xFF, 0xEF,
  0xF8, 0x3C, 0xFD, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xE1,
  0xE0, 0xF0, 0x3C, 0x3C, 0x03, 0x87, 0x80, 0x71, 0xE0, 0x0F, 0x3C, 0x01,
  0xEF, 0x00, 0x39, 0xE3, 0x87, 0x38, 0xF8, 0xE7, 0x1F, 0x3D, 0xE3, 0xE7,
  0xBC, 0x78, 0xF7, 0x0E, 0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xF3, 0x80, 0x1C,
  0x70, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x0F, 0x07, 0xC7, 0xC0,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0x9C, 0x0F, 0x3C,
  0x0C, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xC0, 0x7C, 0x3E,
  0x07, 0x01, 0xE0, 0x20, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xC1, 0xF0, 0x20, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC2, 0x01, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0x79, 0xC0, 0x0F, 0x1C, 0x01,
  0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0x83, 0x80, 0x78, 0x38, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x83, 0x80, 0x70, 0x78, 0x07, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x08, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x3D, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC0,
  0xF8, 0x70, 0x07, 0x8F, 0x00, 0x38, 0xF0, 0x03, 0x8F, 0x00, 0x38, 0xF0,
  0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x70, 0x1F, 0x07,
  0x83, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E,
  0x1F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x7C, 0x78, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x0F, 0xBF, 0x01, 0xE0, 0xF8, 0x3C, 0x07, 0x87, 0x80, 0x3C,
  0x70, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0x70, 0x0F,
  0x87, 0xC1, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7C, 0x1E, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F,
  0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1E, 0x00, 0xE1, 0xF0, 0x3E, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFB, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xC0, 0xE0, 0x01, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x1F,
  0x80, 0xF8, 0x07, 0x00, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0xC0, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x07, 0xE1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xE3, 0xC0,
  0x07, 0x1E, 0x00, 0x39, 0xE0, 0x3F, 0xCE, 0x0F, 0xFE, 0x70, 0xFF, 0xE7,
  0x8F, 0x87, 0x38, 0x78, 0x79, 0xC7, 0x83, 0xDE, 0x38, 0x1C, 0xF1, 0xC0,
  0xE7, 0x1E, 0x0F, 0x38, 0xF0, 0x79, 0xC7, 0x83, 0x8E, 0x1C, 0x1C, 0x70,
  0xF1, 0xE3, 0x87, 0xFF, 0x1E, 0x1F, 0xF0, 0xF0, 0x3F, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x38, 0x00,
  0x79, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C,
  0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x0F, 0x38, 0x00,
  0x7B, 0xC0, 0x03, 0xDC, 0x00, 0x1E, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x70,
  0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x07, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1C, 0x07, 0xC1, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x3C, 0x70, 0x07, 0xC7, 0x01, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xC1,
  0xE0, 0x78, 0x02, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x08, 0x0F, 0x81, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x78, 0x3E, 0x07,
  0x01, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x1E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x3C, 0x70, 0x07, 0xC7, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x07,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xE0, 0xE0, 0x7C, 0x01,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xE1, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x3C, 0x03, 0xC1, 0xF0, 0x1C, 0x07,
  0xC0, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0x80,
  0x1E, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x70, 0x03,
  0xC0, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x78,
  0x1C, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x70,
  0x03, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0E, 0x00,
  0x78, 0x1C, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x0F,
  0x03, 0x80, 0x1E, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0x00, 0x78,
  0x0E, 0x0F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x03,
  0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78,
  0x1E, 0x00, 0xF0, 0x78, 0x01, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x0F, 0x1E,
  0x00, 0x1E, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x81, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F,
  0x07, 0xC0, 0x7E, 0x0D, 0x80, 0xDC, 0x3F, 0x01, 0xB8, 0x6E, 0x07, 0x71,
  0xDC, 0x0E, 0xE3, 0x38, 0x18, 0xCE, 0x70, 0x71, 0x99, 0xC0, 0xE3, 0x73,
  0x81, 0xC7, 0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x78,
  0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0,
  0x03, 0xC3, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0F,
  0x00, 0x70, 0x3F, 0x00, 0xE0, 0x7E, 0x01, 0xC0, 0xFC, 0x07, 0x81, 0xF8,
  0x0E, 0x07, 0x38, 0x1C, 0x0E, 0x70, 0x38, 0x1C, 0xE0, 0xF0, 0x38, 0xE1,
  0xC0, 0xF1, 0xC3, 0x81, 0xC3, 0x87, 0x03, 0x87, 0x0E, 0x07, 0x06, 0x38,
  0x1E, 0x0E, 0x70, 0x38, 0x1C, 0xE0, 0x70, 0x39, 0xC0, 0xE0, 0x77, 0x83,
  0xC0, 0x6E, 0x07, 0x00, 0xFC, 0x0E, 0x01, 0xF8, 0x1C, 0x03, 0xF0, 0x38,
  0x07, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x1E, 0x07, 0x80, 0xF0,
  0xF0, 0x0F, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x07,
  0x38, 0x00, 0x73, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00,
  0x3C, 0x70, 0x07, 0x87, 0x00, 0x70, 0x78, 0x0F, 0x07, 0xC3, 0xE0, 0x3F,
  0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0x03, 0xF0, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E,
  0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x1E, 0x01, 0xE0, 0xE0, 0x1E, 0x07, 0x03, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xE0, 0x3E, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0E, 0x00, 0x71,
  0xE0, 0x07, 0x1C, 0x00, 0x73, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0x70, 0x07, 0x87, 0x00,
  0x78, 0x78, 0x0F, 0x07, 0xC3, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1C,
  0x01, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0x83, 0x80, 0x3C,
  0x1C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xE1, 0xE0, 0x0E, 0x07, 0x80, 0x70, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xC0, 0x60, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x80, 0x1E, 0x0F, 0x03, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0,
  0xF0, 0x03, 0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xC1, 0xE0,
  0x07, 0x07, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x83, 0xC0, 0x0E,
  0x0F, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1E,
  0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x3C, 0x01,
  0xE0, 0x70, 0x07, 0x81, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x0F, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0xF0, 0x0E,
  0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x78, 0x07, 0x07,
  0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0x73,
  0xC0, 0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE1, 0xC1,
  0xC1, 0xC7, 0x87, 0x03, 0x8F, 0x8E, 0x0E, 0x3F, 0x1C, 0x1C, 0x7E, 0x38,
  0x39, 0xDC, 0xE0, 0x73, 0x39, 0xC0, 0xEE, 0x73, 0x81, 0x98, 0x66, 0x07,
  0x70, 0xDC, 0x0E, 0xC1, 0xB8, 0x1F, 0x83, 0x60, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x00, 0x00,
  0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x0F, 0x87, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x0E, 0x00, 0x78, 0x03, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x00, 0xF0, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0,
  0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xEF,
  0x00, 0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x3C, 0xF0, 0x1E, 0x38, 0x1E, 0x1C, 0x1E,
  0x0F, 0x1E, 0x03, 0x9E, 0x01, 0xDE, 0x00, 0xFF, 0x00, 0x3B, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x20, 0x70, 0xF8, 0x7C,
  0x3C, 0x1E, 0x0F, 0x04, 0x00, 0x3F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87,
  0xE0, 0xF0, 0xF0, 0x1C, 0x3C, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x78,
  0x03, 0x8E, 0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE1, 0xE0,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0x70, 0x1F, 0x8E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xEF, 0xC0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xE0, 0x0F, 0x1C,
  0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x07, 0x8E, 0x01, 0xE3, 0xC0,
  0xF8, 0x78, 0x3E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0x61, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x0C, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xE1, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x1E, 0x0F, 0x80, 0x70,
  0x3C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xE0, 0x70,
  0x03, 0x81, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xC0, 0xF0, 0x07,
  0x01, 0xC0, 0x1C, 0x07, 0x80, 0xF0, 0x1F, 0x0F, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xDC, 0x00, 0xFC, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x07, 0xE1, 0xE1, 0xF0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xC0,
  0x0E, 0x78, 0x03, 0xCE, 0x00, 0xFB, 0xC0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xC1, 0xFF, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x0C, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x0E, 0x03,
  0xE0, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x07, 0x81, 0xC0, 0x1E, 0x07, 0x80, 0x70, 0x1F, 0x0F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x60, 0x3E, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xDF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x07, 0xC3, 0x80,
  0xF0, 0xE0, 0x1C, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x1E, 0x78,
  0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xC0, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x8F, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x60, 0x78, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0,
  0xF0, 0x3E, 0x0E, 0x07, 0xC0, 0xE0, 0xF8, 0x1E, 0x3F, 0x01, 0xE7, 0xC0,
  0x1D, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x07, 0x03,
  0xC0, 0x70, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0x70, 0xFF,
  0xDF, 0xF3, 0xFE, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3C, 0x17, 0xFE, 0x7F, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE3, 0xC3, 0x87, 0x1C, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x78, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8F, 0x00,
  0x1C, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x1F, 0x0E,
  0x03, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0,
  0x0E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1,
  0xF0, 0x3C, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xE7, 0x80, 0x3C, 0x70, 0x0F, 0x0F, 0x03, 0xE1, 0xF0, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x07, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1C,
  0x01, 0xE0, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1C,
  0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83, 0x80,
  0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x07, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x1E, 0x0F, 0x81, 0xE1, 0xE0, 0x1E,
  0x3E, 0x01, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0x87, 0x00, 0x38, 0x70, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00,
  0x70, 0x70, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x3E, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFD, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF8,
  0x0F, 0xFF, 0x03, 0xE0, 0x40, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x04,
  0x01, 0xE1, 0xC0, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x18,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C,
  0x70, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0E, 0x38,
  0x07, 0x8E, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x3E, 0x3C, 0x1F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xB8, 0x1F, 0x8E, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03,
  0xDE, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0,
  0x38, 0x78, 0x3C, 0x1C, 0x1C, 0x0E, 0x1E, 0x07, 0x1E, 0x03, 0xCE, 0x01,
  0xEF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1E,
  0x78, 0x00, 0x71, 0xE1, 0xC1, 0xC7, 0x07, 0x0F, 0x1C, 0x3C, 0x38, 0x70,
  0xF0, 0xE1, 0xC7, 0xC7, 0x07, 0x1B, 0x9C, 0x1C, 0xEE, 0x70, 0x77, 0x3B,
  0x81, 0xDC, 0xEE, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x70, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x8F,
  0x00, 0x0F, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x3C, 0x00, 0x78,
  0xF0, 0x03, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x3C,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x7B, 0xC0,
  0x00, 0x7B, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x41, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x63, 0xF8, 0x1C, 0xFF, 0xC7, 0x38, 0x7F, 0xE7,
  0x07, 0xF8, 0xC0, 0x3C, 0x00,
};

const GFXglyph UbuntuMono_Italic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 11, 27, 22, 7, -27 },
  { 39, 13, 11, 22, 9, -27 },
  { 57, 22, 27, 22, 2, -27 },
  { 132, 20, 34, 22, 3, -30 },
  { 217, 26, 27, 22, 0, -27 },
  { 305, 19, 27, 22, 2, -27 },
  { 370, 6, 11, 22, 13, -29 },
  { 379, 16, 37, 22, 6, -30 },
  { 453, 17, 37, 22, 2, -30 },
  { 532, 16, 16, 22, 6, -27 },
  { 564, 18, 19, 22, 4, -21 },
  { 607, 9, 12, 22, 5, -6 },
  { 621, 10, 3, 22, 8, -12 },
  { 625, 7, 6, 22, 7, -6 },
  { 631, 25, 37, 22, -1, -30 },
  { 747, 19, 27, 22, 4, -27 },
  { 812, 16, 27, 22, 4, -27 },
  { 866, 20, 27, 22, 3, -27 },
  { 934, 19, 27, 22, 3, -27 },
  { 999, 20, 27, 22, 2, -27 },
  { 1067, 22, 27, 22, 2, -27 },
  { 1142, 20, 27, 22, 4, -27 },
  { 1210, 19, 27, 22, 6, -27 },
  { 1275, 20, 27, 22, 3, -27 },
  { 1343, 20, 27, 22, 3, -27 },
  { 1411, 10, 20, 22, 7, -20 },
  { 1436, 12, 26, 22, 5, -20 },
  { 1475, 19, 17, 22, 3, -19 },
  { 1516, 20, 11, 22, 3, -17 },
  { 1544, 19, 17, 22, 3, -20 },
  { 1585, 15, 27, 22, 7, -27 },
  { 1636, 21, 33, 22, 3, -27 },
  { 1723, 21, 27, 22, -1, -27 },
  { 1794, 20, 27, 22, 2, -27 },
  { 1862, 21, 27, 22, 4, -27 },
  { 1933, 20, 27, 22, 2, -27 },
  { 2001, 21, 27, 22, 3, -27 },
  { 2072, 22, 27, 22, 3, -27 },
  { 2147, 21, 27, 22, 3, -27 },
  { 2218, 23, 27, 22, 2, -27 },
  { 2296, 20, 27, 22, 3, -27 },
  { 2364, 21, 27, 22, 3, -27 },
  { 2435, 23, 27, 22, 2, -27 },
  { 2513, 16, 27, 22, 2, -27 },
  { 2567, 23, 27, 22, 1, -27 },
  { 2645, 23, 27, 22, 2, -27 },
  { 2723, 20, 27, 22, 3, -27 },
  { 2791, 21, 27, 22, 2, -27 },
  { 2862, 20, 34, 22, 3, -27 },
  { 2947, 21, 27, 22, 2, -27 },
  { 3018, 21, 27, 22, 2, -27 },
  { 3089, 18, 27, 22, 7, -27 },
  { 3150, 22, 27, 22, 3, -27 },
  { 3225, 20, 27, 22, 6, -27 },
  { 3293, 23, 27, 22, 3, -27 },
  { 3371, 26, 27, 22, 0, -27 },
  { 3459, 21, 27, 22, 6, -27 },
  { 3530, 23, 27, 22, 2, -27 },
  { 3608, 20, 37, 22, 4, -30 },
  { 3701, 7, 37, 22, 9, -30 },
  { 3734, 19, 37, 22, 1, -30 },
  { 3822, 17, 14, 22, 5, -27 },
  { 3852, 20, 3, 22, -1, 4 },
  { 3860, 8, 8, 22, 11, -30 },
  { 3868, 19, 22, 22, 3, -21 },
  { 3921, 19, 31, 22, 3, -30 },
  { 3995, 19, 22, 22, 3, -21 },
  { 4048, 22, 31, 22, 3, -30 },
  { 4134, 19, 22, 22, 3, -21 },
  { 4187, 26, 37, 22, 0, -30 },
  { 4308, 22, 28, 22, 1, -21 },
  { 4385, 18, 30, 22, 2, -30 },
  { 4453, 12, 29, 22, 6, -29 },
  { 4497, 21, 36, 22, 1, -29 },
  { 4592, 20, 30, 22, 3, -30 },
  { 4667, 11, 31, 22, 8, -30 },
  { 4710, 21, 21, 22, 1, -21 },
  { 4766, 18, 21, 22, 3, -21 },
  { 4814, 19, 22, 22, 3, -21 },
  { 4867, 21, 28, 22, 1, -21 },
  { 4941, 20, 28, 22, 3, -21 },
  { 5011, 18, 21, 22, 4, -21 },
  { 5059, 19, 22, 22, 3, -21 },
  { 5112, 16, 27, 22, 6, -26 },
  { 5166, 18, 21, 22, 4, -20 },
  { 5214, 17, 20, 22, 6, -20 },
  { 5257, 22, 20, 22, 3, -20 },
  { 5312, 22, 20, 22, 1, -20 },
  { 5367, 24, 27, 22, -1, -20 },
  { 5448, 20, 20, 22, 2, -20 },
  { 5498, 21, 37, 22, 4, -30 },
  { 5596, 12, 37, 22, 7, -30 },
  { 5652, 21, 37, 22, 0, -30 },
  { 5750, 19, 6, 22, 3, -14 },
};

const GFXfont UbuntuMono_Italic43pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic43pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic43pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUMONO_ITALIC43PT7B_H_
