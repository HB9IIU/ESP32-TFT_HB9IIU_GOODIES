#ifndef _UBUNTUMONO_ITALIC38PT7B_H_
#define _UBUNTUMONO_ITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0x07, 0xC3, 0xC1, 0xC0, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0xC3,
  0x98, 0x63, 0x0C, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x60,
  0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x38, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x18, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x38, 0x70, 0x03, 0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00,
  0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0x02, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE1, 0x81, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x0E,
  0x07, 0xE0, 0x38, 0x1F, 0xC0, 0xE0, 0x39, 0x83, 0x80, 0xE3, 0x0E, 0x01,
  0x86, 0x18, 0x03, 0x0C, 0x70, 0x06, 0x39, 0xC0, 0x0C, 0x77, 0x00, 0x1F,
  0xDC, 0x00, 0x3F, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x0E,
  0xFC, 0x00, 0x3B, 0xF8, 0x00, 0xE7, 0x30, 0x03, 0x9C, 0x60, 0x06, 0x30,
  0xC0, 0x1C, 0x61, 0x80, 0x70, 0xC7, 0x01, 0xC1, 0x8E, 0x07, 0x03, 0xF8,
  0x1C, 0x07, 0xE0, 0x30, 0x07, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0xF1, 0xE0, 0x70, 0x70, 0x38, 0x30, 0x38, 0x38, 0x0C, 0x38, 0x07,
  0x3C, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x71, 0xFC, 0x31, 0xEF, 0x38,
  0xE3, 0x9C, 0xE0, 0xFC, 0x70, 0x7E, 0x70, 0x1E, 0x38, 0x0F, 0x1E, 0x0F,
  0x8F, 0x0F, 0xC3, 0xFF, 0x71, 0xFF, 0x38, 0x3E, 0x1C, 0x39, 0xCE, 0xF7,
  0x39, 0xCC, 0x67, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x40, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x1C, 0x27, 0xBB, 0xDF, 0xEF, 0xCF,
  0xFE, 0x01, 0xC0, 0x07, 0xC0, 0x1D, 0xC0, 0x7B, 0xC1, 0xE3, 0xC1, 0xC7,
  0x01, 0x04, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0x0E, 0x3C, 0xF8, 0xE0, 0xFF,
  0xFF, 0xBF, 0xC0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF0, 0xE0, 0xF0,
  0x78, 0xF0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0xBC, 0xE1, 0xDC,
  0x79, 0xEE, 0x7C, 0xE7, 0x3E, 0x77, 0x8E, 0x3B, 0xC0, 0x3D, 0xC0, 0x1C,
  0xE0, 0x1E, 0x70, 0x0E, 0x3C, 0x0F, 0x1E, 0x0F, 0x07, 0x0F, 0x03, 0xFF,
  0x80, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x7F,
  0x07, 0xF8, 0x3E, 0xE0, 0xF3, 0x83, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x81, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0x00,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xF0, 0x40, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xF1,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0C, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x60,
  0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x07,
  0x8E, 0x07, 0x8E, 0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC3, 0x81, 0xC1,
  0xC0, 0xE1, 0xC0, 0x71, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x06, 0x07,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3D, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x83, 0xC7,
  0x00, 0xF3, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x07,
  0x1C, 0x07, 0x8F, 0x07, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x1F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF0, 0xF0, 0xE0,
  0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1E, 0x07, 0x07, 0x87, 0x83,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF3, 0xE0, 0xE0, 0x78, 0xE0, 0x1C,
  0xF0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0xCF, 0x07, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xE0, 0xF1, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCF, 0x00, 0xE7, 0x81, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F,
  0xBC, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x7E, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x0E, 0x1F, 0x1F, 0x1F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8,
  0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x00, 0xE0, 0x38, 0x1E, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x07,
  0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x20, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x08, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x03, 0x00,
  0x00, 0x07, 0xE0, 0x7F, 0xE1, 0xFF, 0x84, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0x0F, 0x0F, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0xF0,
  0x07, 0x38, 0x1F, 0xDC, 0x1F, 0xF7, 0x1F, 0xF9, 0xC7, 0x8E, 0xE3, 0xC3,
  0xB8, 0xE0, 0xEE, 0x30, 0x73, 0x9C, 0x1C, 0xE7, 0x07, 0x39, 0xC1, 0xCE,
  0x38, 0xE3, 0x8F, 0xF8, 0xE1, 0xFE, 0x38, 0x3F, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0,
  0x70, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x70, 0x03, 0x8E, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1F, 0x0E, 0x03, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x03, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFE, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0xE0, 0x3E, 0x3F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xE0, 0x60, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0x83, 0xE0, 0x70,
  0x3C, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x78, 0x03, 0x8E, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00,
  0x71, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x00, 0xF0, 0xE0, 0x3C, 0x38, 0x0F,
  0x07, 0x07, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F,
  0x06, 0x0F, 0x00, 0x87, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x38, 0x03, 0xCE,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x8F, 0x01, 0xC1, 0xC0,
  0x70, 0x7C, 0x1C, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0x80,
  0x38, 0x1C, 0x03, 0xC1, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x78, 0x3C, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0E, 0x00, 0xE0, 0x70,
  0x0F, 0x07, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x01, 0xE0,
  0xF0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x1E, 0x01,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x81, 0x01, 0xE0, 0xE0, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0x00, 0xF0, 0x70, 0x1E, 0x07, 0x03, 0xC0, 0x70, 0x78, 0x0E,
  0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x01,
  0xDE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0x9C, 0x00,
  0x39, 0xE0, 0x03, 0x8F, 0x00, 0x78, 0x70, 0x07, 0x07, 0x80, 0x70, 0x38,
  0x07, 0x03, 0xC0, 0x70, 0x1C, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x6C, 0x3F, 0x06, 0xC3,
  0x60, 0xEC, 0x76, 0x0E, 0xE6, 0x60, 0xCE, 0xCE, 0x0C, 0xEC, 0xE1, 0xC7,
  0x8E, 0x1C, 0x78, 0xC1, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x78, 0x07,
  0x07, 0x80, 0x60, 0xF8, 0x0E, 0x0F, 0xC0, 0xE0, 0xFC, 0x0E, 0x0D, 0xC0,
  0xC1, 0xCC, 0x1C, 0x1C, 0xE1, 0xC1, 0xCE, 0x1C, 0x1C, 0x61, 0xC3, 0x86,
  0x38, 0x38, 0x73, 0x83, 0x87, 0x38, 0x38, 0x73, 0x83, 0x03, 0x30, 0x70,
  0x37, 0x07, 0x03, 0xF0, 0x70, 0x3F, 0x06, 0x03, 0xE0, 0xE0, 0x1E, 0x0E,
  0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3E, 0x1E, 0x0F, 0x03, 0x87, 0x80, 0xE3, 0xC0, 0x3C, 0xE0,
  0x0F, 0x38, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x03,
  0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E,
  0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x78, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x3E,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0x81, 0xE0, 0x70,
  0x1C, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x0E, 0x0E, 0x01, 0xC3, 0xC0,
  0x78, 0x70, 0x0E, 0x0E, 0x07, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3E, 0x1E, 0x0F, 0x03, 0x87, 0x80, 0xE1,
  0xC0, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x0E, 0xF0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F,
  0x38, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x78, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1C, 0x1F, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07,
  0x1E, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x7C, 0x3F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xE1, 0xC0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x38, 0x07, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x60, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x20, 0x07, 0x07,
  0x03, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE1,
  0xC0, 0x3C, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x8F,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xF1, 0xE0, 0x1C, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x1E, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x78, 0x1E, 0x07, 0x87, 0x80, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78,
  0xF0, 0x1C, 0x1C, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x1C,
  0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xC1,
  0xC3, 0x8E, 0x0E, 0x3C, 0x70, 0x71, 0xE3, 0x03, 0x9B, 0x18, 0x19, 0xD9,
  0xC0, 0xCC, 0xCE, 0x0E, 0xE6, 0x60, 0x76, 0x37, 0x03, 0x71, 0xB8, 0x1B,
  0x0D, 0x80, 0xF8, 0x6C, 0x07, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0x80, 0xE0,
  0x07, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7,
  0x00, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x1C,
  0x01, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x1E, 0x1C,
  0x07, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x70, 0x0E, 0x38, 0x03, 0x9C,
  0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xF3, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0x1C, 0x0F, 0x1C, 0x1E, 0x1C,
  0x1C, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0x20, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x21, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x00,
  0x00, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xC3, 0xE0, 0xE3, 0xC0, 0x73, 0xC0,
  0x71, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1C,
  0x03, 0x8E, 0x01, 0xC7, 0x01, 0xC3, 0xC3, 0xE0, 0xFF, 0xF8, 0x7F, 0xDC,
  0x0F, 0xCE, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x7C, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xE0, 0xF0, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xF3,
  0x81, 0xF1, 0xC1, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x02, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x08, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC3, 0x83, 0xE0, 0x70, 0x78, 0x0E, 0x1E, 0x03, 0x83, 0x80,
  0x70, 0xF0, 0x0E, 0x1C, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01,
  0xC1, 0xE0, 0x78, 0x3E, 0x1F, 0x03, 0xFF, 0xE0, 0x3F, 0xDC, 0x03, 0xF3,
  0x80, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0x3C, 0x07, 0x78,
  0x07, 0x70, 0x0F, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0x80, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x08, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x78,
  0x20, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xF0, 0xF0, 0x78, 0x1C, 0x1E, 0x03, 0x87,
  0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0x70, 0xE0, 0x0E, 0x1C,
  0x03, 0x83, 0xC0, 0x70, 0x78, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xEE, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x06, 0x07, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0xF8,
  0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xF3,
  0xFC, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x03,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x60, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x38, 0x3C,
  0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x39, 0xF0, 0x07, 0x78, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF8, 0x00, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0x87, 0x00,
  0xF0, 0xF0, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC0,
  0xFF, 0xBF, 0xCF, 0xF0, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x0D, 0xFF, 0x7F, 0xC7, 0xE0, 0x07, 0xE7, 0x81,
  0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0x3C, 0x71, 0xC3, 0x0E, 0x38, 0x61, 0xC7,
  0x1C, 0x30, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x86, 0x1C,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x60,
  0x07, 0x1C, 0x00, 0xE0, 0x01, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xC1,
  0xE0, 0xE0, 0x78, 0xF0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x1E,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x78, 0x7F, 0xF8, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1C, 0x1F, 0x0F, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38,
  0x07, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x07,
  0x8E, 0x03, 0xC3, 0x83, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x7F, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0xE3, 0xE0, 0x71,
  0xE0, 0x39, 0xE0, 0x3C, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38, 0x07,
  0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xE3, 0xE1, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xDC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x60,
  0x78, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x0F, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC1, 0x83, 0xFF, 0x03, 0xFE,
  0x03, 0xF0, 0x00, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x78, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xE3, 0xC3, 0xE0, 0xFF,
  0xF8, 0x7F, 0xDC, 0x0F, 0xCE, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77,
  0x00, 0xEE, 0x03, 0x9E, 0x07, 0x3C, 0x1E, 0x38, 0x38, 0x70, 0xE0, 0xE1,
  0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x0C, 0x18, 0xE3, 0x87, 0x18, 0x70, 0xE3, 0x1F, 0x18, 0xE3,
  0xE7, 0x1C, 0xFC, 0xE3, 0x99, 0x98, 0x76, 0x37, 0x0E, 0xC6, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x00, 0x0F,
  0x00, 0xE0, 0x70, 0x1C, 0x07, 0x83, 0xC0, 0x38, 0x78, 0x03, 0xC7, 0x00,
  0x1C, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xBC, 0x00, 0xF1, 0xC0, 0x1E, 0x1E,
  0x03, 0xC0, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x70,
  0x07, 0x03, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xC0, 0x0F, 0x1E, 0x00, 0x38,
  0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x04, 0x3E, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x03,
  0x1F, 0xC1, 0x9F, 0xF1, 0xCE, 0x7F, 0xCE, 0x0F, 0xE2, 0x03, 0xC0,
};

const GFXglyph UbuntuMono_Italic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 24, 19, 7, -24 },
  { 28, 11, 9, 19, 8, -24 },
  { 41, 20, 24, 19, 2, -24 },
  { 101, 17, 30, 19, 3, -26 },
  { 165, 23, 24, 19, 0, -24 },
  { 234, 17, 24, 19, 2, -24 },
  { 285, 5, 10, 19, 11, -26 },
  { 292, 14, 33, 19, 6, -27 },
  { 350, 14, 33, 19, 2, -27 },
  { 408, 15, 14, 19, 5, -24 },
  { 435, 16, 17, 19, 3, -18 },
  { 469, 8, 10, 19, 4, -5 },
  { 479, 9, 3, 19, 7, -11 },
  { 483, 5, 5, 19, 7, -5 },
  { 487, 22, 33, 19, -1, -27 },
  { 578, 17, 24, 19, 3, -24 },
  { 629, 14, 24, 19, 3, -24 },
  { 671, 17, 24, 19, 3, -24 },
  { 722, 18, 24, 19, 2, -24 },
  { 776, 17, 24, 19, 2, -24 },
  { 827, 19, 24, 19, 2, -24 },
  { 884, 17, 24, 19, 4, -24 },
  { 935, 17, 24, 19, 5, -24 },
  { 986, 17, 24, 19, 3, -24 },
  { 1037, 17, 24, 19, 3, -24 },
  { 1088, 8, 17, 19, 7, -17 },
  { 1105, 11, 22, 19, 4, -17 },
  { 1136, 17, 15, 19, 3, -17 },
  { 1168, 18, 11, 19, 2, -16 },
  { 1193, 17, 15, 19, 2, -18 },
  { 1225, 14, 24, 19, 6, -24 },
  { 1267, 18, 29, 19, 3, -24 },
  { 1333, 19, 24, 19, -1, -24 },
  { 1390, 18, 24, 19, 2, -24 },
  { 1444, 19, 24, 19, 3, -24 },
  { 1501, 19, 24, 19, 1, -24 },
  { 1558, 19, 24, 19, 3, -24 },
  { 1615, 19, 24, 19, 3, -24 },
  { 1672, 18, 24, 19, 3, -24 },
  { 1726, 21, 24, 19, 1, -24 },
  { 1789, 18, 24, 19, 3, -24 },
  { 1843, 18, 24, 19, 3, -24 },
  { 1897, 20, 24, 19, 2, -24 },
  { 1957, 14, 24, 19, 2, -24 },
  { 1999, 20, 24, 19, 1, -24 },
  { 2059, 20, 24, 19, 2, -24 },
  { 2119, 18, 24, 19, 3, -24 },
  { 2173, 19, 24, 19, 2, -24 },
  { 2230, 18, 30, 19, 3, -24 },
  { 2298, 18, 24, 19, 2, -24 },
  { 2352, 19, 24, 19, 2, -24 },
  { 2409, 16, 24, 19, 6, -24 },
  { 2457, 19, 24, 19, 3, -24 },
  { 2514, 18, 24, 19, 5, -24 },
  { 2568, 21, 24, 19, 2, -24 },
  { 2631, 23, 24, 19, 0, -24 },
  { 2700, 18, 24, 19, 6, -24 },
  { 2754, 21, 24, 19, 1, -24 },
  { 2817, 17, 33, 19, 4, -27 },
  { 2888, 6, 33, 19, 8, -27 },
  { 2913, 17, 33, 19, 1, -27 },
  { 2984, 16, 13, 19, 4, -24 },
  { 3010, 18, 3, 19, -1, 4 },
  { 3017, 7, 7, 19, 10, -26 },
  { 3024, 17, 18, 19, 3, -18 },
  { 3063, 17, 26, 19, 2, -26 },
  { 3119, 16, 18, 19, 3, -18 },
  { 3155, 19, 26, 19, 3, -26 },
  { 3217, 16, 18, 19, 3, -18 },
  { 3253, 23, 32, 19, 0, -26 },
  { 3345, 19, 24, 19, 1, -18 },
  { 3402, 16, 26, 19, 2, -26 },
  { 3454, 11, 26, 19, 5, -26 },
  { 3490, 18, 32, 19, 1, -26 },
  { 3562, 19, 26, 19, 2, -26 },
  { 3624, 10, 26, 19, 7, -26 },
  { 3657, 19, 18, 19, 1, -18 },
  { 3700, 17, 18, 19, 2, -18 },
  { 3739, 16, 18, 19, 3, -18 },
  { 3775, 18, 24, 19, 1, -18 },
  { 3829, 17, 24, 19, 3, -18 },
  { 3880, 17, 18, 19, 3, -18 },
  { 3919, 16, 18, 19, 3, -18 },
  { 3955, 15, 23, 19, 5, -23 },
  { 3999, 17, 18, 19, 3, -18 },
  { 4038, 15, 18, 19, 5, -18 },
  { 4072, 19, 18, 19, 3, -18 },
  { 4115, 20, 18, 19, 1, -18 },
  { 4160, 21, 24, 19, -1, -18 },
  { 4223, 17, 18, 19, 2, -18 },
  { 4262, 19, 33, 19, 3, -27 },
  { 4341, 11, 33, 19, 6, -27 },
  { 4387, 18, 33, 19, 0, -27 },
  { 4462, 17, 6, 19, 3, -16 },
};

const GFXfont UbuntuMono_Italic38pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic38pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic38pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUMONO_ITALIC38PT7B_H_
