#ifndef _UBUNTUMONO_ITALIC24PT7B_H_
#define _UBUNTUMONO_ITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0x80, 0x00, 0x63, 0x8E,
  0x00, 0x66, 0xCD, 0x9A, 0x2C, 0xD9, 0x80, 0x03, 0x10, 0x19, 0x81, 0x8C,
  0x0C, 0xC3, 0xFF, 0x3F, 0xF8, 0x33, 0x03, 0x10, 0x11, 0x87, 0xFF, 0x3F,
  0xF8, 0xC6, 0x06, 0x60, 0x23, 0x03, 0x10, 0x00, 0x01, 0x80, 0x60, 0x1F,
  0x0F, 0xF3, 0x84, 0x60, 0x0C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x19, 0x87, 0x3F, 0xC3, 0xF0, 0x18, 0x02, 0x00, 0xC0, 0x00, 0x0E,
  0x0C, 0x3E, 0x30, 0x6C, 0x41, 0x99, 0x83, 0x26, 0x07, 0xD8, 0x07, 0x60,
  0x01, 0x80, 0x02, 0x70, 0x09, 0xE0, 0x36, 0x40, 0xC8, 0x83, 0x13, 0x0C,
  0x3C, 0x10, 0x70, 0x00, 0x07, 0x81, 0xF8, 0x73, 0x0C, 0x61, 0x8C, 0x33,
  0x03, 0xC0, 0xE3, 0x36, 0x4C, 0x79, 0x8E, 0x60, 0xCE, 0x38, 0xFD, 0x8F,
  0x30, 0x6D, 0xAD, 0x80, 0x00, 0x80, 0x70, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x10, 0x00, 0x02, 0x03, 0x00, 0xC0, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x04, 0x00, 0x0C, 0x03, 0x04, 0xCB, 0xFE,
  0x3F, 0x07, 0x83, 0xF0, 0xCC, 0x22, 0x00, 0x06, 0x01, 0x80, 0x60, 0x10,
  0xFF, 0xFF, 0xF0, 0xC0, 0x20, 0x18, 0x06, 0x00, 0x33, 0xDE, 0x6E, 0x60,
  0x7F, 0xF0, 0x6F, 0xE0, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x07, 0x83, 0xF8, 0x63, 0x18, 0x77, 0x06, 0xC0, 0xDB,
  0xB6, 0x76, 0xCC, 0xD8, 0x1B, 0x06, 0x61, 0xCE, 0x70, 0xFC, 0x1F, 0x00,
  0x01, 0x81, 0xC3, 0xC7, 0xE1, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC3, 0xFB, 0xFC, 0x0F, 0x87, 0xF8, 0x43, 0x00, 0x70, 0x0C,
  0x01, 0x80, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x30, 0x0E, 0x01, 0xFF,
  0x3F, 0xC0, 0x07, 0xC1, 0xFC, 0x21, 0x80, 0x30, 0x06, 0x01, 0xC1, 0xE0,
  0x3C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x64, 0x1C, 0xFF, 0x1F, 0x80, 0x00,
  0x60, 0x1C, 0x07, 0x81, 0xA0, 0x6C, 0x19, 0x86, 0x31, 0x86, 0x31, 0x8C,
  0x33, 0xFF, 0xFF, 0xE0, 0x10, 0x06, 0x00, 0xC0, 0x07, 0xF0, 0x7F, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x41, 0xC7, 0xF8, 0x7E, 0x00, 0x00, 0xE0, 0xFC, 0x3C, 0x0E,
  0x03, 0x80, 0x60, 0x1B, 0xC3, 0xFC, 0xE1, 0xD8, 0x1B, 0x03, 0x60, 0xE6,
  0x38, 0xFE, 0x0F, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38,
  0x00, 0x07, 0x83, 0xF8, 0x63, 0x98, 0x33, 0x06, 0x61, 0x8F, 0xE0, 0xF8,
  0x33, 0x8C, 0x33, 0x03, 0x60, 0xCC, 0x39, 0xFE, 0x1F, 0x80, 0x0F, 0x83,
  0xF8, 0xE3, 0x98, 0x36, 0x06, 0xC0, 0xDC, 0x39, 0xFE, 0x1F, 0xC0, 0x38,
  0x06, 0x03, 0x80, 0xE1, 0xF8, 0x3C, 0x00, 0x18, 0xF3, 0x80, 0x00, 0x00,
  0x00, 0x63, 0xCE, 0x00, 0x0C, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30,
  0xF1, 0xE1, 0x8E, 0x18, 0x00, 0x00, 0x40, 0xF1, 0xFB, 0xF0, 0xC0, 0x3E,
  0x01, 0xF0, 0x1E, 0x01, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x3F, 0xE0, 0x10, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x06, 0x0F, 0xCF,
  0xC7, 0xC0, 0x40, 0x00, 0x3E, 0x3F, 0x23, 0x03, 0x03, 0x06, 0x0C, 0x18,
  0x30, 0x20, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x07, 0xC1, 0xFC, 0x71, 0x98,
  0x17, 0x02, 0xC7, 0xF1, 0xFE, 0x73, 0xCC, 0x5B, 0x1B, 0x63, 0x6C, 0x6C,
  0xF9, 0x8F, 0x30, 0x03, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xC0, 0x38, 0x0D,
  0x81, 0xB0, 0x66, 0x08, 0xC3, 0x18, 0x43, 0x18, 0x67, 0xFC, 0xFF, 0xB0,
  0x36, 0x07, 0x80, 0xF0, 0x18, 0x1F, 0xC1, 0xFE, 0x18, 0x71, 0x83, 0x30,
  0x63, 0x0E, 0x3F, 0xC3, 0xFC, 0x30, 0xC6, 0x06, 0x60, 0x66, 0x0C, 0x41,
  0xCF, 0xF8, 0xFE, 0x00, 0x03, 0xE0, 0xFF, 0x1C, 0x23, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x87,
  0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x18, 0xE1, 0x86, 0x30, 0x73, 0x03,
  0x30, 0x23, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC6, 0x1C, 0xC3, 0x8F, 0xF0,
  0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F,
  0x87, 0xF8, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF1, 0xFE, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0x87,
  0xF8, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x07, 0xC1, 0xFC, 0x70, 0x98, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0,
  0xD8, 0x1B, 0x06, 0x60, 0xCE, 0x18, 0xFF, 0x0F, 0xC0, 0x18, 0x18, 0xC1,
  0x86, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x38, 0xFF, 0x87, 0xFC, 0x60, 0x63,
  0x03, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x06, 0x00, 0x1F, 0xE3,
  0xFC, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x81, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0x88,
  0x71, 0xFC, 0x1F, 0x00, 0x18, 0x38, 0xC3, 0x86, 0x38, 0x33, 0x81, 0xB8,
  0x1B, 0x80, 0xF8, 0x07, 0x80, 0x3E, 0x03, 0x30, 0x18, 0xC0, 0xC7, 0x06,
  0x18, 0x60, 0xE3, 0x03, 0x00, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFE, 0x06, 0x18,
  0x30, 0xC3, 0x8E, 0x14, 0x70, 0xA5, 0x8D, 0x6C, 0x6A, 0x42, 0x72, 0x33,
  0x31, 0x81, 0x88, 0x0C, 0xC0, 0x66, 0x06, 0x30, 0x31, 0x01, 0x80, 0x1C,
  0x18, 0xE0, 0xC7, 0x0C, 0x2C, 0x63, 0x63, 0x1B, 0x18, 0xC8, 0x86, 0x6C,
  0x63, 0x63, 0x1B, 0x18, 0x50, 0xC3, 0x84, 0x1C, 0x60, 0xE3, 0x06, 0x00,
  0x07, 0x83, 0xF8, 0xE3, 0x98, 0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0,
  0xD8, 0x1B, 0x03, 0x60, 0xCE, 0x30, 0xFE, 0x0F, 0x00, 0x0F, 0xC0, 0xFE,
  0x18, 0x71, 0x83, 0x18, 0x31, 0x83, 0x30, 0x63, 0x0E, 0x3F, 0xC3, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x83, 0xF8, 0xE3,
  0x98, 0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x03, 0x60,
  0xCE, 0x38, 0xFE, 0x0F, 0x00, 0xC0, 0x1C, 0x03, 0xE0, 0x18, 0x00, 0x0F,
  0xC1, 0xFE, 0x18, 0x61, 0x83, 0x18, 0x33, 0x03, 0x30, 0x63, 0x0E, 0x3F,
  0xC6, 0xF0, 0x63, 0x06, 0x18, 0x61, 0x8C, 0x18, 0xC0, 0xC0, 0x03, 0xE0,
  0xFF, 0x1C, 0x21, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x41, 0xCF, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0xF0,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x00, 0x30, 0x33, 0x06, 0x30, 0x63, 0x06, 0x60, 0x66,
  0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x18, 0xE3, 0x07,
  0xF0, 0x3C, 0x00, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C, 0x18,
  0x43, 0x06, 0x30, 0x66, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x78, 0x07, 0x80,
  0x70, 0x00, 0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x23, 0x03, 0x18, 0x18,
  0x8C, 0xCC, 0xE4, 0x6F, 0x63, 0x5B, 0x1E, 0x50, 0xA3, 0x87, 0x1C, 0x30,
  0xC3, 0x86, 0x00, 0x0E, 0x0C, 0x0C, 0x38, 0x18, 0x60, 0x39, 0x80, 0x36,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x33, 0x00,
  0xC6, 0x03, 0x86, 0x0E, 0x0C, 0x18, 0x18, 0x00, 0xC0, 0xF8, 0x1B, 0x06,
  0x61, 0x84, 0x30, 0xCC, 0x1B, 0x03, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3E, 0x0F, 0xC0, 0xCC,
  0xC6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x33, 0x33, 0x30, 0x0F, 0xC3,
  0xF0, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC3, 0xF0, 0xF8,
  0x00, 0x06, 0x07, 0x87, 0xC3, 0x63, 0x1B, 0x0F, 0x07, 0x01, 0x7F, 0xFF,
  0xFC, 0x46, 0x31, 0x0F, 0xC7, 0xF7, 0x8D, 0x83, 0xC1, 0xB0, 0x6C, 0x1B,
  0x04, 0xC3, 0x3F, 0xC7, 0xD8, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0xF8, 0xFF, 0x70, 0xD8, 0x36, 0x0D, 0x83, 0x41, 0xF0, 0x6C, 0x73,
  0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0xF7, 0x85, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE1, 0x1F, 0xC3, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x07, 0xC1, 0xFC, 0x38, 0xC6, 0x0C, 0xE1, 0x8C, 0x18, 0xC1,
  0x8C, 0x18, 0xE3, 0x8F, 0xF8, 0x7D, 0x80, 0x0F, 0x8F, 0xF7, 0x0D, 0x83,
  0xC1, 0xFF, 0xEF, 0xE3, 0x00, 0xC1, 0x1F, 0xC3, 0xE0, 0x00, 0x3C, 0x03,
  0xF0, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0xFF, 0x83, 0xFE, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x01, 0xF8,
  0x3F, 0xC3, 0x8C, 0x38, 0x61, 0x83, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30,
  0xE1, 0xFE, 0x07, 0xB0, 0x01, 0x84, 0x18, 0x3F, 0xC1, 0xF8, 0x00, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xF8, 0xFF, 0x30, 0xCC, 0x33,
  0x0D, 0x83, 0x60, 0xD8, 0x36, 0x1B, 0x06, 0xC1, 0x80, 0x0C, 0x3C, 0x30,
  0x00, 0x1F, 0xBE, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0F, 0x8F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x84, 0x30, 0x7F, 0x07, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x39, 0x8E, 0x73, 0x8C, 0xC1, 0xB0, 0x3C, 0x07, 0xC1, 0x9C,
  0x31, 0xC6, 0x18, 0xC1, 0x80, 0x7D, 0xF8, 0x60, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0xBF, 0x3C, 0x3E, 0xE3, 0xFE, 0x33,
  0x23, 0x22, 0x66, 0x66, 0x66, 0x66, 0x64, 0x04, 0xC0, 0xCC, 0x0C, 0xC0,
  0xC0, 0x1F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8, 0x36, 0x1B, 0x06, 0xC1,
  0xB0, 0x6C, 0x30, 0x0F, 0x0F, 0xF7, 0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x06, 0xC3, 0xBF, 0xC3, 0xC0, 0x07, 0xC0, 0xFF, 0x1C, 0x71, 0x83, 0x18,
  0x31, 0x83, 0x10, 0x73, 0x06, 0x31, 0xE3, 0xF8, 0x3F, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x00, 0x07, 0xC3, 0xF8, 0xE3, 0x30, 0x6E, 0x0D, 0x83,
  0x30, 0x66, 0x0C, 0xE3, 0x9F, 0xE1, 0xFC, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x0F, 0xC3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x00, 0x0F, 0x87, 0xF3, 0x08, 0xC0, 0x3C, 0x07,
  0xC0, 0x70, 0x06, 0xC3, 0x3F, 0xC7, 0xE0, 0x0C, 0x0C, 0x06, 0x0F, 0xFF,
  0xF9, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x27, 0xF1, 0xF0, 0x30,
  0xD8, 0x36, 0x0D, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x04, 0xC7, 0x3F, 0xC7,
  0xD8, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xE3, 0x19, 0x86, 0x61, 0xB0, 0x78,
  0x1E, 0x07, 0x00, 0x60, 0x34, 0x02, 0xC0, 0x6C, 0x46, 0xCE, 0xCC, 0xEC,
  0xDE, 0x8F, 0x78, 0xE7, 0x8E, 0x30, 0xC3, 0x00, 0x0C, 0x38, 0x63, 0x81,
  0x98, 0x0D, 0x80, 0x38, 0x01, 0x80, 0x1E, 0x01, 0xB0, 0x18, 0xC1, 0x86,
  0x18, 0x18, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC6, 0x06, 0x30,
  0x33, 0x01, 0x98, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x7C,
  0x03, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xF0, 0x3E, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xF0, 0x0F,
  0x00, 0x30, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03,
  0xE0, 0x1E, 0x00, 0x04, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x60,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x0F, 0xC0, 0xF8, 0x00, 0x38, 0x5F, 0x3C, 0xFA, 0x1E,
};

const GFXglyph UbuntuMono_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 15, 12, 4, -15 },
  { 13, 7, 6, 12, 5, -15 },
  { 19, 13, 15, 12, 1, -15 },
  { 44, 11, 19, 12, 2, -17 },
  { 71, 15, 15, 12, 0, -15 },
  { 100, 11, 15, 12, 1, -15 },
  { 121, 3, 6, 12, 7, -16 },
  { 124, 10, 21, 12, 3, -17 },
  { 151, 9, 21, 12, 1, -17 },
  { 175, 10, 9, 12, 3, -15 },
  { 187, 10, 10, 12, 2, -11 },
  { 200, 5, 6, 12, 3, -3 },
  { 204, 6, 2, 12, 4, -7 },
  { 206, 4, 3, 12, 4, -3 },
  { 208, 13, 21, 12, 0, -17 },
  { 243, 11, 15, 12, 2, -15 },
  { 264, 9, 15, 12, 2, -15 },
  { 281, 11, 15, 12, 2, -15 },
  { 302, 11, 15, 12, 1, -15 },
  { 323, 11, 15, 12, 1, -15 },
  { 344, 12, 15, 12, 1, -15 },
  { 367, 11, 15, 12, 2, -15 },
  { 388, 11, 15, 12, 3, -15 },
  { 409, 11, 15, 12, 2, -15 },
  { 430, 11, 15, 12, 2, -15 },
  { 451, 6, 11, 12, 4, -11 },
  { 460, 7, 14, 12, 3, -11 },
  { 473, 10, 9, 12, 2, -11 },
  { 485, 11, 7, 12, 2, -10 },
  { 495, 11, 9, 12, 1, -11 },
  { 508, 8, 15, 12, 4, -15 },
  { 523, 11, 18, 12, 2, -15 },
  { 548, 11, 15, 12, 0, -15 },
  { 569, 12, 15, 12, 1, -15 },
  { 592, 12, 15, 12, 2, -15 },
  { 615, 12, 15, 12, 1, -15 },
  { 638, 12, 15, 12, 2, -15 },
  { 661, 12, 15, 12, 2, -15 },
  { 684, 11, 15, 12, 2, -15 },
  { 705, 13, 15, 12, 1, -15 },
  { 730, 11, 15, 12, 2, -15 },
  { 751, 11, 15, 12, 2, -15 },
  { 772, 13, 15, 12, 1, -15 },
  { 797, 9, 15, 12, 1, -15 },
  { 814, 13, 15, 12, 0, -15 },
  { 839, 13, 15, 12, 1, -15 },
  { 864, 11, 15, 12, 2, -15 },
  { 885, 12, 15, 12, 1, -15 },
  { 908, 11, 19, 12, 2, -15 },
  { 935, 12, 15, 12, 1, -15 },
  { 958, 12, 15, 12, 1, -15 },
  { 981, 10, 15, 12, 4, -15 },
  { 1000, 12, 15, 12, 2, -15 },
  { 1023, 12, 15, 12, 3, -15 },
  { 1046, 13, 15, 12, 1, -15 },
  { 1071, 15, 15, 12, 0, -15 },
  { 1100, 11, 15, 12, 4, -15 },
  { 1121, 13, 15, 12, 1, -15 },
  { 1146, 11, 21, 12, 2, -17 },
  { 1175, 4, 21, 12, 5, -17 },
  { 1186, 10, 21, 12, 1, -17 },
  { 1213, 9, 8, 12, 3, -15 },
  { 1222, 11, 2, 12, -1, 2 },
  { 1225, 4, 4, 12, 6, -16 },
  { 1227, 10, 11, 12, 2, -11 },
  { 1241, 10, 17, 12, 2, -17 },
  { 1263, 10, 11, 12, 2, -11 },
  { 1277, 12, 17, 12, 2, -17 },
  { 1303, 10, 11, 12, 2, -11 },
  { 1317, 14, 21, 12, 0, -17 },
  { 1354, 13, 15, 12, 0, -11 },
  { 1379, 10, 17, 12, 1, -17 },
  { 1401, 7, 16, 12, 3, -16 },
  { 1415, 12, 20, 12, 0, -16 },
  { 1445, 11, 17, 12, 2, -17 },
  { 1469, 7, 17, 12, 4, -17 },
  { 1484, 12, 11, 12, 1, -11 },
  { 1501, 10, 11, 12, 2, -11 },
  { 1515, 10, 11, 12, 2, -11 },
  { 1529, 12, 15, 12, 0, -11 },
  { 1552, 11, 15, 12, 2, -11 },
  { 1573, 11, 11, 12, 2, -11 },
  { 1589, 10, 11, 12, 2, -11 },
  { 1603, 9, 14, 12, 3, -14 },
  { 1619, 10, 11, 12, 2, -11 },
  { 1633, 10, 11, 12, 3, -11 },
  { 1647, 12, 11, 12, 2, -11 },
  { 1664, 13, 11, 12, 0, -11 },
  { 1682, 13, 15, 12, 0, -11 },
  { 1707, 11, 11, 12, 1, -11 },
  { 1723, 12, 21, 12, 2, -17 },
  { 1755, 7, 21, 12, 4, -17 },
  { 1774, 12, 21, 12, 0, -17 },
  { 1806, 10, 4, 12, 2, -10 },
};

const GFXfont UbuntuMono_Italic24pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Italic24pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Italic24pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUMONO_ITALIC24PT7B_H_
