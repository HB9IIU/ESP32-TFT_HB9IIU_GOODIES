#ifndef _NOTOSANS_BLACK22PT7B_H_
#define _NOTOSANS_BLACK22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x07, 0x7B, 0xDE, 0xF7,
  0xFB, 0xFC, 0xEE, 0x77, 0x3B, 0x9C, 0x07, 0x38, 0x1D, 0xC0, 0x67, 0x03,
  0x9C, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC3, 0x38, 0x1C, 0xE3, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0x1D, 0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x70, 0x0C, 0x01,
  0x80, 0xFF, 0x7F, 0xFF, 0xFD, 0xD8, 0xBB, 0x07, 0xE0, 0xFF, 0x87, 0xF8,
  0x3F, 0x86, 0xF8, 0xCF, 0xFF, 0xFF, 0xF7, 0xFC, 0x0C, 0x01, 0x80, 0x3C,
  0x07, 0x07, 0xE0, 0xF0, 0x7F, 0x0E, 0x07, 0x71, 0xE0, 0xF7, 0x1C, 0x0F,
  0x73, 0x80, 0x77, 0x39, 0xC7, 0xF7, 0x7E, 0x7F, 0x77, 0xF1, 0xCE, 0x77,
  0x01, 0xEF, 0x70, 0x1C, 0xF7, 0x03, 0xCF, 0x70, 0x38, 0x77, 0x07, 0x07,
  0xF0, 0xF0, 0x3E, 0x0F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0x3C, 0x07,
  0x9E, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x3E, 0x7F, 0x9E, 0x7F, 0xEF,
  0x3C, 0xFF, 0x9E, 0x3F, 0x8F, 0x9F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0x3F, 0xFF, 0xF7, 0x77, 0x3C, 0xE7, 0x9C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E,
  0x3C, 0xF3, 0xCF, 0x1C, 0x79, 0xE3, 0xC0, 0xF1, 0xC7, 0x9E, 0x38, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x79, 0xCF, 0x00, 0x0F, 0x01,
  0xC0, 0x18, 0x33, 0x37, 0xFE, 0xFF, 0xE3, 0xC0, 0xFC, 0x3F, 0xC7, 0x38,
  0x24, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x7F, 0xBD, 0xEE, 0x70, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0x1F, 0x07, 0xF1, 0xFF, 0x7D, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xBE, 0xFF, 0x9F, 0xF0, 0xF8, 0x07, 0x87,
  0xC7, 0xEF, 0xFF, 0xFB, 0xBD, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xFE, 0xFF, 0xE7, 0xFF, 0x31, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0x1F, 0xFB, 0xFF, 0x3B, 0xF4, 0x3C, 0x07,
  0x8F, 0xE1, 0xF8, 0x3F, 0x87, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF7, 0xF8, 0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x77, 0x87, 0xBC, 0x79, 0xE3, 0x8F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x07, 0x80, 0x3C, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0x00, 0xE0,
  0x3F, 0xE7, 0xFE, 0xFF, 0xC0, 0x7C, 0x07, 0x80, 0xFC, 0x3F, 0xFF, 0xBF,
  0xF7, 0xF8, 0x07, 0xC3, 0xF8, 0xFF, 0x3E, 0x17, 0x81, 0xE0, 0x3F, 0xF7,
  0xFE, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x9E, 0xFF, 0xDF, 0xF0, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x1F, 0x0F,
  0xFB, 0xFF, 0x79, 0xFF, 0x1E, 0xF7, 0x9F, 0xF1, 0xF8, 0x7F, 0x9F, 0xFB,
  0xC7, 0xF8, 0xFF, 0x1F, 0xFF, 0xDF, 0xF1, 0xFC, 0x1F, 0x0F, 0xF3, 0xFF,
  0x7D, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xDF, 0xFF, 0xEF, 0xFC, 0xF7, 0x80,
  0xF0, 0x7C, 0xFF, 0x1F, 0xE3, 0xF0, 0xFF, 0xF6, 0x00, 0x00, 0x7F, 0xFF,
  0xF7, 0xBC, 0xE0, 0x00, 0x00, 0x03, 0xFD, 0xEF, 0x73, 0x80, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0x3E, 0x03, 0xF0, 0x1F, 0xC0, 0xFC,
  0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8,
  0xFE, 0x7F, 0x1F, 0x83, 0xC0, 0x40, 0x00, 0x1F, 0x1F, 0xFB, 0xFF, 0x39,
  0xF4, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFB, 0xF0,
  0xF0, 0x1E, 0x71, 0xFB, 0x9C, 0xFE, 0x7E, 0x7B, 0x9F, 0xBC, 0xE7, 0xEE,
  0x39, 0xFB, 0x8E, 0x7E, 0xE3, 0x9B, 0x9F, 0xFE, 0xE7, 0xFF, 0x1C, 0x00,
  0x07, 0x80, 0x40, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE,
  0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0xFE,
  0xF1, 0xEF, 0x1E, 0xFF, 0xEF, 0xF8, 0xFF, 0xEF, 0x3E, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0xFE, 0xFF, 0xEF, 0xF8, 0x07, 0xE0, 0xFF, 0xCF, 0xFC, 0xFF,
  0xE7, 0xC1, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0xE3, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE, 0xFE, 0x07, 0xFE, 0x3F,
  0xF9, 0xFF, 0xEF, 0x0F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE1, 0xEF, 0x7F, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0xF0,
  0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x7F,
  0xF9, 0xFF, 0xE7, 0xFF, 0x83, 0xDE, 0x0F, 0x7E, 0x3C, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFE, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x9F, 0xFE, 0xFC, 0xF8, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE7, 0xCF,
  0x3C, 0x7B, 0xE3, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3D, 0xF1, 0xE7,
  0xCF, 0x1E, 0x78, 0xFB, 0xC3, 0xDE, 0x1F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFB, 0x8F, 0xFE, 0xE3, 0xBF, 0xB8, 0xEF, 0xEF, 0x3B, 0xF9,
  0xDC, 0xFE, 0x77, 0x3F, 0x9F, 0xCF, 0xE3, 0xF3, 0xF8, 0xF8, 0xFE, 0x3E,
  0x3F, 0x8F, 0x8F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFD, 0xE3, 0xFB, 0xC7, 0xF3, 0xCF, 0xE7, 0xDF, 0xC7, 0xBF, 0x8F, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xE7, 0xE7, 0xFF, 0x8F,
  0xFE, 0x07, 0xF8, 0xFE, 0x1F, 0xF3, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0xFF, 0xFF, 0xDF, 0xF3, 0xF8, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78,
  0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x07, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF,
  0x1E, 0x78, 0xF3, 0xC7, 0x9F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3D, 0xE1, 0xE7,
  0x8F, 0x3E, 0x78, 0xF3, 0xC7, 0xDE, 0x1F, 0x1F, 0x8F, 0xFD, 0xFF, 0x7C,
  0xEF, 0x01, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE,
  0x3F, 0xFF, 0xBF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x9F,
  0xFF, 0xF9, 0xFF, 0x83, 0xF8, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0, 0xFB, 0xE1,
  0xE7, 0xC7, 0xC7, 0x8F, 0x8F, 0x1E, 0x1F, 0x3C, 0x1E, 0xF8, 0x3D, 0xE0,
  0x7B, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0xF0,
  0x78, 0x3E, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x8F,
  0xC3, 0x87, 0x9F, 0xCF, 0x0F, 0x3B, 0x9E, 0x1E, 0x77, 0x3C, 0x3C, 0xEE,
  0x78, 0x3B, 0xDD, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF0, 0xF8, 0x1E, 0x7C,
  0x3E, 0x3C, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0x78, 0x3C,
  0x7C, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xE1, 0xE3,
  0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0xFF, 0xFF,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF,
  0xFF, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xB8, 0x39, 0xC7,
  0x1C, 0x70, 0xEE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0xF8, 0x78, 0x70, 0x7F, 0xCF, 0xFC, 0xFF, 0x80, 0xF1, 0xFE, 0xFF, 0xFF,
  0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xFB, 0xBE, 0x70, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xF7, 0xC0, 0x1F, 0xDF,
  0xF7, 0xFF, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0xDF, 0xF7, 0xFC,
  0x7E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF3, 0xEF, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xF7,
  0xEF, 0x3E, 0xF0, 0x3F, 0x87, 0xFE, 0x7F, 0xEF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x27, 0xFE, 0x7F, 0xE1, 0xFC, 0x0F, 0xC7, 0xE3,
  0xF8, 0xF8, 0x3C, 0x1F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x3E, 0xF7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFF, 0x7E, 0xF3,
  0xEF, 0x01, 0xFC, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF0, 0x77,
  0xFE, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x7C,
  0xF8, 0x60, 0x07, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xFF, 0xEF, 0xDF, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE3, 0xEF, 0x9F, 0x3E, 0xF8, 0xFB, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xE7, 0x8F, 0x9F, 0x3E, 0x3E, 0xF8, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF7,
  0xE7, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x8F, 0x9F, 0xF8, 0xF1, 0xFF,
  0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F,
  0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF7, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0x3F,
  0x87, 0xFE, 0x7F, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9,
  0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xF7, 0xCF, 0xFE, 0xFF, 0xFF, 0x9F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0xF7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFF, 0x7E, 0xF3,
  0xEF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xF7, 0xFB, 0xFF,
  0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0x7F,
  0xBF, 0xEF, 0x7B, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3E, 0x83, 0xFF, 0xEF,
  0xFB, 0xFC, 0x38, 0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x79, 0x7F, 0x3F, 0x3F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xF7, 0xFF, 0x7F, 0x73, 0xE7, 0xF8,
  0x7B, 0xC3, 0xDE, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0xF0, 0x77, 0x83, 0xFC,
  0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0xF0, 0xF7, 0x9F, 0x9E,
  0x79, 0xF9, 0xE7, 0x9F, 0x9E, 0x39, 0xF9, 0xC3, 0xFF, 0xFC, 0x3F, 0x9F,
  0xC3, 0xF9, 0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0xF8, 0xFD, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xF3, 0xC7, 0xCF, 0xBE, 0x1F, 0xF8, 0x7B,
  0xC3, 0xDE, 0x3C, 0xF1, 0xE3, 0xCF, 0x1E, 0xF0, 0x77, 0x83, 0xFC, 0x1F,
  0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x81, 0xFC, 0x0F, 0xC0,
  0x7C, 0x00, 0xFF, 0xBF, 0xEF, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0x1F, 0x3F, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0xFC, 0xF0, 0xF8, 0xFC, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0x1F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0xF8,
  0xF8, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x1F, 0x1F, 0x3F, 0x38, 0x38,
  0x38, 0x38, 0x78, 0xF8, 0xF8, 0xC0, 0x78, 0x3F, 0xFF, 0xFF, 0xC3, 0xF0,
};

const GFXglyph NotoSans_Black22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 16, 6, 1, -16 },
  { 11, 9, 6, 12, 1, -16 },
  { 18, 14, 16, 15, 0, -16 },
  { 46, 11, 18, 13, 1, -17 },
  { 71, 20, 16, 21, 0, -16 },
  { 111, 17, 16, 18, 1, -16 },
  { 145, 4, 6, 6, 1, -16 },
  { 148, 6, 19, 8, 1, -16 },
  { 163, 6, 19, 8, 1, -16 },
  { 178, 11, 11, 12, 0, -17 },
  { 194, 11, 11, 13, 1, -13 },
  { 210, 5, 6, 7, 1, -3 },
  { 214, 7, 4, 7, 0, -8 },
  { 218, 4, 4, 6, 1, -4 },
  { 220, 10, 16, 10, 0, -16 },
  { 240, 11, 16, 13, 1, -16 },
  { 262, 9, 16, 13, 1, -16 },
  { 280, 12, 16, 13, 0, -16 },
  { 304, 11, 16, 13, 1, -16 },
  { 326, 13, 16, 13, 0, -16 },
  { 352, 11, 16, 13, 1, -16 },
  { 374, 11, 16, 13, 1, -16 },
  { 396, 11, 16, 13, 1, -16 },
  { 418, 11, 16, 13, 1, -16 },
  { 440, 11, 16, 13, 1, -16 },
  { 462, 4, 12, 6, 1, -12 },
  { 468, 5, 15, 7, 1, -12 },
  { 478, 11, 12, 13, 1, -14 },
  { 495, 11, 8, 13, 1, -12 },
  { 506, 11, 12, 13, 1, -14 },
  { 523, 11, 16, 11, 0, -16 },
  { 545, 18, 18, 20, 1, -16 },
  { 586, 16, 16, 16, 0, -16 },
  { 618, 12, 16, 15, 2, -16 },
  { 642, 13, 16, 14, 1, -16 },
  { 668, 13, 16, 16, 2, -16 },
  { 694, 9, 16, 12, 2, -16 },
  { 712, 9, 16, 12, 2, -16 },
  { 730, 14, 16, 16, 1, -16 },
  { 758, 13, 16, 17, 2, -16 },
  { 784, 8, 16, 10, 1, -16 },
  { 800, 8, 21, 8, -2, -16 },
  { 821, 13, 16, 15, 2, -16 },
  { 847, 10, 16, 13, 2, -16 },
  { 867, 18, 16, 21, 2, -16 },
  { 903, 15, 16, 18, 2, -16 },
  { 933, 15, 16, 18, 1, -16 },
  { 963, 11, 16, 14, 2, -16 },
  { 985, 16, 20, 18, 1, -16 },
  { 1025, 13, 16, 15, 2, -16 },
  { 1051, 11, 16, 13, 1, -16 },
  { 1073, 11, 16, 13, 1, -16 },
  { 1095, 13, 16, 17, 2, -16 },
  { 1121, 15, 16, 15, 0, -16 },
  { 1151, 23, 16, 23, 0, -16 },
  { 1197, 16, 16, 16, 0, -16 },
  { 1229, 15, 16, 15, 0, -16 },
  { 1259, 12, 16, 13, 1, -16 },
  { 1283, 6, 20, 7, 1, -16 },
  { 1298, 10, 16, 10, 0, -16 },
  { 1318, 6, 20, 7, 0, -16 },
  { 1333, 12, 11, 12, 0, -16 },
  { 1350, 11, 3, 11, 0, 1 },
  { 1355, 7, 4, 9, 1, -17 },
  { 1359, 11, 12, 14, 1, -12 },
  { 1376, 12, 17, 14, 1, -17 },
  { 1402, 10, 12, 12, 1, -12 },
  { 1417, 12, 17, 14, 1, -17 },
  { 1443, 12, 12, 14, 1, -12 },
  { 1461, 10, 17, 9, 0, -17 },
  { 1483, 12, 17, 14, 1, -12 },
  { 1509, 12, 17, 15, 1, -17 },
  { 1535, 5, 17, 7, 1, -17 },
  { 1546, 7, 22, 7, -1, -17 },
  { 1566, 14, 17, 15, 1, -17 },
  { 1596, 5, 17, 7, 1, -17 },
  { 1607, 20, 12, 22, 1, -12 },
  { 1637, 12, 12, 15, 1, -12 },
  { 1655, 12, 12, 14, 1, -12 },
  { 1673, 12, 17, 14, 1, -12 },
  { 1699, 12, 17, 14, 1, -12 },
  { 1725, 9, 12, 10, 1, -12 },
  { 1739, 10, 12, 11, 1, -12 },
  { 1754, 8, 15, 10, 1, -15 },
  { 1769, 12, 12, 15, 1, -12 },
  { 1787, 13, 12, 13, 0, -12 },
  { 1807, 20, 12, 20, 0, -12 },
  { 1837, 14, 12, 14, 0, -12 },
  { 1858, 13, 17, 13, 0, -12 },
  { 1886, 10, 12, 11, 1, -12 },
  { 1901, 8, 20, 10, 1, -16 },
  { 1921, 3, 22, 11, 4, -17 },
  { 1930, 8, 20, 10, 1, -16 },
  { 1950, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_Black22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black22pt7bBitmaps,
  (GFXglyph *)NotoSans_Black22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_BLACK22PT7B_H_
