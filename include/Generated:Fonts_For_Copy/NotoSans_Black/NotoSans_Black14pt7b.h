#ifndef _NOTOSANS_BLACK14PT7B_H_
#define _NOTOSANS_BLACK14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0x80, 0xD8, 0xDF, 0x6D, 0xB6, 0x1B, 0x0D, 0x86, 0x8F,
  0xF3, 0x61, 0xB3, 0xFE, 0x6C, 0x24, 0x36, 0x00, 0x18, 0x3C, 0x7E, 0xFA,
  0xF8, 0x7C, 0x3E, 0x1F, 0x5F, 0x7E, 0x3C, 0x18, 0x78, 0xC7, 0xC6, 0x36,
  0x61, 0xB6, 0x0F, 0xB7, 0x3F, 0x7C, 0x1B, 0x61, 0x9B, 0x0C, 0xF8, 0xC3,
  0x80, 0x3E, 0x07, 0xE1, 0xDC, 0x1F, 0x03, 0xCE, 0xFD, 0x9B, 0xF7, 0x3C,
  0x7F, 0xC7, 0xFC, 0xFF, 0x3B, 0x98, 0xC6, 0x33, 0x8C, 0x63, 0x1C, 0x70,
  0xE3, 0x8C, 0x63, 0x1C, 0xE6, 0x31, 0x9D, 0xC0, 0x18, 0x31, 0x7F, 0xF3,
  0x8F, 0x8B, 0x80, 0x30, 0x63, 0xFF, 0xF3, 0x06, 0x00, 0x76, 0x6C, 0xFF,
  0xF0, 0x0C, 0x71, 0x8E, 0x30, 0xC7, 0x18, 0x63, 0x80, 0x3C, 0x7E, 0x66,
  0x67, 0xE7, 0xE7, 0x67, 0x66, 0x7E, 0x3C, 0x3B, 0xFF, 0xB9, 0x8C, 0x63,
  0x18, 0xC0, 0x3C, 0xFE, 0x66, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF,
  0xFC, 0x7E, 0x46, 0x0E, 0x3C, 0x3E, 0x07, 0x87, 0xFE, 0xFC, 0x0E, 0x1E,
  0x1E, 0x3E, 0x7E, 0x6E, 0xFF, 0xFF, 0x0E, 0x0E, 0xFD, 0xFB, 0x06, 0x8F,
  0xDF, 0x83, 0xC6, 0xFD, 0xF0, 0x1E, 0x3E, 0x70, 0x6C, 0x7E, 0xF7, 0x67,
  0x67, 0x7E, 0x3C, 0xFF, 0xFC, 0x30, 0xE1, 0xC7, 0x0E, 0x18, 0x71, 0xC0,
  0x3E, 0x7E, 0x66, 0x7E, 0x3C, 0x7E, 0x67, 0xE7, 0x7F, 0x3E, 0x3C, 0x7E,
  0x66, 0xE7, 0x7F, 0x7F, 0x37, 0x0E, 0x7E, 0x78, 0xFC, 0x0F, 0x66, 0x60,
  0x00, 0x76, 0x6C, 0x02, 0x1C, 0xF7, 0x0E, 0x0F, 0x83, 0x81, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC0, 0xE1, 0xFF, 0x38, 0x40, 0x7D, 0xFD,
  0x38, 0x73, 0xC6, 0x00, 0x00, 0x38, 0x60, 0x1F, 0x0F, 0x3B, 0x9B, 0x6F,
  0xBF, 0x37, 0x66, 0xEC, 0xDE, 0xFE, 0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x1E,
  0x07, 0x83, 0xF0, 0xEC, 0x33, 0x1C, 0xE7, 0xF9, 0xFE, 0xE1, 0xF8, 0x70,
  0xFC, 0xFE, 0xE7, 0xE6, 0xFC, 0xFE, 0xE7, 0xE7, 0xFE, 0xFC, 0x3F, 0x7E,
  0xE2, 0xE0, 0xE0, 0xC0, 0xE0, 0xE2, 0x7E, 0x3E, 0xFC, 0x7F, 0xB9, 0xDC,
  0x6E, 0x3F, 0x1F, 0x8D, 0xCE, 0xFE, 0x7E, 0x00, 0xFF, 0xFE, 0x38, 0xFF,
  0xFE, 0x38, 0xFF, 0xF0, 0xFF, 0xFE, 0x38, 0xFF, 0xFE, 0x38, 0xE3, 0x80,
  0x3F, 0x7F, 0xF1, 0xE0, 0xEF, 0xEF, 0xE3, 0xE3, 0x7F, 0x3F, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0xFF, 0xF3,
  0x0C, 0x30, 0xC3, 0x0C, 0xFF, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCF, 0xEF, 0x00, 0xE7, 0xF3, 0xBB, 0x9F, 0x8F, 0xC7, 0xE3, 0xB9, 0xDC,
  0xE7, 0x73, 0xC0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFC,
  0xF0, 0xFE, 0x3F, 0xC7, 0xEC, 0xFD, 0x9F, 0xB6, 0xF7, 0xDE, 0x7B, 0xCE,
  0x79, 0xCC, 0xF1, 0xFC, 0x7F, 0x9F, 0x67, 0xDD, 0xF3, 0x7C, 0xFF, 0x1F,
  0xC7, 0xF0, 0xF0, 0x3E, 0x3F, 0xB8, 0xFC, 0x7E, 0x1F, 0x0F, 0x8F, 0xC7,
  0x7F, 0x1F, 0x00, 0xFD, 0xFF, 0xBF, 0x3F, 0xFF, 0xFE, 0x70, 0xE1, 0xC0,
  0x3E, 0x1F, 0xCE, 0x3B, 0x8E, 0xE1, 0xB8, 0x6E, 0x3B, 0x8E, 0x7F, 0x0F,
  0x80, 0x70, 0x0F, 0xFC, 0x7F, 0x39, 0x9C, 0xCF, 0xE7, 0xE3, 0xB1, 0xDC,
  0xE7, 0x73, 0xC0, 0x7F, 0xFB, 0x17, 0x0F, 0x8F, 0x87, 0xC7, 0xFD, 0xF0,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCE, 0x7F, 0x1F, 0x00, 0xE1, 0xF8,
  0xE7, 0x39, 0xCE, 0x77, 0x0D, 0xC3, 0xF0, 0xF8, 0x1E, 0x07, 0x80, 0xE3,
  0x8D, 0x8E, 0x76, 0x79, 0xDD, 0xE6, 0x76, 0xD8, 0xDB, 0x63, 0x6F, 0x8F,
  0x3C, 0x3C, 0xF0, 0x71, 0xC0, 0xF3, 0xDC, 0xE3, 0xF0, 0xFC, 0x1E, 0x07,
  0x83, 0xF0, 0xFC, 0x73, 0xB8, 0x70, 0xE3, 0xB9, 0x9D, 0xC7, 0xC3, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x7F, 0x7F, 0x07, 0x0E, 0x1C, 0x38,
  0x38, 0x70, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xE1, 0x86, 0x1C,
  0x30, 0xC3, 0x86, 0x1C, 0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10,
  0x38, 0x38, 0x6C, 0x6C, 0xC6, 0xC7, 0xFF, 0xFC, 0xE7, 0x30, 0x3C, 0x7F,
  0x27, 0x3F, 0x7F, 0xE7, 0x7F, 0x7B, 0xE1, 0xC3, 0x87, 0xEF, 0xFD, 0xF9,
  0xF3, 0xEF, 0xFF, 0x70, 0x3F, 0xFE, 0x70, 0xC3, 0x9F, 0xDF, 0x0E, 0x1C,
  0x3B, 0xFF, 0xFD, 0xF1, 0xE3, 0xEF, 0xFD, 0xD8, 0x39, 0xFF, 0xBF, 0xFF,
  0xF8, 0x3F, 0xBF, 0x1C, 0xF7, 0x1F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7, 0x00,
  0x77, 0xFF, 0xBE, 0x3C, 0x7D, 0xFF, 0xBF, 0x0F, 0xFF, 0xF0, 0xE1, 0xC3,
  0x87, 0xEF, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x98, 0xDD, 0x7F, 0xFF, 0xFF,
  0x80, 0x31, 0xC4, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x78, 0xE0, 0xE0,
  0xE0, 0xE7, 0xEE, 0xFC, 0xD8, 0xFC, 0xEE, 0xEE, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xDC, 0xEF, 0xFF, 0xEF, 0x7E, 0x67, 0xE6, 0x7E, 0x67, 0xE6,
  0x7E, 0x67, 0xDD, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x39, 0xFF, 0xBE,
  0x3C, 0x7D, 0xFF, 0xBE, 0xDD, 0xFF, 0xBF, 0x3E, 0x7D, 0xFF, 0xFE, 0xE1,
  0xC3, 0x80, 0x77, 0xFF, 0xBE, 0x3C, 0x7D, 0xFF, 0xBF, 0x0E, 0x1C, 0x38,
  0xDF, 0xFF, 0xCE, 0x73, 0x9C, 0x7F, 0xEC, 0xBC, 0x78, 0x7F, 0xFE, 0x31,
  0xFF, 0xDC, 0x71, 0xC7, 0x1F, 0x3C, 0xE7, 0xCF, 0x9F, 0x3E, 0x7D, 0xFF,
  0xBF, 0xE3, 0xF3, 0x99, 0xCE, 0xC3, 0xE1, 0xF0, 0xF0, 0x38, 0xE7, 0x3B,
  0x39, 0x9B, 0xDC, 0xDB, 0xE7, 0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0xE7,
  0xBB, 0x8F, 0x87, 0xC3, 0xE1, 0xF1, 0xDD, 0xCF, 0xE3, 0xF3, 0x99, 0xCE,
  0xC3, 0x61, 0xF0, 0xF0, 0x38, 0x18, 0x3C, 0x1C, 0x00, 0x7E, 0xFC, 0x70,
  0xC3, 0x8E, 0x3F, 0xFF, 0x1C, 0xF3, 0x0C, 0x33, 0xCF, 0x0C, 0x30, 0xC3,
  0xCF, 0xFF, 0xFC, 0xE3, 0xC3, 0x0C, 0x30, 0xF3, 0xCC, 0x30, 0xCF, 0x3C,
  0xF7, 0xFC,
};

const GFXglyph NotoSans_Black14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 10, 4, 1, -10 },
  { 5, 6, 4, 7, 1, -10 },
  { 8, 9, 10, 9, 0, -10 },
  { 20, 8, 12, 8, 0, -11 },
  { 32, 13, 10, 13, 0, -10 },
  { 49, 11, 10, 11, 0, -10 },
  { 63, 2, 4, 4, 1, -10 },
  { 64, 5, 12, 5, 0, -10 },
  { 72, 5, 12, 5, 0, -10 },
  { 80, 7, 7, 8, 0, -11 },
  { 87, 7, 6, 8, 1, -8 },
  { 93, 4, 4, 4, 0, -2 },
  { 95, 4, 2, 4, 0, -5 },
  { 96, 2, 2, 4, 1, -2 },
  { 97, 6, 10, 6, 0, -10 },
  { 105, 8, 10, 8, 0, -10 },
  { 115, 5, 10, 8, 1, -10 },
  { 122, 8, 10, 8, 0, -10 },
  { 132, 8, 10, 8, 0, -10 },
  { 142, 8, 10, 8, 0, -10 },
  { 152, 7, 10, 8, 1, -10 },
  { 161, 8, 10, 8, 0, -10 },
  { 171, 7, 10, 8, 1, -10 },
  { 180, 8, 10, 8, 0, -10 },
  { 190, 8, 10, 8, 0, -10 },
  { 200, 2, 8, 4, 1, -8 },
  { 202, 4, 10, 4, 0, -8 },
  { 207, 7, 8, 8, 1, -9 },
  { 214, 7, 5, 8, 1, -7 },
  { 219, 7, 8, 8, 1, -9 },
  { 226, 7, 10, 7, 0, -10 },
  { 235, 11, 11, 13, 1, -10 },
  { 251, 10, 10, 10, 0, -10 },
  { 264, 8, 10, 9, 1, -10 },
  { 274, 8, 10, 9, 1, -10 },
  { 284, 9, 10, 10, 1, -10 },
  { 296, 6, 10, 8, 1, -10 },
  { 304, 6, 10, 8, 1, -10 },
  { 312, 8, 10, 10, 1, -10 },
  { 322, 9, 10, 11, 1, -10 },
  { 334, 6, 10, 6, 0, -10 },
  { 342, 5, 13, 5, -1, -10 },
  { 351, 9, 10, 10, 1, -10 },
  { 363, 7, 10, 8, 1, -10 },
  { 372, 11, 10, 14, 1, -10 },
  { 386, 10, 10, 12, 1, -10 },
  { 399, 9, 10, 11, 1, -10 },
  { 411, 7, 10, 9, 1, -10 },
  { 420, 10, 12, 11, 1, -10 },
  { 435, 9, 10, 9, 1, -10 },
  { 447, 7, 10, 8, 1, -10 },
  { 456, 8, 10, 8, 0, -10 },
  { 466, 9, 10, 11, 1, -10 },
  { 478, 10, 10, 10, 0, -10 },
  { 491, 14, 10, 15, 0, -10 },
  { 509, 10, 10, 10, 0, -10 },
  { 522, 9, 10, 9, 0, -10 },
  { 534, 8, 10, 9, 0, -10 },
  { 544, 3, 12, 5, 1, -10 },
  { 549, 6, 10, 6, 0, -10 },
  { 557, 4, 12, 5, 0, -10 },
  { 563, 8, 7, 7, 0, -10 },
  { 570, 7, 2, 7, 0, 1 },
  { 572, 4, 3, 6, 1, -11 },
  { 574, 8, 8, 9, 0, -8 },
  { 582, 7, 11, 9, 1, -11 },
  { 592, 6, 8, 8, 1, -8 },
  { 598, 7, 11, 9, 1, -11 },
  { 608, 7, 8, 9, 1, -8 },
  { 615, 6, 11, 6, 0, -11 },
  { 624, 7, 11, 9, 1, -8 },
  { 634, 7, 11, 9, 1, -11 },
  { 644, 3, 11, 5, 1, -11 },
  { 649, 5, 14, 5, -1, -11 },
  { 658, 8, 11, 9, 1, -11 },
  { 669, 3, 11, 5, 1, -11 },
  { 674, 12, 8, 14, 1, -8 },
  { 686, 7, 8, 9, 1, -8 },
  { 693, 7, 8, 9, 1, -8 },
  { 700, 7, 11, 9, 1, -8 },
  { 710, 7, 11, 9, 1, -8 },
  { 720, 5, 8, 7, 1, -8 },
  { 725, 6, 8, 7, 1, -8 },
  { 731, 6, 9, 6, 0, -9 },
  { 738, 7, 8, 9, 1, -8 },
  { 745, 9, 8, 9, 0, -8 },
  { 754, 13, 8, 13, 0, -8 },
  { 767, 9, 8, 9, 0, -8 },
  { 776, 9, 11, 9, 0, -8 },
  { 789, 7, 8, 7, 0, -8 },
  { 796, 6, 12, 6, 0, -10 },
  { 805, 1, 14, 7, 3, -11 },
  { 807, 6, 12, 6, 0, -10 },
  { 816, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_Black14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black14pt7bBitmaps,
  (GFXglyph *)NotoSans_Black14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_BLACK14PT7B_H_
