#ifndef _NOTOSANS_BLACK18PT7B_H_
#define _NOTOSANS_BLACK18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0x00, 0xEE, 0xE0, 0xEF, 0xDF, 0xBF, 0x7E,
  0x60, 0x0C, 0xC0, 0xCC, 0x0D, 0xC1, 0xDC, 0x7F, 0xF7, 0xFF, 0x19, 0x8F,
  0xFE, 0xFF, 0xEF, 0xFE, 0x33, 0x03, 0x30, 0x37, 0x00, 0x0C, 0x03, 0x03,
  0xFD, 0xFE, 0xEC, 0xBF, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0x74, 0xDD, 0xFF,
  0x7F, 0x87, 0x80, 0xC0, 0x38, 0x18, 0x3E, 0x1C, 0x3B, 0x9C, 0x1D, 0xCC,
  0x0E, 0xEE, 0x03, 0x76, 0x71, 0xF7, 0x7C, 0x7B, 0x77, 0x03, 0xBB, 0x81,
  0x9D, 0xC1, 0xCE, 0xE1, 0xC3, 0xE0, 0xE1, 0xE0, 0x3E, 0x03, 0xF8, 0x1C,
  0xE0, 0xE7, 0x07, 0xF8, 0x1F, 0x81, 0xF9, 0xFF, 0xEE, 0xE7, 0xF7, 0x1F,
  0x3F, 0xF9, 0xFF, 0xE7, 0xE7, 0x80, 0xFF, 0xFE, 0x3B, 0x9D, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xC7, 0xF1, 0xC3, 0x8E, 0x38, 0x71, 0xC7,
  0x1C, 0x71, 0xCE, 0x38, 0xE7, 0x3C, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xF8,
  0xF0, 0xF8, 0xEE, 0x12, 0x00, 0x18, 0x0C, 0x06, 0x1F, 0xFF, 0xFF, 0xFC,
  0x60, 0x30, 0x18, 0x00, 0x7B, 0x9C, 0xE6, 0x70, 0xFF, 0xFE, 0xFF, 0x80,
  0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70,
  0xE0, 0x3E, 0x3F, 0xBF, 0xDC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xFF, 0xCF, 0xE3, 0xE0, 0x0E, 0x7D, 0xFF, 0xFE, 0xE9, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0x1F, 0x1F, 0xEF, 0xF8, 0x8F, 0x03, 0xC0, 0xE0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFD, 0xFF, 0x7F, 0xC0, 0x7E, 0x7F, 0xBF,
  0xC8, 0xE0, 0x71, 0xF0, 0xF8, 0x7E, 0x07, 0x83, 0xFF, 0xFF, 0xEF, 0xE0,
  0x07, 0x81, 0xE0, 0xF8, 0x7E, 0x1F, 0x8F, 0xE7, 0x79, 0xDE, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x07, 0x80, 0x7F, 0x7F, 0xBF, 0xDC, 0x0E, 0x07, 0xF3,
  0xFC, 0x9F, 0x07, 0x83, 0xFF, 0xDF, 0xEF, 0xE0, 0x1F, 0x1F, 0x9F, 0xDE,
  0x0E, 0x47, 0xFB, 0xFF, 0xCF, 0xE3, 0xF1, 0xFF, 0xEF, 0xE3, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07,
  0x07, 0x80, 0x3E, 0x7F, 0xBD, 0xFC, 0xFF, 0x73, 0xF0, 0xF9, 0xFE, 0xE7,
  0xF1, 0xF9, 0xFF, 0xE7, 0xE0, 0x3C, 0x7F, 0xBF, 0xDC, 0xFE, 0x7F, 0x3F,
  0xFF, 0xFF, 0x33, 0x83, 0xBF, 0xDF, 0xCF, 0xC0, 0xFF, 0x80, 0x07, 0xFC,
  0x73, 0x9C, 0x00, 0x00, 0x0F, 0x73, 0x9C, 0xCE, 0x00, 0x01, 0x83, 0xC7,
  0xCF, 0x8F, 0x07, 0xC0, 0xFC, 0x1F, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0xFD, 0xF1,
  0xE0, 0xC0, 0x00, 0x3E, 0x7F, 0x9F, 0xE8, 0x70, 0x78, 0x78, 0x78, 0x30,
  0x00, 0x00, 0x0F, 0x07, 0x83, 0xC0, 0x0F, 0xE0, 0x7F, 0xC3, 0x83, 0x9C,
  0xF7, 0xEF, 0xEF, 0x33, 0xBD, 0xCE, 0xF7, 0x3B, 0xDC, 0xEF, 0x3F, 0xFE,
  0x73, 0x9C, 0x04, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0x80, 0x7C, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x1E, 0xF0, 0xF3, 0x87, 0x1C, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFD, 0xE0, 0xFF, 0x07, 0x80, 0xFF, 0x3F, 0xEF, 0xFF, 0xCF, 0xF3, 0xFF,
  0xEF, 0xFB, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0x00, 0x1F, 0x8F,
  0xF7, 0xFB, 0xC2, 0xF0, 0x3C, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xFD,
  0xFF, 0x1F, 0x80, 0xFE, 0x1F, 0xF3, 0xFF, 0x78, 0xFF, 0x1F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0xFF, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x0F,
  0xC7, 0xFD, 0xFF, 0x7C, 0x2F, 0x01, 0xE7, 0xFC, 0xFF, 0x9F, 0xF0, 0xFE,
  0x1D, 0xFF, 0x9F, 0xF1, 0xFE, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xFF,
  0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xBF, 0xFC, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xF1, 0xFE,
  0x3B, 0xCF, 0x7B, 0xCF, 0x71, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0x9E, 0x73,
  0xCF, 0x78, 0xFF, 0x1E, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE3, 0xFE, 0xC7, 0xFD, 0xCD, 0xFB, 0x9B, 0xF7, 0x77, 0xE6, 0xEF,
  0xCF, 0x9F, 0x9F, 0x3F, 0x1E, 0x7E, 0x38, 0xE0, 0xF8, 0x3F, 0xE1, 0xFF,
  0x0F, 0xFC, 0x7E, 0xE3, 0xF7, 0x9F, 0x9C, 0xFC, 0xF7, 0xE3, 0xBF, 0x1F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0x80, 0x1F, 0x83, 0xFE, 0x7F, 0xEF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x7F, 0xF3, 0xFE,
  0x1F, 0x80, 0xFE, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0xFB, 0xFE,
  0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xF9,
  0xE1, 0xEF, 0x0F, 0x78, 0x3B, 0xC1, 0xDE, 0x0E, 0xF0, 0x77, 0x87, 0x9F,
  0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFE, 0x1F, 0xF3,
  0xFF, 0x79, 0xEF, 0x3D, 0xE7, 0xBF, 0xE7, 0xF8, 0xF7, 0x1E, 0xF3, 0xCF,
  0x78, 0xEF, 0x1E, 0x3F, 0x3F, 0xFF, 0xDC, 0x2F, 0x07, 0xE1, 0xFC, 0x3E,
  0x07, 0xC3, 0xFF, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x3D, 0xFF, 0xBF, 0xE1, 0xF8, 0xF0, 0x7F, 0x0F, 0x78, 0xF7, 0x8E, 0x79,
  0xE3, 0x9E, 0x3D, 0xC3, 0xDC, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0xE1, 0xDC, 0x78, 0x77, 0x1F, 0x1D, 0xC7, 0xCF, 0x79, 0xF3,
  0x8E, 0x6C, 0xE3, 0xBB, 0x38, 0xEE, 0xFE, 0x3B, 0xBF, 0x07, 0xCF, 0xC1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x00, 0xF0, 0xFB, 0xC7, 0x8F, 0x78,
  0x7B, 0xC1, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC1, 0xEF, 0x0E,
  0x78, 0xF1, 0xEF, 0x07, 0x80, 0xF0, 0xF7, 0x0E, 0x79, 0xE3, 0x9C, 0x3F,
  0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xBF, 0xEF, 0xF8, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78,
  0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xFF, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E,
  0x0E, 0x0E, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F,
  0xFF, 0x08, 0x07, 0x01, 0xC0, 0xF8, 0x37, 0x1C, 0xC6, 0x3B, 0x86, 0xC1,
  0xC0, 0xFF, 0xFF, 0xC0, 0xF1, 0xE1, 0xC0, 0x7F, 0x3F, 0xD9, 0xE0, 0x77,
  0xFF, 0xFF, 0x8F, 0xCF, 0xFF, 0xBD, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFF, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF, 0xBB,
  0xC0, 0x3F, 0x7F, 0xFF, 0xF0, 0xE0, 0xE0, 0xF0, 0xFF, 0x7F, 0x3F, 0x03,
  0x81, 0xC0, 0xE0, 0x77, 0xBB, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF,
  0xF7, 0xFB, 0xCC, 0x3E, 0x3F, 0xFC, 0xFC, 0x7F, 0xFF, 0xFF, 0x81, 0xE3,
  0x7F, 0x9F, 0xC0, 0x1E, 0x3F, 0x3E, 0x38, 0x7E, 0xFE, 0xFE, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x7B, 0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xFF, 0xFF, 0xBD, 0xC0, 0xF8, 0xFF, 0xFF, 0xF8, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xF0, 0xEF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xF3,
  0x80, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xEF, 0xFB, 0xE0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x3F, 0xE7, 0x3D, 0xE7, 0xF8, 0xFE,
  0x1F, 0xE3, 0xFE, 0x7B, 0xCF, 0x3D, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xBE, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xEF,
  0xBF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF0,
  0x3E, 0x1F, 0xEF, 0x7B, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xDE, 0x7F, 0x8F,
  0xC0, 0xEF, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFE, 0xFF,
  0xBF, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x7B, 0xBF, 0xFF, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xBD, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0xEF,
  0xDF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE0, 0x7F, 0xFE, 0xE6, 0xF0,
  0xFC, 0x7E, 0x0F, 0xCF, 0xFE, 0xFC, 0x18, 0x38, 0x7F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xFF, 0x7F, 0xDF, 0x70, 0xF1, 0xEE, 0x39, 0xC7, 0x3D,
  0xE3, 0xB8, 0x77, 0x0E, 0xE0, 0xF8, 0x1F, 0x01, 0xC0, 0xF3, 0xC7, 0x73,
  0xC7, 0x73, 0xEE, 0x73, 0xEE, 0x7F, 0xEE, 0x3F, 0x6E, 0x3E, 0x6C, 0x3E,
  0x7C, 0x1E, 0x7C, 0x1E, 0x3C, 0xF1, 0xEF, 0x78, 0xEF, 0x1F, 0xC1, 0xF0,
  0x3E, 0x0F, 0xE1, 0xDE, 0x79, 0xDE, 0x3C, 0xF1, 0xEE, 0x39, 0xC7, 0x3D,
  0xE3, 0xB8, 0x77, 0x06, 0xE0, 0xF8, 0x1F, 0x01, 0xC0, 0x38, 0x4F, 0x07,
  0xC0, 0xF0, 0x00, 0x7F, 0x3F, 0x9F, 0xC1, 0xC1, 0xE1, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0xF3, 0x8E, 0x38, 0xE7, 0x3C, 0xF1, 0xC3, 0x8E,
  0x38, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0xCF,
  0x1C, 0x71, 0xC7, 0x8F, 0x3D, 0xE7, 0x1C, 0x73, 0xCF, 0x38, 0xF8, 0xFF,
  0xE7, 0xE0,
};

const GFXglyph NotoSans_Black18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 13, 5, 1, -13 },
  { 8, 7, 5, 9, 1, -13 },
  { 13, 12, 13, 12, 0, -13 },
  { 33, 10, 15, 10, 0, -14 },
  { 52, 17, 13, 17, 0, -13 },
  { 80, 13, 13, 14, 1, -13 },
  { 102, 3, 5, 5, 1, -13 },
  { 104, 5, 16, 6, 1, -13 },
  { 114, 6, 16, 6, 0, -13 },
  { 126, 9, 9, 10, 0, -14 },
  { 137, 9, 9, 11, 1, -11 },
  { 148, 5, 6, 6, 0, -3 },
  { 152, 5, 3, 6, 0, -6 },
  { 154, 3, 3, 5, 1, -3 },
  { 156, 8, 13, 8, 0, -13 },
  { 169, 9, 13, 11, 1, -13 },
  { 184, 7, 13, 11, 1, -13 },
  { 196, 10, 13, 11, 0, -13 },
  { 213, 9, 13, 11, 1, -13 },
  { 228, 10, 13, 11, 0, -13 },
  { 245, 9, 13, 11, 1, -13 },
  { 260, 9, 13, 11, 1, -13 },
  { 275, 9, 13, 11, 1, -13 },
  { 290, 9, 13, 11, 1, -13 },
  { 305, 9, 13, 11, 1, -13 },
  { 320, 3, 10, 5, 1, -10 },
  { 324, 5, 13, 5, 0, -10 },
  { 333, 9, 9, 11, 1, -11 },
  { 344, 9, 7, 11, 1, -10 },
  { 352, 9, 9, 11, 1, -11 },
  { 363, 9, 13, 9, 0, -13 },
  { 378, 14, 14, 16, 1, -13 },
  { 403, 13, 13, 13, 0, -13 },
  { 425, 10, 13, 12, 1, -13 },
  { 442, 10, 13, 12, 1, -13 },
  { 459, 11, 13, 13, 1, -13 },
  { 477, 8, 13, 10, 1, -13 },
  { 490, 8, 13, 10, 1, -13 },
  { 503, 11, 13, 13, 1, -13 },
  { 521, 11, 13, 14, 1, -13 },
  { 539, 6, 13, 8, 1, -13 },
  { 549, 6, 17, 6, -1, -13 },
  { 562, 11, 13, 12, 1, -13 },
  { 580, 9, 13, 10, 1, -13 },
  { 595, 15, 13, 17, 1, -13 },
  { 620, 13, 13, 15, 1, -13 },
  { 642, 12, 13, 14, 1, -13 },
  { 662, 10, 13, 11, 1, -13 },
  { 679, 13, 16, 14, 1, -13 },
  { 705, 11, 13, 12, 1, -13 },
  { 723, 9, 13, 10, 1, -13 },
  { 738, 10, 13, 11, 0, -13 },
  { 755, 11, 13, 14, 1, -13 },
  { 773, 12, 13, 12, 0, -13 },
  { 793, 18, 13, 19, 0, -13 },
  { 823, 13, 13, 13, 0, -13 },
  { 845, 12, 13, 12, 0, -13 },
  { 865, 10, 13, 11, 1, -13 },
  { 882, 4, 16, 6, 1, -13 },
  { 890, 8, 13, 8, 0, -13 },
  { 903, 5, 16, 6, 0, -13 },
  { 913, 10, 9, 9, 0, -13 },
  { 925, 9, 2, 9, 0, 1 },
  { 928, 6, 3, 8, 1, -14 },
  { 931, 9, 10, 11, 1, -10 },
  { 943, 10, 14, 12, 1, -14 },
  { 961, 8, 10, 10, 1, -10 },
  { 971, 9, 14, 12, 1, -14 },
  { 987, 9, 10, 11, 1, -10 },
  { 999, 8, 14, 7, 0, -14 },
  { 1013, 9, 14, 12, 1, -10 },
  { 1029, 10, 14, 12, 1, -14 },
  { 1047, 4, 14, 6, 1, -14 },
  { 1054, 6, 18, 6, -1, -14 },
  { 1068, 11, 14, 12, 1, -14 },
  { 1088, 4, 14, 6, 1, -14 },
  { 1095, 16, 10, 18, 1, -10 },
  { 1115, 10, 10, 12, 1, -10 },
  { 1128, 10, 10, 11, 1, -10 },
  { 1141, 10, 14, 12, 1, -10 },
  { 1159, 9, 14, 12, 1, -10 },
  { 1175, 7, 10, 8, 1, -10 },
  { 1184, 8, 10, 9, 1, -10 },
  { 1194, 8, 12, 8, 0, -12 },
  { 1206, 10, 10, 12, 1, -10 },
  { 1219, 11, 10, 11, 0, -10 },
  { 1233, 16, 10, 16, 0, -10 },
  { 1253, 11, 10, 11, 0, -10 },
  { 1267, 11, 14, 11, 0, -10 },
  { 1287, 9, 10, 9, 0, -10 },
  { 1299, 6, 16, 8, 1, -13 },
  { 1311, 3, 18, 9, 3, -14 },
  { 1318, 6, 16, 8, 1, -13 },
  { 1330, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_Black18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black18pt7bBitmaps,
  (GFXglyph *)NotoSans_Black18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_BLACK18PT7B_H_
