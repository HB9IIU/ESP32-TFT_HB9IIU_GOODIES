#ifndef _NOTOSANS_BLACK32PT7B_H_
#define _NOTOSANS_BLACK32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x00, 0x00, 0x31, 0xF7, 0xFF, 0xFF, 0xDF, 0x00, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7B, 0xE3, 0xDF, 0x1E, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x00,
  0x78, 0xF0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7,
  0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x03, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF3, 0xF7, 0xF9,
  0xF3, 0x84, 0xF9, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xDF, 0xC0, 0xEF, 0xFE,
  0x7F, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x03, 0xFE, 0x03, 0xE0,
  0x1F, 0xF0, 0x1E, 0x01, 0xFF, 0xC1, 0xF0, 0x0F, 0xBE, 0x0F, 0x00, 0x78,
  0xF0, 0xF8, 0x03, 0xC7, 0x87, 0x80, 0x1E, 0x3C, 0x7C, 0x00, 0xF1, 0xE7,
  0xC0, 0x07, 0xDF, 0x3E, 0x7C, 0x3F, 0xFB, 0xE7, 0xF8, 0xFF, 0x9E, 0x7F,
  0xE7, 0xFD, 0xF7, 0xFF, 0x0F, 0x8F, 0x3E, 0x78, 0x00, 0xF9, 0xF3, 0xE0,
  0x07, 0x8F, 0x9F, 0x00, 0x7C, 0x7C, 0xF8, 0x07, 0xC3, 0xE7, 0xC0, 0x3E,
  0x1F, 0x3C, 0x03, 0xE0, 0xFF, 0xE0, 0x1E, 0x03, 0xFF, 0x01, 0xF0, 0x0F,
  0xF0, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x1F, 0x83, 0xFF, 0x0F, 0xC3, 0xFF, 0xCF, 0xE3, 0xFF, 0xF7,
  0xE3, 0xFB, 0xFF, 0xF1, 0xFC, 0xFF, 0xF8, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0xFC, 0x3E, 0x0F,
  0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E,
  0x3E, 0x3F, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xF3, 0x8E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xE1, 0x0F,
  0xE0, 0x1F, 0xF0, 0x3E, 0xF8, 0x7E, 0xFC, 0x1C, 0x78, 0x04, 0x60, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBE, 0x7C,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0xFB, 0xFF, 0xFF, 0xEF,
  0x80, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xF9, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC,
  0x3F, 0x7E, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFD, 0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x3D, 0xFC, 0x67,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF3, 0xE3,
  0xF8, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x30,
  0x7F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7E, 0x0F, 0xBF, 0x0F, 0x9F, 0x8F, 0xCF,
  0xC7, 0xC7, 0xE7, 0xC3, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE3, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xBF, 0x1F,
  0xDF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF7, 0xF3, 0xF1,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xF8, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xEF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF7,
  0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFE, 0xF8, 0x7E, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x3F, 0x0D, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x0F, 0xBF, 0xFF, 0xFE, 0xF8, 0x3C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF, 0xBF, 0x7C, 0xF9, 0xF7, 0xCF,
  0x9F, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xE3, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xC0,
  0x03, 0xE3, 0xE3, 0xFF, 0x7D, 0xF1, 0xFF, 0xCF, 0x7C, 0xFF, 0xF3, 0xDE,
  0x7E, 0x3C, 0xF7, 0x9F, 0x0F, 0x3F, 0xE7, 0x87, 0xCF, 0xFB, 0xE1, 0xF3,
  0xFE, 0xF8, 0x7C, 0xFF, 0x9E, 0x1F, 0x3F, 0xE7, 0xCF, 0xDF, 0x79, 0xFF,
  0xFF, 0x9E, 0x3F, 0xFF, 0xC7, 0xC7, 0xE3, 0xE0, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x08, 0x07, 0xF0, 0x1E, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7E, 0x1F, 0x01, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3, 0xF8,
  0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x80, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7E, 0xFE, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0x9F, 0xEF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0x8F, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xC0, 0xCF, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x67, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFE,
  0x0F, 0xEF, 0xE1, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xF8, 0x08, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0, 0x3F,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFE, 0x07, 0xFF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x7F,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x7E, 0x0F, 0xE7, 0xF0, 0xFE,
  0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFE, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xF7, 0xFF, 0x78, 0x3D, 0xFF, 0xDF, 0x1F,
  0x7F, 0xF7, 0xC7, 0xDF, 0xFD, 0xF1, 0xE7, 0xFF, 0x3E, 0xF9, 0xFF, 0xCF,
  0xBE, 0x7F, 0xF3, 0xEF, 0x1F, 0xFC, 0x7F, 0xC7, 0xFF, 0x1F, 0xF1, 0xFF,
  0xC7, 0xFC, 0x7F, 0xF1, 0xFE, 0x1F, 0xFC, 0x3F, 0x87, 0xFF, 0x0F, 0xE1,
  0xFF, 0xC3, 0xF0, 0x7C, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x1F, 0xFD, 0xF8, 0x7F, 0xF7, 0xE1, 0xFF, 0xCF, 0xC7, 0xFF, 0x3F,
  0x1F, 0xFC, 0x7E, 0x7F, 0xF1, 0xFD, 0xFF, 0xC3, 0xF7, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7E, 0xFE, 0x03, 0xF9, 0xFC, 0x1F, 0xE7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xE1, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFC, 0x1F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFE, 0x03, 0xF9,
  0xFC, 0x1F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0x8F,
  0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xE7, 0xE0, 0xFE, 0x7F,
  0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0,
  0xFE, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0x7E, 0x06, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xF0, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xBF, 0x03, 0xF8,
  0x0F, 0x9F, 0x81, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x7F,
  0x03, 0xF1, 0xF8, 0x3F, 0xC1, 0xF0, 0xFC, 0x3F, 0xE1, 0xF8, 0x7E, 0x1F,
  0xF0, 0xFC, 0x1F, 0x0F, 0xF8, 0x7E, 0x0F, 0x87, 0xBE, 0x3E, 0x07, 0xE7,
  0xDF, 0x1F, 0x03, 0xF3, 0xEF, 0x9F, 0x80, 0xF9, 0xF3, 0xCF, 0xC0, 0x7C,
  0xF9, 0xE7, 0xE0, 0x3F, 0x78, 0xFB, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07,
  0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x1F, 0x9F, 0xC0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0x3F, 0xBF, 0x80, 0x3F, 0x80, 0xFE,
  0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC7, 0xE0, 0x7F, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C,
  0x1F, 0x1E, 0x0F, 0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xE0,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE1, 0xE3, 0xF8, 0x80, 0xFC, 0x00, 0x7E, 0x1F, 0xFF, 0x3F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xEF, 0x9F, 0xC7, 0xC0, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF3, 0xE1,
  0xFB, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xF1, 0xF8,
  0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xCF, 0xE0, 0x9F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x2F, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x3E,
  0x7E, 0x3F, 0xFF, 0x3F, 0xEF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xE3, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xDF, 0x87, 0xEF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xBE, 0x1F,
  0x8F, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE7, 0xF1, 0xFB,
  0xF0, 0x7D, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x18, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xF0,
  0x1F, 0x80, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF7, 0xE1, 0xFB, 0xFD,
  0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xEF, 0xC0, 0x07, 0xE0,
  0x03, 0xF7, 0x03, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF3, 0xF1, 0xFB, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7B, 0xFF, 0xFF, 0xFC, 0x40, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0, 0xC0, 0x00, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x38, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xFF,
  0xE0, 0xFE, 0xFC, 0x3F, 0x9F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F,
  0xDF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xF9, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xF9, 0xF8, 0x3F, 0xBF,
  0x07, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC,
  0x1F, 0x8F, 0x9F, 0xF7, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F, 0xFE, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0xF8, 0xFC, 0x7C, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xCF, 0xE3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x7E,
  0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7E, 0x7E, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF7, 0xE1, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xEF, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0xF8, 0x7F, 0xCF, 0xFE, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFE, 0xFC, 0x3B, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0x80, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0xE7, 0xFF, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0,
  0xFF, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xEF, 0x8F, 0xE3, 0xC0, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF1,
  0xF8, 0x1F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x1F, 0xC1, 0xFB, 0xF0, 0xFE, 0x0F, 0x9F, 0x87, 0xF0,
  0xFC, 0xFC, 0x7F, 0xC7, 0xE3, 0xE3, 0xFE, 0x3F, 0x1F, 0x9E, 0xF1, 0xF0,
  0xFC, 0xF7, 0x9F, 0x87, 0xE7, 0xBC, 0xFC, 0x1F, 0x7D, 0xF7, 0xC0, 0xFB,
  0xEF, 0xBE, 0x07, 0xDE, 0x3D, 0xF0, 0x3F, 0xF1, 0xEF, 0x80, 0xFF, 0x8F,
  0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF7, 0xF0,
  0xFE, 0x3F, 0x8F, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFD, 0xF8, 0x3F, 0x9F, 0xC3, 0xF8, 0xFC,
  0x7F, 0x0F, 0xEF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF9,
  0xF8, 0x1F, 0x9F, 0x00, 0xFB, 0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x83, 0xF8,
  0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x03, 0xF0, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x3F, 0x01,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x38,
};

const GFXglyph NotoSans_Black32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 23, 9, 1, -23 },
  { 22, 13, 8, 17, 2, -23 },
  { 35, 20, 23, 21, 1, -23 },
  { 93, 17, 26, 18, 1, -24 },
  { 149, 29, 23, 30, 1, -23 },
  { 233, 25, 23, 26, 1, -23 },
  { 305, 5, 8, 9, 2, -23 },
  { 310, 10, 28, 11, 1, -23 },
  { 345, 9, 28, 11, 1, -23 },
  { 377, 16, 15, 17, 1, -24 },
  { 407, 16, 15, 19, 1, -19 },
  { 437, 7, 9, 10, 1, -5 },
  { 445, 9, 5, 10, 1, -11 },
  { 451, 7, 6, 9, 1, -6 },
  { 457, 14, 23, 14, 0, -23 },
  { 498, 17, 23, 19, 1, -23 },
  { 547, 14, 23, 19, 1, -23 },
  { 588, 17, 23, 19, 1, -23 },
  { 637, 16, 23, 19, 1, -23 },
  { 683, 17, 23, 19, 1, -23 },
  { 732, 16, 23, 19, 1, -23 },
  { 778, 17, 23, 19, 1, -23 },
  { 827, 17, 23, 19, 1, -23 },
  { 876, 17, 23, 19, 1, -23 },
  { 925, 17, 23, 19, 1, -23 },
  { 974, 7, 18, 9, 1, -18 },
  { 990, 7, 22, 10, 1, -18 },
  { 1010, 16, 17, 19, 1, -20 },
  { 1044, 16, 11, 19, 1, -17 },
  { 1066, 16, 17, 19, 1, -20 },
  { 1100, 16, 23, 16, 0, -23 },
  { 1146, 26, 25, 29, 1, -23 },
  { 1228, 23, 23, 23, 0, -23 },
  { 1295, 18, 23, 22, 2, -23 },
  { 1347, 18, 23, 21, 2, -23 },
  { 1399, 20, 23, 23, 2, -23 },
  { 1457, 14, 23, 18, 2, -23 },
  { 1498, 14, 23, 17, 2, -23 },
  { 1539, 20, 23, 24, 2, -23 },
  { 1597, 20, 23, 25, 2, -23 },
  { 1655, 12, 23, 14, 1, -23 },
  { 1690, 12, 30, 11, -3, -23 },
  { 1735, 20, 23, 22, 2, -23 },
  { 1793, 15, 23, 19, 2, -23 },
  { 1837, 26, 23, 31, 2, -23 },
  { 1912, 22, 23, 27, 2, -23 },
  { 1976, 22, 23, 26, 2, -23 },
  { 2040, 17, 23, 20, 2, -23 },
  { 2089, 22, 28, 26, 2, -23 },
  { 2166, 20, 23, 22, 2, -23 },
  { 2224, 16, 23, 18, 1, -23 },
  { 2270, 17, 23, 19, 1, -23 },
  { 2319, 20, 23, 24, 2, -23 },
  { 2377, 22, 23, 22, 0, -23 },
  { 2441, 33, 23, 33, 0, -23 },
  { 2536, 23, 23, 23, 0, -23 },
  { 2603, 21, 23, 21, 0, -23 },
  { 2664, 18, 23, 20, 1, -23 },
  { 2716, 8, 28, 10, 2, -23 },
  { 2744, 14, 23, 14, 0, -23 },
  { 2785, 8, 28, 10, 1, -23 },
  { 2813, 17, 15, 17, 0, -23 },
  { 2845, 16, 4, 16, 0, 2 },
  { 2853, 11, 6, 13, 1, -25 },
  { 2862, 17, 18, 20, 1, -18 },
  { 2901, 17, 24, 21, 2, -24 },
  { 2952, 15, 18, 17, 1, -18 },
  { 2986, 17, 24, 21, 1, -24 },
  { 3037, 17, 18, 20, 1, -18 },
  { 3076, 13, 24, 13, 1, -24 },
  { 3115, 17, 26, 21, 1, -18 },
  { 3171, 17, 24, 21, 2, -24 },
  { 3222, 6, 25, 10, 2, -25 },
  { 3241, 10, 33, 10, -2, -25 },
  { 3283, 19, 24, 21, 2, -24 },
  { 3340, 6, 24, 10, 2, -24 },
  { 3358, 28, 18, 32, 2, -18 },
  { 3421, 17, 18, 21, 2, -18 },
  { 3460, 18, 18, 20, 1, -18 },
  { 3501, 17, 26, 21, 2, -18 },
  { 3557, 17, 26, 21, 1, -18 },
  { 3613, 13, 18, 15, 2, -18 },
  { 3643, 14, 18, 17, 1, -18 },
  { 3675, 13, 21, 15, 1, -21 },
  { 3710, 17, 18, 21, 2, -18 },
  { 3749, 20, 18, 20, 0, -18 },
  { 3794, 29, 18, 29, 0, -18 },
  { 3860, 20, 18, 20, 0, -18 },
  { 3905, 20, 26, 20, 0, -18 },
  { 3970, 14, 18, 16, 1, -18 },
  { 4002, 12, 28, 14, 1, -23 },
  { 4044, 4, 31, 16, 6, -24 },
  { 4060, 12, 28, 14, 1, -23 },
  { 4102, 16, 6, 19, 1, -14 },
};

const GFXfont NotoSans_Black32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black32pt7bBitmaps,
  (GFXglyph *)NotoSans_Black32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_BLACK32PT7B_H_
