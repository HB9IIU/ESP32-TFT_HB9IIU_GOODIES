#ifndef _NOTOSANS_BLACK9PT7B_H_
#define _NOTOSANS_BLACK9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x70, 0xB4, 0x2B, 0xF7, 0xBF, 0x51, 0x40, 0x23, 0xF8, 0xE3,
  0xFD, 0xC4, 0x42, 0xE4, 0xAC, 0xEB, 0x55, 0x15, 0x27, 0x20, 0xF1, 0xE3,
  0xBD, 0xF9, 0x9F, 0x80, 0xC0, 0x69, 0x6D, 0x93, 0xC9, 0xB6, 0xDE, 0x25,
  0x7E, 0xA0, 0x27, 0xC8, 0x40, 0x70, 0xE0, 0x70, 0x33, 0x26, 0x64, 0xC0,
  0x23, 0xB7, 0xBD, 0xAD, 0xC0, 0x7F, 0x33, 0x33, 0x27, 0xD6, 0x23, 0x33,
  0xE0, 0x27, 0xC6, 0xE1, 0xCF, 0xC0, 0x31, 0x95, 0xFF, 0x88, 0x72, 0x1C,
  0x39, 0xF8, 0x13, 0xD1, 0xFD, 0xED, 0xC0, 0xF8, 0xCC, 0x62, 0x30, 0x23,
  0xF6, 0xED, 0xED, 0xE0, 0x23, 0xF7, 0xB7, 0x8D, 0xC0, 0xD1, 0xC0, 0xD0,
  0x70, 0x09, 0xF8, 0xE1, 0x80, 0xF8, 0x3E, 0x87, 0x0E, 0xEC, 0x00, 0x2F,
  0x13, 0x62, 0x60, 0x08, 0x36, 0x5F, 0xF5, 0xE7, 0x5E, 0x64, 0x18, 0x38,
  0xF1, 0xA3, 0xEF, 0xD8, 0xC0, 0xF4, 0xFD, 0x39, 0xF8, 0x11, 0xF6, 0x30,
  0xC1, 0xA3, 0x80, 0xF4, 0xE7, 0x3B, 0xF8, 0xF8, 0xE8, 0x8F, 0xF3, 0xF9,
  0x00, 0x11, 0xF6, 0x37, 0xDD, 0xB3, 0xC0, 0x9C, 0xFF, 0x39, 0xCC, 0xF6,
  0x66, 0x6F, 0x24, 0x92, 0x5F, 0x9D, 0xB9, 0xEB, 0x4C, 0x88, 0x88, 0x8F,
  0xCF, 0xDF, 0xBD, 0x7B, 0xF6, 0xC0, 0xCF, 0xBA, 0xEF, 0x9E, 0x70, 0x10,
  0xF9, 0x9E, 0x34, 0x6D, 0x8F, 0x00, 0xF9, 0xFE, 0x88, 0x10, 0xF9, 0x9E,
  0x34, 0x6D, 0x8F, 0x06, 0x06, 0xF4, 0xBD, 0xEB, 0x4C, 0x23, 0xF0, 0xE3,
  0xCF, 0xC0, 0xF9, 0x8C, 0x63, 0x18, 0x9C, 0xE7, 0x3D, 0xF8, 0xCD, 0x37,
  0x9E, 0x38, 0xC0, 0xCD, 0xAE, 0xD7, 0x4E, 0xA7, 0x71, 0xB8, 0xED, 0xE3,
  0x8E, 0x6B, 0x30, 0xCD, 0xE3, 0x0C, 0x30, 0xC0, 0xF8, 0xCC, 0xC4, 0x7C,
  0xFA, 0xAB, 0xC0, 0xCC, 0x46, 0x62, 0x30, 0xF5, 0x57, 0xC0, 0x63, 0x95,
  0x30, 0xF8, 0xE4, 0x7A, 0xDF, 0xB6, 0x80, 0x88, 0xFF, 0x9F, 0xF0, 0x7A,
  0x71, 0x97, 0x00, 0x18, 0xDB, 0xBC, 0xED, 0xA0, 0x7A, 0x7E, 0x97, 0x80,
  0x76, 0xF6, 0x66, 0x60, 0x6E, 0xF3, 0xB6, 0xCD, 0xE0, 0x88, 0xFD, 0x99,
  0x90, 0xFE, 0x55, 0x55, 0xC0, 0x84, 0x27, 0x6E, 0x7A, 0x60, 0xFE, 0xFF,
  0xF6, 0x4C, 0x99, 0x20, 0xFD, 0x99, 0x90, 0x7A, 0xF2, 0xB7, 0x80, 0xFF,
  0x9F, 0xF8, 0x80, 0x6E, 0xF3, 0xB6, 0x8C, 0x60, 0xFE, 0x48, 0x7C, 0x79,
  0xF0, 0x6F, 0x66, 0x67, 0x99, 0x9B, 0xF0, 0xCD, 0x67, 0x9C, 0x30, 0xDB,
  0x5B, 0x5E, 0x76, 0x66, 0xDD, 0xE3, 0x1E, 0xDC, 0xCA, 0xDE, 0xE3, 0x13,
  0x80, 0xF3, 0x64, 0xF0, 0x17, 0x66, 0xC6, 0x67, 0x10, 0xFF, 0x80, 0x8E,
  0x66, 0x36, 0x6C, 0x80, 0xFC, 0x80,
};

const GFXglyph NotoSans_Black9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 3, 0, -6 },
  { 3, 3, 2, 5, 1, -6 },
  { 4, 6, 6, 6, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 8, 7, 9, 0, -7 },
  { 21, 7, 7, 7, 0, -7 },
  { 28, 1, 2, 3, 1, -6 },
  { 29, 3, 8, 3, 0, -7 },
  { 32, 3, 8, 3, 0, -7 },
  { 35, 5, 4, 5, 0, -7 },
  { 38, 5, 4, 5, 0, -5 },
  { 41, 2, 2, 3, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 2, 2, 3, 0, -2 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 5, 7, 5, 0, -7 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 5, 7, 5, 0, -7 },
  { 88, 5, 7, 5, 0, -7 },
  { 93, 2, 5, 3, 0, -5 },
  { 95, 2, 6, 3, 0, -5 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 5, 3, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 4, 7, 5, 0, -7 },
  { 111, 8, 8, 8, 0, -7 },
  { 119, 7, 6, 7, 0, -6 },
  { 125, 5, 6, 6, 1, -6 },
  { 129, 6, 7, 6, 0, -7 },
  { 135, 5, 6, 7, 1, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 3, 6, 5, 1, -6 },
  { 145, 6, 7, 7, 0, -7 },
  { 151, 5, 6, 7, 1, -6 },
  { 155, 4, 6, 4, 0, -6 },
  { 158, 3, 8, 3, -1, -6 },
  { 161, 5, 6, 6, 1, -6 },
  { 165, 4, 6, 5, 1, -6 },
  { 168, 7, 6, 9, 1, -6 },
  { 174, 6, 6, 8, 1, -6 },
  { 179, 7, 7, 7, 0, -7 },
  { 186, 4, 6, 6, 1, -6 },
  { 189, 7, 9, 7, 0, -7 },
  { 197, 5, 6, 6, 1, -6 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 5, 6, 5, 0, -6 },
  { 210, 5, 6, 7, 1, -6 },
  { 214, 6, 6, 6, 0, -6 },
  { 219, 9, 6, 9, 0, -6 },
  { 226, 6, 6, 7, 0, -6 },
  { 231, 6, 6, 6, 0, -6 },
  { 236, 5, 6, 6, 0, -6 },
  { 240, 2, 9, 3, 1, -7 },
  { 243, 4, 7, 4, 0, -7 },
  { 247, 2, 9, 3, 0, -7 },
  { 250, 5, 4, 5, 0, -6 },
  { 253, 5, 1, 5, 0, 1 },
  { 254, 3, 2, 4, 0, -7 },
  { 255, 5, 5, 6, 0, -5 },
  { 259, 4, 7, 6, 1, -7 },
  { 263, 5, 5, 5, 0, -5 },
  { 267, 5, 7, 6, 0, -7 },
  { 272, 5, 5, 6, 0, -5 },
  { 276, 4, 7, 4, 0, -7 },
  { 280, 5, 7, 6, 0, -5 },
  { 285, 4, 7, 6, 1, -7 },
  { 289, 1, 7, 3, 1, -7 },
  { 290, 2, 9, 3, 0, -7 },
  { 293, 5, 7, 6, 1, -7 },
  { 298, 1, 7, 3, 1, -7 },
  { 299, 7, 5, 9, 1, -5 },
  { 304, 4, 5, 6, 1, -5 },
  { 307, 5, 5, 6, 0, -5 },
  { 311, 4, 7, 6, 1, -5 },
  { 315, 5, 7, 6, 0, -5 },
  { 320, 3, 5, 4, 1, -5 },
  { 322, 4, 5, 5, 0, -5 },
  { 325, 4, 6, 4, 0, -6 },
  { 328, 4, 5, 6, 1, -5 },
  { 331, 6, 5, 6, 0, -5 },
  { 335, 8, 5, 8, 0, -5 },
  { 340, 6, 5, 6, 0, -5 },
  { 344, 5, 7, 5, 0, -5 },
  { 349, 4, 5, 5, 0, -5 },
  { 352, 4, 9, 4, 0, -7 },
  { 357, 1, 9, 5, 2, -7 },
  { 359, 4, 9, 4, 0, -7 },
  { 364, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_Black9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black9pt7bBitmaps,
  (GFXglyph *)NotoSans_Black9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_BLACK9PT7B_H_
