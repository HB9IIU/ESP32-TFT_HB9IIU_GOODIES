#ifndef _NOTOSANS_BLACK28PT7B_H_
#define _NOTOSANS_BLACK28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0x9E, 0x78, 0x00,
  0x1E, 0xFF, 0xFF, 0xDE, 0xFB, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE3,
  0xFC, 0x78, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x0E, 0x38, 0x07,
  0x9E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xCF,
  0x00, 0xF3, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3C, 0xC2,
  0x7D, 0x80, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0x80, 0xCF, 0xE1, 0x9E, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0xE0,
  0x3C, 0x07, 0xFC, 0x1E, 0x01, 0xEF, 0x07, 0x80, 0x79, 0xE3, 0xC0, 0x3E,
  0x78, 0xF0, 0x07, 0x9E, 0x78, 0x01, 0xE7, 0x9E, 0x00, 0x7B, 0xEF, 0x3F,
  0x1F, 0xF7, 0xDF, 0xE3, 0xFD, 0xEF, 0xF8, 0x7E, 0xF3, 0xCF, 0x00, 0x3C,
  0xF3, 0xC0, 0x1E, 0x3C, 0xF0, 0x07, 0x8F, 0x3C, 0x03, 0xC3, 0xCF, 0x00,
  0xF0, 0xF7, 0xC0, 0x78, 0x3F, 0xE0, 0x3E, 0x07, 0xF8, 0x0F, 0x00, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x87, 0xC3, 0xFF, 0x3F, 0x1F, 0xFE, 0xFC, 0xFD, 0xFF, 0xE3,
  0xF3, 0xFF, 0x8F, 0xC7, 0xFC, 0x3F, 0x0F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xC0,
  0x0F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF8, 0x0F, 0x80, 0x38, 0x01, 0xC1, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x0F, 0x78, 0xF9, 0xE1, 0x8C, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7B, 0xFF, 0xFF, 0x78, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x0F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xFF, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7,
  0xDF, 0x3F, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x7F,
  0x0F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xF3, 0xBF, 0x33, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x79, 0xFC,
  0xC1, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x30, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0xFE, 0x1F, 0xE0, 0x7E, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0x7C, 0x1F, 0xFC, 0x3E, 0xFC, 0x3C, 0xFC, 0x7C,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x7F, 0xF9, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF,
  0xC8, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x1F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7D, 0xF8, 0xFF, 0xF9, 0xFF, 0xFB, 0xFF,
  0xF7, 0xE3, 0xEF, 0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0x3E, 0x3E, 0x7F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF,
  0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x3F, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0,
  0xFF, 0xC3, 0xFF, 0xCF, 0xCF, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF,
  0xBF, 0xFE, 0xFC, 0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF,
  0xF7, 0xFF, 0xDF, 0xEF, 0x3F, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x7F,
  0xF9, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x33, 0xFF, 0xFF, 0x78, 0x40, 0x00,
  0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x31, 0xFF, 0xFF, 0x7C, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x7D, 0xF7, 0x9E, 0xFB, 0xEF, 0x3C, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x1F,
  0xF1, 0xFF, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x1F,
  0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x70, 0xFC, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0x8F, 0xF7, 0x9E, 0x7F, 0xE7, 0xBC, 0xFF, 0xCF, 0xF3, 0xC7, 0x9F,
  0xE7, 0x8F, 0x3F, 0xCE, 0x1E, 0x7F, 0x9C, 0x3C, 0xFF, 0x3C, 0x79, 0xFE,
  0x79, 0xF7, 0xBC, 0xFF, 0xFF, 0x3C, 0xFE, 0xFC, 0x78, 0x70, 0xF0, 0x78,
  0x00, 0x00, 0xFC, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F,
  0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7E, 0x03, 0xE7, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x7E, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0x8E, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x86, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xCF, 0xF7, 0xE1,
  0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFD, 0xFB, 0xFE, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0x83, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0x7C, 0x07,
  0xDF, 0x81, 0xF7, 0xE0, 0x7C, 0xFE, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFC, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xEF, 0xFB, 0xFC, 0xFF, 0x3F, 0x00, 0xFC, 0x1F, 0xFE,
  0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xCF, 0xCF, 0xC7, 0xE7, 0xC3, 0xF7, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x87, 0xE7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x1F, 0xBF,
  0x0F, 0xDF, 0x83, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFB, 0xC7, 0xBF, 0xF7, 0x8F, 0x7F, 0xEF, 0x1E, 0xFF, 0xDF, 0x79, 0xFF,
  0x9E, 0xF3, 0xFF, 0x3D, 0xE7, 0xFE, 0x7F, 0xCF, 0xFC, 0x7F, 0x1F, 0xF8,
  0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0xE3, 0xF0, 0xFF, 0xC3, 0xE1, 0xF0, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFF, 0xDF, 0x1F, 0xFB, 0xF3, 0xFF, 0x3E, 0x7F, 0xE7,
  0xEF, 0xFC, 0x7D, 0xFF, 0x8F, 0xFF, 0xF0, 0xFB, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7,
  0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07,
  0xE7, 0xF8, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xCF, 0xDF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFE, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xF8, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xCF, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0xC3,
  0xF3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x83,
  0xF0, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0xFC, 0x3B, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xFC, 0x7F,
  0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFC, 0x07, 0xFF,
  0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF8, 0xFC, 0x1F, 0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0x7C, 0x07,
  0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0x81,
  0xFB, 0xE0, 0x7C, 0x0F, 0x9F, 0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x83, 0xE3,
  0xE1, 0xFC, 0x3F, 0x1F, 0x0F, 0xE1, 0xF0, 0xF8, 0x7F, 0x8F, 0x87, 0xC7,
  0xBC, 0x7C, 0x1E, 0x3D, 0xE3, 0xE0, 0xF9, 0xEF, 0x3E, 0x07, 0xCF, 0x79,
  0xF0, 0x3E, 0xFB, 0xEF, 0x80, 0xF7, 0x8F, 0x7C, 0x07, 0xFC, 0x7B, 0xC0,
  0x3F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07,
  0xF7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x9F, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xF9, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0x3F,
  0xFC, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xF1, 0xF0,
  0x3E, 0x7E, 0x07, 0xEF, 0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xBC, 0x1E, 0x78, 0x3C, 0x78, 0xF0, 0xF1, 0xE0, 0xF3, 0x81, 0xEF, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE1, 0x87, 0xE0, 0x0F, 0xC3,
  0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xEF, 0x9F, 0x8F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x1C, 0x3E, 0xFE, 0x7F, 0xFC, 0xFF, 0xFD, 0xFD,
  0xFB, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xFC, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0x3F, 0x00, 0x03, 0xE0,
  0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xF7, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x37, 0xFF, 0x9F, 0xFC, 0xFF, 0xE1, 0xFE,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE1, 0xC7, 0xCF,
  0xEF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7E, 0xFF, 0xFD, 0xFF, 0xF9,
  0xFD, 0xF1, 0xF1, 0xE0, 0x07, 0xC0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC3, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x27, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x1F, 0xE3,
  0xFC, 0xFF, 0x9F, 0xE3, 0xE0, 0x7C, 0x3F, 0xF7, 0xFE, 0xFF, 0xDF, 0xF8,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x0F, 0x00, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7, 0xEF,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0x9F, 0x00, 0x3F, 0x00,
  0xFD, 0xF7, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFE, 0x07, 0xF0, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x1C, 0x3E, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xE0, 0x37, 0xFF, 0xF7, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFE, 0xFC, 0xF0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x7E,
  0xF8, 0x7E, 0xF8, 0xFC, 0xF9, 0xF8, 0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFC, 0xFC, 0xF8, 0xFC, 0xF8, 0x7E,
  0xF8, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x78, 0xF3, 0xF9, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0x00, 0xE1, 0xE7, 0xF3, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0xFC, 0x3E,
  0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x7C, 0x3E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xE1, 0xF7, 0xF3,
  0xFF, 0xE7, 0xFF, 0xEF, 0xEF, 0xDF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE,
  0x7D, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x7C, 0xFF, 0xFB, 0xFF, 0xF7,
  0xEF, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0x9F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC, 0x3F, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x0F, 0x83,
  0xFF, 0x7F, 0xFF, 0xFE, 0xF8, 0x6F, 0xC0, 0xFF, 0x87, 0xFE, 0x3F, 0xF0,
  0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F,
  0x80, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xCF, 0xC7, 0x80, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x07,
  0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0x7C, 0x07, 0xBC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0x80, 0xFC, 0x3F, 0x0F, 0xBE, 0x3F, 0x87, 0xDF, 0x1F, 0xC7, 0xCF,
  0x8F, 0xF3, 0xE3, 0xE7, 0xF9, 0xF1, 0xF7, 0xBC, 0xF8, 0xFB, 0xDE, 0xF8,
  0x3D, 0xEF, 0x7C, 0x1E, 0xF3, 0xFE, 0x0F, 0x79, 0xFE, 0x07, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0xFE, 0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x3F, 0x1F, 0x87, 0xEF, 0xE1, 0xFC, 0xFC,
  0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0,
  0x7C, 0xF8, 0x3E, 0xF8, 0x0F, 0x7C, 0x07, 0xBC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xCF,
  0xE3, 0xF0, 0xF8, 0x3F, 0x87, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0x0F,
  0xE3, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xFC, 0x3F,
  0x07, 0xC7, 0xF1, 0xF8, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x3F,
  0x8F, 0xC3, 0xF0, 0xC0, 0x00, 0x10, 0x05, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFE, 0x03, 0xC0,
};

const GFXglyph NotoSans_Black28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 20, 8, 1, -20 },
  { 16, 11, 7, 15, 2, -20 },
  { 26, 18, 20, 19, 0, -20 },
  { 71, 15, 23, 16, 1, -21 },
  { 115, 26, 20, 27, 0, -20 },
  { 180, 22, 20, 22, 1, -20 },
  { 235, 5, 7, 8, 2, -20 },
  { 240, 8, 25, 10, 1, -21 },
  { 265, 8, 25, 10, 1, -21 },
  { 290, 13, 13, 15, 1, -21 },
  { 312, 14, 14, 16, 1, -17 },
  { 337, 6, 8, 9, 1, -4 },
  { 343, 7, 5, 9, 1, -10 },
  { 348, 6, 5, 8, 1, -5 },
  { 352, 12, 20, 12, 0, -20 },
  { 382, 14, 20, 16, 1, -20 },
  { 417, 12, 20, 16, 1, -20 },
  { 447, 14, 20, 16, 1, -20 },
  { 482, 14, 20, 16, 1, -20 },
  { 517, 16, 20, 16, 0, -20 },
  { 557, 14, 20, 16, 1, -20 },
  { 592, 15, 20, 16, 1, -20 },
  { 630, 14, 20, 16, 1, -20 },
  { 665, 15, 20, 16, 1, -20 },
  { 703, 14, 20, 16, 1, -20 },
  { 738, 6, 16, 8, 1, -16 },
  { 750, 6, 20, 8, 1, -16 },
  { 765, 14, 16, 16, 1, -18 },
  { 793, 14, 10, 16, 1, -15 },
  { 811, 14, 16, 16, 1, -18 },
  { 839, 14, 20, 14, 0, -20 },
  { 874, 23, 22, 25, 1, -20 },
  { 938, 20, 20, 20, 0, -20 },
  { 988, 16, 20, 19, 2, -20 },
  { 1028, 16, 20, 18, 1, -20 },
  { 1068, 17, 20, 21, 2, -20 },
  { 1111, 12, 20, 15, 2, -20 },
  { 1141, 12, 20, 15, 2, -20 },
  { 1171, 18, 20, 21, 1, -20 },
  { 1216, 17, 20, 21, 2, -20 },
  { 1259, 10, 20, 12, 1, -20 },
  { 1284, 10, 26, 10, -2, -20 },
  { 1317, 17, 20, 19, 2, -20 },
  { 1360, 13, 20, 16, 2, -20 },
  { 1393, 23, 20, 27, 2, -20 },
  { 1451, 19, 20, 23, 2, -20 },
  { 1499, 20, 20, 22, 1, -20 },
  { 1549, 15, 20, 18, 2, -20 },
  { 1587, 20, 25, 22, 1, -20 },
  { 1650, 17, 20, 19, 2, -20 },
  { 1693, 14, 20, 16, 1, -20 },
  { 1728, 15, 20, 17, 1, -20 },
  { 1766, 17, 20, 21, 2, -20 },
  { 1809, 19, 20, 19, 0, -20 },
  { 1857, 29, 20, 29, 0, -20 },
  { 1930, 20, 20, 20, 0, -20 },
  { 1980, 19, 20, 19, 0, -20 },
  { 2028, 15, 20, 17, 1, -20 },
  { 2066, 6, 26, 9, 2, -21 },
  { 2086, 12, 20, 12, 0, -20 },
  { 2116, 6, 26, 9, 1, -21 },
  { 2136, 15, 13, 15, 0, -20 },
  { 2161, 14, 3, 14, 0, 2 },
  { 2167, 10, 4, 12, 1, -21 },
  { 2172, 15, 16, 17, 1, -16 },
  { 2202, 15, 21, 18, 2, -21 },
  { 2242, 13, 16, 15, 1, -16 },
  { 2268, 15, 21, 18, 1, -21 },
  { 2308, 15, 16, 17, 1, -16 },
  { 2338, 11, 21, 12, 1, -21 },
  { 2367, 15, 23, 18, 1, -16 },
  { 2411, 15, 21, 19, 2, -21 },
  { 2451, 5, 22, 9, 2, -22 },
  { 2465, 8, 29, 9, -1, -22 },
  { 2494, 16, 21, 18, 2, -21 },
  { 2536, 5, 21, 9, 2, -21 },
  { 2550, 24, 16, 28, 2, -16 },
  { 2598, 15, 16, 19, 2, -16 },
  { 2628, 16, 16, 18, 1, -16 },
  { 2660, 15, 23, 18, 2, -16 },
  { 2704, 15, 23, 18, 1, -16 },
  { 2748, 11, 16, 13, 2, -16 },
  { 2770, 12, 16, 14, 1, -16 },
  { 2794, 11, 19, 13, 1, -19 },
  { 2821, 15, 15, 19, 2, -15 },
  { 2850, 17, 15, 17, 0, -15 },
  { 2882, 25, 15, 25, 0, -15 },
  { 2929, 18, 15, 18, 0, -15 },
  { 2963, 17, 22, 17, 0, -15 },
  { 3010, 13, 15, 14, 1, -15 },
  { 3035, 10, 25, 12, 1, -20 },
  { 3067, 4, 27, 14, 5, -21 },
  { 3081, 10, 25, 12, 1, -20 },
  { 3113, 14, 6, 16, 1, -13 },
};

const GFXfont NotoSans_Black28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black28pt7bBitmaps,
  (GFXglyph *)NotoSans_Black28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_BLACK28PT7B_H_
