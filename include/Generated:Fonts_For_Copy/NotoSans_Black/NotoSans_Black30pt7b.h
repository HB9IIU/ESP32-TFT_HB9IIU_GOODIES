#ifndef _NOTOSANS_BLACK30PT7B_H_
#define _NOTOSANS_BLACK30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC0, 0x00, 0x00, 0x7D, 0xFB, 0xF7, 0xE7, 0xC0, 0xF9, 0xFF, 0x9F, 0xF9,
  0xFF, 0x9F, 0xF9, 0xFF, 0x9E, 0xF1, 0xE0, 0x03, 0xCF, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC3, 0xCF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xE0, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFB, 0x84, 0xFB,
  0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03,
  0xFE, 0x03, 0xBF, 0x03, 0x9F, 0xE3, 0xBE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0xE0, 0xF8, 0x0F, 0x3C,
  0x1E, 0x01, 0xE7, 0x87, 0xC0, 0x3C, 0xF8, 0xF0, 0x07, 0x9F, 0x3C, 0x00,
  0xF3, 0xC7, 0x80, 0x1E, 0x79, 0xE7, 0xE3, 0xFF, 0x7D, 0xFE, 0x3F, 0xCF,
  0x3F, 0xE3, 0xFB, 0xEF, 0xBC, 0x18, 0x79, 0xE7, 0xC0, 0x1F, 0x3C, 0xF8,
  0x03, 0xC7, 0x9F, 0x00, 0xF0, 0xF3, 0xE0, 0x1E, 0x1E, 0x7C, 0x07, 0x83,
  0xEF, 0x01, 0xF0, 0x3F, 0xE0, 0x3C, 0x07, 0xF8, 0x0F, 0x80, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0xBF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC3, 0xF1, 0xFF, 0x87, 0xE7, 0xFF,
  0x9F, 0x8F, 0xFF, 0xBF, 0x3F, 0x3F, 0xFC, 0x7E, 0x3F, 0xF8, 0xFC, 0x3F,
  0xE1, 0xFC, 0x7F, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x8F, 0x8F,
  0x87, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x8F,
  0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x00, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xE7, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xBC, 0x7C, 0xF8, 0x71, 0x80,
  0x44, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7E, 0xF9, 0xF3, 0xE7, 0x9F,
  0x3E, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0x80,
  0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0xFC, 0x7E,
  0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0x7C, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x3F,
  0xF3, 0xFF, 0xFF, 0xFD, 0xF7, 0xE7, 0x3F, 0x11, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xEF, 0x9F, 0xCC, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xC0, 0x7F, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xE6, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x01, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0xFC, 0x3E,
  0xFC, 0x7C, 0xFC, 0xF8, 0xFC, 0xF8, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF9, 0xFF, 0xF9, 0xDF, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xC7, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xFC, 0x7F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7C, 0x7E, 0x7C, 0x7E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFC, 0x7E, 0xFE, 0xFC, 0x7E, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF0, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFC, 0xFC,
  0x7E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0x3F, 0xBE, 0x0F, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x03,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x39, 0xFF, 0xFF,
  0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7C, 0x38, 0xFB,
  0xF7, 0xE7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2F, 0x9F, 0x3E,
  0x7C, 0xF3, 0xE7, 0xCF, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xF0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7E, 0x03, 0xFC, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3E, 0x00,
  0x60, 0x00, 0x07, 0x80, 0x7F, 0xE3, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC6,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x07, 0xE1,
  0xF0, 0x00, 0xF0, 0xF0, 0xFF, 0xBC, 0xF9, 0xFF, 0xDE, 0x79, 0xFF, 0xE7,
  0x3C, 0xF0, 0xF3, 0xFC, 0xF8, 0xF9, 0xFE, 0x78, 0x7C, 0xFF, 0x3C, 0x3C,
  0x7F, 0x9E, 0x1E, 0x3B, 0xCF, 0x8F, 0x3D, 0xE3, 0xFF, 0xFE, 0x79, 0xFF,
  0xFE, 0x3C, 0x7F, 0x7E, 0x1F, 0x04, 0x04, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80,
  0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC3, 0xF7, 0xE1,
  0xFB, 0xF0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xC3, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00, 0x01, 0xF0, 0x03,
  0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF8, 0x33, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0x3F, 0xEF, 0x9F,
  0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xBF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC0, 0xCF, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xDF, 0xF7, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xBF, 0xCF,
  0xE3, 0xE0, 0xFC, 0x0F, 0xFF, 0x83, 0xF3, 0xF0, 0xFE, 0x7E, 0x1F, 0x8F,
  0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F,
  0x1F, 0x87, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xEF, 0xC0, 0xFE, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xEF, 0x07, 0xBF, 0xF7, 0x83, 0xFF, 0xFB, 0xE3, 0xFF, 0xFD, 0xF1, 0xEF,
  0xFE, 0x78, 0xF7, 0xFF, 0x3E, 0x7B, 0xFF, 0x9F, 0x7D, 0xFF, 0xC7, 0xBC,
  0xFF, 0xE3, 0xDE, 0x7F, 0xF1, 0xFF, 0x3F, 0xF8, 0xFF, 0x1F, 0xFC, 0x3F,
  0x8F, 0xFE, 0x1F, 0xC7, 0xFF, 0x0F, 0xE3, 0xFF, 0x87, 0xE1, 0xF8, 0xFF,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0x7E, 0x1F, 0xF9, 0xF8, 0xFF, 0xCF,
  0xC7, 0xFE, 0x3F, 0x3F, 0xF1, 0xF9, 0xFF, 0x87, 0xEF, 0xFC, 0x3F, 0x7F,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x87, 0xF3,
  0xF8, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0xFE, 0xFE, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F,
  0x87, 0xE3, 0xF0, 0x7E, 0x7E, 0x0F, 0xEF, 0xC0, 0xFE, 0x03, 0xC0, 0x3F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xC3, 0xBF, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xBF, 0x03, 0xF3, 0xF0, 0x7E, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFE,
  0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE, 0x0F, 0xE3, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x03, 0xE7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0xF8,
  0x1F, 0xC0, 0xF9, 0xF8, 0x3F, 0x83, 0xF3, 0xF0, 0x7F, 0x07, 0xE3, 0xE0,
  0xFE, 0x0F, 0xC7, 0xC1, 0xFE, 0x1F, 0x0F, 0xC7, 0xFC, 0x3E, 0x1F, 0x8F,
  0x78, 0xFC, 0x1F, 0x1E, 0xF1, 0xF8, 0x3E, 0x3D, 0xF3, 0xE0, 0x7C, 0xFB,
  0xE7, 0xC0, 0xFD, 0xF3, 0xCF, 0x80, 0xFB, 0xC7, 0xBF, 0x01, 0xF7, 0x8F,
  0x7C, 0x03, 0xEF, 0x1E, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF8,
  0x7E, 0x07, 0xE3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x1F, 0x83, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE,
  0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x7F, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C,
  0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xC0, 0x07, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x1C, 0x7F,
  0x00, 0x3F, 0x00, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0x8F,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0xF0, 0xFD, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8, 0x03, 0xF0,
  0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7F, 0xF9, 0xF8, 0x2F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0x7F, 0x3D, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x1F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF,
  0x1F, 0x8F, 0x03, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3F,
  0x7C, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x07, 0xE1, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0x23, 0xF0, 0x3F, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0x9F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7E,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x40,
  0x3F, 0x78, 0x7F, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xE7, 0xFF,
  0xFB, 0xFE, 0xFF, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xFB, 0xF0, 0xFE, 0xFC,
  0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3E, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xBF, 0x0F, 0xCF, 0xE3,
  0xF1, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0xF8, 0x3E, 0x3E, 0xFF, 0x3F, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xFF, 0xC3,
  0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0,
  0xF8, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x03, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xF3, 0xF1, 0xFB, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xE3,
  0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0xF0,
  0xFB, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFD, 0xF8, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x9F,
  0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7E, 0x3F,
  0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0xFF,
  0x9F, 0xFB, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC1, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xC3, 0x7E, 0x03, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF1, 0x3F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x3F, 0x8F, 0xFC, 0x0F, 0xFF, 0x03,
  0xF7, 0xE0, 0xFD, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xF1, 0xF0,
  0x7C, 0xFC, 0x1F, 0x3E, 0x07, 0xEF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x3F, 0x87, 0xEF, 0x87, 0xF0, 0xFD, 0xF0, 0xFE, 0x1F, 0x3F, 0x1F, 0xE3,
  0xE7, 0xE3, 0xFC, 0xFC, 0x7C, 0xF7, 0x9F, 0x8F, 0x9E, 0xF3, 0xE1, 0xF3,
  0xDE, 0x7C, 0x1F, 0x7B, 0xEF, 0x83, 0xEF, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xEF,
  0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFE, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xFD, 0xF8, 0x3E, 0x3E,
  0x1F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x03, 0xEF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0x3F, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x7F, 0x8F, 0xE1, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7F, 0x0F, 0xE0, 0xFC,
  0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0xF0, 0xFE, 0x07,
  0xC3, 0xF8, 0xFF, 0x1F, 0x83, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Black30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 21, 9, 1, -21 },
  { 20, 12, 7, 16, 2, -21 },
  { 31, 18, 21, 20, 1, -21 },
  { 79, 16, 25, 17, 1, -23 },
  { 129, 27, 22, 28, 1, -22 },
  { 204, 23, 22, 24, 1, -22 },
  { 268, 5, 7, 9, 2, -21 },
  { 273, 9, 27, 11, 1, -22 },
  { 304, 9, 27, 11, 1, -22 },
  { 335, 14, 15, 16, 1, -23 },
  { 362, 15, 15, 18, 1, -18 },
  { 391, 7, 8, 9, 1, -4 },
  { 398, 8, 4, 10, 1, -10 },
  { 402, 6, 5, 9, 1, -5 },
  { 406, 13, 22, 13, 0, -22 },
  { 442, 16, 22, 18, 1, -22 },
  { 486, 13, 21, 18, 1, -21 },
  { 521, 15, 22, 18, 1, -22 },
  { 563, 15, 22, 18, 1, -22 },
  { 605, 16, 21, 18, 1, -21 },
  { 647, 15, 21, 18, 1, -21 },
  { 687, 16, 22, 18, 1, -22 },
  { 731, 16, 21, 18, 1, -21 },
  { 773, 16, 22, 18, 1, -22 },
  { 817, 16, 22, 18, 1, -22 },
  { 861, 6, 17, 9, 1, -17 },
  { 874, 7, 21, 9, 1, -17 },
  { 893, 15, 16, 18, 1, -19 },
  { 923, 15, 11, 18, 1, -16 },
  { 944, 15, 16, 18, 1, -19 },
  { 974, 15, 22, 15, 0, -22 },
  { 1016, 25, 24, 27, 1, -22 },
  { 1091, 22, 22, 22, 0, -22 },
  { 1152, 17, 21, 20, 2, -21 },
  { 1197, 17, 22, 19, 2, -22 },
  { 1244, 18, 21, 22, 2, -21 },
  { 1292, 13, 21, 16, 2, -21 },
  { 1327, 13, 21, 16, 2, -21 },
  { 1362, 18, 22, 22, 2, -22 },
  { 1412, 19, 21, 23, 2, -21 },
  { 1462, 11, 21, 13, 1, -21 },
  { 1491, 10, 28, 11, -2, -21 },
  { 1526, 19, 21, 21, 2, -21 },
  { 1576, 14, 21, 17, 2, -21 },
  { 1613, 25, 21, 29, 2, -21 },
  { 1679, 21, 21, 25, 2, -21 },
  { 1735, 20, 22, 24, 2, -22 },
  { 1790, 16, 21, 19, 2, -21 },
  { 1832, 21, 27, 24, 2, -22 },
  { 1903, 19, 21, 20, 2, -21 },
  { 1953, 15, 22, 17, 1, -22 },
  { 1995, 16, 21, 18, 1, -21 },
  { 2037, 19, 21, 23, 2, -21 },
  { 2087, 21, 21, 21, 0, -21 },
  { 2143, 31, 21, 31, 0, -21 },
  { 2225, 22, 21, 22, 0, -21 },
  { 2283, 20, 21, 20, 0, -21 },
  { 2336, 17, 21, 18, 1, -21 },
  { 2381, 7, 27, 10, 2, -22 },
  { 2405, 13, 22, 13, 0, -22 },
  { 2441, 7, 27, 10, 1, -22 },
  { 2465, 16, 15, 16, 0, -22 },
  { 2495, 15, 4, 15, 0, 2 },
  { 2503, 10, 5, 13, 1, -23 },
  { 2510, 16, 17, 19, 1, -17 },
  { 2544, 16, 23, 19, 2, -23 },
  { 2590, 14, 17, 16, 1, -17 },
  { 2620, 16, 23, 19, 1, -23 },
  { 2666, 16, 17, 19, 1, -17 },
  { 2700, 12, 23, 12, 1, -23 },
  { 2735, 16, 24, 19, 1, -17 },
  { 2783, 16, 23, 20, 2, -23 },
  { 2829, 6, 23, 10, 2, -23 },
  { 2847, 10, 30, 10, -2, -23 },
  { 2885, 18, 23, 20, 2, -23 },
  { 2937, 6, 23, 10, 2, -23 },
  { 2955, 26, 17, 30, 2, -17 },
  { 3011, 16, 17, 20, 2, -17 },
  { 3045, 17, 17, 19, 1, -17 },
  { 3082, 16, 24, 19, 2, -17 },
  { 3130, 16, 24, 19, 1, -17 },
  { 3178, 12, 17, 14, 2, -17 },
  { 3204, 13, 17, 16, 1, -17 },
  { 3232, 12, 20, 14, 1, -20 },
  { 3262, 16, 17, 20, 2, -17 },
  { 3296, 18, 17, 18, 0, -17 },
  { 3335, 27, 17, 27, 0, -17 },
  { 3393, 19, 17, 19, 0, -17 },
  { 3434, 18, 24, 18, 0, -17 },
  { 3488, 13, 17, 15, 1, -17 },
  { 3516, 11, 27, 13, 1, -22 },
  { 3554, 4, 30, 15, 6, -23 },
  { 3569, 11, 27, 13, 1, -22 },
  { 3607, 15, 5, 18, 1, -13 },
};

const GFXfont NotoSans_Black30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black30pt7bBitmaps,
  (GFXglyph *)NotoSans_Black30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_BLACK30PT7B_H_
