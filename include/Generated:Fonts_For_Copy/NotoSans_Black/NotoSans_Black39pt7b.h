#ifndef _NOTOSANS_BLACK39PT7B_H_
#define _NOTOSANS_BLACK39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x38, 0xFE,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF1,
  0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xF1,
  0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7,
  0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x8F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xF7, 0x82, 0x3F, 0x3C, 0x01, 0xFD, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x3F, 0x80, 0x79, 0xFD, 0x83,
  0xCF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x3F, 0xFC, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0xFC, 0x01, 0xF9,
  0xF8, 0x3F, 0x00, 0x3F, 0x3F, 0x07, 0xC0, 0x07, 0xC7, 0xE1, 0xF8, 0x00,
  0xF8, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF1, 0xF0,
  0x00, 0x7E, 0x7E, 0x7E, 0x3F, 0x0F, 0xDF, 0x9F, 0x9F, 0xF8, 0xFF, 0xF3,
  0xF7, 0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xF1, 0xFF, 0x9F, 0x3F, 0xFF, 0x0F,
  0xC7, 0xE7, 0xE7, 0xE0, 0x00, 0xF8, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x9F,
  0x80, 0x07, 0xC3, 0xF3, 0xF0, 0x01, 0xF8, 0x7E, 0x7E, 0x00, 0x7E, 0x0F,
  0xCF, 0xC0, 0x0F, 0xC1, 0xF9, 0xF8, 0x03, 0xF0, 0x3F, 0x3F, 0x00, 0x7C,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x87, 0xF8, 0x3F, 0xFC, 0x1F, 0xE1, 0xFF, 0xF0, 0xFF,
  0x0F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xCF, 0xF1, 0xFE, 0xFF, 0xFF, 0x87,
  0xF1, 0xFF, 0xFE, 0x3F, 0xC3, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0x83, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7C, 0xF8, 0x03, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x83, 0xE0, 0xBE, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x3F, 0x1F,
  0x81, 0xE3, 0xC0, 0x08, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x7E, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0x8F, 0xE7, 0xF0, 0xFF, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F,
  0x0F, 0xF7, 0xF8, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0xFF, 0x3C, 0xFF, 0x38, 0xFF, 0x10, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x1F, 0xF1, 0xC0, 0xFF, 0x08,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1C, 0x1F, 0xE1, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xF9, 0xFC, 0x1F, 0xCF, 0xE1,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x40, 0x1F, 0x9F,
  0xE0, 0xFD, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xF9, 0xFE, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFE, 0xFE, 0x0F,
  0xF7, 0xF0, 0x7F, 0xBF, 0xC3, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x8F, 0xF1,
  0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x7F, 0xBF,
  0xC1, 0xFD, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF,
  0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFB, 0xF0, 0x7F,
  0xBF, 0x80, 0xE1, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0xCF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7E, 0x1E, 0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xF8, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7,
  0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCE, 0x03, 0xF9, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x3F, 0x1F, 0x83, 0xFE, 0x3E, 0x7E, 0x1F, 0xFF, 0x7E, 0xF8,
  0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0xFC, 0xFF, 0xE7, 0xF1, 0xF1, 0xFF, 0x8F,
  0x83, 0xE3, 0xFF, 0x3F, 0x07, 0xC7, 0xFE, 0x7E, 0x0F, 0x8F, 0xFC, 0xF8,
  0x1F, 0x1F, 0xF9, 0xF0, 0x3E, 0x3F, 0xF3, 0xF0, 0xFC, 0x7F, 0xE7, 0xE1,
  0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xEF, 0x8F, 0xFF, 0xFF, 0xDF, 0x8F, 0xFD,
  0xFF, 0x1F, 0x0F, 0xF1, 0xFC, 0x3F, 0x01, 0x00, 0x40, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFD,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFE, 0x07,
  0x1F, 0xF0, 0x04, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x09, 0xFF, 0x80, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x0F, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x03,
  0xFC, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xF0, 0x1C, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0xC0, 0x7F, 0x7F, 0xE0, 0x7F,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xFC, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xE8, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE,
  0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03,
  0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFD, 0xF0, 0x1F, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xFD,
  0xF8, 0x1F, 0x7F, 0xFF, 0xF8, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE,
  0xFC, 0x3E, 0x7F, 0xFE, 0xFC, 0x3E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE,
  0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7C, 0x7F, 0xFE, 0x7E, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFE,
  0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE,
  0x1F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFF, 0xBF, 0xC1, 0xFF, 0xF3, 0xF8, 0x3F,
  0xFF, 0x7F, 0x87, 0xFF, 0xE7, 0xF0, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0x8F,
  0xE3, 0xFF, 0xF1, 0xFE, 0x7F, 0xFE, 0x1F, 0xCF, 0xFF, 0xC3, 0xFD, 0xFF,
  0xF8, 0x3F, 0xBF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xF3, 0xFE, 0x03,
  0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0xC1, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x7F,
  0x80, 0x3F, 0xCF, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF,
  0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xC0, 0xE7, 0xF0, 0x04, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x83,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xF7, 0xF8, 0x0F, 0xF8,
  0x0F, 0xE7, 0xF0, 0x1F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x7F, 0x9F,
  0xC0, 0xFF, 0xC0, 0xFE, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF,
  0x83, 0xF8, 0x7F, 0x07, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xBE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x7C, 0x3F, 0x81, 0xFC, 0x7E, 0xFC, 0x7F, 0x03, 0xF8, 0xFD,
  0xF8, 0xFE, 0x07, 0xF3, 0xF3, 0xF3, 0xF8, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0,
  0x0F, 0xCF, 0xC7, 0xCF, 0xE0, 0x1F, 0xDF, 0x8F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x1F, 0xBF, 0x00, 0x7F, 0x7C, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF9, 0xFE,
  0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xBF, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x3E, 0x1F, 0x03, 0xF0,
  0xFC, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xF7,
  0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xE7, 0xFC, 0x10, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFE, 0x7F, 0xBF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0x9F, 0x8F, 0xF0, 0xFC, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFC, 0xFF, 0x8F, 0xC7, 0xF0,
  0x01, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xF8, 0x33, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x06,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xC7, 0xF8, 0xFF, 0xBF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0x3F, 0x87, 0xF0, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF8, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x01, 0x7F, 0x80, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC3, 0xF8, 0xFF, 0x9F, 0xCF, 0xFE, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xDF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0x7F, 0x87,
  0xF3, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x40, 0x0F, 0xF3, 0xFB, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x07, 0xF7, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFC, 0x7E, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0xE7, 0xF0, 0xFF,
  0x8F, 0xE1, 0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0x9F, 0xE0, 0x7F, 0x7F, 0x80,
  0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF0, 0x7F, 0x9F, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x7F, 0xDF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x3F, 0xF1, 0xFF, 0x8F, 0xDF, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF,
  0xC7, 0xFB, 0xFC, 0x3F, 0xE0, 0xFE, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x81,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x07, 0xF0,
  0x3F, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0xF8, 0x3F, 0x07, 0xE7, 0xFE, 0x3F,
  0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x8F,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0xFC, 0x3E, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE7, 0xF0, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC3, 0xF8, 0xFF,
  0x9F, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF1, 0xFF, 0x7F, 0x87, 0xF3, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xF8, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xF0,
  0xF3, 0xF8, 0x09, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xF3, 0xFF, 0xBF, 0x8F, 0xF0,
  0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81,
  0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7,
  0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xEF,
  0xE0, 0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xF0, 0x7F, 0x3F, 0x83, 0xFF, 0x0F,
  0xE3, 0xF8, 0x7F, 0xE1, 0xFC, 0x7F, 0x0F, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF,
  0x8F, 0xE1, 0xFC, 0x7D, 0xF1, 0xFC, 0x1F, 0xCF, 0xBF, 0x3F, 0x83, 0xF9,
  0xF7, 0xE7, 0xF0, 0x7F, 0x7E, 0xFC, 0xFC, 0x0F, 0xEF, 0xCF, 0xBF, 0x80,
  0xFD, 0xF1, 0xF7, 0xF0, 0x1F, 0xBE, 0x3F, 0xFC, 0x03, 0xF7, 0xC7, 0xFF,
  0x80, 0x3E, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x7F,
  0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F,
  0xF7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF8, 0x1F,
  0xE7, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0x81, 0xFE, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFC, 0x02,
  0x80, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xA0, 0x07, 0xE0,
};

const GFXglyph NotoSans_Black39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 28, 11, 2, -28 },
  { 29, 16, 10, 20, 2, -28 },
  { 49, 24, 28, 26, 1, -28 },
  { 133, 21, 32, 23, 1, -30 },
  { 217, 35, 28, 37, 1, -28 },
  { 340, 30, 28, 31, 1, -28 },
  { 445, 7, 10, 11, 2, -28 },
  { 454, 12, 35, 14, 1, -29 },
  { 507, 12, 35, 14, 1, -29 },
  { 560, 19, 19, 21, 1, -30 },
  { 606, 19, 19, 23, 2, -23 },
  { 652, 9, 11, 12, 1, -6 },
  { 665, 11, 6, 12, 1, -13 },
  { 674, 8, 7, 11, 2, -7 },
  { 681, 17, 28, 17, 0, -28 },
  { 741, 20, 28, 23, 1, -28 },
  { 811, 16, 28, 23, 2, -28 },
  { 867, 20, 28, 23, 1, -28 },
  { 937, 20, 28, 23, 1, -28 },
  { 1007, 21, 28, 23, 1, -28 },
  { 1081, 19, 28, 23, 2, -28 },
  { 1148, 21, 28, 23, 1, -28 },
  { 1222, 21, 28, 23, 1, -28 },
  { 1296, 21, 28, 23, 1, -28 },
  { 1370, 21, 28, 23, 1, -28 },
  { 1444, 8, 22, 11, 2, -22 },
  { 1466, 9, 27, 12, 1, -22 },
  { 1497, 19, 22, 23, 2, -25 },
  { 1550, 19, 14, 23, 2, -21 },
  { 1584, 19, 22, 23, 2, -25 },
  { 1637, 19, 28, 20, 0, -28 },
  { 1704, 31, 31, 35, 2, -28 },
  { 1825, 28, 28, 28, 0, -28 },
  { 1923, 21, 28, 26, 3, -28 },
  { 1997, 22, 28, 25, 2, -28 },
  { 2074, 24, 28, 29, 3, -28 },
  { 2158, 17, 28, 21, 3, -28 },
  { 2218, 16, 28, 21, 3, -28 },
  { 2274, 24, 28, 29, 2, -28 },
  { 2358, 24, 28, 30, 3, -28 },
  { 2442, 15, 28, 17, 1, -28 },
  { 2495, 14, 37, 14, -3, -28 },
  { 2560, 24, 28, 27, 3, -28 },
  { 2644, 18, 28, 23, 3, -28 },
  { 2707, 32, 28, 38, 3, -28 },
  { 2819, 27, 28, 33, 3, -28 },
  { 2914, 27, 28, 31, 2, -28 },
  { 3009, 20, 28, 25, 3, -28 },
  { 3079, 28, 35, 31, 2, -28 },
  { 3202, 24, 28, 26, 3, -28 },
  { 3286, 19, 28, 23, 2, -28 },
  { 3353, 21, 28, 23, 1, -28 },
  { 3427, 24, 28, 30, 3, -28 },
  { 3511, 27, 28, 27, 0, -28 },
  { 3606, 39, 28, 41, 1, -28 },
  { 3743, 28, 28, 28, 0, -28 },
  { 3841, 26, 28, 26, 0, -28 },
  { 3932, 22, 28, 24, 1, -28 },
  { 4009, 10, 36, 13, 2, -29 },
  { 4054, 17, 28, 17, 0, -28 },
  { 4114, 9, 36, 13, 1, -29 },
  { 4155, 21, 18, 20, 0, -28 },
  { 4203, 20, 4, 20, 0, 3 },
  { 4213, 13, 6, 16, 2, -30 },
  { 4223, 21, 22, 24, 1, -22 },
  { 4281, 20, 30, 25, 3, -30 },
  { 4356, 18, 22, 21, 2, -22 },
  { 4406, 21, 30, 25, 2, -30 },
  { 4485, 20, 22, 24, 2, -22 },
  { 4540, 16, 30, 16, 1, -30 },
  { 4600, 21, 31, 25, 2, -22 },
  { 4682, 21, 30, 26, 3, -30 },
  { 4761, 8, 30, 13, 2, -30 },
  { 4791, 12, 39, 13, -2, -30 },
  { 4850, 23, 30, 26, 3, -30 },
  { 4937, 7, 30, 13, 3, -30 },
  { 4964, 34, 22, 39, 3, -22 },
  { 5058, 21, 22, 26, 3, -22 },
  { 5116, 21, 22, 25, 2, -22 },
  { 5174, 20, 31, 25, 3, -22 },
  { 5252, 21, 31, 25, 2, -22 },
  { 5334, 15, 22, 18, 3, -22 },
  { 5376, 17, 22, 20, 2, -22 },
  { 5423, 16, 26, 18, 1, -26 },
  { 5475, 21, 22, 26, 3, -22 },
  { 5533, 24, 22, 24, 0, -22 },
  { 5599, 35, 22, 35, 0, -22 },
  { 5696, 24, 22, 25, 0, -22 },
  { 5762, 24, 31, 24, 0, -22 },
  { 5855, 18, 22, 20, 1, -22 },
  { 5905, 15, 35, 17, 1, -28 },
  { 5971, 5, 39, 20, 7, -30 },
  { 5996, 15, 35, 17, 1, -28 },
  { 6062, 19, 7, 23, 2, -17 },
};

const GFXfont NotoSans_Black39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black39pt7bBitmaps,
  (GFXglyph *)NotoSans_Black39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_BLACK39PT7B_H_
