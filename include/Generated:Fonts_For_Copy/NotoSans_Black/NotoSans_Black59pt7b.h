#ifndef _NOTOSANS_BLACK59PT7B_H_
#define _NOTOSANS_BLACK59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF,
  0xFF, 0x7F, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x01, 0xC0, 0xFF,
  0xE3, 0xFF, 0x7F, 0xE3, 0xFF, 0x7F, 0xE3, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF9, 0xF8, 0x3C, 0x3F, 0xE3, 0xF0, 0x08, 0x7F, 0xC7, 0xE0,
  0x00, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0xDF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF3, 0xFF, 0x80,
  0x07, 0xE3, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0xFC,
  0x3F, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x1F, 0xE1, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xF3, 0xFE, 0x3F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x3F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC7, 0xFC, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE0, 0x0F, 0x80, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x87, 0xFC,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x1F, 0xFE,
  0x7F, 0xFD, 0xFF, 0xE0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x08, 0x03, 0xF8, 0x01, 0x78, 0x1F, 0xC0, 0x7B, 0xFC, 0x7E,
  0x3F, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x01, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xF1, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xC3,
  0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7F, 0xFD, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF,
  0xE3, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xCF, 0xFE, 0x03, 0xFF,
  0x9F, 0xFC, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFD,
  0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF,
  0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF,
  0x80, 0x7F, 0xF7, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xDF, 0xFC, 0x7F, 0xCF, 0xFE, 0x1F, 0x87, 0xFF, 0x0F,
  0x83, 0xFF, 0x83, 0x81, 0xFF, 0xC0, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xC0, 0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xF0, 0x78, 0x01, 0xFF, 0xC0,
  0x60, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xCF, 0xFF, 0xE0, 0xF0, 0x07,
  0xFF, 0x83, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xE0, 0x03,
  0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0x1F, 0xFC, 0x01,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x8E, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xFC,
  0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x20, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xFF,
  0x00, 0x7F, 0xE7, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF,
  0xC7, 0xFE, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x3F, 0xFD,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xBF,
  0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFB, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xF1,
  0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x87,
  0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x7F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0xEF, 0xFF, 0x01,
  0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xF9, 0xFF, 0xF3, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xEF, 0xFE,
  0x01, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0x3F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xE0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x40, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F,
  0xFD, 0xFF, 0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xE3, 0xFF, 0x9F, 0xFD, 0xFF,
  0xEF, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x38, 0x00, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE,
  0x7F, 0xF1, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF1, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xC7,
  0xC0, 0x0F, 0xFE, 0x10, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF,
  0x83, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xE3, 0xFC, 0x7F,
  0x83, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0x3F,
  0xE1, 0xFF, 0x83, 0xFC, 0x3F, 0x9F, 0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xCF,
  0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xE7, 0xF8, 0xFF, 0x80, 0xFF, 0x07, 0xFB,
  0xFC, 0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF,
  0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xBF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0xDF, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xE3, 0xFC, 0x3F, 0xE1, 0xFF, 0xCF, 0xF1, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xE0, 0xFF, 0xFE, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF,
  0xFE, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE0, 0xFF, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0x87, 0xFF,
  0xC0, 0x01, 0x83, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0x1F, 0xFF, 0xC0, 0x1F, 0x87, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0xF3, 0xFF,
  0x80, 0x3F, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFD,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xC0,
  0x0F, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFC, 0xFF,
  0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x01, 0xE0, 0x7F, 0xFE, 0x00, 0x02, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xF0, 0x00, 0xFF,
  0xEF, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xFC,
  0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x7F,
  0xF8, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF,
  0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xE7,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xE0,
  0x07, 0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F,
  0xF7, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xF7, 0xFF, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF7, 0xFF, 0xFF, 0x9F, 0xF0, 0x1F, 0xE7, 0xFF, 0xFF, 0xDF, 0xF0, 0x1F,
  0xE7, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xE7, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F,
  0xE7, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F,
  0xC7, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0xC7, 0xFF, 0xFF, 0xC7, 0xFC, 0x7F,
  0x87, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0x87, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0xFC, 0x03, 0xFF,
  0xFF, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xFF, 0x8F,
  0xFE, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0x03,
  0xFF, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xFF,
  0xC3, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0xFF, 0xF3, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xC0,
  0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x80,
  0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0xC0,
  0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE7, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0x3F, 0xFC, 0x00, 0xF1,
  0xFF, 0xC0, 0x01, 0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF,
  0x7F, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x70,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFF,
  0x9F, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF,
  0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xBF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xDF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFB, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x7F,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE7, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x07, 0xFC, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xC7, 0xFC,
  0x7F, 0xC7, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0xE0, 0x03,
  0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE3, 0xFC, 0x1F, 0xF3,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xDF,
  0xF0, 0x7F, 0xDF, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x07, 0xFB, 0xFF, 0x00,
  0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xF0, 0x1F,
  0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xCF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xBF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF,
  0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0xFF,
  0x80, 0x03, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x3F, 0xFE,
  0x06, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x0F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF9, 0xFF, 0xF8, 0x7F,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF, 0x87,
  0xFE, 0x3F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x0A, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x38, 0x7F,
  0xFC, 0x00, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x27, 0xFF, 0xC0, 0x0E,
  0x3F, 0xFF, 0x9F, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0x0F,
  0xFF, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFE, 0x1F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F,
  0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x07,
  0xFF, 0xF3, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0x7F,
  0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x04, 0x3F, 0xFE, 0x00, 0x3C, 0x3F, 0xFF, 0xEF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x86, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0x07, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF,
  0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF,
  0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF,
  0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xFE, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xF7, 0xFF, 0x03, 0xFF, 0xE7, 0xFF,
  0x01, 0xFF, 0x87, 0xFF, 0x00, 0x38, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x20, 0x00, 0x0F, 0xFF, 0x3E, 0x00, 0x1F, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xF0,
  0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x1F, 0x07, 0xFC, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x00, 0x3E, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x03,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xF0,
  0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xF3,
  0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xDF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x7F,
  0xFB, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0x1F, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFB, 0xFF, 0xF8, 0x7F, 0xF3, 0xFF, 0xE0, 0xFF,
  0xE3, 0xFF, 0x01, 0xFF, 0xC0, 0x60, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF,
  0xFB, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC,
  0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF0,
  0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xF0,
  0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF0,
  0x07, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xFE,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x07, 0xFF,
  0xF7, 0xFF, 0x03, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x38,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x37, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xE7, 0xFC, 0xFF, 0xE0, 0x1E, 0x3F, 0xF8,
  0x00, 0x87, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFD, 0x00, 0x07, 0xFF, 0x7C,
  0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE7, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x03, 0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x1F,
  0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0x1F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xBF, 0xC1, 0xFF, 0x81,
  0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xBF, 0xE3, 0xFF,
  0x81, 0xFF, 0xC7, 0xF9, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0x9F, 0xE3,
  0xFF, 0x00, 0xFF, 0xCF, 0xF9, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x1F,
  0xE3, 0xFF, 0x00, 0xFF, 0xCF, 0xF1, 0xFF, 0x7F, 0xE0, 0x07, 0xFC, 0xFF,
  0x0F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xF0, 0xFF, 0x7F, 0xE0, 0x07, 0xFF,
  0xFE, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0x7F, 0xC0, 0x03,
  0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x03,
  0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x8F, 0xFF,
  0x80, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x80,
  0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC,
  0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0B, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF4, 0x00, 0x0F, 0xFF, 0x20, 0x00,
  0x07, 0xC0,
};

const GFXglyph NotoSans_Black59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 13, 43, 17, 2, -42 },
  { 71, 24, 15, 31, 3, -42 },
  { 116, 37, 42, 39, 1, -42 },
  { 311, 31, 48, 34, 2, -45 },
  { 497, 54, 43, 56, 1, -43 },
  { 788, 45, 44, 47, 2, -43 },
  { 1036, 11, 15, 17, 3, -42 },
  { 1057, 18, 52, 21, 2, -43 },
  { 1174, 17, 52, 21, 2, -43 },
  { 1285, 29, 28, 32, 1, -45 },
  { 1387, 29, 28, 35, 3, -35 },
  { 1489, 13, 17, 18, 2, -9 },
  { 1517, 17, 9, 19, 1, -20 },
  { 1537, 13, 11, 17, 2, -10 },
  { 1555, 26, 44, 26, 0, -43 },
  { 1698, 31, 44, 35, 2, -43 },
  { 1869, 25, 42, 35, 2, -42 },
  { 2001, 31, 43, 35, 1, -43 },
  { 2168, 30, 44, 35, 2, -43 },
  { 2333, 33, 42, 35, 1, -42 },
  { 2507, 29, 43, 35, 3, -42 },
  { 2663, 31, 44, 35, 2, -43 },
  { 2834, 31, 42, 35, 2, -42 },
  { 2997, 31, 44, 35, 2, -43 },
  { 3168, 31, 44, 35, 2, -43 },
  { 3339, 13, 34, 17, 2, -33 },
  { 3395, 13, 41, 18, 2, -33 },
  { 3462, 29, 33, 35, 3, -38 },
  { 3582, 29, 21, 35, 3, -31 },
  { 3659, 29, 33, 35, 3, -38 },
  { 3779, 29, 44, 30, 0, -43 },
  { 3939, 49, 47, 53, 2, -43 },
  { 4227, 43, 42, 43, 0, -42 },
  { 4453, 32, 42, 40, 5, -42 },
  { 4621, 33, 44, 38, 3, -43 },
  { 4803, 35, 42, 43, 5, -42 },
  { 4987, 25, 42, 32, 5, -42 },
  { 5119, 24, 42, 32, 5, -42 },
  { 5245, 37, 44, 44, 3, -43 },
  { 5449, 36, 42, 45, 5, -42 },
  { 5638, 22, 42, 26, 2, -42 },
  { 5754, 21, 55, 21, -5, -42 },
  { 5899, 36, 42, 41, 5, -42 },
  { 6088, 27, 42, 34, 5, -42 },
  { 6230, 48, 42, 57, 5, -42 },
  { 6482, 40, 42, 49, 5, -42 },
  { 6692, 41, 44, 47, 3, -43 },
  { 6918, 30, 42, 37, 5, -42 },
  { 7076, 42, 53, 47, 3, -43 },
  { 7355, 36, 42, 40, 5, -42 },
  { 7544, 29, 44, 34, 3, -43 },
  { 7704, 32, 42, 35, 1, -42 },
  { 7872, 36, 43, 45, 4, -42 },
  { 8066, 41, 42, 41, 0, -42 },
  { 8282, 59, 42, 61, 1, -42 },
  { 8592, 42, 42, 43, 0, -42 },
  { 8813, 39, 42, 39, 0, -42 },
  { 9018, 33, 42, 36, 2, -42 },
  { 9192, 15, 53, 19, 3, -43 },
  { 9292, 26, 44, 26, 0, -43 },
  { 9435, 15, 53, 19, 1, -43 },
  { 9535, 32, 28, 31, 0, -42 },
  { 9647, 30, 7, 30, 0, 4 },
  { 9674, 20, 9, 25, 2, -45 },
  { 9697, 31, 34, 37, 2, -33 },
  { 9829, 31, 46, 38, 4, -45 },
  { 10008, 28, 34, 32, 2, -33 },
  { 10127, 32, 46, 38, 2, -45 },
  { 10311, 32, 34, 36, 2, -33 },
  { 10447, 25, 45, 24, 1, -45 },
  { 10588, 32, 47, 38, 2, -33 },
  { 10776, 32, 45, 40, 4, -45 },
  { 10956, 12, 46, 19, 4, -46 },
  { 11025, 19, 60, 19, -3, -46 },
  { 11168, 35, 45, 39, 4, -45 },
  { 11365, 11, 45, 19, 4, -45 },
  { 11427, 51, 33, 59, 4, -33 },
  { 11638, 32, 33, 40, 4, -33 },
  { 11770, 33, 34, 38, 2, -33 },
  { 11911, 31, 47, 38, 4, -33 },
  { 12094, 32, 47, 38, 2, -33 },
  { 12282, 23, 33, 28, 4, -33 },
  { 12377, 26, 34, 31, 2, -33 },
  { 12488, 23, 40, 27, 2, -39 },
  { 12603, 32, 34, 40, 4, -33 },
  { 12739, 36, 33, 36, 0, -33 },
  { 12888, 52, 33, 54, 1, -33 },
  { 13103, 37, 33, 37, 0, -33 },
  { 13256, 36, 47, 36, 0, -33 },
  { 13468, 27, 33, 30, 1, -33 },
  { 13580, 22, 53, 26, 2, -43 },
  { 13726, 8, 58, 30, 11, -45 },
  { 13784, 22, 53, 26, 2, -43 },
  { 13930, 29, 11, 35, 3, -26 },
};

const GFXfont NotoSans_Black59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black59pt7bBitmaps,
  (GFXglyph *)NotoSans_Black59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_BLACK59PT7B_H_
