#ifndef _NOTOSANS_BLACK25PT7B_H_
#define _NOTOSANS_BLACK25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF0, 0x03, 0xFF, 0xFB,
  0xC0, 0x7B, 0xEF, 0x7D, 0xEF, 0x3C, 0xE7, 0x9C, 0xE3, 0x9C, 0x70, 0x03,
  0x9C, 0x07, 0x9C, 0x07, 0x3C, 0x07, 0x3C, 0x07, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x0E, 0x78, 0x0E, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x06,
  0x00, 0x30, 0x0F, 0xF8, 0xFF, 0xEF, 0xFF, 0x7B, 0x3B, 0xD8, 0x1F, 0xC0,
  0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x6F, 0x83, 0x3F, 0x9B, 0xFF,
  0xFE, 0xFF, 0xF7, 0xFE, 0x01, 0x80, 0x0C, 0x00, 0x1E, 0x01, 0xE0, 0x7E,
  0x07, 0x81, 0xFE, 0x0E, 0x03, 0x9C, 0x3C, 0x0F, 0x3C, 0x70, 0x1E, 0x79,
  0xE0, 0x3C, 0xF7, 0x80, 0x39, 0xCE, 0x7C, 0x7F, 0xBD, 0xFC, 0x7F, 0x73,
  0xFC, 0x79, 0xEF, 0x78, 0x03, 0x9E, 0xF0, 0x0F, 0x3C, 0xE0, 0x1C, 0x7B,
  0xC0, 0x78, 0xF7, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFC, 0x0F, 0x01, 0xF0,
  0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0x7C, 0x03, 0xCF, 0x80,
  0x79, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC7, 0xCF, 0xF8, 0xF9,
  0xFF, 0xBE, 0x7D, 0xFF, 0xCF, 0x9F, 0xF1, 0xF1, 0xFE, 0x3F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xF9, 0xFC, 0x7B, 0xDE, 0xF7, 0xB9, 0xC0,
  0x1E, 0x78, 0xF3, 0xC7, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x7C, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC7, 0x8F, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3C, 0x78,
  0xF3, 0xC7, 0x9E, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x0C, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0x3F, 0x87, 0xBC, 0x79, 0xE1, 0x10, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7B, 0xDF, 0xEF, 0x7B, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xF8, 0xFF,
  0xEF, 0x9F, 0x7C, 0x7B, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0xF9, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00,
  0x03, 0xE1, 0xFC, 0x7F, 0x9F, 0xF7, 0xFF, 0xFF, 0xDE, 0xF9, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x83, 0xFF, 0x3F, 0xFD, 0xFF, 0xE7, 0x1F, 0x10, 0x78, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE2, 0x1F, 0x00, 0xF8, 0x07, 0x83, 0xF8, 0x1F, 0x80, 0xFF, 0x07,
  0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFC,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1,
  0xEF, 0x07, 0xBC, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xFE, 0x0F, 0xFC, 0x7F, 0xE7,
  0xFF, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0xC0, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xE3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF, 0xE7, 0xC0, 0x7C,
  0x03, 0xCF, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7D, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0xC3, 0xFF, 0x1F, 0xFD, 0xFB, 0xEF, 0x8F, 0x3C,
  0x79, 0xFF, 0xC7, 0xFC, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xF3, 0xEF, 0x0F,
  0xF8, 0x7F, 0xE7, 0xFF, 0xFE, 0x7F, 0xF1, 0xFE, 0x00, 0x1F, 0x81, 0xFF,
  0x1F, 0xF9, 0xFF, 0xEF, 0x8F, 0x78, 0x7F, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFE, 0x7D, 0xE0, 0x0F, 0x00, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F,
  0xC3, 0xF8, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xBC,
  0x77, 0xFF, 0xF3, 0x00, 0x00, 0x00, 0x1E, 0xF7, 0xFB, 0xDE, 0xF0, 0x00,
  0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xE3, 0xF8, 0xFC, 0x0F, 0xC0, 0xFF,
  0x01, 0xFE, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x0F,
  0xF3, 0xFC, 0xFF, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0xCF, 0xFE, 0xFF,
  0xF7, 0xFF, 0x60, 0xF0, 0x1F, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xE0, 0x1E, 0x3C, 0x30, 0xE7,
  0x9F, 0xEF, 0x73, 0xFE, 0x7F, 0x7C, 0xE7, 0xF7, 0x8E, 0x7E, 0x70, 0xE7,
  0xE7, 0x0E, 0x7E, 0x71, 0xE7, 0xF7, 0xFF, 0xFF, 0x3F, 0xFE, 0x71, 0xF3,
  0xC7, 0x80, 0x00, 0x3E, 0x03, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC,
  0x03, 0xEF, 0x00, 0xF3, 0xC0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0x83,
  0xE1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9, 0xF0,
  0x3E, 0xFC, 0x0F, 0xFE, 0x01, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF,
  0xFE, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0xBE, 0x3F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF, 0x7E, 0x09, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x17, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF, 0x81,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x8F, 0xDF, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x1F,
  0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x03, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7E, 0x04, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x1F,
  0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xEF, 0xF7, 0xF3, 0xF0, 0xC0, 0xF8, 0x3F, 0xF0, 0xFB, 0xE3, 0xF7,
  0xC7, 0xCF, 0x9F, 0x1F, 0x7E, 0x3E, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x87, 0xFF, 0x8F, 0x9F, 0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7E,
  0xF8, 0x7D, 0xF0, 0xFC, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0x78, 0xEF, 0xF7, 0x9E, 0xFF, 0x79, 0xEF, 0xF3, 0x9C, 0xFF, 0x3D,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1,
  0xF8, 0xFF, 0x0F, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xDF, 0x1F, 0xEF, 0x8F, 0xF3, 0xE7, 0xF9,
  0xF3, 0xFC, 0x7D, 0xFE, 0x3E, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0xC0, 0xFB, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x87, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x87, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0xFC, 0xFF,
  0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0x9F, 0x1F, 0x3E, 0x3E, 0x3E,
  0x7C, 0x7E, 0xF8, 0x7D, 0xF0, 0xFC, 0x1F, 0xE1, 0xFF, 0xDF, 0xFD, 0xFF,
  0xEF, 0x82, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF, 0xDF, 0xFE, 0xFF, 0xE3, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xC0, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0x83,
  0xE7, 0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x1F, 0x3E, 0x0F,
  0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x1E, 0x07, 0xDE, 0x0F,
  0xC1, 0xE7, 0xC3, 0xF0, 0xF9, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x8F,
  0x0F, 0xC3, 0xC3, 0xC7, 0xF8, 0xF0, 0xF9, 0xFE, 0x7C, 0x3E, 0x7F, 0x9F,
  0x07, 0x9C, 0xE7, 0x81, 0xEF, 0x3D, 0xE0, 0x7B, 0xCF, 0xF8, 0x1F, 0xF3,
  0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0xDF, 0x87, 0xE3, 0xE1,
  0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x07,
  0xCF, 0x83, 0xF3, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0xBF, 0x03, 0xF0, 0xF8,
  0x1F, 0xBE, 0x0F, 0x9F, 0x0F, 0x87, 0xC7, 0xC3, 0xE7, 0xC0, 0xFB, 0xE0,
  0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xFC, 0x0E, 0xE0, 0xF7, 0x87,
  0x1C, 0x78, 0xF3, 0x83, 0xBC, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x3E, 0x1F, 0x07, 0x1F, 0xC3, 0xFF, 0x8F, 0xFC, 0x73, 0xF0,
  0x0F, 0x87, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF,
  0xF7, 0xF7, 0xBF, 0x3C, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x79, 0xE3, 0xDF, 0x9F, 0xFE, 0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBD, 0xF0, 0x0F,
  0xE3, 0xFF, 0x7F, 0xE7, 0xFE, 0xFC, 0x2F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0x7F, 0xE7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x8F, 0x3C, 0xFD, 0xEF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0xFF, 0x7F, 0xFB,
  0xFB, 0xC7, 0x8E, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF9, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x1F, 0x06, 0xFF, 0xF3, 0xFF,
  0x87, 0xF8, 0x1F, 0xCF, 0xF3, 0xF8, 0xFA, 0x7C, 0x1F, 0xEF, 0xFB, 0xFE,
  0xFF, 0x9F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC0, 0x1E, 0x79, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F,
  0xBC, 0x01, 0xE8, 0x1F, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x79, 0xF3, 0xDF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3E, 0xF7, 0xFF, 0xC0, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x1E, 0x1F, 0x1E, 0x0C, 0x00, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xFF, 0x0F, 0xBC, 0x7C, 0xF3, 0xE3, 0xDF,
  0x8F, 0x7C, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xBF, 0x3C, 0x7C, 0xF1,
  0xFB, 0xC3, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE3, 0xE3, 0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0x8F, 0xFC, 0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F,
  0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F,
  0x87, 0xF8, 0x7C, 0x3C, 0xE3, 0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7C, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xF7, 0xCF, 0x9F, 0xFE,
  0x3F, 0xF0, 0x3F, 0x00, 0xF3, 0xC7, 0xBF, 0x3F, 0xFD, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x7B, 0xE3, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x79, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0xBC,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xE3, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x80, 0x3F, 0x8F, 0xFF, 0xFF, 0x7C, 0x6F, 0x81, 0xFE, 0x1F, 0xF1,
  0xFE, 0x0F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x1C, 0x07,
  0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0xF3, 0xFC, 0xFF, 0x1F, 0xC0, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF7, 0xF7, 0x9F, 0x3C, 0xF8, 0x3E, 0xF0, 0x7D, 0xF0,
  0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x0F, 0xBE, 0x0F, 0x78, 0x1E, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x7C,
  0x3D, 0xE3, 0xF0, 0xF7, 0x8F, 0xE7, 0xDF, 0x3F, 0x9F, 0x7C, 0xFE, 0x78,
  0xF3, 0xB9, 0xE3, 0xDE, 0xEF, 0x8F, 0x7B, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F,
  0x3F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F,
  0x80, 0xFC, 0x3E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E,
  0x7C, 0x7C, 0x7E, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7D, 0xF0, 0xF3, 0xE3,
  0xE3, 0xC7, 0xC7, 0xCF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1E, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x8F, 0xC7, 0xE3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3E, 0x7E, 0x3E, 0x1F, 0x0F, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xF1, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F,
  0xC7, 0xE1, 0xF3, 0xF9, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x1F, 0x8F,
  0xC7, 0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xE8, 0x04, 0x00,
};

const GFXglyph NotoSans_Black25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 11, 7, 13, 1, -18 },
  { 23, 16, 18, 17, 0, -18 },
  { 59, 13, 20, 14, 1, -19 },
  { 92, 23, 18, 24, 0, -18 },
  { 144, 19, 18, 20, 1, -18 },
  { 187, 5, 7, 7, 1, -18 },
  { 192, 7, 22, 9, 1, -18 },
  { 212, 7, 22, 9, 1, -18 },
  { 232, 12, 12, 13, 1, -19 },
  { 250, 13, 12, 15, 1, -15 },
  { 270, 5, 7, 8, 1, -4 },
  { 275, 6, 4, 8, 1, -9 },
  { 278, 5, 4, 7, 1, -4 },
  { 281, 11, 18, 11, 0, -18 },
  { 306, 13, 18, 15, 1, -18 },
  { 336, 11, 18, 15, 1, -18 },
  { 361, 13, 18, 15, 1, -18 },
  { 391, 13, 18, 15, 1, -18 },
  { 421, 14, 18, 15, 0, -18 },
  { 453, 13, 18, 15, 1, -18 },
  { 483, 13, 18, 15, 1, -18 },
  { 513, 13, 18, 15, 1, -18 },
  { 543, 13, 18, 15, 1, -18 },
  { 573, 13, 18, 15, 1, -18 },
  { 603, 5, 14, 7, 1, -14 },
  { 612, 5, 17, 7, 1, -14 },
  { 623, 12, 14, 15, 1, -16 },
  { 644, 13, 9, 15, 1, -13 },
  { 659, 12, 14, 15, 1, -16 },
  { 680, 12, 18, 13, 0, -18 },
  { 707, 20, 20, 22, 1, -18 },
  { 757, 18, 18, 18, 0, -18 },
  { 798, 14, 18, 17, 2, -18 },
  { 830, 14, 18, 16, 1, -18 },
  { 862, 15, 18, 18, 2, -18 },
  { 896, 11, 18, 14, 2, -18 },
  { 921, 10, 18, 13, 2, -18 },
  { 944, 16, 18, 19, 1, -18 },
  { 980, 15, 18, 19, 2, -18 },
  { 1014, 9, 18, 11, 1, -18 },
  { 1035, 9, 24, 9, -2, -18 },
  { 1062, 15, 18, 17, 2, -18 },
  { 1096, 12, 18, 15, 2, -18 },
  { 1123, 20, 18, 24, 2, -18 },
  { 1168, 17, 18, 21, 2, -18 },
  { 1207, 18, 18, 20, 1, -18 },
  { 1248, 13, 18, 16, 2, -18 },
  { 1278, 18, 22, 20, 1, -18 },
  { 1328, 15, 18, 17, 2, -18 },
  { 1362, 13, 18, 14, 1, -18 },
  { 1392, 13, 18, 15, 1, -18 },
  { 1422, 15, 18, 19, 2, -18 },
  { 1456, 17, 18, 17, 0, -18 },
  { 1495, 26, 18, 26, 0, -18 },
  { 1554, 18, 18, 18, 0, -18 },
  { 1595, 17, 18, 17, 0, -18 },
  { 1634, 14, 18, 15, 1, -18 },
  { 1666, 7, 22, 8, 1, -18 },
  { 1686, 11, 18, 11, 0, -18 },
  { 1711, 6, 22, 8, 1, -18 },
  { 1728, 13, 12, 13, 0, -18 },
  { 1748, 13, 3, 13, 0, 2 },
  { 1753, 8, 4, 10, 1, -19 },
  { 1757, 13, 14, 16, 1, -14 },
  { 1780, 13, 19, 16, 2, -19 },
  { 1811, 12, 14, 13, 1, -14 },
  { 1832, 13, 19, 16, 1, -19 },
  { 1863, 13, 14, 15, 1, -14 },
  { 1886, 10, 19, 10, 1, -19 },
  { 1910, 13, 20, 16, 1, -14 },
  { 1943, 13, 19, 17, 2, -19 },
  { 1974, 5, 19, 8, 2, -19 },
  { 1986, 8, 25, 8, -1, -19 },
  { 2011, 14, 19, 16, 2, -19 },
  { 2045, 4, 19, 8, 2, -19 },
  { 2055, 21, 14, 25, 2, -14 },
  { 2092, 13, 14, 17, 2, -14 },
  { 2115, 14, 14, 16, 1, -14 },
  { 2140, 13, 20, 16, 2, -14 },
  { 2173, 13, 20, 16, 1, -14 },
  { 2206, 9, 14, 12, 2, -14 },
  { 2222, 11, 14, 13, 1, -14 },
  { 2242, 10, 17, 12, 1, -17 },
  { 2264, 13, 14, 17, 2, -14 },
  { 2287, 15, 14, 15, 0, -14 },
  { 2314, 22, 14, 23, 0, -14 },
  { 2353, 16, 14, 16, 0, -14 },
  { 2381, 15, 20, 15, 0, -14 },
  { 2419, 11, 14, 13, 1, -14 },
  { 2439, 9, 22, 11, 1, -18 },
  { 2464, 3, 24, 13, 5, -19 },
  { 2473, 9, 22, 11, 1, -18 },
  { 2498, 13, 5, 15, 1, -11 },
};

const GFXfont NotoSans_Black25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black25pt7bBitmaps,
  (GFXglyph *)NotoSans_Black25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_BLACK25PT7B_H_
