#ifndef _NOTOSANS_BLACK7PT7B_H_
#define _NOTOSANS_BLACK7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black7pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0xEC, 0x77, 0xD5, 0xE6, 0x00, 0x7A, 0x6B, 0xE0, 0xC9,
  0x63, 0x71, 0x76, 0xC0, 0x71, 0xC6, 0xBE, 0x7C, 0xD0, 0x7A, 0xD0, 0xD5,
  0x70, 0x4F, 0x60, 0x2F, 0x20, 0xE0, 0xC0, 0xC0, 0x2D, 0x28, 0x6F, 0xDF,
  0x60, 0x7C, 0x92, 0xEB, 0x24, 0xF0, 0xE3, 0x63, 0xE0, 0x26, 0xEF, 0x20,
  0x6C, 0xF3, 0xE0, 0x7C, 0xFD, 0x70, 0xF3, 0x26, 0x40, 0x7F, 0x69, 0xF0,
  0x6F, 0xF3, 0x60, 0xC3, 0xC3, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xC0,
  0xE5, 0x84, 0x79, 0xFA, 0xEF, 0x48, 0xC0, 0x72, 0x95, 0xFD, 0x80, 0xF7,
  0xDE, 0x74, 0xCC, 0x70, 0xEB, 0xBB, 0xE0, 0xF3, 0x4E, 0xF3, 0x48, 0x7A,
  0x37, 0xB7, 0x80, 0xBB, 0xFB, 0xB0, 0xE9, 0x2E, 0x24, 0x93, 0xF0, 0xBE,
  0xCA, 0xB0, 0x92, 0x4E, 0x9E, 0xF7, 0xDA, 0x80, 0xDD, 0xFB, 0xB0, 0x7E,
  0x73, 0x97, 0x80, 0xF7, 0xC8, 0x7E, 0x73, 0x97, 0x8C, 0xEA, 0xEE, 0xB0,
  0x7C, 0x63, 0xE0, 0xF6, 0x66, 0x60, 0xBB, 0xBB, 0xE0, 0xDE, 0x94, 0xE6,
  0x00, 0xD3, 0xB5, 0xBB, 0x66, 0xC0, 0xDA, 0x88, 0xAD, 0x80, 0xDB, 0x98,
  0x42, 0x00, 0xF3, 0x64, 0xF0, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x46,
  0xB0, 0xF0, 0xE0, 0x73, 0xDF, 0xCF, 0xDD, 0xF0, 0x7C, 0xC6, 0x17, 0xDD,
  0x70, 0x7D, 0xE7, 0x7D, 0x24, 0x7D, 0xD7, 0xB6, 0xCF, 0xDD, 0xD0, 0xFF,
  0xC0, 0xFF, 0xF8, 0xC6, 0xF9, 0xED, 0x80, 0xFF, 0xC0, 0xFD, 0xAF, 0x5E,
  0xB0, 0xFD, 0xDD, 0x7D, 0xD7, 0xFD, 0xDF, 0xCC, 0x7D, 0xD7, 0x11, 0xFB,
  0x60, 0x79, 0xF0, 0x5D, 0x26, 0xDD, 0xD7, 0x97, 0x66, 0xB7, 0xD7, 0x5A,
  0xD6, 0x6D, 0xD7, 0x66, 0x6C, 0xE5, 0x70, 0x69, 0x64, 0xC0, 0xFE, 0xC9,
  0x35, 0x80, 0xF0,
};

const GFXglyph NotoSans_Black7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 4, 0, -5 },
  { 4, 5, 5, 5, 0, -5 },
  { 8, 4, 5, 4, 0, -5 },
  { 11, 7, 5, 7, 0, -5 },
  { 16, 6, 5, 6, 0, -5 },
  { 20, 2, 2, 2, 0, -5 },
  { 21, 2, 6, 3, 0, -5 },
  { 23, 2, 6, 3, 0, -5 },
  { 25, 4, 3, 4, 0, -5 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 2, 2, 2, 0, -1 },
  { 30, 2, 1, 2, 0, -2 },
  { 31, 2, 1, 2, 0, -1 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 4, 5, 4, 0, -5 },
  { 37, 3, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 4, 5, 4, 0, -5 },
  { 60, 4, 5, 4, 0, -5 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 4, 3, 4, 0, -4 },
  { 72, 3, 5, 4, 0, -5 },
  { 74, 6, 6, 6, 0, -5 },
  { 79, 5, 5, 5, 0, -5 },
  { 83, 3, 5, 5, 1, -5 },
  { 85, 4, 5, 5, 0, -5 },
  { 88, 4, 5, 5, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 3, 5, 4, 1, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 4, 5, 5, 1, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 3, 7, 2, -1, -5 },
  { 107, 4, 5, 5, 1, -5 },
  { 110, 3, 5, 4, 1, -5 },
  { 112, 5, 5, 7, 1, -5 },
  { 116, 4, 5, 6, 1, -5 },
  { 119, 5, 5, 6, 0, -5 },
  { 123, 3, 5, 4, 1, -5 },
  { 125, 5, 6, 6, 0, -5 },
  { 129, 4, 5, 5, 1, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 4, 5, 4, 0, -5 },
  { 138, 4, 5, 5, 1, -5 },
  { 141, 5, 5, 5, 0, -5 },
  { 145, 7, 5, 7, 0, -5 },
  { 150, 5, 5, 5, 0, -5 },
  { 154, 5, 5, 5, 0, -5 },
  { 158, 4, 5, 4, 0, -5 },
  { 161, 2, 6, 2, 0, -5 },
  { 163, 3, 5, 3, 0, -5 },
  { 165, 2, 6, 2, 0, -5 },
  { 167, 4, 3, 4, 0, -5 },
  { 169, 4, 1, 4, 0, 0 },
  { 170, 3, 1, 3, 0, -5 },
  { 171, 4, 4, 4, 0, -4 },
  { 173, 4, 5, 5, 0, -5 },
  { 176, 4, 4, 4, 0, -4 },
  { 178, 4, 5, 5, 0, -5 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 3, 5, 3, 0, -5 },
  { 185, 4, 6, 5, 0, -4 },
  { 188, 4, 5, 5, 0, -5 },
  { 191, 2, 5, 2, 0, -5 },
  { 193, 2, 7, 2, 0, -5 },
  { 195, 5, 5, 5, 0, -5 },
  { 199, 2, 5, 2, 0, -5 },
  { 201, 7, 4, 7, 0, -4 },
  { 205, 4, 4, 5, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 6, 5, 0, -4 },
  { 212, 4, 6, 5, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 3, 4, 4, 0, -4 },
  { 219, 3, 5, 3, 0, -5 },
  { 221, 4, 4, 5, 0, -4 },
  { 223, 4, 4, 4, 0, -4 },
  { 225, 6, 4, 6, 0, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 6, 4, 0, -4 },
  { 233, 3, 4, 4, 0, -4 },
  { 235, 3, 6, 3, 0, -5 },
  { 238, 1, 7, 4, 1, -5 },
  { 239, 3, 6, 3, 0, -5 },
  { 242, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Black7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black7pt7bBitmaps,
  (GFXglyph *)NotoSans_Black7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_BLACK7PT7B_H_
