#ifndef _NOTOSANS_BLACK40PT7B_H_
#define _NOTOSANS_BLACK40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFE, 0x3F, 0xFF, 0x1F, 0xDF, 0x8F,
  0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E,
  0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x1F,
  0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0,
  0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFE, 0x70,
  0xE7, 0xF3, 0x81, 0x3F, 0x9C, 0x01, 0xFE, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xEF, 0xF0, 0x07, 0x3F, 0xC0, 0x38, 0xFD, 0xC1,
  0xCF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x03, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0x0F,
  0xCF, 0xC0, 0xFC, 0x00, 0xFC, 0xFC, 0x0F, 0x80, 0x0F, 0xCF, 0xC1, 0xF8,
  0x00, 0xFC, 0x7C, 0x3F, 0x00, 0x0F, 0xC7, 0xC3, 0xF0, 0x00, 0xFC, 0xFC,
  0x7E, 0x00, 0x0F, 0xCF, 0xC7, 0xE1, 0xC0, 0xFC, 0xFC, 0xFC, 0x7F, 0x8F,
  0xFF, 0xCF, 0x8F, 0xFC, 0x7F, 0xF9, 0xF9, 0xFF, 0xE3, 0xFF, 0x9F, 0x3F,
  0xFE, 0x1F, 0xF3, 0xF3, 0xF3, 0xF0, 0xFC, 0x7E, 0x3F, 0x3F, 0x00, 0x07,
  0xE3, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE3, 0xF0,
  0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x1F, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0x3F,
  0x3F, 0x00, 0x3E, 0x03, 0xF7, 0xF0, 0x07, 0xE0, 0x3F, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFC, 0x3F, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0x7F,
  0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xE0, 0x7F,
  0xF8, 0x1F, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F,
  0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x07, 0x1F, 0x1E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xBF, 0x03, 0xF9, 0xF8, 0x1F, 0x1F, 0xC0, 0x70, 0xE0, 0x01, 0x08,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x3F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0x3F, 0xCF, 0xF0, 0xFE,
  0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0xC3,
  0xF9, 0xFE, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xC1, 0xFE, 0x18, 0x07, 0xF0, 0x40, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7C, 0x7F, 0xC3, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF7,
  0xF8, 0x1F, 0xDF, 0xE0, 0x7E, 0x7F, 0x83, 0xF9, 0xFE, 0x1F, 0xC7, 0xF8,
  0x7E, 0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x38, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0xE0, 0x1F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0xFE, 0xFF, 0x87, 0xEF, 0xFE, 0x3F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0xC3, 0xFD, 0xFE,
  0x1F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFE,
  0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xF7, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFE, 0xFF, 0x9F, 0xE3, 0xFD, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xEF, 0xF0, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xEF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xDF, 0xC3,
  0xFC, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3F, 0x3F, 0xDF, 0xEF, 0xF7, 0xFB, 0xF8, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF,
  0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0x87, 0xF9, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x3F, 0x0F, 0xFF, 0x3E, 0x7E, 0x3F, 0xFF,
  0x3F, 0x7C, 0x7F, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0x1F, 0xFC, 0xFC, 0x1F,
  0x1F, 0xF8, 0xFC, 0x1F, 0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF9, 0xF8, 0x3F,
  0x1F, 0xF9, 0xF8, 0x3F, 0x1F, 0xF9, 0xF8, 0x3F, 0x1F, 0xF8, 0xF8, 0x3F,
  0x3F, 0xF8, 0xFC, 0x7F, 0x3E, 0xF8, 0xFF, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFC, 0x7F, 0xEF, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xC0, 0x1F, 0xFE, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3,
  0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xBF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFE, 0x3E, 0x3F, 0xF0, 0x0C, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x9F, 0xF8, 0x0E, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF3, 0xF0, 0xFF, 0xC0, 0x08, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB,
  0xFE, 0x01, 0xFC, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xE0,
  0x3F, 0xEF, 0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xDF, 0xFF, 0xFE, 0x07, 0xEF, 0xFF,
  0xDF, 0x83, 0xF7, 0xFF, 0xEF, 0xC1, 0xFB, 0xFF, 0xF7, 0xE0, 0xF9, 0xFF,
  0xFB, 0xF0, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E, 0x7F, 0xFE, 0x7E, 0x3E, 0x3F,
  0xFF, 0x3F, 0x3F, 0x1F, 0xFF, 0x8F, 0xDF, 0x8F, 0xFF, 0xC7, 0xEF, 0xC7,
  0xFF, 0xE3, 0xF7, 0xC3, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xF0,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0x03, 0xF8, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFB, 0xF8, 0x3F, 0xFF, 0x7F, 0x87, 0xFF, 0xE7, 0xF0, 0xFF, 0xFC, 0xFF,
  0x1F, 0xFF, 0x8F, 0xF3, 0xFF, 0xF1, 0xFE, 0x7F, 0xFE, 0x1F, 0xEF, 0xFF,
  0xC3, 0xFC, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0x07, 0xFB, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF8, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7,
  0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xF8,
  0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x9F, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0x87, 0xCF, 0xF0, 0x0C, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x7F,
  0x01, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x81, 0xFE, 0x7F, 0x01, 0xFF,
  0x81, 0xFC, 0x7F, 0x81, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0x81, 0xFC,
  0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0xC3, 0xF8, 0x3F, 0x83,
  0xFF, 0xC3, 0xF8, 0x1F, 0xC7, 0xEF, 0xC3, 0xF8, 0x1F, 0xC7, 0xEF, 0xC3,
  0xF8, 0x1F, 0xC7, 0xE7, 0xE7, 0xF8, 0x1F, 0xC7, 0xE7, 0xE7, 0xF0, 0x0F,
  0xE7, 0xE7, 0xE7, 0xF0, 0x0F, 0xEF, 0xC7, 0xE7, 0xF0, 0x0F, 0xEF, 0xC7,
  0xE7, 0xF0, 0x0F, 0xEF, 0xC3, 0xFF, 0xE0, 0x07, 0xEF, 0xC3, 0xFF, 0xE0,
  0x07, 0xEF, 0x83, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x07, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x80,
  0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0,
  0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3C, 0x1F, 0xE1, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xE1, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xFC, 0x7F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0x9F, 0xFC,
  0xFC, 0x3F, 0xC3, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x80, 0xFE, 0x7F, 0x87, 0xF7, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xCF, 0xFC, 0x7E, 0x3F, 0xC0, 0x00,
  0x10, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE7, 0xFC, 0x04, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x02, 0xFF, 0x80, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x20, 0xFF, 0x0F, 0xF3, 0xF8, 0xFF, 0xDF, 0xCF, 0xFE, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xF7, 0xF1, 0xFF, 0x3F, 0x87, 0xF0,
  0xFC, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFE, 0x1F, 0xDF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x13, 0xFE, 0x07,
  0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0x9F, 0xC7, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xBF, 0x8F, 0xF9, 0xFC, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFA, 0x00, 0x3F, 0xDF, 0x8F, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x80, 0xFE, 0x7F, 0xC7, 0xF7,
  0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x3E, 0x3F, 0x9F, 0xFF, 0xF7, 0xF3,
  0xF8, 0x70, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0,
  0x7F, 0x03, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x18, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xFB, 0xF8, 0x3F, 0xE7, 0xF0, 0xFF, 0x8F, 0xE1,
  0xFE, 0x1F, 0xC7, 0xF8, 0x3F, 0x9F, 0xE0, 0x7F, 0x7F, 0xC0, 0xFE, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xEF, 0xF8, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F, 0xF1,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xE7, 0xF0, 0x3F, 0xEF, 0xE0, 0x3F, 0xDF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x30, 0x3F, 0x1F,
  0xF0, 0xFF, 0x8F, 0xCF, 0xFE, 0x7F, 0xFB, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xC1, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8,
  0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF,
  0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFC, 0x00, 0x04, 0x07, 0xE3,
  0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x30, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xF8, 0xFF, 0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x07, 0xF9, 0xFF, 0x3F, 0xE7, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x04, 0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x7F, 0xE3, 0xF9,
  0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0x9F, 0xC7, 0xFE, 0xFE,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xBF, 0x8F,
  0xF9, 0xFC, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x05, 0xF8, 0x7F, 0xF3,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0xEF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0x19, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFB, 0xF3, 0xFF, 0x9F, 0x8F, 0xF0, 0xFC, 0xFF, 0x00, 0xFF, 0x7F,
  0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xE0, 0xFE, 0x7F,
  0x87, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0xE0, 0xFE, 0x3F, 0x87, 0xFE, 0x1F,
  0xE3, 0xF8, 0x7F, 0xF1, 0xFC, 0x3F, 0x87, 0xFF, 0x1F, 0xC1, 0xFC, 0xFF,
  0xF1, 0xFC, 0x1F, 0xCF, 0xDF, 0x1F, 0xC1, 0xFC, 0xF9, 0xF3, 0xF8, 0x1F,
  0xCF, 0x9F, 0xBF, 0x80, 0xFD, 0xF9, 0xFB, 0xF8, 0x0F, 0xDF, 0x9F, 0xBF,
  0x00, 0xFF, 0xF8, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F, 0xBF, 0x00, 0x7F, 0xF0,
  0xFB, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0xFF, 0x8F,
  0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFC, 0x0F, 0xF1,
  0xFE, 0x0F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0xC7, 0xFC, 0x1F, 0xF7, 0xFC,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC3, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x07,
  0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x17,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x7F, 0xE8, 0x00, 0x70,
};

const GFXglyph NotoSans_Black40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 29, 12, 2, -29 },
  { 30, 17, 11, 21, 2, -29 },
  { 54, 25, 29, 26, 1, -29 },
  { 145, 21, 32, 23, 1, -30 },
  { 229, 36, 29, 38, 1, -29 },
  { 360, 31, 29, 32, 1, -29 },
  { 473, 7, 11, 12, 2, -29 },
  { 483, 12, 35, 14, 1, -29 },
  { 536, 12, 35, 14, 1, -29 },
  { 589, 20, 19, 21, 1, -30 },
  { 637, 20, 20, 23, 2, -24 },
  { 687, 9, 12, 12, 1, -6 },
  { 701, 11, 6, 13, 1, -14 },
  { 710, 8, 7, 12, 2, -7 },
  { 717, 18, 29, 18, 0, -29 },
  { 783, 21, 29, 23, 1, -29 },
  { 860, 16, 29, 23, 2, -29 },
  { 918, 21, 29, 23, 1, -29 },
  { 995, 21, 29, 23, 1, -29 },
  { 1072, 22, 29, 23, 1, -29 },
  { 1152, 20, 29, 23, 2, -29 },
  { 1225, 21, 29, 23, 1, -29 },
  { 1302, 20, 29, 23, 2, -29 },
  { 1375, 21, 29, 23, 1, -29 },
  { 1452, 21, 29, 23, 1, -29 },
  { 1529, 8, 22, 12, 2, -22 },
  { 1551, 9, 28, 12, 1, -22 },
  { 1583, 20, 22, 23, 2, -25 },
  { 1638, 20, 14, 23, 2, -21 },
  { 1673, 20, 22, 23, 2, -25 },
  { 1728, 19, 29, 20, 0, -29 },
  { 1797, 32, 32, 36, 2, -29 },
  { 1925, 29, 29, 29, 0, -29 },
  { 2031, 22, 29, 27, 3, -29 },
  { 2111, 23, 29, 26, 2, -29 },
  { 2195, 24, 29, 29, 3, -29 },
  { 2282, 17, 29, 22, 3, -29 },
  { 2344, 17, 29, 22, 3, -29 },
  { 2406, 25, 29, 30, 2, -29 },
  { 2497, 25, 29, 31, 3, -29 },
  { 2588, 15, 29, 18, 1, -29 },
  { 2643, 14, 38, 14, -3, -29 },
  { 2710, 25, 29, 27, 3, -29 },
  { 2801, 19, 29, 23, 3, -29 },
  { 2870, 33, 29, 39, 3, -29 },
  { 2990, 27, 29, 33, 3, -29 },
  { 3088, 28, 29, 32, 2, -29 },
  { 3190, 21, 29, 25, 3, -29 },
  { 3267, 29, 36, 32, 2, -29 },
  { 3398, 25, 29, 27, 3, -29 },
  { 3489, 20, 29, 23, 2, -29 },
  { 3562, 22, 29, 24, 1, -29 },
  { 3642, 24, 29, 30, 3, -29 },
  { 3729, 28, 29, 28, 0, -29 },
  { 3831, 40, 29, 42, 1, -29 },
  { 3976, 29, 29, 29, 0, -29 },
  { 4082, 27, 29, 27, 0, -29 },
  { 4180, 22, 29, 24, 1, -29 },
  { 4260, 10, 36, 13, 2, -29 },
  { 4305, 18, 29, 18, 0, -29 },
  { 4371, 10, 36, 13, 1, -29 },
  { 4416, 22, 19, 21, 0, -29 },
  { 4469, 20, 4, 20, 0, 3 },
  { 4479, 13, 7, 17, 2, -31 },
  { 4491, 21, 23, 25, 1, -23 },
  { 4552, 21, 30, 26, 3, -30 },
  { 4631, 19, 23, 22, 2, -23 },
  { 4686, 21, 30, 26, 2, -30 },
  { 4765, 21, 23, 25, 2, -23 },
  { 4826, 17, 31, 17, 1, -31 },
  { 4892, 21, 33, 26, 2, -23 },
  { 4979, 21, 30, 27, 3, -30 },
  { 5058, 9, 31, 13, 2, -31 },
  { 5093, 13, 41, 13, -2, -31 },
  { 5160, 23, 30, 26, 3, -30 },
  { 5247, 7, 30, 13, 3, -30 },
  { 5274, 34, 23, 40, 3, -23 },
  { 5372, 21, 23, 27, 3, -23 },
  { 5433, 22, 23, 25, 2, -23 },
  { 5497, 21, 33, 26, 3, -23 },
  { 5584, 21, 33, 26, 2, -23 },
  { 5671, 15, 23, 19, 3, -23 },
  { 5715, 17, 23, 21, 2, -23 },
  { 5764, 16, 27, 18, 1, -27 },
  { 5818, 21, 22, 27, 3, -22 },
  { 5876, 24, 22, 24, 0, -22 },
  { 5942, 36, 22, 36, 0, -22 },
  { 6041, 25, 22, 25, 0, -22 },
  { 6110, 24, 32, 24, 0, -22 },
  { 6206, 18, 22, 20, 1, -22 },
  { 6256, 15, 36, 17, 1, -29 },
  { 6324, 5, 39, 20, 8, -30 },
  { 6349, 15, 36, 17, 1, -29 },
  { 6417, 20, 8, 23, 2, -18 },
};

const GFXfont NotoSans_Black40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black40pt7bBitmaps,
  (GFXglyph *)NotoSans_Black40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_BLACK40PT7B_H_
