#ifndef _NOTOSANS_BLACK61PT7B_H_
#define _NOTOSANS_BLACK61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-Black.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Black61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0xFF, 0xE7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xCF, 0xFC, 0x3F,
  0xC0, 0x70, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xDF, 0xF8,
  0xFF, 0xC7, 0xC0, 0xF0, 0xFF, 0x87, 0xC0, 0x10, 0xFF, 0x87, 0xC0, 0x00,
  0xFF, 0xC7, 0xC0, 0x00, 0xFF, 0xE7, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xCF, 0xFF,
  0x00, 0x07, 0xC7, 0xFF, 0x00, 0x07, 0xC3, 0xFF, 0x40, 0x07, 0xC3, 0xFF,
  0x78, 0x07, 0xC7, 0xFF, 0x7F, 0xC7, 0xDF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC1, 0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x7F, 0xC7, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xFE, 0x3F, 0xF7, 0xFE, 0x07,
  0xFF, 0x83, 0xFC, 0x3F, 0xE3, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x3F, 0xE3,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x03, 0xF8, 0x02, 0x7C,
  0x0F, 0xE0, 0x7D, 0xFF, 0x3F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xCF, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x03, 0xFC, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x7F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F, 0xF0, 0x0F,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F,
  0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x1F,
  0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xBF, 0xFC, 0x7F, 0xCF,
  0xFF, 0x0F, 0xE3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0x78, 0x3F, 0xFC, 0x08,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF0, 0x1F, 0xFF, 0x0F, 0xE0, 0x1F, 0xFF, 0x07, 0x80, 0x0F, 0xFF,
  0x03, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xF8, 0x3C, 0x00, 0xFF, 0xF0, 0x20,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xE0,
  0x0F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x20, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x20, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x08, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x7F,
  0xE3, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xFE, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFE, 0x7F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFE, 0x7F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF,
  0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF7, 0xFE, 0x0F,
  0xFF, 0xE7, 0xFE, 0x07, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x87, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x3F, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFC, 0x0E, 0x00, 0x0F, 0xC1, 0xFF, 0x9F,
  0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xF9, 0xFF,
  0x83, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0xC2, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF,
  0xFC, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x07, 0xFF,
  0xFF, 0xC7, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0xF1, 0xFF, 0x0F, 0xF7, 0xFC, 0x3F,
  0xF0, 0x3F, 0xC3, 0xFD, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x7F, 0x87,
  0xFC, 0x07, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF7, 0xF8,
  0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF,
  0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xFF, 0xE3, 0xFE, 0x01, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xE0, 0xFE,
  0x7F, 0x87, 0xF8, 0x0F, 0xF8, 0x7F, 0x9F, 0xE1, 0xFF, 0x07, 0xFF, 0x1F,
  0xE7, 0xF8, 0x7F, 0xF7, 0xFF, 0xFF, 0xF1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xDF,
  0xFC, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xFB,
  0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x7F, 0xE0,
  0x7F, 0xFE, 0x00, 0x7C, 0x1F, 0xFF, 0x80, 0x01, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x87, 0xFF, 0xE0, 0x00, 0x70, 0xFF, 0xFF, 0x00,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xF1,
  0xFF, 0xC0, 0x0F, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFE, 0xFF,
  0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00,
  0x3F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFF, 0x7F,
  0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0x7F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFB,
  0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x3C, 0x0F, 0xFF, 0xC0, 0x00, 0x10, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xF0, 0x00, 0x7F,
  0xF7, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0xFF, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xFE, 0x03, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xF8,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0xFF, 0xF8, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xFC,
  0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x8F, 0xFF,
  0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x1F,
  0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xFB, 0xFF, 0xFF,
  0xDF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0xFF,
  0xF7, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0x8F, 0xFF,
  0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xE7, 0xFF,
  0xFF, 0xC7, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F,
  0xFF, 0xFC, 0x3F, 0xF3, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFB, 0xFE, 0x1F,
  0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xBF, 0xFC, 0x03,
  0xFF, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xFF,
  0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0x87,
  0xFF, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0xFF, 0xFE, 0x01, 0xFF, 0xEF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00,
  0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00,
  0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xD0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC7,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xCF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x03, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFF,
  0x3F, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xCF,
  0xFF, 0x00, 0x1E, 0x3F, 0xFC, 0x00, 0x18, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00,
  0xFF, 0xF9, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF9,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFD, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x7F,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x7F, 0xC3,
  0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFF,
  0x00, 0x1F, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0xE7, 0xFE,
  0x1F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xFC, 0x00,
  0x1F, 0xF9, 0xFF, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x1F,
  0xF7, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x7F, 0xF9, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0xFF,
  0xF9, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xEF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00,
  0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07,
  0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x1F, 0xFF, 0x01, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x07, 0xFF,
  0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x9F,
  0xFF, 0xC1, 0xFF, 0xDF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xE0, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFD, 0xFF,
  0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xBF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x07, 0xFF, 0xBF, 0xFC, 0x03, 0xFF,
  0xDF, 0xFF, 0x03, 0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF,
  0xFE, 0x0F, 0xFC, 0x3F, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0,
  0x78, 0xFF, 0xF8, 0x00, 0x8F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x06, 0x7F, 0xFC, 0x01, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x0F,
  0xFE, 0x7F, 0xF8, 0x07, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0C, 0x7F, 0xFE, 0x00, 0x7C, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF,
  0xE7, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1C,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x40, 0x00,
  0x0F, 0xFF, 0x78, 0x00, 0x3F, 0xFF, 0x7F, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0x9F, 0xFF, 0xE1,
  0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x3F, 0xC7, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F,
  0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0xFF, 0xF8,
  0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF,
  0xCF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x3F, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC1, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xBF,
  0xFE, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFF, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0xFC, 0x1F, 0xFD, 0xFF, 0xFF, 0x0F,
  0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFF,
  0xBF, 0xFE, 0x07, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x80,
  0x7F, 0xFB, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xFC,
  0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F,
  0xF8, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF,
  0xE7, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1C,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1E, 0x3F, 0xF8, 0x01,
  0x8F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xC7,
  0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0x83, 0xFD, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xF7, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xDF, 0xF0, 0xFF, 0xC0, 0x7F,
  0xF1, 0xFF, 0x7F, 0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0xFF, 0x1F, 0xFC,
  0x03, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0x8F, 0xF9,
  0xFF, 0x80, 0x3F, 0xF9, 0xFE, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xEF, 0xF8,
  0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xBF, 0xE1, 0xFE, 0x7F, 0xE0, 0x07, 0xFE,
  0xFF, 0x07, 0xFB, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x03,
  0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xFB, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xDF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x80,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC,
  0x7F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xA0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x04, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFB, 0x00, 0x0F, 0xFF, 0xC8, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph NotoSans_Black61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 13, 45, 18, 2, -44 },
  { 75, 24, 16, 32, 4, -44 },
  { 123, 38, 44, 40, 1, -44 },
  { 332, 32, 50, 35, 2, -46 },
  { 532, 56, 44, 58, 1, -44 },
  { 840, 47, 45, 49, 2, -44 },
  { 1105, 10, 16, 18, 4, -44 },
  { 1125, 18, 55, 22, 2, -45 },
  { 1249, 18, 55, 22, 2, -45 },
  { 1373, 30, 29, 33, 1, -46 },
  { 1482, 30, 29, 36, 3, -36 },
  { 1591, 13, 17, 19, 2, -9 },
  { 1619, 17, 9, 19, 1, -21 },
  { 1639, 12, 12, 18, 3, -11 },
  { 1657, 27, 45, 27, 0, -44 },
  { 1809, 32, 45, 36, 2, -44 },
  { 1989, 26, 44, 36, 2, -44 },
  { 2132, 32, 44, 36, 1, -44 },
  { 2308, 31, 45, 36, 2, -44 },
  { 2483, 34, 44, 36, 1, -44 },
  { 2670, 30, 45, 36, 3, -44 },
  { 2839, 32, 45, 36, 2, -44 },
  { 3019, 32, 44, 36, 2, -44 },
  { 3195, 32, 45, 36, 2, -44 },
  { 3375, 32, 45, 36, 2, -44 },
  { 3555, 12, 35, 18, 3, -34 },
  { 3608, 13, 42, 18, 2, -34 },
  { 3677, 30, 34, 36, 3, -39 },
  { 3805, 30, 21, 36, 3, -32 },
  { 3884, 30, 34, 36, 3, -39 },
  { 4012, 30, 45, 31, 0, -44 },
  { 4181, 50, 49, 55, 2, -44 },
  { 4488, 44, 44, 44, 0, -44 },
  { 4730, 33, 44, 41, 5, -44 },
  { 4912, 35, 45, 40, 3, -44 },
  { 5109, 37, 44, 45, 5, -44 },
  { 5313, 26, 44, 33, 5, -44 },
  { 5456, 25, 44, 33, 5, -44 },
  { 5594, 38, 45, 45, 3, -44 },
  { 5808, 37, 44, 47, 5, -44 },
  { 6012, 23, 44, 27, 2, -44 },
  { 6139, 22, 58, 21, -5, -44 },
  { 6299, 37, 44, 42, 5, -44 },
  { 6503, 28, 44, 36, 5, -44 },
  { 6657, 49, 44, 59, 5, -44 },
  { 6927, 41, 44, 51, 5, -44 },
  { 7153, 42, 45, 49, 3, -44 },
  { 7390, 31, 44, 39, 5, -44 },
  { 7561, 44, 54, 49, 3, -44 },
  { 7858, 37, 44, 41, 5, -44 },
  { 8062, 30, 45, 35, 3, -44 },
  { 8231, 33, 44, 36, 2, -44 },
  { 8413, 38, 45, 46, 4, -44 },
  { 8627, 42, 44, 42, 0, -44 },
  { 8858, 61, 44, 63, 1, -44 },
  { 9194, 44, 44, 44, 0, -44 },
  { 9436, 41, 44, 41, 0, -44 },
  { 9662, 34, 44, 37, 2, -44 },
  { 9849, 15, 55, 20, 3, -45 },
  { 9953, 27, 45, 27, 0, -44 },
  { 10105, 15, 55, 20, 1, -45 },
  { 10209, 33, 29, 32, 0, -44 },
  { 10329, 31, 7, 31, 0, 4 },
  { 10357, 21, 10, 26, 2, -47 },
  { 10384, 32, 35, 38, 2, -34 },
  { 10524, 33, 47, 39, 4, -46 },
  { 10718, 28, 35, 33, 3, -34 },
  { 10841, 32, 47, 39, 3, -46 },
  { 11029, 32, 35, 38, 3, -34 },
  { 11169, 26, 47, 25, 1, -47 },
  { 11322, 32, 49, 39, 3, -34 },
  { 11518, 33, 46, 41, 4, -46 },
  { 11708, 12, 47, 20, 4, -47 },
  { 11779, 19, 62, 20, -3, -47 },
  { 11927, 36, 46, 40, 4, -46 },
  { 12134, 12, 46, 20, 4, -46 },
  { 12203, 53, 34, 61, 4, -34 },
  { 12429, 33, 34, 41, 4, -34 },
  { 12570, 33, 35, 39, 3, -34 },
  { 12715, 33, 49, 39, 4, -34 },
  { 12918, 32, 49, 39, 3, -34 },
  { 13114, 24, 34, 29, 4, -34 },
  { 13216, 26, 35, 32, 3, -34 },
  { 13330, 24, 42, 28, 2, -41 },
  { 13456, 33, 35, 41, 4, -34 },
  { 13601, 37, 34, 37, 0, -34 },
  { 13759, 54, 34, 56, 1, -34 },
  { 13989, 38, 34, 38, 0, -34 },
  { 14151, 37, 49, 37, 0, -34 },
  { 14378, 28, 34, 31, 1, -34 },
  { 14497, 22, 54, 26, 2, -44 },
  { 14646, 8, 59, 31, 12, -46 },
  { 14705, 23, 54, 26, 2, -44 },
  { 14861, 30, 11, 36, 3, -27 },
};

const GFXfont NotoSans_Black61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Black61pt7bBitmaps,
  (GFXglyph *)NotoSans_Black61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_BLACK61PT7B_H_
