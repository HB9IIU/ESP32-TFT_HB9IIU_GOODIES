#ifndef _NOTOSANS_SEMICONDENSED_BLACK31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x80, 0x00, 0x00, 0xFB, 0xF7, 0xEF, 0xCF, 0x80, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x1F, 0x07, 0x8F, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xC7, 0x87, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0xF3, 0xC0, 0x38, 0xF0,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1E, 0x78, 0x0F,
  0x1E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF,
  0x7D, 0xC4, 0xFB, 0x81, 0xF7, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xBF, 0x07, 0x7F, 0xCE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x0F, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x3F, 0x00, 0xF8, 0x0F, 0xF0, 0x1E, 0x03, 0xFF, 0x07, 0x80, 0x79, 0xE0,
  0xF0, 0x0F, 0x3C, 0x3C, 0x01, 0xE7, 0x87, 0x80, 0x3C, 0xF1, 0xE0, 0x07,
  0x9E, 0x3C, 0x00, 0xF3, 0xCF, 0x0C, 0x1E, 0x79, 0xE7, 0xE3, 0xFF, 0x79,
  0xFE, 0x3F, 0xCF, 0x7F, 0xE3, 0xF3, 0xCF, 0x3C, 0x00, 0x79, 0xE7, 0x80,
  0x1E, 0x3C, 0xF0, 0x03, 0xC7, 0x9F, 0x00, 0xF0, 0xF3, 0xC0, 0x1E, 0x1E,
  0x78, 0x07, 0x83, 0xEF, 0x00, 0xF0, 0x3F, 0xE0, 0x3C, 0x07, 0xF8, 0x0F,
  0x80, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xDF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x1F, 0x8F, 0xFC, 0x7E,
  0x7F, 0xFB, 0xF3, 0xF7, 0xFF, 0xCF, 0xCF, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC,
  0x3F, 0xC3, 0xF9, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7F, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xC7, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xFC, 0x7C, 0xF8,
  0xF3, 0xC0, 0x84, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7E, 0xF9,
  0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xEF,
  0xCF, 0x8F, 0xBF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0x7C, 0x7C, 0xFD,
  0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0xC1, 0xFE, 0x3F, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xBF, 0x39, 0xF8,
  0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xE0, 0xFF,
  0xF3, 0xFF, 0xF7, 0xFF, 0xE7, 0xDF, 0xC6, 0x0F, 0x88, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE3, 0x9F,
  0xC4, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xE3,
  0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0x40, 0x7F, 0xF0, 0xFF, 0xF1,
  0xFF, 0xF3, 0xFF, 0xE2, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0xF3, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3E, 0x70, 0xFB, 0xF9, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xC7, 0xFF,
  0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7E, 0xFD, 0xFD, 0xFF, 0xF1, 0xFF,
  0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xEF, 0x8F, 0xDF, 0x1F,
  0x3F, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x81, 0xFF, 0xC7, 0xFF, 0xCF,
  0xDF, 0xBF, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xFF, 0xFB, 0xFF,
  0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF,
  0xEF, 0xCF, 0xDF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFB, 0xE7, 0xF7, 0xC1, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x87, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0x7C,
  0x7C, 0xFB, 0xFB, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0x9F, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0xFE, 0x0F, 0xFC, 0x7F, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x40, 0x00, 0x3F, 0xE3, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x78,
  0xFC, 0x81, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x1E, 0x00, 0x3E, 0x3C, 0x1F,
  0x1E, 0x7C, 0x7F, 0xCF, 0x78, 0xFF, 0xCF, 0x79, 0xF3, 0xCF, 0xF3, 0xE3,
  0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3,
  0xCF, 0xF3, 0xC7, 0xCE, 0xF1, 0xFF, 0xFE, 0x79, 0xFF, 0xFC, 0x78, 0xFC,
  0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0,
  0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xEF,
  0xE0, 0x3F, 0x7E, 0x01, 0xFC, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF0, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3, 0xFD, 0xE3,
  0xF8, 0x11, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x01, 0x1F, 0xEF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xC7, 0x9F, 0xC0, 0x27, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0x7C,
  0x3F, 0xDF, 0x8F, 0xF7, 0xE0, 0x7D, 0xF8, 0x1F, 0x7F, 0x07, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0x07,
  0xEF, 0xC3, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3,
  0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC3, 0xF3, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xFE, 0xFC, 0x1F, 0xBF, 0x07, 0xF0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xDF, 0xFB, 0xC3,
  0xDF, 0xFB, 0xE3, 0xDF, 0xFB, 0xE7, 0xDF, 0xF9, 0xE7, 0x9F, 0xF9, 0xE7,
  0x9F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF,
  0x1F, 0xF8, 0xFF, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFB, 0xF3, 0xFF, 0xBF, 0x3F, 0xF9, 0xFB, 0xFF, 0x9F, 0x9F, 0xF8, 0xFD,
  0xFF, 0x8F, 0xDF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x9F, 0xE7,
  0xF0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xE0, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF9,
  0xFE, 0x3F, 0x83, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x7F, 0x07, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFC, 0xFE, 0x3F, 0x1F,
  0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07,
  0xF0, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xE7, 0x9F, 0x81,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x7D, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xF0,
  0x3E, 0xFE, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F,
  0x0F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x0F,
  0xC0, 0xFB, 0xE0, 0x7E, 0x0F, 0xDF, 0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x83,
  0xF7, 0xE1, 0xFC, 0x1F, 0x1F, 0x0F, 0xF0, 0xF8, 0xF8, 0x7F, 0x8F, 0xC7,
  0xC3, 0xFC, 0x7E, 0x3F, 0x3F, 0xE3, 0xE0, 0xF9, 0xFF, 0x1F, 0x07, 0xCF,
  0x7C, 0xF8, 0x3E, 0x7B, 0xEF, 0xC1, 0xF3, 0xCF, 0x7C, 0x0F, 0xFE, 0x7B,
  0xE0, 0x3F, 0xF3, 0xDF, 0x01, 0xFF, 0x1E, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x3F,
  0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x9F,
  0x81, 0xF9, 0xF8, 0x3F, 0x0F, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xE0,
  0x7F, 0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x3E, 0x3E, 0x07, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3C, 0xF0, 0x1E, 0x7C, 0x1F,
  0x1E, 0x0F, 0x0F, 0x8F, 0x83, 0xC7, 0x81, 0xF7, 0xC0, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xF0, 0x3E, 0x07,
  0xC0, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF1, 0x07, 0xE0, 0x0F,
  0xC3, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xDF, 0x3F, 0x1E, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xFC,
  0xFB, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBE, 0xFE, 0x7C, 0xF8, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFE, 0x7E, 0x13, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x01, 0x7F, 0x39, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x1F, 0xBF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x4F, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0x81, 0xFF, 0x3F,
  0xE3, 0xFE, 0x3F, 0xE3, 0xE0, 0x3E, 0x07, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x9F, 0x3F, 0xDF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x60, 0x7E,
  0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xFC, 0xFB,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x7B, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xDF, 0xEF, 0xF7, 0xF3, 0xF0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x7E, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x3F, 0x1F, 0x3F, 0x0F,
  0xBF, 0x07, 0xDF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC,
  0x3F, 0x3F, 0x1F, 0x1F, 0x8F, 0x87, 0xE7, 0xC3, 0xF3, 0xE0, 0xFD, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0xFE, 0x7F, 0xFE, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF3, 0xFF, 0xE3, 0xF8, 0xFF, 0xF1,
  0xF8, 0x7F, 0xF8, 0x7C, 0x3F, 0xF8, 0x3E, 0x1F, 0xFC, 0x1F, 0x0F, 0xFE,
  0x0F, 0x87, 0xFF, 0x07, 0xC3, 0xFF, 0x83, 0xE1, 0xFF, 0xC1, 0xF0, 0xFF,
  0xE0, 0xF8, 0x7F, 0xF0, 0x7C, 0x3F, 0xF8, 0x3E, 0x1F, 0x80, 0xF1, 0xF9,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0xF9, 0xF9, 0xF7, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFC, 0xF9, 0xF1,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x1F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E, 0x7F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xBF, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x00, 0x3F, 0xE3, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0x82, 0x7F, 0x03, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFB,
  0xFF, 0xDF, 0xFC, 0xFF, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0x27, 0xFC, 0xFF, 0x8F, 0xF0, 0xFE, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xEF, 0x3F, 0x1E, 0xFC, 0x0F, 0xDF, 0x07, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x7E, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x0F,
  0xDF, 0x0F, 0xE3, 0xF7, 0xC7, 0xF8, 0xF9, 0xF9, 0xFE, 0x3E, 0x7E, 0x7F,
  0x8F, 0x8F, 0x9F, 0xE7, 0xE3, 0xE7, 0xFD, 0xF0, 0xFB, 0xEF, 0x7C, 0x3E,
  0xF3, 0xDF, 0x07, 0xFC, 0xF7, 0xC1, 0xFF, 0x3D, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x9F, 0x8F, 0xE3, 0xF3, 0xF0,
  0xFD, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF1, 0xF8, 0x7E, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xDF, 0x07,
  0xE7, 0xE1, 0xF9, 0xF8, 0x7C, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x7F, 0x8F, 0xE1,
  0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xE0, 0xFF, 0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0xF0, 0xFE, 0x07, 0xC3, 0xF8, 0xFF, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x87, 0xF0, 0xFE, 0x1F, 0x83,
  0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Black31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 22, 9, 1, -22 },
  { 21, 12, 8, 16, 2, -22 },
  { 33, 18, 22, 19, 1, -22 },
  { 83, 15, 26, 17, 1, -24 },
  { 132, 27, 22, 28, 1, -22 },
  { 207, 22, 22, 23, 1, -22 },
  { 268, 5, 8, 9, 2, -22 },
  { 273, 9, 28, 11, 1, -23 },
  { 305, 9, 28, 11, 1, -23 },
  { 337, 14, 15, 16, 1, -24 },
  { 364, 15, 16, 17, 1, -19 },
  { 394, 7, 9, 9, 1, -5 },
  { 402, 8, 5, 10, 1, -11 },
  { 407, 6, 5, 9, 1, -5 },
  { 411, 13, 22, 14, 0, -22 },
  { 447, 15, 22, 17, 1, -22 },
  { 489, 13, 22, 17, 1, -22 },
  { 525, 15, 22, 17, 1, -22 },
  { 567, 15, 22, 17, 1, -22 },
  { 609, 16, 22, 17, 1, -22 },
  { 653, 15, 22, 17, 1, -22 },
  { 695, 15, 22, 17, 1, -22 },
  { 737, 15, 22, 17, 1, -22 },
  { 779, 15, 22, 17, 1, -22 },
  { 821, 15, 22, 17, 1, -22 },
  { 863, 6, 17, 9, 1, -17 },
  { 876, 7, 21, 9, 1, -17 },
  { 895, 15, 16, 17, 1, -19 },
  { 925, 15, 11, 17, 1, -16 },
  { 946, 15, 16, 17, 1, -19 },
  { 976, 14, 22, 14, 0, -22 },
  { 1015, 24, 24, 26, 1, -22 },
  { 1087, 21, 22, 21, 0, -22 },
  { 1145, 16, 22, 20, 2, -22 },
  { 1189, 17, 22, 19, 1, -22 },
  { 1236, 18, 22, 21, 2, -22 },
  { 1286, 12, 22, 16, 2, -22 },
  { 1319, 12, 22, 16, 2, -22 },
  { 1352, 18, 22, 21, 1, -22 },
  { 1402, 18, 22, 22, 2, -22 },
  { 1452, 11, 22, 13, 1, -22 },
  { 1483, 10, 29, 10, -2, -22 },
  { 1520, 18, 22, 20, 2, -22 },
  { 1570, 13, 22, 16, 2, -22 },
  { 1606, 24, 22, 28, 2, -22 },
  { 1672, 20, 22, 24, 2, -22 },
  { 1727, 20, 22, 23, 1, -22 },
  { 1782, 15, 22, 18, 2, -22 },
  { 1824, 21, 27, 23, 1, -22 },
  { 1895, 18, 22, 20, 2, -22 },
  { 1945, 15, 22, 16, 1, -22 },
  { 1987, 15, 22, 17, 1, -22 },
  { 2029, 18, 22, 22, 2, -22 },
  { 2079, 20, 22, 20, 0, -22 },
  { 2134, 29, 22, 30, 0, -22 },
  { 2214, 20, 22, 20, 0, -22 },
  { 2269, 19, 22, 19, 0, -22 },
  { 2322, 16, 22, 17, 1, -22 },
  { 2366, 7, 28, 10, 2, -23 },
  { 2391, 13, 22, 14, 0, -22 },
  { 2427, 7, 28, 10, 1, -23 },
  { 2452, 17, 14, 16, 0, -22 },
  { 2482, 16, 4, 16, 0, 2 },
  { 2490, 10, 5, 12, 1, -24 },
  { 2497, 15, 17, 18, 1, -17 },
  { 2529, 15, 24, 19, 2, -24 },
  { 2574, 14, 17, 16, 1, -17 },
  { 2604, 16, 24, 19, 1, -24 },
  { 2652, 15, 17, 18, 1, -17 },
  { 2684, 12, 24, 12, 1, -24 },
  { 2720, 16, 24, 19, 1, -17 },
  { 2768, 15, 24, 19, 2, -24 },
  { 2813, 6, 24, 9, 2, -24 },
  { 2831, 9, 31, 9, -1, -24 },
  { 2866, 17, 24, 19, 2, -24 },
  { 2917, 5, 24, 9, 2, -24 },
  { 2932, 25, 17, 29, 2, -17 },
  { 2986, 15, 17, 19, 2, -17 },
  { 3018, 16, 17, 18, 1, -17 },
  { 3052, 15, 24, 19, 2, -17 },
  { 3097, 16, 24, 19, 1, -17 },
  { 3145, 11, 17, 13, 2, -17 },
  { 3169, 13, 17, 15, 1, -17 },
  { 3197, 11, 21, 13, 1, -21 },
  { 3226, 15, 17, 19, 2, -17 },
  { 3258, 18, 17, 18, 0, -17 },
  { 3297, 26, 17, 26, 0, -17 },
  { 3353, 18, 17, 18, 0, -17 },
  { 3392, 18, 24, 18, 0, -17 },
  { 3446, 13, 17, 14, 1, -17 },
  { 3474, 11, 27, 13, 1, -22 },
  { 3512, 4, 31, 15, 5, -24 },
  { 3528, 11, 27, 13, 1, -22 },
  { 3566, 15, 6, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Black31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK31PT7B_H_
