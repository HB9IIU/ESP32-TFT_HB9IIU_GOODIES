#ifndef _NOTOSANS_SEMICONDENSED_BLACK22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x6F, 0xFF, 0xF7, 0xFB, 0xFD,
  0xFE, 0xFF, 0x3B, 0x9C, 0x06, 0x70, 0x73, 0x83, 0x98, 0x1D, 0xC7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xE3, 0x9C, 0x1C, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0x9C, 0x1C, 0xC0, 0xE6, 0x07, 0x70, 0x0C, 0x03, 0x03, 0xFB, 0xFF, 0xFF,
  0xBB, 0x2E, 0xC3, 0xF0, 0x7F, 0x0F, 0xF0, 0xFC, 0x37, 0x8D, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0C, 0x03, 0x00, 0x3C, 0x0E, 0x07, 0xE0, 0xE0, 0x7F, 0x1C,
  0x07, 0x71, 0xC0, 0xF7, 0x38, 0x0F, 0x73, 0x80, 0x77, 0x73, 0x87, 0xF7,
  0x7C, 0x7E, 0xEF, 0xE1, 0xCE, 0xEE, 0x01, 0xCE, 0xE0, 0x1C, 0xEF, 0x03,
  0x8E, 0xE0, 0x38, 0xEE, 0x07, 0x07, 0xE0, 0x70, 0x3C, 0x1F, 0x00, 0x7F,
  0x81, 0xFF, 0x03, 0xCE, 0x07, 0x9C, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0x9F,
  0x7F, 0x3D, 0xFF, 0x7B, 0xDF, 0xF7, 0x9F, 0xCF, 0x1F, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x9F, 0xFF, 0xFF, 0xF7, 0x3C, 0xE7, 0x9C, 0x73, 0xCF, 0x3C,
  0xE3, 0x8E, 0x3C, 0xF3, 0xCF, 0x1C, 0x78, 0xE3, 0xC0, 0xF0, 0xF0, 0xE1,
  0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C,
  0x73, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x37, 0x77, 0xFF, 0xFF, 0xC7, 0xC0,
  0xFC, 0x7B, 0xC7, 0x30, 0x24, 0x00, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF,
  0xFF, 0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x7F, 0xFE, 0xEE, 0xFF,
  0xFF, 0xFF, 0x6F, 0xFF, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0x1E, 0x1F, 0xE7, 0xFB, 0xEF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xDF, 0xF7, 0xF8, 0xFC, 0x07, 0x87, 0xC7, 0xEF,
  0xFF, 0xFF, 0xBD, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x1F, 0x07, 0xFB, 0xFF, 0xBF, 0xF2, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xFF, 0xDF, 0xFB, 0xFF,
  0x3F, 0x3F, 0xEF, 0xFD, 0x9F, 0x03, 0xC0, 0xE3, 0xF8, 0xF8, 0x3F, 0x8F,
  0xF0, 0x3C, 0x0F, 0x87, 0xFF, 0xFF, 0xFB, 0xFC, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xBC, 0x7B, 0xC7, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x70, 0x3C, 0x0F, 0xF3, 0xFE, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x87,
  0xFF, 0xFF, 0xFB, 0xFC, 0x0F, 0xCF, 0xF3, 0xFD, 0xF0, 0xF0, 0x3C, 0x0E,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F, 0xCF, 0xF3, 0xDF, 0xF7, 0xF8, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0x1F, 0x1F, 0xEF, 0xFF,
  0xCF, 0xF3, 0xFE, 0xF7, 0xF8, 0xFC, 0x7F, 0xBF, 0xFF, 0x3F, 0x87, 0xF1,
  0xFF, 0xF7, 0xFC, 0xFC, 0x1E, 0x1F, 0xEF, 0xFB, 0xDF, 0xF3, 0xFC, 0xFF,
  0x3F, 0xDF, 0xFF, 0xDF, 0x73, 0x9C, 0x0F, 0x07, 0x9F, 0xE7, 0xF1, 0xF0,
  0xFF, 0xF6, 0x00, 0x00, 0x6F, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x07, 0xFF,
  0xEE, 0xE0, 0x00, 0x40, 0x30, 0x3C, 0x3F, 0x3F, 0x3F, 0x0F, 0x81, 0xF8,
  0x1F, 0xC1, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0x3F, 0x81, 0xF0, 0x7C,
  0x7F, 0xFE, 0x3E, 0x0E, 0x02, 0x00, 0x3F, 0x3F, 0xEF, 0xFD, 0xCF, 0x03,
  0xC0, 0xF0, 0xF8, 0x7C, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83,
  0xE0, 0x70, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x8F, 0x87, 0x01, 0xE7, 0x1F,
  0x73, 0x3F, 0xDF, 0x9C, 0xEF, 0xDC, 0x67, 0xEE, 0x33, 0xF7, 0x39, 0xFB,
  0x9C, 0xDD, 0xFF, 0xEE, 0x7D, 0xE3, 0x80, 0x01, 0xE0, 0x10, 0x7F, 0xF0,
  0x1F, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x77,
  0x01, 0xEE, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x3C, 0x70, 0x78, 0xF0,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0x07, 0xBE, 0x0F, 0x7C, 0x1F, 0xFE,
  0x1F, 0xF3, 0xFF, 0x7B, 0xFF, 0x3F, 0xE7, 0xBF, 0xF7, 0xFC, 0xFF, 0xDE,
  0x7F, 0xC7, 0xF8, 0xFF, 0x3F, 0xFF, 0xBF, 0xF7, 0xF8, 0x0F, 0xC1, 0xFF,
  0x3F, 0xE7, 0xEE, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x67, 0xFE, 0x3F, 0xE1, 0xFE, 0xFE, 0x0F, 0xF8,
  0xFF, 0xCF, 0xFE, 0xF1, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xFF, 0x1E, 0xF7, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0xFC, 0xE7,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x7F, 0xF3, 0xFF, 0x9F, 0xFE, 0x1F, 0xF0,
  0xF7, 0xC7, 0xBF, 0xFC, 0xFF, 0xE1, 0xFE, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFB, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xDF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x1F, 0x9E, 0xFE, 0xFC, 0xF8, 0xF0, 0xFF, 0x1E, 0xF3, 0xEF, 0x3C,
  0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xF7, 0x8F, 0x7C,
  0xF3, 0xCF, 0x3E, 0xF1, 0xEF, 0x1F, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xEE, 0x77, 0xEE, 0x77, 0xEE, 0x77, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xF8, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x1F, 0xBC, 0xFD, 0xE7, 0xE7, 0xBF, 0x3D,
  0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0x0F, 0xC0,
  0xFF, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF,
  0x03, 0xF8, 0xFE, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xFF,
  0xFF, 0xBF, 0xEF, 0xE3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x0F, 0xC0,
  0xFF, 0xC3, 0xFF, 0x9F, 0x3E, 0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0x7C, 0xF9, 0xFF, 0xE3, 0xFF,
  0x03, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0xFE, 0x0F, 0xF8,
  0xFF, 0xCF, 0x7C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xF7, 0x8F, 0x78, 0xF3, 0xCF, 0x3E, 0xF1, 0xEF, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xEE, 0xF0, 0x3E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x0F,
  0xC7, 0xFF, 0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1E, 0xF0, 0xF7, 0xCF,
  0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0xF8, 0x3F, 0xE1, 0xF7, 0x87, 0xDE, 0x1E,
  0x7C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0xF0, 0x70, 0x7F,
  0x87, 0xC3, 0xDE, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F, 0x3C, 0x7C,
  0x78, 0xE7, 0x73, 0x87, 0xBB, 0xBC, 0x3D, 0xDD, 0xE1, 0xEE, 0xEF, 0x07,
  0x77, 0x78, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x01, 0xF1, 0xF0, 0xF8, 0x7D, 0xE1, 0xE3, 0xCF, 0x8F, 0x3C, 0x1F, 0xF0,
  0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xF8,
  0x3C, 0xF1, 0xF3, 0xE7, 0x87, 0xBE, 0x1F, 0xF0, 0x7B, 0xC3, 0xDE, 0x3C,
  0x79, 0xE3, 0xDE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xFF, 0xF0, 0x1C,
  0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x06, 0x00, 0xE0,
  0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xB8, 0x39, 0xC7, 0x1C, 0x70, 0xEF, 0x0E,
  0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0xF0, 0xF0, 0x70, 0x7F,
  0x9F, 0xF3, 0xFC, 0x0F, 0x1F, 0xDF, 0xFF, 0xFF, 0xCF, 0xF3, 0xFF, 0xFF,
  0xFD, 0xF7, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xEF, 0xBF, 0xF7,
  0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0xFE,
  0xF7, 0x80, 0x3F, 0xBF, 0xDF, 0xFE, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8,
  0xBF, 0xDF, 0xE7, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x7B,
  0xDF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFF,
  0xFB, 0xFF, 0x3C, 0xE0, 0x3F, 0x8F, 0xFB, 0xEF, 0x78, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x4F, 0xF9, 0xFF, 0x0F, 0xE0, 0x0F, 0x0F, 0xCF,
  0xC7, 0x83, 0xC3, 0xFB, 0xFD, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x3D, 0xEF, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFD, 0xFF, 0x9E, 0xF0, 0x1F, 0x07,
  0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xEF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x7F, 0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0xF3, 0xC6, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x1F, 0xF1, 0xEF, 0x3C, 0xF7, 0x8F, 0x78, 0xFF, 0x8F,
  0xF8, 0xFF, 0xCF, 0x3C, 0xF1, 0xEF, 0x1F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0xCF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xCF, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F,
  0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF7, 0xDF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xF0, 0x3F, 0x8F, 0xF9, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xEF, 0xF9, 0xFF, 0x0F, 0x80, 0xF7, 0xDF, 0xFB, 0xFF, 0xFC,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF, 0x7B, 0xCF,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x3D, 0xEF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFF, 0xFD, 0xFF, 0x9E, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F, 0xFF, 0xBD, 0xDE, 0x0F,
  0xC7, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xBF, 0xDF, 0xC0, 0x1C, 0x0E, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xF9,
  0xFC, 0x7E, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF9, 0xEF, 0xFD, 0xFF, 0x9F, 0x70, 0xF0, 0xF7, 0x8F, 0x78, 0xF7,
  0x9E, 0x39, 0xE3, 0xDC, 0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xF0, 0xF1, 0xF3, 0xDC, 0x7C, 0xF7, 0x9F, 0x3D, 0xEF, 0xCE, 0x7B, 0xB3,
  0x8E, 0xEF, 0xE3, 0xBB, 0xF8, 0xEC, 0xFC, 0x3F, 0x3F, 0x07, 0xCF, 0xC1,
  0xF1, 0xF0, 0x7C, 0x78, 0xF8, 0xF3, 0xEF, 0x0F, 0x78, 0x7F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3F, 0xC1, 0xEF, 0x1E, 0x7D, 0xF1, 0xF0,
  0xF0, 0xF7, 0x8F, 0x78, 0xF7, 0x9E, 0x39, 0xE3, 0xDE, 0x3D, 0xC1, 0xFC,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x7E, 0x07, 0xE0,
  0x7C, 0x00, 0x7F, 0xDF, 0xF7, 0xF8, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0x0E, 0x7C, 0xF9, 0xE3, 0x87, 0x0E, 0x1C,
  0xF9, 0xE3, 0xE7, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x7C, 0x78, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE3, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x3E, 0x3C, 0xF9, 0xF3, 0x87, 0x0E, 0x1C, 0x79, 0xF3,
  0xC6, 0x00, 0x78, 0x7F, 0xFF, 0xFE, 0x3F,
};

const GFXglyph NotoSans_SemiCondensed_Black22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 13, 16, 14, 0, -16 },
  { 42, 10, 18, 12, 1, -17 },
  { 65, 20, 16, 20, 0, -16 },
  { 105, 15, 16, 16, 1, -16 },
  { 135, 4, 6, 6, 1, -16 },
  { 138, 6, 19, 8, 1, -16 },
  { 153, 7, 19, 8, 0, -16 },
  { 170, 11, 11, 11, 0, -17 },
  { 186, 10, 11, 12, 1, -13 },
  { 200, 4, 6, 7, 1, -3 },
  { 203, 6, 4, 7, 1, -8 },
  { 206, 4, 4, 6, 1, -4 },
  { 208, 10, 16, 10, 0, -16 },
  { 228, 10, 16, 12, 1, -16 },
  { 248, 9, 16, 12, 1, -16 },
  { 266, 11, 16, 12, 0, -16 },
  { 288, 10, 16, 12, 1, -16 },
  { 308, 12, 16, 12, 0, -16 },
  { 332, 10, 16, 12, 1, -16 },
  { 352, 10, 16, 12, 1, -16 },
  { 372, 10, 16, 12, 1, -16 },
  { 392, 10, 16, 12, 1, -16 },
  { 412, 10, 16, 12, 1, -16 },
  { 432, 4, 12, 6, 1, -12 },
  { 438, 4, 15, 6, 1, -12 },
  { 446, 10, 12, 12, 1, -14 },
  { 461, 10, 8, 12, 1, -12 },
  { 471, 10, 12, 12, 1, -14 },
  { 486, 10, 16, 10, 0, -16 },
  { 506, 17, 18, 19, 1, -16 },
  { 545, 15, 16, 15, 0, -16 },
  { 575, 11, 16, 14, 2, -16 },
  { 597, 12, 16, 13, 1, -16 },
  { 621, 12, 16, 15, 2, -16 },
  { 645, 8, 16, 11, 2, -16 },
  { 661, 8, 16, 11, 2, -16 },
  { 677, 13, 16, 15, 1, -16 },
  { 703, 12, 16, 16, 2, -16 },
  { 727, 7, 16, 9, 1, -16 },
  { 741, 8, 21, 7, -2, -16 },
  { 762, 12, 16, 14, 2, -16 },
  { 786, 9, 16, 12, 2, -16 },
  { 804, 16, 16, 20, 2, -16 },
  { 836, 13, 16, 17, 2, -16 },
  { 862, 14, 16, 16, 1, -16 },
  { 890, 10, 16, 13, 2, -16 },
  { 910, 14, 20, 16, 1, -16 },
  { 945, 12, 16, 14, 2, -16 },
  { 969, 10, 16, 12, 1, -16 },
  { 989, 11, 16, 12, 0, -16 },
  { 1011, 13, 16, 15, 1, -16 },
  { 1037, 14, 16, 14, 0, -16 },
  { 1065, 21, 16, 21, 0, -16 },
  { 1107, 14, 16, 14, 0, -16 },
  { 1135, 13, 16, 13, 0, -16 },
  { 1161, 11, 16, 12, 1, -16 },
  { 1183, 6, 20, 7, 1, -16 },
  { 1198, 10, 16, 10, 0, -16 },
  { 1218, 6, 20, 7, 0, -16 },
  { 1233, 12, 11, 12, 0, -16 },
  { 1250, 11, 3, 11, 0, 1 },
  { 1255, 7, 4, 9, 1, -17 },
  { 1259, 10, 12, 13, 1, -12 },
  { 1274, 11, 17, 13, 1, -17 },
  { 1298, 9, 12, 11, 1, -12 },
  { 1312, 11, 17, 13, 1, -17 },
  { 1336, 11, 12, 13, 1, -12 },
  { 1353, 9, 17, 8, 0, -17 },
  { 1373, 11, 17, 13, 1, -12 },
  { 1397, 11, 17, 14, 1, -17 },
  { 1421, 4, 17, 7, 1, -17 },
  { 1430, 6, 22, 7, -1, -17 },
  { 1447, 12, 17, 13, 1, -17 },
  { 1473, 4, 17, 7, 1, -17 },
  { 1482, 18, 12, 20, 1, -12 },
  { 1509, 11, 12, 14, 1, -12 },
  { 1526, 11, 12, 13, 1, -12 },
  { 1543, 11, 17, 13, 1, -12 },
  { 1567, 11, 17, 13, 1, -12 },
  { 1591, 8, 12, 10, 1, -12 },
  { 1603, 9, 12, 10, 1, -12 },
  { 1617, 9, 15, 9, 0, -15 },
  { 1634, 11, 12, 14, 1, -12 },
  { 1651, 12, 12, 12, 0, -12 },
  { 1669, 18, 12, 19, 0, -12 },
  { 1696, 13, 12, 13, 0, -12 },
  { 1716, 12, 17, 12, 0, -12 },
  { 1742, 10, 12, 10, 0, -12 },
  { 1757, 7, 20, 9, 1, -16 },
  { 1775, 3, 22, 10, 4, -17 },
  { 1784, 7, 20, 9, 1, -16 },
  { 1802, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Black22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK22PT7B_H_
