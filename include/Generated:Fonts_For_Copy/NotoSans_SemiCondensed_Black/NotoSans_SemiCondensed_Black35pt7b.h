#ifndef _NOTOSANS_SEMICONDENSED_BLACK35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFE,
  0x7E, 0x7C, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFE, 0x1E, 0xF8, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x87,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x1F, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0xFF, 0x83, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFD, 0xC2, 0x7C, 0xE0, 0x3F, 0x70, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x73, 0xF0, 0x39, 0xF6, 0x1D, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F,
  0x80, 0x3E, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x07, 0xC0, 0x3F, 0xF8,
  0x1F, 0x00, 0xF9, 0xF0, 0xF8, 0x03, 0xE7, 0xC3, 0xE0, 0x0F, 0x9F, 0x1F,
  0x00, 0x3E, 0x7C, 0x7C, 0x00, 0xF9, 0xF3, 0xE0, 0x03, 0xE7, 0xCF, 0x80,
  0x0F, 0x9F, 0x7C, 0x7E, 0x3F, 0xF9, 0xF3, 0xFC, 0x7F, 0xEF, 0x9F, 0xF8,
  0xFF, 0x3E, 0xFF, 0xE1, 0xF9, 0xF3, 0xE7, 0xC0, 0x07, 0xCF, 0x9F, 0x00,
  0x3E, 0x3E, 0x7C, 0x00, 0xF8, 0xF9, 0xF0, 0x07, 0xC3, 0xE7, 0xC0, 0x1F,
  0x0F, 0x9F, 0x00, 0xF8, 0x3E, 0x7C, 0x03, 0xE0, 0xFF, 0xE0, 0x1F, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xF9, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xE1, 0xFF,
  0x87, 0xF1, 0xFF, 0xE3, 0xF1, 0xFF, 0xFB, 0xF9, 0xFD, 0xFF, 0xFC, 0xFE,
  0x7F, 0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x87, 0xFE, 0x1F, 0xC1, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD, 0xFE,
  0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xF8, 0x07,
  0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x83, 0xC1, 0xF3, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3E, 0x7C, 0x7E, 0x7E, 0x0C, 0x38, 0x04, 0x20, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3C, 0xFD, 0xFF, 0xF7, 0xEF, 0xC0, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x1F, 0xDF, 0x8F, 0xEF,
  0xE7, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7E, 0xFC, 0xF3, 0xF1, 0x8F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0xF8, 0x1F,
  0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3, 0xE3, 0xF8, 0xE0, 0xFC,
  0x20, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF1, 0xC3, 0xF8, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0xF9, 0xF8,
  0x7E, 0x7E, 0x1F, 0x1F, 0x8F, 0x87, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF1, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x30, 0x3E, 0xFF, 0x3F, 0x7F, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xDF, 0x87,
  0xEF, 0xE7, 0xF7, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xF7, 0xF3, 0xF1, 0xFD, 0xF8, 0xFE, 0xFC,
  0x7E, 0x7F, 0x7F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFF, 0xFC, 0xFE, 0x7E, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xF7, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xF7, 0xF1, 0xFB, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xEF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xBF,
  0x07, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xE3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x33, 0xFF, 0xFF, 0xFF,
  0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0x18,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xF8,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF,
  0x38, 0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0x8F, 0x83, 0xF8, 0xF1, 0xF1, 0xFF, 0xDF, 0x7C, 0x7F, 0xF9, 0xEF, 0x9F,
  0xFF, 0x3D, 0xE3, 0xE3, 0xC7, 0xBC, 0xF8, 0x78, 0xFF, 0x9F, 0x0F, 0x1F,
  0xF3, 0xE1, 0xE3, 0xFE, 0x7C, 0x3C, 0x7F, 0xCF, 0x8F, 0x8F, 0xF9, 0xF1,
  0xF3, 0xEF, 0x3F, 0xFF, 0xF9, 0xE3, 0xFF, 0xFF, 0x3E, 0x3F, 0x9F, 0xC7,
  0xC3, 0xE1, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x00, 0xFF, 0x01,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x0B, 0x40, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03,
  0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F,
  0xDF, 0xC7, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xF0, 0xFE, 0xFE, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F,
  0x7F, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x9F, 0xE0, 0xC7, 0xF0, 0x13, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x09, 0xFE, 0x0E,
  0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xE3, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE7, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFC, 0x1C, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x03, 0xF7, 0xF8, 0x3F, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF9, 0xFE, 0xFF, 0xEF, 0xFE,
  0xFF, 0xCF, 0xF8, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x83,
  0xF9, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFE, 0xFE, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xDF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBE, 0x1F, 0xFF, 0xF7, 0xC3, 0xFF, 0xFE,
  0xF8, 0xFB, 0xFF, 0xCF, 0x9F, 0x7F, 0xF9, 0xF3, 0xEF, 0xFF, 0x3E, 0x7D,
  0xFF, 0xE7, 0xFF, 0x3F, 0xFC, 0x7F, 0xE7, 0xFF, 0x8F, 0xFC, 0xFF, 0xF1,
  0xFF, 0x1F, 0xFE, 0x3F, 0xE3, 0xFF, 0xC3, 0xFC, 0x7F, 0xF8, 0x7F, 0x8F,
  0xFF, 0x0F, 0xE1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xE0, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F,
  0xF7, 0xE1, 0xFF, 0xDF, 0xC7, 0xFF, 0x3F, 0x1F, 0xFC, 0xFE, 0x7F, 0xF1,
  0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0x0F, 0xDF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFE, 0x1F,
  0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xE1, 0xFE, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x9F, 0xEF, 0xE1, 0xFB, 0xF8, 0x7F, 0xFE,
  0x1F, 0xBF, 0x87, 0xEF, 0xE3, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFE, 0x1F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFE,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xE3, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC,
  0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0xE7,
  0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xCF,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xF8, 0x73, 0xF8, 0x08, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xDF,
  0x0F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF8, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F,
  0x87, 0xE0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0xFE, 0x01,
  0xF9, 0xFC, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0xBF, 0x01, 0xF8, 0x1F, 0xDF, 0x81, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x83, 0xF1, 0xF8, 0x3F, 0xC1, 0xF8, 0xFC,
  0x3F, 0xE1, 0xFC, 0x7E, 0x1F, 0xF0, 0xFC, 0x3F, 0x0F, 0xF8, 0x7E, 0x0F,
  0x87, 0xFE, 0x3F, 0x07, 0xE3, 0xDF, 0x1F, 0x83, 0xF3, 0xEF, 0x9F, 0xC1,
  0xF9, 0xF7, 0xCF, 0xC0, 0xFC, 0xF9, 0xE7, 0xE0, 0x3E, 0x7C, 0xFB, 0xF0,
  0x1F, 0xBE, 0x7D, 0xF8, 0x0F, 0xFE, 0x3E, 0xF8, 0x07, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0xFE, 0x07, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF9, 0xFC, 0x03,
  0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xBF,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x1F, 0xE0, 0xFE,
  0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7F, 0x3F,
  0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF7,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x00, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xE1, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xF3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xDF, 0xF3,
  0xE3, 0xF1, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xE0, 0xFC, 0xFE, 0x3F,
  0x7F, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xE1,
  0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7E,
  0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0x7F, 0x8F, 0x8F, 0xC0, 0x01, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x7F, 0xBC, 0x7F, 0x04, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0x7F, 0x06, 0x7F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x1C, 0x3F, 0x1F, 0xCF, 0xCF, 0xFB, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF7, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xF0, 0xFC, 0x7C, 0x01, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE0,
  0xF9, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x09, 0xFE, 0x3C, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x3F,
  0xE3, 0xFF, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x07, 0x80, 0x07, 0xF3, 0xF3, 0xFE, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xEF, 0xF7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xF1, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x3F, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF6, 0x01, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFF, 0xE0, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xE0, 0xFC,
  0xFE, 0x3F, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFC, 0x7D, 0xFB, 0xFF, 0xFF, 0xC7, 0x00,
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x07, 0xC1, 0xF8, 0x3F, 0x87, 0xF0,
  0xFC, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0xFE, 0x7E, 0x3F, 0x8F,
  0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0x7F, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xF7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x0E,
  0x0F, 0x9F, 0xE3, 0xFC, 0xFF, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC7, 0xFF, 0xE1, 0xFC,
  0x3F, 0xFE, 0x1F, 0x83, 0xFF, 0xE1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F,
  0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x3F, 0x00, 0x38, 0x3E, 0x7F, 0x8F,
  0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0x00, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE1, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7,
  0xF1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x38, 0x3F, 0x3F, 0x8F, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xE3, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xDF, 0xE3, 0xF3, 0xF0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x07, 0xF3, 0xF3, 0xFE, 0xFC, 0xFF,
  0xFF, 0x7F, 0xFF, 0xDF, 0xEF, 0xF7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7,
  0xF1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x3F,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC7, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x7F, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xF0, 0x6F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x9F, 0xF8, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFE, 0x7F, 0xF1,
  0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFB, 0xF1, 0xFC, 0x7C,
  0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF9,
  0xF0, 0x0F, 0xBF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0xFE, 0x1F, 0xE1, 0xFB, 0xF0, 0xFF, 0x0F, 0xDF, 0x87, 0xF8, 0x7E, 0xFC,
  0x7F, 0xC7, 0xE3, 0xF3, 0xFE, 0x3F, 0x1F, 0x9F, 0xF9, 0xF8, 0xFC, 0xF7,
  0xCF, 0xC7, 0xE7, 0xBE, 0x7C, 0x1F, 0x7D, 0xF7, 0xE0, 0xFB, 0xE7, 0xBF,
  0x07, 0xFF, 0x3D, 0xF8, 0x3F, 0xF9, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x07,
  0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF7,
  0xF0, 0xFE, 0x3F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x9F, 0x83, 0xF9,
  0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFE, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x3F,
  0x8F, 0xF8, 0xFF, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x7F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFF, 0x07,
  0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xF0,
  0x00, 0x0C, 0x00, 0xBF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 25, 10, 1, -25 },
  { 26, 14, 9, 18, 2, -25 },
  { 42, 20, 25, 22, 1, -25 },
  { 105, 17, 29, 19, 1, -27 },
  { 167, 30, 25, 32, 1, -25 },
  { 261, 25, 25, 26, 1, -25 },
  { 340, 6, 9, 10, 2, -25 },
  { 347, 11, 32, 12, 1, -26 },
  { 391, 10, 32, 12, 1, -26 },
  { 431, 16, 17, 18, 1, -27 },
  { 465, 17, 17, 19, 1, -21 },
  { 502, 8, 10, 10, 1, -5 },
  { 512, 9, 5, 11, 1, -12 },
  { 518, 7, 6, 10, 1, -6 },
  { 524, 15, 25, 15, 0, -25 },
  { 571, 17, 25, 19, 1, -25 },
  { 625, 14, 25, 19, 1, -25 },
  { 669, 17, 25, 19, 1, -25 },
  { 723, 17, 25, 19, 1, -25 },
  { 777, 18, 25, 19, 1, -25 },
  { 834, 16, 25, 19, 2, -25 },
  { 884, 17, 25, 19, 1, -25 },
  { 938, 17, 25, 19, 1, -25 },
  { 992, 17, 25, 19, 1, -25 },
  { 1046, 17, 25, 19, 1, -25 },
  { 1100, 6, 20, 10, 2, -20 },
  { 1115, 8, 25, 10, 1, -20 },
  { 1140, 17, 19, 19, 1, -22 },
  { 1181, 17, 13, 19, 1, -19 },
  { 1209, 17, 19, 19, 1, -22 },
  { 1250, 16, 25, 16, 0, -25 },
  { 1300, 27, 28, 30, 1, -25 },
  { 1395, 23, 25, 23, 0, -25 },
  { 1467, 19, 25, 22, 2, -25 },
  { 1527, 18, 25, 21, 2, -25 },
  { 1584, 20, 25, 24, 2, -25 },
  { 1647, 14, 25, 18, 2, -25 },
  { 1691, 14, 25, 18, 2, -25 },
  { 1735, 20, 25, 24, 2, -25 },
  { 1798, 20, 25, 25, 2, -25 },
  { 1861, 12, 25, 14, 1, -25 },
  { 1899, 12, 33, 12, -3, -25 },
  { 1949, 21, 25, 22, 2, -25 },
  { 2015, 15, 25, 18, 2, -25 },
  { 2062, 27, 25, 32, 2, -25 },
  { 2147, 22, 25, 27, 2, -25 },
  { 2216, 22, 25, 26, 2, -25 },
  { 2285, 18, 25, 21, 2, -25 },
  { 2342, 22, 31, 26, 2, -25 },
  { 2428, 20, 25, 22, 2, -25 },
  { 2491, 17, 25, 19, 1, -25 },
  { 2545, 17, 25, 19, 1, -25 },
  { 2599, 20, 25, 24, 2, -25 },
  { 2662, 23, 25, 23, 0, -25 },
  { 2734, 33, 25, 33, 0, -25 },
  { 2838, 23, 25, 23, 0, -25 },
  { 2910, 21, 25, 21, 0, -25 },
  { 2976, 18, 25, 20, 1, -25 },
  { 3033, 8, 32, 11, 2, -26 },
  { 3065, 15, 25, 15, 0, -25 },
  { 3112, 8, 32, 11, 1, -26 },
  { 3144, 19, 16, 19, 0, -25 },
  { 3182, 18, 4, 18, 0, 2 },
  { 3191, 11, 6, 14, 1, -27 },
  { 3200, 17, 20, 20, 1, -20 },
  { 3243, 18, 27, 21, 2, -27 },
  { 3304, 16, 20, 18, 1, -20 },
  { 3344, 18, 27, 21, 1, -27 },
  { 3405, 18, 20, 20, 1, -20 },
  { 3450, 13, 27, 13, 1, -27 },
  { 3494, 18, 28, 21, 1, -20 },
  { 3557, 18, 27, 22, 2, -27 },
  { 3618, 7, 27, 11, 2, -27 },
  { 3642, 11, 35, 11, -2, -27 },
  { 3691, 19, 27, 21, 2, -27 },
  { 3756, 6, 27, 11, 2, -27 },
  { 3777, 28, 20, 32, 2, -20 },
  { 3847, 18, 20, 22, 2, -20 },
  { 3892, 18, 20, 21, 1, -20 },
  { 3937, 18, 28, 21, 2, -20 },
  { 4000, 18, 28, 21, 1, -20 },
  { 4063, 13, 20, 15, 2, -20 },
  { 4096, 14, 20, 17, 1, -20 },
  { 4131, 13, 23, 15, 1, -23 },
  { 4169, 18, 19, 22, 2, -19 },
  { 4212, 20, 19, 20, 0, -19 },
  { 4260, 29, 19, 30, 0, -19 },
  { 4329, 20, 19, 20, 0, -19 },
  { 4377, 20, 27, 20, 0, -19 },
  { 4445, 15, 19, 16, 1, -19 },
  { 4481, 12, 31, 14, 1, -25 },
  { 4528, 5, 35, 17, 6, -27 },
  { 4550, 12, 31, 14, 1, -25 },
  { 4597, 17, 7, 19, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_Black35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK35PT7B_H_
