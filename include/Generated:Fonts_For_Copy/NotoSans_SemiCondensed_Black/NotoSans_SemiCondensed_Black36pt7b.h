#ifndef _NOTOSANS_SEMICONDENSED_BLACK36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0x7F,
  0x7F, 0x7E, 0x7E, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0x7C, 0x7D, 0xE1, 0xF0, 0x03, 0xE3, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x1F, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x3E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x7F,
  0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF3, 0xF7, 0x1C,
  0xFD, 0xC0, 0x3F, 0x70, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x77, 0xE0, 0x1C,
  0xFE, 0x07, 0x3F, 0x71, 0xCF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFE, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x07,
  0xFF, 0x01, 0xF0, 0x0F, 0x9F, 0x07, 0xC0, 0x1F, 0x3E, 0x0F, 0x80, 0x3E,
  0x7C, 0x3E, 0x00, 0x7C, 0xF8, 0x7C, 0x00, 0xF9, 0xF1, 0xF0, 0x01, 0xF3,
  0xE3, 0xE0, 0x03, 0xE7, 0xCF, 0x87, 0x87, 0xCF, 0x9F, 0x3F, 0x87, 0xFE,
  0x7C, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0x8F, 0xF3, 0xE7, 0xDF, 0x0F, 0xC7,
  0xCF, 0x9F, 0x00, 0x1F, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0xF8, 0x01, 0xF1, 0xF1, 0xF0, 0x07, 0xC1, 0xF3, 0xE0, 0x0F, 0x83,
  0xE7, 0xC0, 0x3E, 0x07, 0xFF, 0x00, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x0F,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x02, 0x0F, 0xFC, 0x3F, 0x0F,
  0xFF, 0x1F, 0xC7, 0xFF, 0xE7, 0xF1, 0xFF, 0xFD, 0xF8, 0xFE, 0x7F, 0xFE,
  0x3F, 0x8F, 0xFF, 0x8F, 0xE1, 0xFF, 0xC3, 0xF8, 0x3F, 0xF0, 0xFF, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7D, 0xE0, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC3, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x0E, 0x3C,
  0x77, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x03,
  0xFE, 0x03, 0xFF, 0x03, 0xF7, 0xC3, 0xF3, 0xF0, 0xF8, 0xF0, 0x18, 0x60,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFB, 0xFF, 0xFF, 0xDF, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0xBF, 0x87, 0xEF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8,
  0xFE, 0x7F, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x7D, 0xFC, 0x73, 0xF8,
  0x47, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0xFE, 0x20, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF9, 0xF3,
  0xFC, 0x40, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x83, 0xFF, 0x81,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xF7, 0xF0, 0xFD, 0xFC, 0x3E,
  0x7F, 0x1F, 0x9F, 0xC7, 0xC7, 0xF3, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x7B,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x0F, 0xF8,
  0x23, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x9F, 0x07, 0xDF, 0xF3,
  0xF7, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFD, 0xF8, 0x7F, 0x7F, 0x3F, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xCF, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7F, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x3F, 0xBF,
  0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xDF, 0xEF, 0xE3, 0xFB,
  0xF8, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFE, 0xFC, 0xFF, 0xBE, 0x1F, 0xDF, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x7D, 0xFB, 0xFF, 0xFF, 0xDF,
  0x84, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFF, 0xFF, 0xF3,
  0xE0, 0x3E, 0x7E, 0x7F, 0x7F, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xFC,
  0xFC, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x7C, 0x7F,
  0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x00,
  0x7C, 0x1F, 0x01, 0x03, 0xE3, 0xE1, 0xFF, 0x9E, 0x3C, 0x3F, 0xF9, 0xF7,
  0xC7, 0xFF, 0x9F, 0x7C, 0xFC, 0xF8, 0xF7, 0x8F, 0x8F, 0x8F, 0x79, 0xF0,
  0xF8, 0xFF, 0x9F, 0x0F, 0x8F, 0xF9, 0xF0, 0xF8, 0xFF, 0x9F, 0x0F, 0x8F,
  0xF9, 0xF0, 0xF9, 0xFF, 0x9F, 0x1F, 0x9E, 0x78, 0xFF, 0xFF, 0xE7, 0xCF,
  0xFF, 0xFC, 0x7C, 0x7F, 0xBF, 0x83, 0xE1, 0xE0, 0xF0, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x20, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xBF, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF8, 0x19, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x01,
  0x7F, 0xC3, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xEF, 0xC0, 0xFE, 0xFC,
  0x0F, 0xEF, 0xC1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x01, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xFC, 0x3F, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFE, 0x00,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x8F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC1,
  0xFC, 0xFC, 0x3F, 0xCF, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xCF, 0xF0, 0xFC,
  0xFE, 0x0F, 0xDF, 0xC0, 0xFD, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC7, 0xF0,
  0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xFC, 0xFC, 0x1F,
  0xCF, 0xC1, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFB, 0xE0, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xEF, 0x87, 0xDF, 0xFD, 0xF8,
  0xFB, 0xFF, 0x9F, 0x1F, 0x7F, 0xFB, 0xE3, 0xEF, 0xFF, 0x7E, 0xF9, 0xFF,
  0xEF, 0xDF, 0x3F, 0xFC, 0xFB, 0xE7, 0xFF, 0x9F, 0xF8, 0xFF, 0xF3, 0xFF,
  0x1F, 0xFE, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x7F, 0xF8, 0xFF, 0x0F, 0xFF,
  0x1F, 0xE1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xE0,
  0xFC, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xFF, 0xEF, 0xC3, 0xFF, 0xBF, 0x8F, 0xFE, 0x7E, 0x3F, 0xF9, 0xFC,
  0xFF, 0xE3, 0xF3, 0xFF, 0xCF, 0xEF, 0xFF, 0x1F, 0xBF, 0xFC, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0x1F, 0xC0, 0xFF, 0x7F, 0x80, 0xFE,
  0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE7, 0xFC,
  0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0x1F, 0xC0, 0xFF, 0x7F, 0x80, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xE7, 0xFC, 0x7F,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFC,
  0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F,
  0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xF8, 0x08, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0xC7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x0F,
  0xE7, 0xF9, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFD, 0xFC,
  0x07, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0,
  0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF8,
  0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x1F,
  0xDF, 0x80, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x81, 0xFD, 0xF8, 0x0F, 0xE0,
  0x7E, 0x7F, 0x07, 0xF8, 0x1F, 0x8F, 0xC1, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F,
  0x83, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xE3,
  0xFF, 0x0F, 0xC1, 0xF8, 0xFF, 0xC7, 0xF0, 0x7E, 0x3E, 0xF9, 0xFC, 0x1F,
  0x8F, 0xBE, 0x7E, 0x07, 0xE7, 0xEF, 0x9F, 0x80, 0xFD, 0xF3, 0xE7, 0xE0,
  0x3F, 0x7C, 0xF9, 0xF8, 0x0F, 0xDF, 0x1E, 0xFC, 0x03, 0xF7, 0xC7, 0xFF,
  0x00, 0xFD, 0xF1, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x01, 0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0x7F, 0x7F, 0x01, 0xFC, 0x7F, 0x03,
  0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFD, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xC0,
  0xFE, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x0F, 0xEF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE0, 0xF8,
  0x7C, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xFC, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x82, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFE, 0xFC, 0x7F, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF9, 0xF0, 0xFF, 0xFF,
  0x3F, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0x7F, 0xCF, 0xCF, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7F, 0x86, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0x7F, 0x07, 0x7F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x3F, 0x3F, 0x1F, 0xEF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0x1F, 0xDF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xF9, 0xF0, 0xFC, 0x7C, 0x07, 0xFC,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xBF, 0x9F, 0xC3, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x09, 0xFF, 0x3E, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x80, 0x3F, 0xF1, 0xFF,
  0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0x43, 0xF8, 0x0F, 0xE0, 0x3F, 0xF3, 0xFF,
  0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC7, 0xC7, 0xF9,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xDF, 0x83, 0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFE, 0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF6, 0x01, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF9, 0xF8, 0xFD, 0xFF, 0x3F, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0x83, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0xFF, 0xFE, 0x1F, 0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFF, 0xFC, 0x0F, 0xDF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0x0F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE,
  0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF8, 0xFE, 0x1F, 0xC7, 0xEF, 0xF9, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF1,
  0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFE, 0x1F, 0xC1, 0xFF,
  0xF0, 0xFE, 0x0F, 0xFF, 0x87, 0xF0, 0x7F, 0xFC, 0x3F, 0x83, 0xFF, 0xE1,
  0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xC3, 0xF8,
  0x3F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x87, 0xF0, 0x7F,
  0xFC, 0x3F, 0x83, 0xF0, 0xF8, 0xFE, 0x3F, 0x7F, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFE, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0xC7,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE,
  0x00, 0xFC, 0x7C, 0x3F, 0x7F, 0xCF, 0xDF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFB, 0xF8, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xC7, 0xF9, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xC7, 0xF7, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xDF, 0x83, 0xF7, 0xF1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFE, 0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0xF8, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xE7, 0x9F, 0xC1, 0x3F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE3, 0xFF, 0x80,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE2, 0x7F, 0xF3, 0xFF, 0x8F, 0xFC,
  0x7F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE, 0x7C, 0x7F, 0x1F,
  0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0x7E, 0x3F, 0x0F,
  0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x9F, 0x81, 0xF9,
  0xF8, 0x0F, 0x9F, 0x80, 0xFD, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFD, 0xF8, 0x7F, 0x83, 0xF7, 0xE1, 0xFE,
  0x1F, 0xDF, 0x87, 0xFC, 0x7E, 0x7F, 0x1F, 0xF1, 0xF8, 0xFC, 0xFF, 0xC7,
  0xE3, 0xF3, 0xFF, 0x3F, 0x8F, 0xCF, 0xBC, 0xFC, 0x3F, 0x3E, 0xFB, 0xF0,
  0x7E, 0xFB, 0xEF, 0xC1, 0xFB, 0xCF, 0xBF, 0x07, 0xFF, 0x3E, 0xF8, 0x1F,
  0xFC, 0xFB, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF7, 0xF0, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF9, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFD, 0xFC, 0x3F, 0x9F, 0xC3,
  0xF8, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x7F,
  0x7F, 0x07, 0xF7, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0xFD,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xC0,
  0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xFC,
  0x3F, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE1, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x1F, 0x00, 0x3F, 0x00, 0x5F, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE8, 0x01, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Black36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 26, 10, 1, -26 },
  { 27, 14, 10, 18, 2, -26 },
  { 45, 21, 26, 22, 1, -26 },
  { 114, 18, 29, 20, 1, -27 },
  { 180, 31, 26, 33, 1, -26 },
  { 281, 26, 26, 27, 1, -26 },
  { 366, 6, 10, 10, 2, -26 },
  { 374, 11, 32, 12, 1, -26 },
  { 418, 10, 32, 12, 1, -26 },
  { 458, 17, 16, 19, 1, -27 },
  { 492, 17, 17, 20, 1, -21 },
  { 529, 8, 10, 11, 1, -5 },
  { 539, 10, 5, 12, 1, -12 },
  { 546, 7, 6, 10, 2, -6 },
  { 552, 16, 26, 16, 0, -26 },
  { 604, 18, 26, 20, 1, -26 },
  { 663, 15, 26, 20, 1, -26 },
  { 712, 17, 26, 20, 1, -26 },
  { 768, 17, 26, 20, 1, -26 },
  { 824, 18, 26, 20, 1, -26 },
  { 883, 16, 26, 20, 2, -26 },
  { 935, 18, 26, 20, 1, -26 },
  { 994, 18, 26, 20, 1, -26 },
  { 1053, 18, 26, 20, 1, -26 },
  { 1112, 18, 26, 20, 1, -26 },
  { 1171, 7, 20, 10, 2, -20 },
  { 1189, 8, 25, 10, 1, -20 },
  { 1214, 17, 20, 20, 1, -23 },
  { 1257, 18, 13, 20, 1, -19 },
  { 1287, 18, 20, 20, 1, -23 },
  { 1332, 16, 26, 17, 0, -26 },
  { 1384, 28, 29, 31, 1, -26 },
  { 1486, 24, 26, 24, 0, -26 },
  { 1564, 18, 26, 23, 3, -26 },
  { 1623, 18, 26, 21, 2, -26 },
  { 1682, 20, 26, 24, 3, -26 },
  { 1747, 14, 26, 18, 3, -26 },
  { 1793, 14, 26, 18, 3, -26 },
  { 1839, 21, 26, 25, 2, -26 },
  { 1908, 20, 26, 25, 3, -26 },
  { 1973, 13, 26, 15, 1, -26 },
  { 2016, 12, 34, 12, -3, -26 },
  { 2067, 20, 26, 23, 3, -26 },
  { 2132, 15, 26, 19, 3, -26 },
  { 2181, 27, 26, 33, 3, -26 },
  { 2269, 22, 26, 28, 3, -26 },
  { 2341, 23, 26, 26, 2, -26 },
  { 2416, 17, 26, 21, 3, -26 },
  { 2472, 23, 32, 26, 2, -26 },
  { 2564, 20, 26, 23, 3, -26 },
  { 2629, 17, 26, 19, 1, -26 },
  { 2685, 18, 26, 20, 1, -26 },
  { 2744, 21, 26, 25, 2, -26 },
  { 2813, 23, 26, 23, 0, -26 },
  { 2888, 34, 26, 34, 0, -26 },
  { 2999, 23, 26, 23, 0, -26 },
  { 3074, 22, 26, 22, 0, -26 },
  { 3146, 18, 26, 20, 1, -26 },
  { 3205, 9, 32, 11, 2, -26 },
  { 3241, 16, 26, 16, 0, -26 },
  { 3293, 9, 32, 11, 1, -26 },
  { 3329, 19, 17, 19, 0, -26 },
  { 3370, 18, 5, 18, 0, 2 },
  { 3382, 12, 6, 14, 1, -28 },
  { 3391, 18, 20, 21, 1, -20 },
  { 3436, 18, 27, 22, 2, -27 },
  { 3497, 16, 20, 18, 1, -20 },
  { 3537, 18, 27, 22, 1, -27 },
  { 3598, 18, 20, 20, 1, -20 },
  { 3643, 14, 28, 14, 1, -28 },
  { 3692, 18, 29, 22, 1, -20 },
  { 3758, 18, 27, 22, 2, -27 },
  { 3819, 7, 28, 11, 2, -28 },
  { 3844, 11, 37, 11, -2, -28 },
  { 3895, 20, 27, 22, 2, -27 },
  { 3963, 7, 27, 11, 2, -27 },
  { 3987, 29, 20, 33, 2, -20 },
  { 4060, 18, 20, 22, 2, -20 },
  { 4105, 19, 20, 21, 1, -20 },
  { 4153, 18, 29, 22, 2, -20 },
  { 4219, 18, 29, 22, 1, -20 },
  { 4285, 13, 20, 16, 2, -20 },
  { 4318, 15, 20, 17, 1, -20 },
  { 4356, 13, 24, 15, 1, -24 },
  { 4395, 18, 20, 22, 2, -20 },
  { 4440, 20, 20, 20, 0, -20 },
  { 4490, 30, 20, 30, 0, -20 },
  { 4565, 20, 20, 21, 0, -20 },
  { 4615, 20, 29, 20, 0, -20 },
  { 4688, 15, 20, 17, 1, -20 },
  { 4726, 13, 32, 15, 1, -26 },
  { 4778, 5, 36, 17, 6, -28 },
  { 4801, 13, 32, 15, 1, -26 },
  { 4853, 18, 7, 20, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_Black36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK36PT7B_H_
