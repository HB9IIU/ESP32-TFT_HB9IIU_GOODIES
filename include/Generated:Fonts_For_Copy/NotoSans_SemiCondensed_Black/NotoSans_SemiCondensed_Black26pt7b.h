#ifndef _NOTOSANS_SEMICONDENSED_BLACK26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0xF0, 0x00, 0x9F, 0xFF,
  0xDE, 0xFB, 0xFF, 0x7D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF3, 0xDC, 0x70, 0x07,
  0x9C, 0x07, 0xBC, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x70, 0x0E, 0x70, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3D,
  0xE0, 0x06, 0x00, 0x60, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0xF6, 0x2F,
  0x60, 0xFE, 0x07, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x6F, 0x86, 0x7F,
  0x6F, 0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x3C, 0x03,
  0x81, 0xF8, 0x1E, 0x0F, 0xF0, 0x70, 0x3D, 0xC3, 0xC0, 0xE7, 0x0E, 0x03,
  0x9E, 0x78, 0x0E, 0x79, 0xC0, 0x39, 0xEF, 0x00, 0xF7, 0x39, 0xF3, 0xFD,
  0xEF, 0xE7, 0xE7, 0x7F, 0xCF, 0x3D, 0xEF, 0x00, 0xE7, 0xBC, 0x07, 0x9E,
  0xF0, 0x1C, 0x7B, 0xC0, 0xF1, 0xEF, 0x03, 0x83, 0xFC, 0x1E, 0x0F, 0xE0,
  0xF0, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0xE3, 0xE7, 0xFC, 0xFB, 0xFF, 0xBE, 0xF9, 0xFF, 0x3E, 0x7F, 0xCF, 0x8F,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0xFC, 0xFF, 0xDE,
  0xF7, 0xBD, 0xC0, 0x1F, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x7C, 0x3C,
  0x3E, 0x1F, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C,
  0xF8, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x8E, 0x27, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x0F, 0x3C, 0x31, 0x80, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7B, 0xDF, 0xFF, 0x7B, 0xDC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x27, 0xFF, 0xF7, 0x80, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x03, 0xFC,
  0x7F, 0xE7, 0xFE, 0x79, 0xFF, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF9, 0xF7, 0xFF, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xFF, 0xF7, 0xBD, 0xCF,
  0x23, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xFC, 0xFF, 0xEF, 0xFF, 0x7B, 0xF6, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xFC, 0xFF, 0xE7,
  0xFF, 0x61, 0xF0, 0x1F, 0x01, 0xE0, 0x7E, 0x3F, 0xC3, 0xF8, 0x3F, 0xE0,
  0x7F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x80,
  0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xFC, 0x3D, 0xF0, 0xF7, 0xC7, 0x9F, 0x1E, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFC, 0x7F, 0xE7,
  0xFE, 0x7F, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x7F, 0x80, 0x03, 0xF0, 0x7F, 0x8F, 0xFC, 0x7F, 0xE7, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0x7D, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xCF, 0xFE, 0x7F, 0xF1, 0xFF, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF,
  0x9F, 0x7C, 0xF9, 0xE7, 0xCF, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xF9, 0xFF,
  0xEF, 0x9F, 0x78, 0x7F, 0xC3, 0xFF, 0x3E, 0xFF, 0xF3, 0xFF, 0x0F, 0xF0,
  0x0F, 0x01, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF, 0x9F, 0x7C, 0x7B, 0xC3, 0xDF,
  0x1E, 0xF9, 0xFF, 0xFF, 0x9F, 0xFC, 0xFD, 0xE1, 0xCF, 0x00, 0xF8, 0x07,
  0x8F, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0, 0x27, 0xFF, 0xF7, 0x80, 0x00,
  0x00, 0x09, 0xFF, 0xFD, 0xE0, 0x27, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00,
  0xF7, 0xBF, 0xFE, 0xF7, 0xB8, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F,
  0xCF, 0xF0, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xF0, 0x0F, 0x00,
  0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x01, 0xF0, 0x7F, 0x1F, 0xE7, 0xF8, 0xFE, 0x0F, 0x00, 0xC0, 0x08,
  0x00, 0x0F, 0x07, 0xFC, 0xFF, 0xE7, 0xFF, 0x61, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xF0, 0x3C, 0x3C, 0x01, 0xE7, 0x8F, 0xEE, 0x71, 0xFE, 0xFF,
  0x3F, 0xE7, 0xF7, 0x8E, 0x7E, 0x70, 0xE7, 0xE7, 0x1E, 0x7E, 0x71, 0xE7,
  0xE7, 0x9E, 0xFF, 0x7F, 0xFE, 0xF3, 0xF7, 0xE7, 0x1E, 0x38, 0x78, 0x00,
  0x03, 0xE0, 0x30, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7B, 0xC0,
  0x3D, 0xF0, 0x3E, 0x78, 0x1F, 0x3C, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFC, 0xF8, 0x3E, 0x7C, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xE0, 0xFF, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF, 0x9F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x3E, 0xFF, 0xE7, 0xFF, 0x3F, 0xFD, 0xF3, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF0, 0x03,
  0xE0, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7E, 0x39, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xFC, 0x03, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFE, 0xF9, 0xFB, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xBF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xE7, 0xF0, 0xCF, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xC1, 0xEF, 0x83, 0xDF, 0x87, 0xBF,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF1, 0xF7, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF8, 0x7F,
  0xF0, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x7E, 0x3E, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xBE, 0x1F, 0x3E,
  0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF9, 0xF0, 0xFB, 0xE1, 0xF8, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xF7, 0x9F, 0xFF,
  0x79, 0xDF, 0xF7, 0x9D, 0xFF, 0x3B, 0xDF, 0xF3, 0xFD, 0xFF, 0x3F, 0x9F,
  0xF3, 0xF9, 0xFF, 0x1F, 0x9F, 0xF1, 0xF9, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1,
  0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x8F, 0xF7, 0x8F, 0xF7, 0xCF, 0xF7, 0xCF, 0xF3, 0xEF, 0xF3,
  0xEF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7,
  0xE3, 0xF3, 0xE0, 0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xF8, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x0F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x00, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3,
  0xE0, 0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xF8, 0xFC, 0xFF, 0xFE, 0x3F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0x8F, 0x9F, 0x9F,
  0x1F, 0x3E, 0x3E, 0x7C, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF9, 0xF1, 0xFB,
  0xE1, 0xF8, 0x0F, 0x83, 0xFF, 0x7F, 0xFF, 0xFE, 0xF8, 0xEF, 0x80, 0xFC,
  0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xC1,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC1, 0xFE, 0x00,
  0xF8, 0x1F, 0xFE, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xEF, 0x00, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0xBC, 0x1F, 0x07, 0x9E,
  0x0F, 0x87, 0xCF, 0x87, 0xC3, 0xE7, 0xC7, 0xE1, 0xF3, 0xE3, 0xF8, 0xF0,
  0xF1, 0xFC, 0x78, 0x78, 0xEE, 0x7C, 0x3E, 0x77, 0x3E, 0x1F, 0x7B, 0x9F,
  0x07, 0xBD, 0xEF, 0x03, 0xDE, 0xF7, 0x81, 0xEE, 0x7B, 0xC0, 0xF7, 0x1F,
  0xE0, 0x7F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1,
  0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x3E, 0x1F, 0x8F, 0x8F, 0x87,
  0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7D,
  0xF0, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x0F, 0xBF, 0x07, 0xE0, 0xF8, 0x1F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3E, 0x78, 0x1F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0xFF, 0xFF, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01,
  0xDE, 0x0F, 0x38, 0x38, 0xF1, 0xE1, 0xC7, 0x87, 0xBC, 0x0E, 0xF0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x7C, 0x1E, 0x0F, 0x03, 0x07, 0xFE,
  0x3F, 0xF3, 0xFF, 0x20, 0xF0, 0x0F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0x8F,
  0xF8, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x7E, 0x70, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x83, 0xDF, 0x9F, 0xFC, 0xFF, 0xF7, 0xCF,
  0xBC, 0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xDF, 0x3E, 0xFF, 0xF7,
  0xFF, 0xBF, 0xF9, 0xEF, 0x80, 0x03, 0x03, 0xFC, 0xFF, 0xBF, 0xF7, 0xC5,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xBF, 0xF7, 0xFE, 0x7F,
  0xC7, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x86, 0x7C,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xFC,
  0x3F, 0xE3, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xDF, 0xDE, 0x7C, 0xF0, 0x07,
  0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0xF8, 0x67, 0xFF, 0x1F, 0xF8, 0x7F, 0x80,
  0x07, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xE0, 0x7C, 0x1F, 0xF7, 0xFE, 0xFF,
  0xC7, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x00, 0x0C, 0x01, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFC, 0xFB, 0xE0, 0x1F, 0x80, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF,
  0xC7, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0xC3, 0xDF, 0x9F, 0xFE, 0xFF, 0xF7, 0xCF, 0xBE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xF0,
  0x7F, 0xFE, 0xF0, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF0, 0x1E, 0x7C, 0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0xFF, 0xFF, 0xFD, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x0F,
  0xBC, 0x7C, 0xF3, 0xE3, 0xCF, 0x8F, 0x7C, 0x3F, 0xE0, 0xFF, 0x83, 0xFF,
  0x0F, 0xFE, 0x3E, 0xF8, 0xF1, 0xF3, 0xC7, 0xCF, 0x0F, 0xBC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x81, 0x8E,
  0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF9, 0xFF, 0x8F, 0x8F,
  0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0x01,
  0x87, 0x3F, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0x7C, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xE0,
  0x03, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3E, 0xFB, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F,
  0x00, 0x01, 0x07, 0xBF, 0x3F, 0xF9, 0xFF, 0xEF, 0x9F, 0x78, 0x7B, 0xC3,
  0xDE, 0x1F, 0xF0, 0xFF, 0x87, 0xBE, 0x7D, 0xFF, 0xEF, 0xFF, 0x7F, 0xF3,
  0xDF, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x0C, 0x01, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0xFB,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC0, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xBF, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x07, 0x81, 0xE1, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x3C, 0xF8, 0x3E, 0xF0, 0xF9,
  0xF1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0xBC, 0x0F, 0x78, 0x1F,
  0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0xFC, 0x7D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9F, 0x3F, 0x3E, 0x7D, 0xFE,
  0xF8, 0xF7, 0xFB, 0xC3, 0xDD, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE, 0xF0,
  0x77, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0xFC, 0x7E, 0xF9, 0xF8, 0xFB, 0xE1, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFB, 0xE1, 0xF7,
  0xC7, 0xC7, 0xDF, 0x8F, 0xC0, 0xF8, 0x3E, 0xF0, 0xF9, 0xF1, 0xF3, 0xE3,
  0xC3, 0xC7, 0x87, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x7F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x03,
  0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x8F, 0xC7, 0xE3, 0xF1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3E, 0x1F, 0x3F, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xF8, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x3F, 0x1F, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0xE1, 0xF1, 0xF9, 0xFC, 0xF8, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x8F, 0xC7, 0xE3, 0xE0, 0x10, 0x1F, 0xE1, 0xFF,
  0xFF, 0xFF, 0x83, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 11, 7, 13, 1, -19 },
  { 23, 16, 19, 16, 0, -19 },
  { 61, 12, 22, 14, 1, -20 },
  { 94, 22, 19, 24, 1, -19 },
  { 147, 18, 19, 19, 1, -19 },
  { 190, 5, 7, 7, 1, -19 },
  { 195, 8, 23, 9, 1, -19 },
  { 218, 8, 23, 9, 0, -19 },
  { 241, 13, 12, 13, 0, -20 },
  { 261, 12, 13, 14, 1, -16 },
  { 281, 5, 8, 8, 1, -4 },
  { 286, 7, 4, 8, 1, -9 },
  { 290, 5, 5, 7, 1, -5 },
  { 294, 11, 19, 11, 0, -19 },
  { 321, 12, 19, 14, 1, -19 },
  { 350, 10, 19, 14, 1, -19 },
  { 374, 12, 19, 14, 1, -19 },
  { 403, 12, 19, 14, 1, -19 },
  { 432, 14, 19, 14, 0, -19 },
  { 466, 12, 19, 14, 1, -19 },
  { 495, 13, 19, 14, 1, -19 },
  { 526, 13, 19, 14, 1, -19 },
  { 557, 13, 19, 14, 1, -19 },
  { 588, 13, 19, 14, 1, -19 },
  { 619, 5, 15, 7, 1, -15 },
  { 629, 5, 19, 8, 1, -15 },
  { 641, 12, 14, 14, 1, -16 },
  { 662, 12, 9, 14, 1, -14 },
  { 676, 12, 14, 14, 1, -16 },
  { 697, 12, 19, 12, 0, -19 },
  { 726, 20, 21, 22, 1, -19 },
  { 779, 17, 19, 17, 0, -19 },
  { 820, 13, 19, 16, 2, -19 },
  { 851, 14, 19, 16, 1, -19 },
  { 885, 14, 19, 18, 2, -19 },
  { 919, 10, 19, 13, 2, -19 },
  { 943, 10, 19, 13, 2, -19 },
  { 967, 15, 19, 18, 1, -19 },
  { 1003, 15, 19, 18, 2, -19 },
  { 1039, 9, 19, 11, 1, -19 },
  { 1061, 9, 25, 9, -2, -19 },
  { 1090, 15, 19, 17, 2, -19 },
  { 1126, 11, 19, 14, 2, -19 },
  { 1153, 20, 19, 24, 2, -19 },
  { 1201, 16, 19, 20, 2, -19 },
  { 1239, 17, 19, 19, 1, -19 },
  { 1280, 12, 19, 15, 2, -19 },
  { 1309, 17, 23, 19, 1, -19 },
  { 1358, 15, 19, 16, 2, -19 },
  { 1394, 12, 19, 14, 1, -19 },
  { 1423, 13, 19, 14, 1, -19 },
  { 1454, 14, 19, 18, 2, -19 },
  { 1488, 17, 19, 17, 0, -19 },
  { 1529, 25, 19, 25, 0, -19 },
  { 1589, 17, 19, 17, 0, -19 },
  { 1630, 16, 19, 16, 0, -19 },
  { 1668, 13, 19, 15, 1, -19 },
  { 1699, 7, 23, 8, 1, -19 },
  { 1720, 11, 19, 11, 0, -19 },
  { 1747, 6, 23, 8, 1, -19 },
  { 1765, 14, 13, 14, 0, -19 },
  { 1788, 13, 3, 13, 0, 2 },
  { 1793, 8, 4, 10, 1, -20 },
  { 1797, 12, 15, 15, 1, -15 },
  { 1820, 13, 20, 16, 2, -20 },
  { 1853, 11, 15, 13, 1, -15 },
  { 1874, 13, 20, 16, 1, -20 },
  { 1907, 13, 15, 15, 1, -15 },
  { 1932, 11, 20, 10, 0, -20 },
  { 1960, 13, 21, 16, 1, -15 },
  { 1995, 13, 20, 16, 2, -20 },
  { 2028, 5, 20, 8, 1, -20 },
  { 2041, 7, 26, 8, -1, -20 },
  { 2064, 14, 20, 16, 2, -20 },
  { 2099, 4, 20, 8, 2, -20 },
  { 2109, 20, 15, 24, 2, -15 },
  { 2147, 13, 15, 16, 2, -15 },
  { 2172, 13, 15, 15, 1, -15 },
  { 2197, 13, 21, 16, 2, -15 },
  { 2232, 13, 21, 16, 1, -15 },
  { 2267, 9, 15, 11, 2, -15 },
  { 2284, 10, 15, 12, 1, -15 },
  { 2303, 10, 17, 11, 0, -17 },
  { 2325, 13, 14, 16, 2, -14 },
  { 2348, 15, 14, 15, 0, -14 },
  { 2375, 22, 14, 22, 0, -14 },
  { 2414, 15, 14, 15, 0, -14 },
  { 2441, 15, 20, 15, 0, -14 },
  { 2479, 11, 14, 12, 1, -14 },
  { 2499, 9, 23, 11, 1, -19 },
  { 2525, 4, 26, 12, 4, -20 },
  { 2538, 9, 23, 11, 1, -19 },
  { 2564, 12, 5, 14, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Black26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK26PT7B_H_
