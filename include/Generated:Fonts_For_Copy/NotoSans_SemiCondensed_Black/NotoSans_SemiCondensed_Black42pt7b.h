#ifndef _NOTOSANS_SEMICONDENSED_BLACK42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xF7, 0xE3, 0xFB, 0xF1, 0xFD, 0xF8, 0xFE, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF8, 0x01,
  0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07,
  0xE3, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x1F,
  0x8F, 0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xF3, 0x87, 0x3F, 0x9C, 0x01, 0xFC, 0xE0, 0x07, 0xF7, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x39, 0xFC,
  0x01, 0xCF, 0xE8, 0x0E, 0x7F, 0x78, 0x77, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x07, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0xFC, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0xFC, 0x00, 0xFC,
  0x7C, 0x1F, 0x80, 0x0F, 0xC7, 0xC1, 0xF8, 0x00, 0xFC, 0x7E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x7E, 0x00, 0x0F, 0xC7, 0xC7,
  0xE0, 0x00, 0xFC, 0xFC, 0xFC, 0x7F, 0x87, 0xFF, 0xCF, 0xCF, 0xFC, 0x7F,
  0xFD, 0xF9, 0xFF, 0xE3, 0xFF, 0x9F, 0x9F, 0xFE, 0x3F, 0xF3, 0xF3, 0xFF,
  0xF0, 0xFE, 0x3F, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xF3, 0xF0, 0x00, 0x7E,
  0x3E, 0x3F, 0x00, 0x0F, 0xC3, 0xE3, 0xF0, 0x00, 0xFC, 0x3E, 0x3F, 0x00,
  0x1F, 0x83, 0xE3, 0xF0, 0x01, 0xF8, 0x3F, 0x3F, 0x00, 0x3F, 0x03, 0xF3,
  0xF0, 0x03, 0xF0, 0x3F, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xE0,
  0x1F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xE3, 0xFC, 0x3F,
  0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x3F, 0xC7, 0xFB, 0xFF, 0xFE, 0x1F, 0xC7,
  0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xDF, 0xF8,
  0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xF8, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x06, 0x1F, 0x06, 0x7D,
  0xF7, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xF9, 0xF8,
  0x3F, 0x9F, 0xC1, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x20, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x3F, 0x9F, 0xCF, 0xE7, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF, 0xF1, 0xFE,
  0x7F, 0x87, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xF7, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFB,
  0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0x3F, 0xC3,
  0xF9, 0xFE, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F,
  0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0xFE,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0x1F, 0xF3, 0xC0, 0xFF, 0x18, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1C, 0x1F, 0xF1, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xF7,
  0xF0, 0x1F, 0xDF, 0xC0, 0x7E, 0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFD, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC7, 0xC0, 0xFE, 0xFF, 0x87, 0xEF,
  0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xCF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0x83,
  0xFD, 0xFE, 0x1F, 0xEF, 0xF1, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x3F, 0xE7, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x87,
  0xF1, 0xFC, 0x7F, 0x8F, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x1F, 0xE3, 0xFC, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x8F, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xDF, 0xC7, 0xFC, 0xFC, 0x0F, 0xCF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x08, 0x04, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE7, 0xF3, 0xF9, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF,
  0xC7, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0x07, 0xF9, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x03, 0xF0, 0x7E, 0x3E, 0x0F, 0xFF, 0x3E, 0x7E, 0x3F, 0xFF, 0x3E,
  0x7C, 0x7F, 0xFF, 0x3F, 0xFC, 0x7F, 0xFF, 0x1F, 0xFC, 0xFC, 0x3F, 0x1F,
  0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xF8, 0x3F, 0x1F, 0xF8, 0xF8, 0x3F, 0x1F,
  0xF9, 0xF8, 0x3F, 0x1F, 0xF9, 0xF8, 0x3F, 0x1F, 0xF8, 0xF8, 0x3F, 0x3F,
  0xF8, 0xF8, 0x7F, 0x3E, 0xF8, 0xFC, 0x7F, 0x3E, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFC, 0x3F, 0xEF, 0xF8, 0x7E, 0x1F, 0xC3, 0xF0,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xC0,
  0x1F, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x7F,
  0x9F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xE7,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF,
  0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF,
  0xCF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0x7F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0x0F, 0x1F,
  0xF0, 0x04, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x9F, 0xFC, 0x1E, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0x3F, 0xFC,
  0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC,
  0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xF0, 0x3C, 0x7F, 0xE0,
  0x04, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0xC0, 0x7F, 0x3F, 0xF0,
  0x7F, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE3, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF0,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F,
  0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0x7F, 0xFE, 0xFC, 0x3F,
  0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0xFC, 0x3F, 0x7F, 0xFE, 0x7E, 0x7E,
  0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7E, 0x7E, 0x7F, 0xFE, 0x7F, 0x7C,
  0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xFE, 0x3F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8,
  0x7F, 0xFE, 0x1F, 0xF8, 0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xF8, 0x7F,
  0xFE, 0xFF, 0x1F, 0xFF, 0x9F, 0xC7, 0xFF, 0xE7, 0xF9, 0xFF, 0xF8, 0xFE,
  0x7F, 0xFE, 0x3F, 0xDF, 0xFF, 0x8F, 0xF7, 0xFF, 0xE1, 0xFE, 0xFF, 0xF8,
  0x7F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE,
  0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F,
  0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xF0,
  0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03,
  0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC1, 0xE7,
  0xF8, 0x04, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE3, 0xFF, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFD,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07,
  0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x3F, 0x81, 0xFF, 0x81, 0xFE, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F, 0x81,
  0xFF, 0x81, 0xFC, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x1F, 0xC1, 0xFF, 0xC3,
  0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x1F,
  0xC3, 0xFF, 0xC3, 0xF8, 0x1F, 0xE3, 0xF7, 0xC7, 0xF8, 0x0F, 0xE7, 0xE7,
  0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0,
  0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x07, 0xF7, 0xE3, 0xEF, 0xF0, 0x07, 0xF7,
  0xC3, 0xEF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF,
  0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xCF, 0xF8, 0x0F, 0xF8,
  0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0x8F, 0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE7, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0x8F,
  0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xBF,
  0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3,
  0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3C, 0x3F, 0xC1, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFD, 0xFC, 0xFF, 0xE7, 0xE3, 0xFC, 0x3F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0C, 0x07, 0xF3,
  0xFC, 0x3F, 0xBF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0x81,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xF3, 0xFE, 0x1F, 0x8F, 0xE0, 0x00,
  0x30, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFE, 0x04, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x67, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0x07, 0xF8, 0x7F, 0x3F, 0xC7, 0xFD, 0xFE, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7F, 0xCF, 0xE1, 0xFC, 0x3F, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x02, 0x7F, 0xC1, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0x80, 0x00,
  0x7F, 0x1F, 0xC7, 0xFC, 0xFE, 0x7F, 0xF7, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xDF, 0xE1, 0xFC, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xA0, 0x03, 0xFC, 0xE0, 0x3F, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x1C, 0x07, 0xF3, 0xFC, 0x3F, 0xBF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0x0C, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00,
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x00, 0x80, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x08,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xFB, 0xF8, 0x1F,
  0xE7, 0xF0, 0x7F, 0x8F, 0xE1, 0xFE, 0x1F, 0xC7, 0xFC, 0x3F, 0x8F, 0xF0,
  0x7F, 0x3F, 0xC0, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0x8F, 0xE0, 0xFF, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0xF0, 0x7E, 0x3F, 0xC1,
  0xFE, 0x3F, 0x7F, 0xFB, 0xFF, 0x9F, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0,
  0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE,
  0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x1E, 0x07, 0xE3,
  0xFC, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x00,
  0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF9, 0xFE, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x9F, 0xF7,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x0C, 0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE1, 0xFE, 0xFE,
  0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8,
  0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFB, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0x1F, 0xC7, 0xFC, 0xFE, 0x7F, 0xF7, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xDF, 0xE1, 0xFC, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x1D, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x01,
  0xE0, 0x1F, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x0E, 0xFE, 0x02, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC1, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x87, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xDF, 0x8F, 0xFC, 0xFC, 0x3F, 0xC3, 0xE0, 0xFF, 0x00, 0xFF, 0x7F,
  0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x83, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xEF, 0xE0, 0x07,
  0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xEF, 0xE0, 0xFF,
  0x83, 0xFD, 0xFC, 0x1F, 0xF8, 0x7F, 0x3F, 0xC3, 0xFF, 0x0F, 0xE3, 0xF8,
  0x7F, 0xE1, 0xFC, 0x7F, 0x1F, 0xFC, 0x3F, 0x8F, 0xE3, 0xFF, 0x8F, 0xE1,
  0xFC, 0x7D, 0xF9, 0xFC, 0x1F, 0xCF, 0xBF, 0x3F, 0x83, 0xF9, 0xF7, 0xE7,
  0xF0, 0x7F, 0x7E, 0xFC, 0xFC, 0x0F, 0xEF, 0xCF, 0xBF, 0x80, 0xFD, 0xF9,
  0xF7, 0xF0, 0x1F, 0xBE, 0x3F, 0xFE, 0x03, 0xF7, 0xC7, 0xFF, 0x80, 0x7E,
  0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x7F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xE7,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03,
  0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x83, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE8, 0x01,
  0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Black42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 12, 2, -30 },
  { 32, 17, 11, 21, 2, -30 },
  { 56, 24, 30, 26, 1, -30 },
  { 146, 21, 34, 23, 1, -32 },
  { 236, 36, 30, 38, 1, -30 },
  { 371, 30, 30, 31, 1, -30 },
  { 484, 7, 11, 12, 2, -30 },
  { 494, 12, 38, 15, 2, -31 },
  { 551, 12, 38, 15, 1, -31 },
  { 608, 20, 20, 22, 1, -32 },
  { 658, 20, 20, 23, 2, -25 },
  { 708, 9, 12, 12, 1, -6 },
  { 722, 11, 6, 13, 1, -14 },
  { 731, 8, 8, 12, 2, -7 },
  { 739, 18, 30, 18, 0, -30 },
  { 807, 21, 30, 23, 1, -30 },
  { 886, 16, 30, 23, 2, -30 },
  { 946, 20, 30, 23, 1, -30 },
  { 1021, 20, 30, 23, 1, -30 },
  { 1096, 22, 30, 23, 1, -30 },
  { 1179, 19, 30, 23, 2, -30 },
  { 1251, 21, 30, 23, 1, -30 },
  { 1330, 20, 30, 23, 2, -30 },
  { 1405, 21, 30, 23, 1, -30 },
  { 1484, 21, 30, 23, 1, -30 },
  { 1563, 8, 25, 12, 2, -24 },
  { 1588, 9, 30, 12, 1, -24 },
  { 1622, 20, 22, 23, 2, -26 },
  { 1677, 20, 15, 23, 2, -22 },
  { 1715, 20, 22, 23, 2, -26 },
  { 1770, 19, 31, 20, 0, -30 },
  { 1844, 32, 33, 36, 2, -30 },
  { 1976, 28, 30, 28, 0, -30 },
  { 2081, 22, 30, 27, 3, -30 },
  { 2164, 22, 30, 25, 2, -30 },
  { 2247, 24, 30, 29, 3, -30 },
  { 2337, 17, 30, 21, 3, -30 },
  { 2401, 16, 30, 21, 3, -30 },
  { 2461, 24, 30, 29, 2, -30 },
  { 2551, 24, 30, 30, 3, -30 },
  { 2641, 15, 30, 17, 1, -30 },
  { 2698, 14, 39, 14, -3, -30 },
  { 2767, 24, 30, 27, 3, -30 },
  { 2857, 18, 30, 22, 3, -30 },
  { 2925, 32, 30, 38, 3, -30 },
  { 3045, 26, 30, 32, 3, -30 },
  { 3143, 27, 30, 31, 2, -30 },
  { 3245, 20, 30, 25, 3, -30 },
  { 3320, 27, 37, 31, 2, -30 },
  { 3445, 24, 30, 26, 3, -30 },
  { 3535, 19, 30, 22, 2, -30 },
  { 3607, 21, 30, 23, 1, -30 },
  { 3686, 23, 30, 29, 3, -30 },
  { 3773, 27, 30, 27, 0, -30 },
  { 3875, 40, 30, 40, 0, -30 },
  { 4025, 27, 30, 27, 0, -30 },
  { 4127, 26, 30, 26, 0, -30 },
  { 4225, 22, 30, 24, 1, -30 },
  { 4308, 10, 38, 13, 2, -31 },
  { 4356, 18, 30, 18, 0, -30 },
  { 4424, 10, 38, 13, 1, -31 },
  { 4472, 23, 20, 22, 0, -30 },
  { 4530, 21, 5, 21, 0, 3 },
  { 4544, 13, 7, 16, 2, -32 },
  { 4556, 21, 24, 24, 1, -24 },
  { 4619, 21, 32, 25, 3, -32 },
  { 4703, 18, 24, 21, 2, -24 },
  { 4757, 21, 32, 25, 2, -32 },
  { 4841, 20, 24, 24, 2, -24 },
  { 4901, 16, 32, 16, 1, -32 },
  { 4965, 21, 34, 25, 2, -24 },
  { 5055, 21, 32, 26, 3, -32 },
  { 5139, 8, 33, 13, 2, -33 },
  { 5172, 12, 43, 13, -2, -33 },
  { 5237, 23, 32, 26, 3, -32 },
  { 5329, 7, 32, 13, 3, -32 },
  { 5357, 33, 24, 39, 3, -24 },
  { 5456, 21, 24, 26, 3, -24 },
  { 5519, 21, 24, 25, 2, -24 },
  { 5582, 21, 34, 25, 3, -24 },
  { 5672, 21, 34, 25, 2, -24 },
  { 5762, 15, 24, 18, 3, -24 },
  { 5807, 16, 24, 20, 2, -24 },
  { 5855, 16, 28, 18, 1, -28 },
  { 5911, 21, 23, 26, 2, -23 },
  { 5972, 24, 23, 24, 0, -23 },
  { 6041, 35, 23, 36, 0, -23 },
  { 6142, 24, 23, 24, 0, -23 },
  { 6211, 24, 33, 24, 0, -23 },
  { 6310, 18, 23, 20, 1, -23 },
  { 6362, 15, 37, 17, 1, -30 },
  { 6432, 6, 41, 20, 7, -32 },
  { 6463, 15, 37, 17, 1, -30 },
  { 6533, 20, 8, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Black42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK42PT7B_H_
