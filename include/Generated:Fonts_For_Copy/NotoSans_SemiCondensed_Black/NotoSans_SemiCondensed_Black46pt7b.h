#ifndef _NOTOSANS_SEMICONDENSED_BLACK46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x04, 0x00, 0xFF, 0x1F, 0xFF, 0xE3, 0xFD, 0xFC, 0x7F, 0xBF,
  0x8F, 0xF7, 0xF1, 0xFE, 0xFE, 0x3F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7F,
  0x0F, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x87, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x01, 0xF8, 0xFC, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87,
  0xC0, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xE7, 0x86, 0x3F, 0x1E, 0x00, 0xFE, 0x78,
  0x03, 0xFD, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1E, 0xFF, 0x00, 0x79, 0xFE, 0x01, 0xE7,
  0xFF, 0x07, 0xBF, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0xFE,
  0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x7F, 0x07,
  0xE0, 0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7F,
  0x1F, 0x80, 0x00, 0xFE, 0x7F, 0x3F, 0x0F, 0xE0, 0x7E, 0x7E, 0x3F, 0x1F,
  0xF8, 0x7F, 0xFE, 0x7E, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0xFC, 0x3F,
  0xFC, 0xFC, 0x7F, 0xFE, 0x1F, 0xF8, 0xFC, 0xFE, 0x7E, 0x0F, 0xF1, 0xF8,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x7F,
  0x00, 0x03, 0xF0, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x7F, 0x00, 0x07,
  0xE0, 0xFC, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x7F, 0x00, 0x0F, 0xC0, 0xFC,
  0x7E, 0x00, 0x1F, 0x80, 0xFE, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00,
  0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x83,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0xFC,
  0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0xFF, 0xC3, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x81,
  0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x01, 0x03, 0xF0, 0x27, 0x8F, 0x87, 0x9F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xDF,
  0xC0, 0xFF, 0x3F, 0x81, 0xF8, 0xFF, 0x03, 0xE1, 0xF0, 0x03, 0x07, 0x00,
  0x04, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3,
  0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1F, 0xE3, 0xFE, 0xFF, 0x87, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0,
  0x7F, 0xBF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1,
  0xFE, 0xFF, 0x87, 0xF9, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFD, 0xFC, 0xFF, 0x3E, 0x3F, 0xC7, 0x0F, 0xF0, 0x83, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xC3, 0xFF, 0x1E, 0x07, 0xFC, 0x20, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8E, 0x03, 0xFE, 0x10, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFB, 0x00, 0x3F, 0xEF,
  0xC7, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xEF, 0xF0, 0x0F, 0xEF,
  0xF0, 0x1F, 0xCF, 0xF0, 0x1F, 0xCF, 0xF0, 0x3F, 0x8F, 0xF0, 0x3F, 0x8F,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x30, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xC6, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xC7, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC7, 0xC0, 0xFE, 0x7F,
  0xC3, 0xFB, 0xFF, 0x8F, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F,
  0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x1F, 0xF1, 0xFF,
  0x7F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC7, 0xFC, 0x7F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3,
  0xFE, 0x7F, 0x83, 0xFD, 0xFF, 0x07, 0xFB, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xDF, 0xF1, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xEF, 0xF0,
  0xFF, 0x9F, 0xC0, 0x7E, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0x82, 0x00, 0x0F, 0x0F, 0xE7, 0xFD,
  0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0xFE, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFE, 0x3F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0x81, 0xFF, 0x10,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x81, 0xFF, 0x0F, 0xC7,
  0xE0, 0xFF, 0xF9, 0xF9, 0xFC, 0x3F, 0xFF, 0x1F, 0xBF, 0x0F, 0xFF, 0xE3,
  0xF7, 0xE3, 0xFF, 0xFC, 0x7F, 0xF8, 0xFE, 0x1F, 0x8F, 0xFF, 0x1F, 0xC3,
  0xF0, 0xFF, 0xE3, 0xF0, 0x7E, 0x1F, 0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0x9F,
  0x81, 0xF8, 0x7F, 0xF3, 0xF0, 0x3F, 0x1F, 0xFE, 0x7E, 0x07, 0xE3, 0xFF,
  0xCF, 0xE0, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0x8F, 0xBF, 0x1F, 0xC7, 0xF3,
  0xF7, 0xE3, 0xFF, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xC3, 0xFF,
  0x7F, 0xE1, 0xF8, 0x3F, 0xC7, 0xF8, 0x3F, 0x81, 0xE0, 0x3C, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x10, 0x07, 0xFC, 0x00, 0x1C, 0x00,
  0x7F, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0x87, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF0, 0x1C, 0x3F, 0xE0, 0x04,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x02,
  0x3F, 0xF0, 0x0E, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFE,
  0x1F, 0xFC, 0xFF, 0x81, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0xBF, 0xE1, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x38, 0x3F, 0xF0, 0x01,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB,
  0xFE, 0x00, 0xFF, 0x7F, 0xE0, 0x1F, 0xE7, 0xFE, 0x03, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0x7F,
  0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07,
  0xFE, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xFE,
  0x07, 0xEF, 0xFF, 0xF7, 0xE0, 0xFE, 0xFF, 0xFF, 0x7F, 0x0F, 0xEF, 0xFF,
  0xF7, 0xF0, 0xFC, 0xFF, 0xFF, 0x7F, 0x0F, 0xCF, 0xFF, 0xF3, 0xF9, 0xFC,
  0xFF, 0xFF, 0x3F, 0x9F, 0x8F, 0xFF, 0xF3, 0xF9, 0xF8, 0xFF, 0xFF, 0x1F,
  0xBF, 0x8F, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0x07, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xC3, 0xFF,
  0xFD, 0xFF, 0x1F, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0x3F, 0xE7, 0xFF, 0xF8,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFC, 0xFF, 0xFE, 0x1F, 0xE7, 0xFF, 0xF0, 0xFF,
  0xBF, 0xFF, 0x83, 0xFD, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFE,
  0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xC7, 0xFE,
  0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xBF, 0xE3, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF,
  0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8,
  0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF9, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF,
  0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xF0, 0x3C, 0xFF, 0x00, 0x27, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x3F,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F,
  0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE,
  0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF7, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xFF, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF,
  0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0x9F, 0x8F, 0xF0, 0x0F, 0xF1, 0xF9, 0xF8,
  0xFF, 0x00, 0xFF, 0x3F, 0x9F, 0x8F, 0xF0, 0x07, 0xF3, 0xF9, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x9F, 0xDF, 0xE0, 0x07, 0xFB, 0xF0, 0xFD, 0xFE, 0x00,
  0x7F, 0xBF, 0x0F, 0xDF, 0xE0, 0x03, 0xFB, 0xF0, 0xFD, 0xFC, 0x00, 0x3F,
  0xFF, 0x0F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF9, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0xFE,
  0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xF1, 0xFF, 0x03, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFB, 0xFC, 0x3F, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0x7F, 0x1F, 0xFC,
  0xFE, 0x1F, 0xE0, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0x03, 0xFC, 0xFF, 0x87,
  0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x3F,
  0xEF, 0xFE, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFC, 0xFF, 0xC3, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFC, 0x0C, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x67, 0xFE, 0x3E, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x07, 0xC3, 0xFC, 0x3F, 0xE7, 0xF8, 0xFF, 0xEF,
  0xF3, 0xFF, 0xDF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFD,
  0xFE, 0x3F, 0xF1, 0xFC, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFC, 0x7F, 0xDF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x9F,
  0xF0, 0x0E, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x10, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x7F, 0xF7, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFE, 0xFF, 0x1F,
  0xF9, 0xFE, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xCE, 0x00, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x1F, 0x03, 0xFC, 0xFF, 0x87, 0xFB, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x7F,
  0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xE1, 0xFE, 0x3F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xF1,
  0xFE, 0x07, 0xFC, 0xFF, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x3E, 0x07, 0xE3, 0xFF, 0x87, 0xFE, 0x3F, 0xBF, 0xFE,
  0x7F, 0xF9, 0xFD, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xE3,
  0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x7F, 0xC3, 0xF9, 0xFF, 0xE7, 0xF7, 0xFF,
  0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFE,
  0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0x81, 0xFC, 0x7F,
  0xC3, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFB, 0xFE,
  0x1F, 0xF7, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0x7F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF3, 0xFC,
  0x7F, 0xF7, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x9F, 0xFE, 0xFF, 0x1F, 0xF9, 0xFE, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xBF, 0x9F, 0xDF,
  0xDF, 0xEF, 0xEF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xE1,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xF0, 0xF3, 0xFC, 0x04, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xF1, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F,
  0x9F, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x1F,
  0xE7, 0xF8, 0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xF8, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFF,
  0x07, 0xF9, 0xFE, 0x0F, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xFC, 0x1F, 0xE3,
  0xFC, 0x3F, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0xE1, 0xFE, 0x1F, 0xE3, 0xF7, 0xE3, 0xFC, 0x1F, 0xC7, 0xEF, 0xC7, 0xF0,
  0x3F, 0xCF, 0xDF, 0x9F, 0xE0, 0x7F, 0x9F, 0xBF, 0x3F, 0xC0, 0xFF, 0x7F,
  0x7E, 0x7F, 0x80, 0xFE, 0xFC, 0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0xFD, 0xFC,
  0x03, 0xFB, 0xF1, 0xFB, 0xF8, 0x07, 0xF7, 0xE3, 0xF7, 0xF0, 0x07, 0xEF,
  0xC7, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF3, 0xFE, 0x03, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFE,
  0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE7, 0xFC,
  0x07, 0xF9, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F,
  0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFE,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x04, 0xFF, 0x80,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x80, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 34, 13, 2, -33 },
  { 40, 19, 12, 23, 2, -33 },
  { 69, 27, 33, 28, 1, -33 },
  { 181, 22, 38, 25, 2, -35 },
  { 286, 40, 33, 42, 1, -33 },
  { 451, 33, 33, 34, 1, -33 },
  { 588, 8, 12, 13, 2, -33 },
  { 600, 13, 41, 16, 2, -34 },
  { 667, 13, 41, 16, 1, -34 },
  { 734, 22, 22, 24, 1, -35 },
  { 795, 22, 22, 25, 2, -27 },
  { 856, 10, 13, 14, 1, -7 },
  { 873, 13, 7, 15, 1, -16 },
  { 885, 9, 9, 13, 2, -8 },
  { 896, 20, 33, 20, 0, -33 },
  { 979, 22, 33, 25, 2, -33 },
  { 1070, 18, 33, 25, 2, -33 },
  { 1145, 22, 33, 25, 1, -33 },
  { 1236, 22, 33, 25, 2, -33 },
  { 1327, 24, 33, 25, 1, -33 },
  { 1426, 21, 33, 25, 2, -33 },
  { 1513, 22, 33, 25, 2, -33 },
  { 1604, 22, 33, 25, 2, -33 },
  { 1695, 23, 33, 25, 1, -33 },
  { 1790, 23, 33, 25, 1, -33 },
  { 1885, 9, 27, 13, 2, -26 },
  { 1916, 10, 32, 13, 1, -26 },
  { 1956, 22, 25, 25, 2, -29 },
  { 2025, 22, 16, 25, 2, -24 },
  { 2069, 22, 25, 25, 2, -29 },
  { 2138, 21, 34, 21, 0, -33 },
  { 2228, 35, 36, 39, 2, -33 },
  { 2386, 31, 33, 31, 0, -33 },
  { 2514, 24, 33, 29, 3, -33 },
  { 2613, 24, 33, 27, 2, -33 },
  { 2712, 26, 33, 31, 3, -33 },
  { 2820, 18, 33, 23, 3, -33 },
  { 2895, 18, 33, 23, 3, -33 },
  { 2970, 27, 33, 32, 2, -33 },
  { 3082, 26, 33, 33, 3, -33 },
  { 3190, 16, 33, 19, 1, -33 },
  { 3256, 15, 43, 15, -3, -33 },
  { 3337, 27, 33, 29, 3, -33 },
  { 3449, 20, 33, 24, 3, -33 },
  { 3532, 36, 33, 42, 3, -33 },
  { 3681, 29, 33, 35, 3, -33 },
  { 3801, 30, 33, 34, 2, -33 },
  { 3925, 23, 33, 27, 3, -33 },
  { 4020, 30, 41, 34, 2, -33 },
  { 4174, 26, 33, 29, 3, -33 },
  { 4282, 21, 33, 24, 2, -33 },
  { 4369, 23, 33, 25, 1, -33 },
  { 4464, 26, 33, 32, 3, -33 },
  { 4572, 30, 33, 30, 0, -33 },
  { 4696, 44, 33, 44, 0, -33 },
  { 4878, 30, 33, 30, 0, -33 },
  { 5002, 28, 33, 28, 0, -33 },
  { 5118, 24, 33, 26, 1, -33 },
  { 5217, 12, 42, 15, 2, -34 },
  { 5280, 20, 33, 20, 0, -33 },
  { 5363, 11, 42, 15, 1, -34 },
  { 5421, 25, 22, 24, 0, -33 },
  { 5490, 23, 6, 23, 0, 3 },
  { 5508, 14, 7, 18, 2, -35 },
  { 5521, 23, 26, 27, 1, -26 },
  { 5596, 23, 35, 28, 3, -35 },
  { 5697, 20, 26, 23, 2, -26 },
  { 5762, 23, 35, 28, 2, -35 },
  { 5863, 22, 26, 26, 2, -26 },
  { 5935, 18, 35, 18, 1, -35 },
  { 6014, 23, 37, 28, 2, -26 },
  { 6121, 23, 35, 28, 3, -35 },
  { 6222, 8, 36, 14, 3, -36 },
  { 6258, 13, 47, 14, -2, -36 },
  { 6335, 25, 35, 28, 3, -35 },
  { 6445, 8, 35, 14, 3, -35 },
  { 6480, 37, 26, 42, 3, -26 },
  { 6601, 23, 26, 28, 3, -26 },
  { 6676, 23, 26, 27, 2, -26 },
  { 6751, 23, 37, 28, 3, -26 },
  { 6858, 23, 37, 28, 2, -26 },
  { 6965, 17, 26, 20, 3, -26 },
  { 7021, 18, 26, 22, 2, -26 },
  { 7080, 17, 31, 19, 1, -31 },
  { 7146, 23, 25, 28, 3, -25 },
  { 7218, 26, 25, 26, 0, -25 },
  { 7300, 39, 25, 39, 0, -25 },
  { 7422, 26, 25, 26, 0, -25 },
  { 7504, 26, 36, 26, 0, -25 },
  { 7621, 19, 25, 21, 1, -25 },
  { 7681, 17, 41, 19, 1, -33 },
  { 7769, 6, 45, 22, 8, -35 },
  { 7803, 17, 41, 19, 1, -33 },
  { 7891, 22, 9, 25, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Black46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK46PT7B_H_
