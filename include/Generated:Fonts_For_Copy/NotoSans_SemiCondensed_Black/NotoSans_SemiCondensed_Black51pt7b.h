#ifndef _NOTOSANS_SEMICONDENSED_BLACK51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x7F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0xFE, 0x0C, 0x00,
  0xFF, 0x9F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E,
  0x1F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x3C, 0x3C,
  0xFE, 0x3C, 0x04, 0xFE, 0x3C, 0x00, 0xFF, 0x3C, 0x00, 0xFF, 0xBC, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3D, 0xFF, 0x00, 0x3C, 0xFF, 0x00, 0x3C, 0x7F,
  0x80, 0x3C, 0x7F, 0xF0, 0x3C, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xE0, 0x7F, 0x3F,
  0x8F, 0xE3, 0xFF, 0x87, 0xFF, 0xF9, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0x1F,
  0xCF, 0xFF, 0xC3, 0xFF, 0xF3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFE, 0x3F, 0x9F,
  0xFF, 0xE0, 0xFF, 0xC7, 0xF1, 0xFC, 0x7F, 0x03, 0xF0, 0x7F, 0x1F, 0xC7,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC7, 0xF0,
  0x00, 0x1F, 0xC3, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC7, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF9, 0xFF,
  0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xFD,
  0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x9F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x9F, 0xCF, 0xE7, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x60, 0x7E, 0x06, 0x7C,
  0x7E, 0x3E, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xE7, 0xF8, 0x1F,
  0xE7, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xC3, 0xF0, 0x03, 0xC1, 0xC0, 0x00,
  0x81, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF1, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x81,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xE3,
  0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xC3,
  0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x9F,
  0xF1, 0xF1, 0xFF, 0x0E, 0x1F, 0xF0, 0x41, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0x83, 0xFF, 0x0F, 0x80, 0xFF, 0x83, 0x80, 0x7F, 0xC0, 0x80, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1E, 0x07, 0xFE, 0x10, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x7F,
  0xE0, 0x3F, 0xDF, 0xF8, 0x1F, 0xE7, 0xFE, 0x07, 0xF1, 0xFF, 0x83, 0xFC,
  0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F, 0x87, 0xFE, 0x3F, 0xC1, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0xE1, 0xFE,
  0xFF, 0xF8, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFE, 0x3F, 0xF7, 0xFE, 0x0F, 0xFB, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFF, 0x1F, 0xF9, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFC,
  0x7F, 0xC1, 0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xF0, 0x7F, 0x8F, 0xF8, 0x7F,
  0xC7, 0xFE, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xBF, 0xF9, 0xFF,
  0x87, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0x9F, 0xFD,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3,
  0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFE, 0xFF, 0x1F, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x03, 0xE1,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x04, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0x7F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0x3F, 0x81, 0x00, 0x02, 0x03, 0xF8, 0xFF, 0x9F, 0xF7,
  0xFE, 0xFF, 0xDF, 0xF9, 0xFF, 0x3F, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3E, 0x03, 0xFE, 0x30, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x03, 0xF0, 0x7F,
  0x07, 0xFF, 0xF7, 0xF1, 0xFC, 0x1F, 0xFF, 0xC7, 0xE3, 0xF0, 0x7F, 0xFF,
  0x8F, 0xEF, 0xE1, 0xFF, 0xFF, 0x1F, 0xDF, 0xC7, 0xFF, 0xFE, 0x1F, 0xBF,
  0x0F, 0xE0, 0xFC, 0x3F, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0xFC, 0x7F, 0x03,
  0xF0, 0xFF, 0xF8, 0xFE, 0x07, 0xE1, 0xFF, 0xE1, 0xF8, 0x1F, 0xC3, 0xFF,
  0xC3, 0xF0, 0x3F, 0x87, 0xFF, 0x87, 0xE0, 0x7F, 0x0F, 0xFF, 0x0F, 0xC0,
  0xFE, 0x1F, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0xFE, 0x3F, 0x83, 0xF8, 0xFD,
  0xFC, 0x7F, 0x8F, 0xF3, 0xFB, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC7, 0xF0, 0xFF, 0xF7, 0xFF, 0x0F, 0xE0, 0xFF, 0xC7, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x3F, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xFE, 0xFF, 0x81,
  0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF,
  0x81, 0xFF, 0x3F, 0xE3, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0x87,
  0xFF, 0x00, 0x30, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x23, 0xFF, 0x80, 0x1C, 0x7F, 0xFE, 0x3F, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xEF, 0xF8, 0x0F,
  0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0xFF,
  0xEF, 0xF8, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xE0, 0xFF, 0xE0, 0x00, 0x83, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xDF, 0xF8,
  0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0x00,
  0x7F, 0xCF, 0xFC, 0x01, 0xFF, 0x3F, 0xFC, 0x07, 0xFC, 0x7F, 0xFE, 0x7F,
  0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0xE0,
  0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x07,
  0xFC, 0x7F, 0xF0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xF9,
  0xFF, 0x80, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xBF, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF,
  0x80, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xFD, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0x7F, 0xFF, 0xDF, 0xC0,
  0xFE, 0xFF, 0xFF, 0xBF, 0xC1, 0xFD, 0xFF, 0xFF, 0x7F, 0x87, 0xF3, 0xFF,
  0xFE, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0xFF, 0x1F, 0xCF, 0xFF, 0xF9, 0xFE,
  0x3F, 0x9F, 0xFF, 0xF1, 0xFC, 0xFE, 0x3F, 0xFF, 0xE3, 0xF9, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFB, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0x3F, 0xE1,
  0xFF, 0xFF, 0x3F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0x1F, 0xF9,
  0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0x07, 0xFD,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFC,
  0x03, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F,
  0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x87, 0xFC,
  0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80,
  0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xFD, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xE0, 0xFC, 0xFF, 0xC0, 0x18, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE,
  0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7,
  0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0x8F,
  0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE7,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x3F,
  0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xDF, 0x83, 0xFE, 0x07, 0xFC,
  0x3F, 0xBF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x1F, 0xF1,
  0xFE, 0xFE, 0x1F, 0xE0, 0x1F, 0xE3, 0xFD, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7,
  0xF3, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xE3, 0xF9, 0xFF, 0x00, 0xFF, 0x9F,
  0xC7, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0x8F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF,
  0x1F, 0xCF, 0xF0, 0x03, 0xFD, 0xFC, 0x3F, 0xBF, 0xE0, 0x07, 0xFB, 0xF8,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0x83, 0xFF, 0x04, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE,
  0x7F, 0x3F, 0xFC, 0x7F, 0x1F, 0xF8, 0x3F, 0x01, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3C, 0x03, 0xFE, 0x3F,
  0xC0, 0xFF, 0x9F, 0xFC, 0x3F, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xFB,
  0xFF, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F,
  0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x3F, 0xEF,
  0xFC, 0x1F, 0xFB, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xCF,
  0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xE0, 0x31, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x09, 0xFF, 0xC1, 0xE7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3C, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0xEF, 0xF8,
  0xFF, 0xFB, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF7, 0xF8, 0x7F, 0xF1, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3,
  0xFE, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x31, 0xFF, 0xE0, 0xF8,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0x84, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xC3, 0xFF, 0x9F, 0xE3, 0xFF, 0xEF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xBF, 0xC7, 0xFF, 0xFF,
  0xE1, 0xFF, 0xDF, 0xF0, 0x7F, 0x8F, 0xF8, 0x06, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x60, 0x01, 0xFF, 0xBF, 0x03, 0xFF, 0xDF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x1E, 0x03, 0xFE, 0x3F, 0xE0,
  0xFF, 0xBF, 0xFE, 0x3F, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xFB, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFC, 0x08, 0x1F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0x00, 0x40, 0x07, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE9, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x81, 0xFF,
  0x8F, 0xF8, 0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x8F, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x0F, 0xFB, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xF8,
  0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x7F, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xCF, 0xFF, 0x8F, 0xFF,
  0x9F, 0xEF, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x0F, 0xF3, 0xFF, 0xE3,
  0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xEF, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xF8, 0x7F,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF1, 0xFF,
  0xC3, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF,
  0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xEF, 0xFC, 0x0F, 0xFB, 0xFF, 0x03, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF,
  0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xC3, 0xFE, 0x7F, 0xE0, 0xFF, 0x8F,
  0xF0, 0x3F, 0xE0, 0x20, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xC3,
  0xFF, 0x9F, 0xE3, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF,
  0x0F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xBF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xF0, 0x7F, 0x8F, 0xF8,
  0x06, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xDF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xEF,
  0xF7, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0x8B, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF8, 0x3C, 0xFF, 0x80, 0x4F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x14, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x40, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0x9F, 0xC7,
  0xFF, 0x8F, 0xE0, 0xFF, 0x87, 0xF0, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xFC,
  0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xE3, 0xFE, 0x1F, 0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFF, 0xE0, 0xFF, 0x0F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xDF, 0x87, 0xFC, 0x1F, 0xE1,
  0xFB, 0xF0, 0xFF, 0x83, 0xFE, 0x7F, 0x7F, 0x1F, 0xE0, 0x7F, 0xCF, 0xEF,
  0xE7, 0xFC, 0x0F, 0xF9, 0xFD, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xBF, 0x9F,
  0xF0, 0x1F, 0xE7, 0xF3, 0xF3, 0xFC, 0x03, 0xFC, 0xFC, 0x7F, 0x7F, 0x80,
  0x7F, 0xBF, 0x8F, 0xEF, 0xF0, 0x07, 0xFF, 0xF1, 0xFD, 0xFE, 0x00, 0xFF,
  0xFE, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF7, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x9F, 0xF8, 0x0F, 0xFD,
  0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F,
  0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x7F,
  0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x11, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x50, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x01, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x01, 0x3F, 0xF0, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 37, 14, 2, -36 },
  { 48, 20, 13, 26, 3, -36 },
  { 81, 30, 36, 32, 1, -36 },
  { 216, 24, 42, 28, 2, -39 },
  { 342, 44, 37, 46, 1, -37 },
  { 546, 36, 38, 38, 2, -37 },
  { 717, 9, 13, 14, 3, -36 },
  { 732, 15, 45, 18, 2, -37 },
  { 817, 15, 45, 18, 1, -37 },
  { 902, 24, 24, 26, 1, -39 },
  { 974, 24, 24, 28, 2, -30 },
  { 1046, 11, 14, 15, 1, -7 },
  { 1066, 14, 8, 16, 1, -18 },
  { 1080, 10, 10, 14, 2, -9 },
  { 1093, 22, 38, 22, 0, -37 },
  { 1198, 24, 38, 28, 2, -37 },
  { 1312, 20, 36, 28, 2, -36 },
  { 1402, 25, 37, 28, 1, -37 },
  { 1518, 24, 38, 28, 2, -37 },
  { 1632, 26, 36, 28, 1, -36 },
  { 1749, 24, 37, 28, 2, -36 },
  { 1860, 25, 38, 28, 2, -37 },
  { 1979, 24, 36, 28, 2, -36 },
  { 2087, 25, 38, 28, 2, -37 },
  { 2206, 24, 38, 28, 2, -37 },
  { 2320, 10, 30, 15, 2, -29 },
  { 2358, 11, 36, 15, 1, -29 },
  { 2408, 24, 27, 28, 2, -32 },
  { 2489, 24, 18, 28, 2, -27 },
  { 2543, 24, 27, 28, 2, -32 },
  { 2624, 23, 38, 24, 0, -37 },
  { 2734, 39, 41, 43, 2, -37 },
  { 2934, 34, 37, 34, 0, -37 },
  { 3092, 26, 36, 32, 4, -36 },
  { 3209, 27, 38, 30, 2, -37 },
  { 3338, 28, 36, 35, 4, -36 },
  { 3464, 20, 36, 26, 4, -36 },
  { 3554, 20, 36, 26, 4, -36 },
  { 3644, 30, 38, 35, 2, -37 },
  { 3787, 29, 36, 36, 4, -36 },
  { 3918, 17, 36, 21, 2, -36 },
  { 3995, 17, 47, 17, -4, -36 },
  { 4095, 29, 36, 33, 4, -36 },
  { 4226, 21, 36, 27, 4, -36 },
  { 4321, 39, 36, 46, 4, -36 },
  { 4497, 32, 36, 39, 4, -36 },
  { 4641, 33, 38, 37, 2, -37 },
  { 4798, 24, 36, 30, 4, -36 },
  { 4906, 34, 46, 37, 2, -37 },
  { 5102, 29, 36, 32, 4, -36 },
  { 5233, 24, 38, 27, 2, -37 },
  { 5347, 26, 36, 28, 1, -36 },
  { 5464, 29, 37, 35, 3, -36 },
  { 5599, 33, 36, 33, 0, -36 },
  { 5748, 47, 36, 49, 1, -36 },
  { 5960, 33, 36, 33, 0, -36 },
  { 6109, 31, 36, 31, 0, -36 },
  { 6249, 26, 36, 29, 1, -36 },
  { 6366, 12, 46, 16, 3, -37 },
  { 6435, 22, 38, 22, 0, -37 },
  { 6540, 13, 46, 16, 1, -37 },
  { 6615, 27, 25, 27, 0, -37 },
  { 6700, 26, 6, 26, 0, 3 },
  { 6720, 16, 8, 20, 2, -39 },
  { 6736, 24, 30, 29, 2, -29 },
  { 6826, 26, 40, 31, 3, -39 },
  { 6956, 22, 30, 26, 2, -29 },
  { 7039, 25, 40, 31, 2, -39 },
  { 7164, 25, 30, 29, 2, -29 },
  { 7258, 20, 39, 19, 1, -39 },
  { 7356, 25, 41, 31, 2, -29 },
  { 7485, 26, 39, 32, 3, -39 },
  { 7612, 10, 40, 15, 3, -40 },
  { 7662, 15, 52, 15, -2, -40 },
  { 7760, 28, 39, 31, 3, -39 },
  { 7897, 9, 39, 15, 3, -39 },
  { 7941, 41, 29, 47, 3, -29 },
  { 8090, 26, 29, 32, 3, -29 },
  { 8185, 26, 30, 30, 2, -29 },
  { 8283, 26, 41, 31, 3, -29 },
  { 8417, 25, 41, 31, 2, -29 },
  { 8546, 19, 29, 22, 3, -29 },
  { 8615, 20, 30, 24, 2, -29 },
  { 8690, 19, 35, 21, 1, -34 },
  { 8774, 25, 29, 32, 3, -28 },
  { 8865, 29, 28, 29, 0, -28 },
  { 8967, 43, 28, 43, 0, -28 },
  { 9118, 29, 28, 29, 0, -28 },
  { 9220, 29, 40, 29, 0, -28 },
  { 9365, 22, 28, 24, 1, -28 },
  { 9442, 18, 46, 21, 1, -37 },
  { 9546, 7, 50, 24, 9, -39 },
  { 9590, 19, 46, 21, 1, -37 },
  { 9700, 24, 10, 28, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Black51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK51PT7B_H_
