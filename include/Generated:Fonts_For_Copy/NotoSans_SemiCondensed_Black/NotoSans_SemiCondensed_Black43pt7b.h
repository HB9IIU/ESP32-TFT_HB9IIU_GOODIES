#ifndef _NOTOSANS_SEMICONDENSED_BLACK43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFE, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x1F, 0x0F,
  0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFB,
  0xCF, 0x3F, 0x9E, 0x09, 0xFC, 0xF0, 0x0F, 0xE7, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xEF, 0xE0,
  0x0F, 0x3F, 0x60, 0x79, 0xFB, 0xE3, 0xDF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x7E, 0x00, 0x7E, 0x7E, 0x03,
  0xE0, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0xFC,
  0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xE7, 0xE1, 0xF0, 0x7E, 0x7E,
  0x3E, 0x3F, 0xE1, 0xFF, 0xF3, 0xF3, 0xFF, 0x8F, 0xFF, 0x9F, 0x3F, 0xFE,
  0x3F, 0xF9, 0xF9, 0xFF, 0xF0, 0xFF, 0x8F, 0x8F, 0xDF, 0xC3, 0xF8, 0xFC,
  0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x1F, 0x80,
  0x03, 0xE1, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0x7E,
  0x3F, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x00, 0xF8, 0x0F, 0xCF, 0xC0, 0x0F,
  0xC0, 0x7F, 0xFC, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFE,
  0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x81, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0x83, 0xFC,
  0x1F, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0xBF, 0xC3,
  0xFC, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F,
  0xC1, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x07, 0xF0,
  0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x04, 0x0F, 0x82, 0x78,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFD, 0xF8,
  0x3F, 0x9F, 0xC3, 0xF8, 0xFC, 0x0F, 0x0F, 0x00, 0x30, 0x60, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x9F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x18, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x7F, 0xCF, 0xF1, 0xFE,
  0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF0,
  0x7F, 0xBF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFB,
  0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3,
  0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0xFE, 0x3F, 0xCF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xDF,
  0xE7, 0xCF, 0xF1, 0xC7, 0xF8, 0xC3, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC7, 0xC1, 0xFE, 0x1C, 0x0F, 0xF0, 0x40, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7C, 0xFF, 0xC3,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xDF, 0xE0, 0x7F, 0x7F, 0x81, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F,
  0x1F, 0xE1, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1,
  0x87, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0x47, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x7F, 0x07, 0xF7, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFE, 0x0F, 0xEF,
  0xF0, 0xFF, 0x7F, 0xCF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFE, 0x1F, 0xCF, 0xF0, 0xFF,
  0x7F, 0x87, 0xF3, 0xFC, 0x3F, 0x8F, 0xF3, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0x1F, 0xF7, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFB, 0xFE, 0xFF, 0xDF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0x7F, 0xCF, 0xF0, 0xFE, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF,
  0xC3, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFE, 0xFE, 0x1F, 0xE7, 0xF0, 0x3C, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08,
  0x1F, 0x1F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3, 0xF9,
  0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0x87,
  0xF9, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x07, 0xFE,
  0x3F, 0x3F, 0x0F, 0xFF, 0xDF, 0x9F, 0x8F, 0xFF, 0xE7, 0xCF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xC7, 0xF1, 0xF1, 0xFF, 0xE7, 0xF0, 0xF8, 0xFF, 0xE3, 0xF0,
  0x7C, 0x3F, 0xF1, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x1F, 0x0F, 0xFC, 0x7C,
  0x0F, 0x8F, 0xFE, 0x3E, 0x0F, 0xC7, 0xFF, 0x1F, 0x87, 0xE3, 0xEF, 0x8F,
  0xC3, 0xF1, 0xF7, 0xC7, 0xF3, 0xFD, 0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7C, 0x3F, 0xE7, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0C, 0x00,
  0x7F, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80,
  0x1F, 0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF,
  0x80, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFB, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC3, 0xFE, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xF8, 0x0C, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x02, 0x3F, 0xF0,
  0x78, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE,
  0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xC0, 0x08, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD,
  0xFF, 0x01, 0xFE, 0xFF, 0xC0, 0xFF, 0x3F, 0xF8, 0x7F, 0x9F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x38, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F,
  0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F, 0xEF,
  0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xC1,
  0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFB, 0xFC, 0x07,
  0xFE, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xEF, 0xFF, 0xDF, 0x83, 0xF7,
  0xFF, 0xEF, 0xC1, 0xFB, 0xFF, 0xF7, 0xE0, 0xFD, 0xFF, 0xFB, 0xF8, 0xFC,
  0xFF, 0xFC, 0xFC, 0x7E, 0x7F, 0xFE, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0x9F,
  0x9F, 0xFF, 0x9F, 0xDF, 0x8F, 0xFF, 0xC7, 0xEF, 0xC7, 0xFF, 0xE3, 0xF7,
  0xE3, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFC, 0x3F,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0x07, 0xFF,
  0xEF, 0xF0, 0xFF, 0xFC, 0xFE, 0x1F, 0xFF, 0x9F, 0xE3, 0xFF, 0xF3, 0xFC,
  0x7F, 0xFE, 0x3F, 0xCF, 0xFF, 0xC7, 0xF9, 0xFF, 0xF8, 0x7F, 0xBF, 0xFF,
  0x0F, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFE, 0xFF, 0xF3, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x03,
  0xFE, 0x3F, 0xF9, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0xC7,
  0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F,
  0xE7, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x07, 0xFC, 0x3F,
  0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xF8, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xDF, 0xCF, 0xF0, 0x1C, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFE, 0xFC, 0x7F, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0x7F, 0xE7, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F,
  0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFB, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF1, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x7F,
  0x83, 0xFF, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF,
  0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0xF0, 0x7F, 0x03, 0xF8, 0x3E, 0xF8, 0x3F,
  0x81, 0xFE, 0x3F, 0x7E, 0x3F, 0xC0, 0xFF, 0x1F, 0xBF, 0x1F, 0xE0, 0x3F,
  0x8F, 0xDF, 0x8F, 0xE0, 0x1F, 0xC7, 0xEF, 0xC7, 0xF0, 0x0F, 0xE7, 0xF7,
  0xE3, 0xF8, 0x07, 0xF3, 0xF1, 0xFB, 0xFC, 0x01, 0xFD, 0xF8, 0xFD, 0xFE,
  0x00, 0xFE, 0xFC, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x3F, 0x7F, 0x00, 0x3F,
  0xBF, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x07, 0xDF, 0xC0, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF1, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xFE, 0x00, 0xFF,
  0x9F, 0xE0, 0x0F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80,
  0x3F, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xFE, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03, 0xF9, 0xF8,
  0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x38, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFB, 0xFD, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFE, 0xFC, 0xFF, 0xE7, 0xE3, 0xFC,
  0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0xF1, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xF1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0x9F,
  0xF8, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFC, 0x3B, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x77, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x3F,
  0xC7, 0xFC, 0xFE, 0x7F, 0xF7, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xEF, 0xE3, 0xFE, 0x7F, 0x0F, 0xE1,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xEF, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0x1F, 0xF8, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE3,
  0xF8, 0xFF, 0x9F, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFD, 0xFC, 0x7F, 0xDF, 0xE1, 0xFC,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0xE0, 0x1F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x3F, 0x9F, 0xF1, 0xFD, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x3F, 0xBF, 0xFF, 0xF7,
  0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xF7, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x1F, 0xC3, 0xFE, 0x3F,
  0x8F, 0xF8, 0x7F, 0x1F, 0xE0, 0xFE, 0x7F, 0x81, 0xFD, 0xFF, 0x03, 0xFB,
  0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0xFF, 0x8F, 0xE0, 0xFF, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFF,
  0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x3F, 0xF9, 0xFF, 0xCF, 0xDF, 0xFE, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xE7, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xFF, 0x07, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xF8, 0x1F,
  0xE0, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFF,
  0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x83,
  0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F, 0x87, 0xE7, 0xFE, 0x3F, 0x7F,
  0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xF8, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0xFC, 0x3F, 0x07, 0xE3, 0xFE, 0x3F, 0xBF, 0xF9, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFB, 0xFF, 0x1F, 0xCF, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0xFF,
  0x9F, 0xCF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFD, 0xFC, 0x7F, 0xCF, 0xE1, 0xFC, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFC, 0x3F, 0xF8, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0xF8, 0x1F, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF9, 0xF3,
  0xF8, 0x19, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0,
  0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE1,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xFC, 0xFF, 0xE7,
  0xE3, 0xFC, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFC,
  0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xE0, 0xFF,
  0x7F, 0x87, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0xE0, 0xFE, 0x7F, 0x87, 0xFE,
  0x0F, 0xE3, 0xF8, 0x7F, 0xF1, 0xFE, 0x3F, 0x87, 0xFF, 0x1F, 0xC3, 0xFC,
  0xFF, 0xF1, 0xFC, 0x3F, 0xCF, 0xFF, 0x1F, 0xC1, 0xFC, 0xFD, 0xF3, 0xFC,
  0x1F, 0xCF, 0x9F, 0xBF, 0x81, 0xFC, 0xF9, 0xFB, 0xF8, 0x1F, 0xDF, 0x9F,
  0xBF, 0x80, 0xFD, 0xF9, 0xFB, 0xF8, 0x0F, 0xFF, 0x8F, 0xBF, 0x00, 0xFF,
  0xF8, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x7F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE,
  0x3F, 0xE3, 0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xF8, 0x1F, 0xF7, 0xF8,
  0x1F, 0xE7, 0xFC, 0x3F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFE, 0x7F, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC,
  0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F, 0xE7, 0xF8,
  0x0F, 0xE7, 0xF8, 0x0F, 0xF7, 0xF0, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0xE1, 0xFF,
  0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Black43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 18, 11, 22, 2, -31 },
  { 58, 25, 31, 27, 1, -31 },
  { 155, 21, 36, 24, 1, -33 },
  { 250, 37, 31, 39, 1, -31 },
  { 394, 31, 31, 32, 1, -31 },
  { 515, 8, 11, 12, 2, -31 },
  { 526, 12, 39, 15, 2, -32 },
  { 585, 12, 39, 15, 1, -32 },
  { 644, 20, 20, 22, 1, -33 },
  { 694, 20, 21, 24, 2, -26 },
  { 747, 9, 12, 13, 1, -6 },
  { 761, 12, 7, 14, 1, -15 },
  { 772, 8, 9, 12, 2, -8 },
  { 781, 19, 31, 19, 0, -31 },
  { 855, 21, 31, 24, 1, -31 },
  { 937, 17, 31, 24, 2, -31 },
  { 1003, 21, 31, 24, 1, -31 },
  { 1085, 21, 31, 24, 1, -31 },
  { 1167, 22, 31, 24, 1, -31 },
  { 1253, 20, 31, 24, 2, -31 },
  { 1331, 21, 31, 24, 1, -31 },
  { 1413, 20, 31, 24, 2, -31 },
  { 1491, 21, 31, 24, 1, -31 },
  { 1573, 21, 31, 24, 1, -31 },
  { 1655, 8, 25, 12, 2, -24 },
  { 1680, 9, 30, 13, 1, -24 },
  { 1714, 20, 23, 24, 2, -27 },
  { 1772, 20, 15, 24, 2, -23 },
  { 1810, 20, 23, 24, 2, -27 },
  { 1868, 19, 32, 20, 0, -31 },
  { 1944, 33, 34, 37, 2, -31 },
  { 2085, 29, 31, 29, 0, -31 },
  { 2198, 22, 31, 27, 3, -31 },
  { 2284, 22, 31, 26, 2, -31 },
  { 2370, 24, 31, 29, 3, -31 },
  { 2463, 17, 31, 22, 3, -31 },
  { 2529, 17, 31, 22, 3, -31 },
  { 2595, 25, 31, 30, 2, -31 },
  { 2692, 24, 31, 30, 3, -31 },
  { 2785, 15, 31, 18, 1, -31 },
  { 2844, 14, 41, 14, -3, -31 },
  { 2916, 25, 31, 27, 3, -31 },
  { 3013, 18, 31, 23, 3, -31 },
  { 3083, 33, 31, 39, 3, -31 },
  { 3211, 27, 31, 33, 3, -31 },
  { 3316, 27, 31, 31, 2, -31 },
  { 3421, 21, 31, 25, 3, -31 },
  { 3503, 28, 38, 31, 2, -31 },
  { 3636, 24, 31, 27, 3, -31 },
  { 3729, 20, 31, 23, 2, -31 },
  { 3807, 21, 31, 23, 1, -31 },
  { 3889, 24, 31, 30, 3, -31 },
  { 3982, 28, 31, 28, 0, -31 },
  { 4091, 41, 31, 41, 0, -31 },
  { 4250, 28, 31, 28, 0, -31 },
  { 4359, 26, 31, 26, 0, -31 },
  { 4460, 22, 31, 24, 1, -31 },
  { 4546, 11, 39, 14, 2, -32 },
  { 4600, 19, 31, 19, 0, -31 },
  { 4674, 10, 39, 14, 1, -32 },
  { 4723, 23, 21, 23, 0, -31 },
  { 4784, 22, 5, 22, 0, 3 },
  { 4798, 13, 7, 17, 2, -33 },
  { 4810, 21, 24, 25, 1, -24 },
  { 4873, 21, 33, 26, 3, -33 },
  { 4960, 18, 24, 22, 2, -24 },
  { 5014, 21, 33, 26, 2, -33 },
  { 5101, 21, 24, 24, 2, -24 },
  { 5164, 16, 33, 16, 1, -33 },
  { 5230, 21, 34, 26, 2, -24 },
  { 5320, 21, 33, 27, 3, -33 },
  { 5407, 9, 33, 13, 2, -33 },
  { 5445, 13, 43, 13, -2, -33 },
  { 5515, 23, 33, 26, 3, -33 },
  { 5610, 7, 33, 13, 3, -33 },
  { 5639, 34, 24, 40, 3, -24 },
  { 5741, 21, 24, 27, 3, -24 },
  { 5804, 22, 24, 26, 2, -24 },
  { 5870, 21, 34, 26, 3, -24 },
  { 5960, 21, 34, 26, 2, -24 },
  { 6050, 15, 24, 19, 3, -24 },
  { 6095, 17, 24, 20, 2, -24 },
  { 6146, 16, 29, 18, 1, -29 },
  { 6204, 21, 24, 27, 3, -24 },
  { 6267, 24, 24, 24, 0, -24 },
  { 6339, 36, 24, 36, 0, -24 },
  { 6447, 24, 24, 25, 0, -24 },
  { 6519, 24, 34, 24, 0, -24 },
  { 6621, 18, 24, 20, 1, -24 },
  { 6675, 15, 38, 18, 1, -31 },
  { 6747, 6, 43, 20, 7, -33 },
  { 6780, 16, 38, 18, 1, -31 },
  { 6856, 20, 8, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Black43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK43PT7B_H_
