#ifndef _NOTOSANS_SEMICONDENSED_BLACK38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0x9F, 0xBF, 0xFF, 0xFF, 0xFD,
  0xF0, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x1F, 0xBE, 0x3F, 0x7C, 0x7E, 0xF8, 0x7C, 0x01, 0xF3, 0xE0, 0x07,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x8F,
  0x00, 0x3E, 0x7C, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8,
  0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07,
  0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0xE3, 0x9F, 0x9C, 0x03, 0xF3,
  0x80, 0x7F, 0x70, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x77, 0xF0, 0x0E,
  0x7E, 0x81, 0xCF, 0xDF, 0x3B, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x03,
  0xE0, 0x0F, 0xFE, 0x03, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0x07, 0xEF, 0xC1,
  0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0xF8, 0x00, 0xF8, 0xF8,
  0x7C, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x3E, 0x1E, 0x0F, 0xDF, 0x9F, 0x3F, 0xC3, 0xFF, 0x9F, 0x3F, 0xF1, 0xFF,
  0xCF, 0xBF, 0xFC, 0x7F, 0xCF, 0x9F, 0xFE, 0x1F, 0xC7, 0xCF, 0x9F, 0x01,
  0x07, 0xC7, 0xCF, 0xC0, 0x03, 0xE7, 0xE7, 0xE0, 0x03, 0xE3, 0xF3, 0xF0,
  0x01, 0xF1, 0xF9, 0xF8, 0x01, 0xF0, 0x7C, 0xFC, 0x00, 0xF8, 0x3E, 0x7C,
  0x00, 0xF8, 0x1F, 0x3E, 0x00, 0x7C, 0x0F, 0xFF, 0x00, 0x7C, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFC,
  0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE1, 0xFC, 0x3F, 0xF8, 0x7F, 0x8F, 0xFF, 0x8F, 0xE3,
  0xFF, 0xF9, 0xFC, 0x7F, 0x7F, 0xFF, 0x9F, 0xC7, 0xFF, 0xE3, 0xF8, 0x7F,
  0xFC, 0x7F, 0x07, 0xFF, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0x3F, 0xF8, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF,
  0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x3E,
  0x7C, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x81, 0xE0, 0xBC, 0x79, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x83,
  0xF3, 0xF1, 0xF8, 0xF8, 0x0E, 0x1C, 0x00, 0x84, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xEF, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF,
  0xC3, 0xF9, 0xF8, 0x3F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F,
  0x0F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0xEF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0xF9, 0xFC, 0xE3, 0xF8, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x40, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xF7, 0xFC, 0xF0, 0x7F, 0x10, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC3, 0xFC, 0x40, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC3, 0xF3,
  0xF8, 0xFC, 0x7F, 0x1F, 0x8F, 0xE7, 0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x04, 0x00,
  0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x3F,
  0x7F, 0x8F, 0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF7, 0xE0, 0xFE, 0xFE,
  0x1F, 0xDF, 0xEF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0xFE, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0xFF, 0x8F, 0xF7, 0xF9, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xCF, 0xF7, 0xF0, 0xFE, 0xFE,
  0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF1, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFD, 0xF8, 0x1F,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x10, 0x3F, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x7E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xFE,
  0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFC, 0xF0, 0xFE, 0x40,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x1C, 0x1F, 0x0F, 0xC3,
  0xFF, 0x3E, 0x3E, 0x3F, 0xFC, 0xF9, 0xF1, 0xFF, 0xF1, 0xE7, 0xC7, 0xE7,
  0xC7, 0xDF, 0x3F, 0x1F, 0x1F, 0x7C, 0xF8, 0x7C, 0x7D, 0xE3, 0xE1, 0xF1,
  0xFF, 0x8F, 0x87, 0xC7, 0xFE, 0x3E, 0x1F, 0x1F, 0xF8, 0xF8, 0x7C, 0x79,
  0xE3, 0xE1, 0xF3, 0xE7, 0x8F, 0xCF, 0xCF, 0x9F, 0x3F, 0xFF, 0xFC, 0x7C,
  0x7F, 0xDF, 0xE1, 0xF8, 0xFE, 0x3F, 0x83, 0xE0, 0xE0, 0x30, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFE, 0x01,
  0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xE7,
  0xC7, 0xF8, 0x04, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x06, 0x7F, 0xF7, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF8, 0x7F, 0xDF,
  0xC1, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xEF, 0xE1, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x04,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0x1F, 0x1F, 0xF0, 0x08, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x07, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xF8, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xFB, 0xFF,
  0xDF, 0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0x20, 0x00, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x1F,
  0xE3, 0xF8, 0xFE, 0x1F, 0xCF, 0xF0, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF3, 0xFC, 0x3F, 0x9F, 0xE1, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x9F, 0xC1, 0xFE,
  0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFE, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0xFB, 0xE1, 0xF7, 0xFF, 0xDF, 0x8F,
  0xBF, 0xFE, 0xFC, 0x7D, 0xFF, 0xF3, 0xE7, 0xEF, 0xFF, 0x9F, 0xBE, 0x7F,
  0xFC, 0xFD, 0xF3, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x1F, 0xFC, 0xFF, 0xF8,
  0xFF, 0xC7, 0xFF, 0xC7, 0xFE, 0x3F, 0xFE, 0x1F, 0xF1, 0xFF, 0xF0, 0xFF,
  0x0F, 0xFF, 0x87, 0xF8, 0x7F, 0xFC, 0x3F, 0xC3, 0xFF, 0xE0, 0xFE, 0x1F,
  0xFF, 0x07, 0xE0, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFD, 0xFC,
  0x7F, 0xFD, 0xFC, 0x7F, 0xFC, 0xFE, 0x7F, 0xFC, 0xFE, 0x7F, 0xFC, 0x7F,
  0x7F, 0xFC, 0x7F, 0x7F, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x3F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87,
  0xF1, 0xFC, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF7, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFF,
  0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFE, 0x00, 0x60, 0x01, 0xFF, 0xC1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF9, 0xF9, 0xFC,
  0x04, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xC7, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8,
  0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFE,
  0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xC0, 0x7F,
  0x7F, 0x03, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x03, 0xFC,
  0x0F, 0xE3, 0xF0, 0x3F, 0xC0, 0xFE, 0x3F, 0x03, 0xFE, 0x0F, 0xC3, 0xF8,
  0x7F, 0xE0, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0xE1, 0xFC,
  0x1F, 0x87, 0xFF, 0x1F, 0xC1, 0xF8, 0xFF, 0xF1, 0xF8, 0x1F, 0xCF, 0xDF,
  0x1F, 0x81, 0xFC, 0xF9, 0xF3, 0xF8, 0x0F, 0xCF, 0x9F, 0x3F, 0x80, 0xFC,
  0xF9, 0xF3, 0xF0, 0x0F, 0xDF, 0x9F, 0xBF, 0x00, 0xFF, 0xF8, 0xFB, 0xF0,
  0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x3F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0xFF,
  0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0x7F, 0xBF, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xFD,
  0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0x07,
  0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xBF, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xF0,
  0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x18, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x0F, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xDF, 0x9F, 0xF3,
  0xF1, 0xFC, 0x3E, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x7E,
  0x1F, 0xDF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x3F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7E, 0x7F, 0xCF, 0xC7, 0xE0,
  0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF3, 0xFC,
  0x39, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x04, 0xFF, 0x8E, 0x7F, 0xFF,
  0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x3F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFE,
  0x0F, 0xDF, 0xC3, 0xFB, 0xFC, 0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFB, 0xF0, 0xFE, 0x3E, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0xDF, 0xC1, 0xFB, 0xF0,
  0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x06, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xF8, 0x3F, 0xF1,
  0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0xFF, 0x23, 0xF8, 0x0F, 0xE0, 0x3F, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x0F,
  0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0x3F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F, 0xDF, 0xC3, 0xFB, 0xFC,
  0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFB, 0xF0, 0xFE,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFB, 0x00, 0x7F, 0x7E, 0x3F, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x7F, 0x1F, 0xDF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7,
  0xE7, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF,
  0xF9, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0x87, 0xF9, 0xFC, 0x3F, 0x8F, 0xE3,
  0xF8, 0x7F, 0x3F, 0xC3, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFC, 0xFE, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F,
  0x83, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x7F,
  0x07, 0xF1, 0xFB, 0xFF, 0x3F, 0xF3, 0xF7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x3F, 0xFF, 0xC3, 0xFC,
  0x3F, 0xFF, 0x87, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1,
  0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x83, 0xF8, 0x3F, 0xFF, 0x07, 0xF0, 0x7F,
  0xFE, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xF8, 0x3F, 0x83, 0xFF,
  0xF0, 0x7F, 0x07, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x7F, 0x1F, 0x9F,
  0xF3, 0xF7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8,
  0xFE, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7,
  0xF8, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xFC, 0x7F, 0x1F, 0x9F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7F, 0x7F, 0xCF, 0xE7, 0xE1, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFE, 0x0F,
  0xDF, 0xC3, 0xFB, 0xFC, 0x7F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFB, 0xF0, 0xFE, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFC, 0xFE, 0x0C, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF1, 0x3F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x9F, 0xF9, 0xF1, 0xFE, 0x3E, 0xFE, 0x03, 0xFD, 0xFC,
  0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x7E, 0x0F,
  0xF0, 0x7E, 0x7F, 0x0F, 0xF0, 0x7E, 0x7F, 0x0F, 0xF8, 0xFE, 0x7F, 0x1F,
  0xF8, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x9F,
  0xF8, 0xFC, 0x3F, 0xBF, 0xFD, 0xFC, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE,
  0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F, 0xBE,
  0x7D, 0xF0, 0x0F, 0xBC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xE3,
  0xF8, 0xFF, 0x0F, 0xF3, 0xF8, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0xFF, 0x3F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1,
  0xFE, 0xFF, 0x03, 0xFC, 0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x07,
  0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x0F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF,
  0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFF, 0x03,
  0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x2F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xA0,
  0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 27, 11, 2, -27 },
  { 25, 15, 10, 19, 2, -27 },
  { 44, 22, 27, 24, 1, -27 },
  { 119, 19, 31, 21, 1, -29 },
  { 193, 33, 28, 35, 1, -28 },
  { 309, 27, 27, 28, 1, -27 },
  { 401, 7, 10, 11, 2, -27 },
  { 410, 12, 34, 13, 1, -28 },
  { 461, 11, 34, 13, 1, -28 },
  { 508, 18, 18, 20, 1, -29 },
  { 549, 18, 19, 21, 2, -23 },
  { 592, 8, 11, 11, 1, -6 },
  { 603, 10, 6, 12, 1, -13 },
  { 611, 7, 7, 11, 2, -7 },
  { 618, 16, 28, 17, 0, -28 },
  { 674, 19, 28, 21, 1, -28 },
  { 741, 15, 27, 21, 2, -27 },
  { 792, 18, 28, 21, 1, -28 },
  { 855, 18, 28, 21, 1, -28 },
  { 918, 19, 27, 21, 1, -27 },
  { 983, 17, 27, 21, 2, -27 },
  { 1041, 19, 28, 21, 1, -28 },
  { 1108, 19, 27, 21, 1, -27 },
  { 1173, 19, 28, 21, 1, -28 },
  { 1240, 19, 28, 21, 1, -28 },
  { 1307, 7, 21, 11, 2, -21 },
  { 1326, 8, 26, 11, 1, -21 },
  { 1352, 18, 20, 21, 1, -24 },
  { 1397, 18, 13, 21, 2, -20 },
  { 1427, 18, 20, 21, 2, -24 },
  { 1472, 17, 28, 18, 0, -28 },
  { 1532, 30, 30, 32, 1, -27 },
  { 1645, 25, 27, 25, 0, -27 },
  { 1730, 19, 27, 24, 3, -27 },
  { 1795, 20, 28, 23, 2, -28 },
  { 1865, 21, 27, 26, 3, -27 },
  { 1936, 15, 27, 19, 3, -27 },
  { 1987, 15, 27, 19, 3, -27 },
  { 2038, 22, 28, 26, 2, -28 },
  { 2115, 21, 27, 27, 3, -27 },
  { 2186, 13, 27, 16, 1, -27 },
  { 2230, 13, 36, 13, -3, -27 },
  { 2289, 21, 27, 24, 3, -27 },
  { 2360, 16, 27, 20, 3, -27 },
  { 2414, 29, 27, 35, 3, -27 },
  { 2512, 24, 27, 29, 3, -27 },
  { 2593, 24, 28, 28, 2, -28 },
  { 2677, 18, 27, 22, 3, -27 },
  { 2738, 24, 34, 28, 2, -28 },
  { 2840, 21, 27, 24, 3, -27 },
  { 2911, 18, 28, 20, 1, -28 },
  { 2974, 19, 27, 21, 1, -27 },
  { 3039, 21, 27, 26, 3, -27 },
  { 3110, 25, 27, 25, 0, -27 },
  { 3195, 36, 27, 36, 0, -27 },
  { 3317, 25, 27, 25, 0, -27 },
  { 3402, 23, 27, 23, 0, -27 },
  { 3480, 19, 27, 21, 1, -27 },
  { 3545, 9, 34, 12, 2, -28 },
  { 3584, 16, 28, 17, 0, -28 },
  { 3640, 9, 34, 12, 1, -28 },
  { 3679, 20, 18, 20, 0, -27 },
  { 3724, 19, 5, 19, 0, 2 },
  { 3736, 11, 6, 15, 2, -29 },
  { 3745, 19, 21, 22, 1, -21 },
  { 3795, 19, 29, 23, 2, -29 },
  { 3864, 17, 21, 19, 1, -21 },
  { 3909, 19, 29, 23, 1, -29 },
  { 3978, 19, 21, 22, 1, -21 },
  { 4028, 14, 29, 14, 1, -29 },
  { 4079, 19, 30, 23, 1, -21 },
  { 4151, 19, 29, 23, 2, -29 },
  { 4220, 7, 29, 12, 2, -29 },
  { 4246, 11, 38, 11, -2, -29 },
  { 4299, 21, 29, 23, 2, -29 },
  { 4376, 7, 29, 11, 2, -29 },
  { 4402, 31, 21, 35, 2, -21 },
  { 4484, 19, 21, 23, 2, -21 },
  { 4534, 20, 21, 23, 1, -21 },
  { 4587, 19, 30, 23, 2, -21 },
  { 4659, 19, 30, 23, 1, -21 },
  { 4731, 14, 21, 17, 2, -21 },
  { 4768, 16, 21, 18, 1, -21 },
  { 4810, 14, 25, 16, 1, -25 },
  { 4854, 19, 21, 23, 2, -21 },
  { 4904, 22, 21, 22, 0, -21 },
  { 4962, 32, 21, 32, 0, -21 },
  { 5046, 22, 21, 22, 0, -21 },
  { 5104, 22, 30, 22, 0, -21 },
  { 5187, 16, 21, 18, 1, -21 },
  { 5229, 13, 34, 16, 1, -28 },
  { 5285, 6, 37, 18, 6, -29 },
  { 5313, 14, 34, 16, 1, -28 },
  { 5373, 19, 7, 21, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_Black38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK38PT7B_H_
