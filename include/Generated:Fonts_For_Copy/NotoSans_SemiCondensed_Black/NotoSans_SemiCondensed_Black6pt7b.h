#ifndef _NOTOSANS_SEMICONDENSED_BLACK6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black6pt7bBitmaps[] PROGMEM = {
  0x00, 0xD0, 0xA0, 0x6F, 0xEA, 0x5F, 0x3E, 0xD7, 0x4E, 0xB0, 0x66, 0xBF,
  0x80, 0x6A, 0x40, 0xD5, 0x80, 0x5F, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x69, 0x40, 0xF6, 0xB0, 0x74, 0x90, 0xE5, 0x70, 0xEC, 0xF0, 0x6F, 0x90,
  0xFC, 0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xF0, 0xA0, 0xB0,
  0x39, 0x80, 0xFC, 0x8F, 0x00, 0xE8, 0x20, 0x7F, 0xF6, 0xE0, 0x66, 0xF9,
  0xEE, 0xFE, 0x72, 0x30, 0xED, 0xDE, 0xFF, 0x70, 0xFF, 0x60, 0x7B, 0xD7,
  0xDF, 0xDD, 0xD7, 0xFF, 0x80, 0xFE, 0xEF, 0xDB, 0x70, 0xDE, 0xEF, 0x50,
  0xDB, 0xB9, 0x79, 0xD7, 0xFF, 0x60, 0x79, 0xD7, 0x30, 0xEE, 0xEF, 0xF8,
  0xF0, 0xE9, 0x20, 0xDD, 0xD6, 0xB6, 0x66, 0xBE, 0xE7, 0x96, 0xF6, 0x6B,
  0xF6, 0x44, 0xE9, 0x70, 0xEA, 0xC0, 0x89, 0x30, 0xD5, 0xC0, 0x56, 0x80,
  0xE0, 0xC0, 0xFF, 0x80, 0x93, 0xDE, 0xF1, 0x80, 0x27, 0xDE, 0xFD, 0x80,
  0x5D, 0x40, 0xF7, 0xF0, 0x93, 0xDA, 0xB8, 0xBC, 0x89, 0xAE, 0xB0, 0xF8,
  0xFD, 0x6A, 0xF6, 0x80, 0xF5, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xF2, 0x00,
  0xEF, 0x80, 0x7D, 0xB7, 0x80, 0xAD, 0x00, 0xAE, 0xD4, 0xEE, 0x80, 0xAD,
  0x60, 0xEB, 0x80, 0x5D, 0x40, 0xFC, 0xD5, 0xC0, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Black6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 2, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 1, 3, 2, 0, -3 },
  { 47, 1, 4, 2, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 2, 3, 0, -3 },
  { 51, 3, 3, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 5, 4, 5, 0, -4 },
  { 58, 4, 4, 4, 0, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 2, 5, 2, 0, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 5, 4, 5, 0, -4 },
  { 84, 4, 4, 5, 0, -4 },
  { 86, 4, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 4, 5, 4, 0, -4 },
  { 93, 4, 4, 4, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 4, 4, 4, 0, -4 },
  { 101, 4, 4, 4, 0, -4 },
  { 103, 6, 4, 6, 0, -4 },
  { 106, 4, 4, 4, 0, -4 },
  { 108, 4, 4, 4, 0, -4 },
  { 110, 3, 4, 3, 0, -4 },
  { 112, 2, 5, 2, 0, -4 },
  { 114, 3, 4, 3, 0, -4 },
  { 116, 2, 5, 2, 0, -4 },
  { 118, 3, 3, 3, 0, -4 },
  { 120, 3, 1, 3, 0, 0 },
  { 121, 2, 1, 2, 0, -5 },
  { 122, 3, 3, 3, 0, -3 },
  { 124, 3, 5, 4, 0, -5 },
  { 126, 3, 3, 3, 0, -3 },
  { 128, 3, 5, 4, 0, -5 },
  { 130, 3, 3, 3, 0, -3 },
  { 132, 2, 5, 2, 0, -5 },
  { 134, 3, 4, 4, 0, -3 },
  { 136, 3, 5, 4, 0, -5 },
  { 138, 1, 5, 2, 0, -5 },
  { 139, 1, 6, 2, 0, -5 },
  { 140, 4, 5, 4, 0, -5 },
  { 143, 1, 5, 2, 0, -5 },
  { 144, 5, 3, 6, 0, -3 },
  { 146, 3, 3, 4, 0, -3 },
  { 148, 3, 3, 4, 0, -3 },
  { 150, 3, 4, 4, 0, -3 },
  { 152, 3, 4, 4, 0, -3 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 2, 4, 3, 0, -4 },
  { 159, 3, 3, 4, 0, -3 },
  { 161, 3, 3, 3, 0, -3 },
  { 163, 5, 3, 5, 0, -3 },
  { 165, 3, 3, 3, 0, -3 },
  { 167, 3, 4, 3, 0, -3 },
  { 169, 3, 3, 3, 0, -3 },
  { 171, 2, 5, 2, 0, -4 },
  { 173, 1, 6, 3, 1, -5 },
  { 174, 2, 5, 2, 0, -4 },
  { 176, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Black6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK6PT7B_H_
