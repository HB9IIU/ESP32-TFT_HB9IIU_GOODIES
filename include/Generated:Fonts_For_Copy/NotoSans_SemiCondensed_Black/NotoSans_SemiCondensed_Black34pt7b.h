#ifndef _NOTOSANS_SEMICONDENSED_BLACK34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x80, 0x00, 0x00, 0xF3, 0xFF, 0xFF, 0xDF, 0xBE, 0xFC, 0xFF,
  0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E,
  0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C, 0xF0,
  0x07, 0xCF, 0x00, 0x78, 0xF0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x0F, 0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1E,
  0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0x80, 0x3C, 0x78, 0x03,
  0xC7, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0xC3, 0xFF,
  0xF3, 0xFF, 0xFB, 0xFF, 0xF9, 0xFB, 0x9C, 0xF9, 0xC0, 0x7C, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xEF, 0xC0, 0x77, 0xEC, 0x3B, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x02, 0x01, 0xFC, 0x01, 0xE0, 0x1F, 0xF0, 0x1F,
  0x00, 0xFF, 0xC0, 0xF0, 0x0F, 0xBE, 0x0F, 0x80, 0x7C, 0xF0, 0x78, 0x03,
  0xC7, 0x87, 0xC0, 0x1E, 0x3E, 0x3C, 0x00, 0xF1, 0xF3, 0xE0, 0x07, 0x8F,
  0x1E, 0x00, 0x3E, 0x79, 0xF1, 0xF1, 0xF7, 0xCF, 0x3F, 0xC7, 0xFE, 0xFB,
  0xFF, 0x3F, 0xE7, 0x9F, 0xF8, 0xFE, 0x7C, 0xF3, 0xE1, 0xC3, 0xCF, 0x9F,
  0x00, 0x3E, 0x7C, 0xF8, 0x01, 0xE3, 0xE7, 0xC0, 0x1F, 0x1F, 0x3E, 0x00,
  0xF0, 0xF9, 0xF0, 0x0F, 0x83, 0xCF, 0x80, 0x78, 0x1F, 0xFC, 0x07, 0xC0,
  0xFF, 0xC0, 0x3C, 0x03, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x40, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x7E, 0x1F, 0xF0, 0x7E,
  0x3F, 0xF8, 0xFE, 0x7F, 0xFC, 0xFC, 0x7E, 0xFF, 0xFC, 0xFE, 0x7F, 0xFC,
  0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x07, 0xC3, 0xE1, 0xF8, 0x7C,
  0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x1F,
  0x87, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E,
  0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xC3, 0xC6, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0xF8, 0x7E, 0x7C, 0x1C,
  0x78, 0x04, 0x20, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7E,
  0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x7C, 0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0xFE, 0x3F, 0x7F, 0x1F, 0xBF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF,
  0xC7, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xDF, 0xBF, 0x3C, 0xFC, 0x63, 0xF1, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0x80, 0x1F, 0xF8, 0x3F,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x38, 0x7F, 0x30, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x3F,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x30, 0x7F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7E, 0x0F, 0xBF, 0x0F, 0x9F, 0x8F, 0xCF,
  0xC7, 0xC7, 0xE7, 0xC3, 0xF3, 0xE1, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xE4, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0x00,
  0x3C, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0x10,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x7C, 0x3F, 0x7F, 0x9F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xDF, 0x8F, 0xEF, 0xC7, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x07, 0xFC,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC,
  0x7E, 0x7E, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0xE1, 0xFF, 0xF8, 0xFE, 0xFE, 0xFE, 0x3F, 0x7E, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xE3, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F,
  0xF8, 0x00, 0x01, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xFF,
  0x0F, 0xFF, 0xCF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xBE,
  0x0F, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x7B, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C,
  0xFD, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xBF, 0x7E, 0xFD, 0xF3, 0xE7, 0xDF, 0x3E, 0x7C, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0xF3,
  0xFF, 0xF7, 0xFF, 0xF7, 0xFF, 0xEF, 0xDF, 0xC8, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x07, 0x80, 0x81, 0xE1, 0xF1, 0xFF, 0xBE, 0x7C, 0x7F,
  0xF3, 0xCF, 0x9F, 0xFE, 0x79, 0xE7, 0xE7, 0xCF, 0x3C, 0xF8, 0xF9, 0xFF,
  0x9E, 0x1F, 0x3F, 0xF3, 0xC3, 0xE7, 0xFE, 0x78, 0x7C, 0xF7, 0xCF, 0x0F,
  0x9E, 0xF9, 0xE1, 0xF3, 0xDF, 0x3E, 0x7E, 0xF9, 0xE3, 0xFF, 0xFE, 0x3C,
  0x7F, 0xBF, 0x87, 0xC3, 0xE3, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0x00, 0xFE, 0x03, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0x80, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0xCF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F,
  0x7F, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE, 0x3F, 0xBF,
  0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x60, 0x03,
  0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x0D,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x67, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xCF, 0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC,
  0xFE, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xE0, 0x27, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xBF, 0xC3, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFA, 0xFF, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0x83, 0x80, 0xFE,
  0x07, 0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFE, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xE7, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x8F, 0xE1,
  0xF8, 0xFE, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xF7, 0xFF, 0x7C, 0x7D, 0xFF, 0xDF, 0x1F, 0x7F, 0xF7, 0xC7, 0xDF, 0xFD,
  0xF3, 0xE7, 0xFF, 0x3E, 0xF9, 0xFF, 0xCF, 0xBE, 0x7F, 0xF3, 0xEF, 0x1F,
  0xFC, 0xFF, 0xC7, 0xFF, 0x1F, 0xF1, 0xFF, 0xC7, 0xFC, 0x7F, 0xF1, 0xFE,
  0x1F, 0xFC, 0x3F, 0x87, 0xFF, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0xF0,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xF7, 0xE3, 0xFF, 0xDF, 0xCF, 0xFF, 0x3F, 0x3F, 0xFC,
  0xFE, 0xFF, 0xF1, 0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x70, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9,
  0xFC, 0x1F, 0xDF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0xFE, 0x1F,
  0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF,
  0x9F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F,
  0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00,
  0x7E, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x9F, 0xC3, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F,
  0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0xFE,
  0x7E, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xCF,
  0xE1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x00, 0xE0, 0x0F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x04, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFD, 0xFC, 0x3F, 0xBF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0xFE, 0x01, 0xFD,
  0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF8, 0xFC,
  0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00,
  0xFD, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x7E, 0x07, 0xE0, 0x3F, 0x7E,
  0x07, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x3F,
  0x0F, 0xF0, 0x7E, 0x3F, 0x0F, 0xF0, 0x7E, 0x3F, 0x0F, 0xF8, 0xFC, 0x3F,
  0x0F, 0xF8, 0xFC, 0x1F, 0x1F, 0xF8, 0xFC, 0x1F, 0x9F, 0x78, 0xFC, 0x1F,
  0x9F, 0x7C, 0xFC, 0x1F, 0x9F, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x0F,
  0xBE, 0x7D, 0xF8, 0x0F, 0xBE, 0x3D, 0xF8, 0x0F, 0xFE, 0x3D, 0xF0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF9, 0xFC, 0x0F, 0xC3, 0xF8, 0x7F, 0x07,
  0xE1, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x87,
  0xF1, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x03, 0xFB,
  0xF0, 0x3F, 0x9F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F, 0xC7,
  0xE0, 0x7F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3D, 0xF0, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F, 0x03, 0xEF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xF7, 0xF0, 0x81, 0xFC, 0x00, 0xFE, 0x0F,
  0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xE7, 0xCF, 0xE3,
  0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF9, 0xF0, 0xFD, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x7C, 0x7E, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0xE1, 0x9F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0xDF,
  0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x1F, 0x3F, 0x1F, 0xDF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xF3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xF7, 0xE1, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF,
  0x1F, 0xEF, 0x87, 0xE7, 0xC0, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xF3, 0xF3, 0xF0, 0xFD, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x09, 0xFC,
  0x1C, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xF0,
  0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0x80, 0xFC, 0x07, 0xFE, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF, 0xFB, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xF7, 0xE0, 0x03, 0xF0,
  0x01, 0xFB, 0x01, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE,
  0x07, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF9, 0xF8, 0xFD, 0xFE, 0x7F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xF0, 0xFC, 0x3F,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0xFC, 0x1F, 0x9F,
  0x87, 0xF3, 0xF1, 0xFC, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1, 0xFB, 0xF8, 0x3F,
  0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xE7, 0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC,
  0x1F, 0xDF, 0x81, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0xFC, 0x3F, 0x1F, 0x3F, 0xCF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0x8F, 0xE1, 0xFF,
  0xE0, 0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xFF, 0x83, 0xF0, 0xFF, 0xF0, 0x7E,
  0x1F, 0xFE, 0x0F, 0xC3, 0xFF, 0xC1, 0xF8, 0x7F, 0xF8, 0x3F, 0x0F, 0xFF,
  0x07, 0xE1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xFF, 0x83, 0xF0,
  0xFF, 0xF0, 0x7E, 0x1F, 0x80, 0xF8, 0xFC, 0x7C, 0xFF, 0x3E, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xE0, 0x07, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7,
  0xE1, 0xFB, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xE7, 0xFB, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0xF8, 0x7C, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7E, 0xFF, 0x3F, 0x3F, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x8F, 0x8F, 0xF7, 0xCF, 0xFB, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF0, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xF7, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0xF8, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFE, 0xFC, 0x7B, 0xF0, 0x4F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0x9F, 0xF7, 0xC7, 0xE3, 0xE0, 0xFC, 0x07, 0xFF, 0xC0,
  0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7,
  0xE0, 0xF8, 0xFC, 0x1F, 0x9F, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC3, 0xF7, 0xE1, 0xFC,
  0x3F, 0x7E, 0x3F, 0xC3, 0xF7, 0xE3, 0xFC, 0x3F, 0x7E, 0x3F, 0xE3, 0xE3,
  0xE3, 0xFE, 0x7E, 0x3F, 0x3D, 0xE7, 0xE3, 0xF7, 0xDE, 0x7E, 0x3F, 0x7D,
  0xE7, 0xC1, 0xF7, 0xDF, 0x7C, 0x1F, 0x79, 0xFF, 0xC1, 0xF7, 0x9F, 0xFC,
  0x1F, 0x78, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xEF, 0xE1, 0xF8, 0xFC, 0x7F, 0x1F, 0xCF, 0xC1, 0xFB,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xEF,
  0xE1, 0xFC, 0xFC, 0x3F, 0x1F, 0xCF, 0xE1, 0xFB, 0xF8, 0x3F, 0x80, 0xFE,
  0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE3, 0xF0, 0xFC, 0x7E,
  0x3F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x03, 0xF7, 0xE0, 0x3E,
  0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x70, 0x3F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x8F, 0xF8, 0xFF,
  0x0F, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0x0F, 0xF1, 0xFF, 0x1F, 0xC1, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xC0, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF4, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Black34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 24, 10, 1, -24 },
  { 22, 14, 9, 17, 2, -24 },
  { 38, 20, 24, 21, 1, -24 },
  { 98, 17, 28, 19, 1, -26 },
  { 158, 29, 25, 31, 1, -25 },
  { 249, 24, 25, 25, 1, -25 },
  { 324, 6, 9, 9, 2, -24 },
  { 331, 10, 30, 12, 1, -25 },
  { 369, 9, 30, 12, 1, -25 },
  { 403, 16, 16, 17, 1, -26 },
  { 435, 16, 16, 19, 1, -20 },
  { 467, 7, 10, 10, 1, -5 },
  { 476, 9, 5, 11, 1, -12 },
  { 482, 7, 6, 10, 1, -6 },
  { 488, 15, 25, 15, 0, -25 },
  { 535, 17, 25, 19, 1, -25 },
  { 589, 14, 24, 19, 1, -24 },
  { 631, 16, 25, 19, 1, -25 },
  { 681, 16, 25, 19, 1, -25 },
  { 731, 17, 24, 19, 1, -24 },
  { 782, 15, 24, 19, 2, -24 },
  { 827, 17, 25, 19, 1, -25 },
  { 881, 17, 24, 19, 1, -24 },
  { 932, 17, 25, 19, 1, -25 },
  { 986, 17, 25, 19, 1, -25 },
  { 1040, 6, 19, 10, 2, -19 },
  { 1055, 7, 24, 10, 1, -19 },
  { 1076, 16, 18, 19, 1, -21 },
  { 1112, 16, 12, 19, 1, -18 },
  { 1136, 16, 18, 19, 1, -21 },
  { 1172, 15, 25, 16, 0, -25 },
  { 1219, 27, 28, 29, 1, -25 },
  { 1314, 23, 24, 23, 0, -24 },
  { 1383, 18, 24, 21, 2, -24 },
  { 1437, 17, 25, 20, 2, -25 },
  { 1491, 20, 24, 23, 2, -24 },
  { 1551, 14, 24, 17, 2, -24 },
  { 1593, 14, 24, 17, 2, -24 },
  { 1635, 19, 25, 23, 2, -25 },
  { 1695, 20, 24, 24, 2, -24 },
  { 1755, 12, 24, 14, 1, -24 },
  { 1791, 11, 32, 11, -2, -24 },
  { 1835, 20, 24, 22, 2, -24 },
  { 1895, 15, 24, 18, 2, -24 },
  { 1940, 26, 24, 31, 2, -24 },
  { 2018, 22, 24, 26, 2, -24 },
  { 2084, 21, 25, 25, 2, -25 },
  { 2150, 17, 24, 20, 2, -24 },
  { 2201, 22, 31, 25, 2, -25 },
  { 2287, 20, 24, 21, 2, -24 },
  { 2347, 16, 25, 18, 1, -25 },
  { 2397, 17, 24, 18, 1, -24 },
  { 2448, 19, 24, 24, 2, -24 },
  { 2505, 22, 24, 22, 0, -24 },
  { 2571, 32, 24, 32, 0, -24 },
  { 2667, 22, 24, 22, 0, -24 },
  { 2733, 21, 24, 21, 0, -24 },
  { 2796, 17, 24, 19, 1, -24 },
  { 2847, 8, 31, 11, 2, -25 },
  { 2878, 15, 25, 15, 0, -25 },
  { 2925, 8, 31, 11, 1, -25 },
  { 2956, 18, 16, 18, 0, -24 },
  { 2992, 17, 4, 17, 0, 2 },
  { 3001, 11, 5, 13, 1, -26 },
  { 3008, 17, 19, 20, 1, -19 },
  { 3049, 17, 26, 20, 2, -26 },
  { 3105, 15, 19, 17, 1, -19 },
  { 3141, 17, 26, 20, 1, -26 },
  { 3197, 17, 19, 19, 1, -19 },
  { 3238, 13, 26, 13, 1, -26 },
  { 3281, 17, 27, 20, 1, -19 },
  { 3339, 17, 26, 21, 2, -26 },
  { 3395, 6, 26, 10, 2, -26 },
  { 3415, 10, 34, 10, -2, -26 },
  { 3458, 19, 26, 21, 2, -26 },
  { 3520, 6, 26, 10, 2, -26 },
  { 3540, 27, 19, 31, 2, -19 },
  { 3605, 17, 19, 21, 2, -19 },
  { 3646, 18, 19, 20, 1, -19 },
  { 3689, 17, 27, 20, 2, -19 },
  { 3747, 17, 27, 20, 1, -19 },
  { 3805, 12, 19, 15, 2, -19 },
  { 3834, 14, 19, 16, 1, -19 },
  { 3868, 12, 23, 14, 1, -23 },
  { 3903, 17, 19, 21, 2, -19 },
  { 3944, 19, 19, 19, 0, -19 },
  { 3990, 28, 19, 29, 0, -19 },
  { 4057, 19, 19, 19, 0, -19 },
  { 4103, 19, 27, 19, 0, -19 },
  { 4168, 14, 19, 16, 1, -19 },
  { 4202, 12, 31, 14, 1, -25 },
  { 4249, 4, 34, 16, 6, -26 },
  { 4266, 12, 31, 14, 1, -25 },
  { 4313, 17, 6, 19, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_Black34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK34PT7B_H_
