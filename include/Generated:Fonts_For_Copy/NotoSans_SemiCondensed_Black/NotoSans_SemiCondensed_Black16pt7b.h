#ifndef _NOTOSANS_SEMICONDENSED_BLACK16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF8, 0xDF, 0x80, 0xEF, 0x3C, 0xF3, 0x1B, 0x86, 0xC1,
  0xB1, 0xFF, 0x7F, 0xCC, 0xCF, 0xFB, 0xFE, 0x36, 0x0D, 0x86, 0x60, 0x10,
  0xFF, 0xFE, 0x9D, 0x1F, 0x1F, 0x8F, 0x17, 0xFF, 0xF1, 0x81, 0x00, 0x30,
  0x01, 0xE1, 0x8F, 0xCC, 0x3B, 0x30, 0xED, 0x81, 0xF6, 0xE7, 0xB7, 0xCC,
  0xDB, 0x06, 0x6C, 0x19, 0xB0, 0xC7, 0xC7, 0x0E, 0x0C, 0x03, 0xF0, 0x3F,
  0x03, 0x30, 0x3F, 0x03, 0xE0, 0x7E, 0xE7, 0xFE, 0xE7, 0xC7, 0x3C, 0x7F,
  0xE3, 0xEF, 0xFB, 0x60, 0x37, 0x6E, 0xEC, 0xCC, 0xCC, 0xEE, 0x67, 0x30,
  0xE3, 0x9C, 0x63, 0x9C, 0xE7, 0x39, 0xCE, 0x67, 0x33, 0x80, 0x18, 0x18,
  0x7F, 0xFF, 0x3C, 0x7E, 0x26, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18,
  0x77, 0x6E, 0xFF, 0xFE, 0xDF, 0x80, 0x0E, 0x1C, 0x30, 0xE1, 0x83, 0x0E,
  0x18, 0x70, 0xE1, 0x87, 0x00, 0x10, 0xFB, 0xFF, 0x7E, 0xF9, 0xF3, 0xF7,
  0xEF, 0xDF, 0xF3, 0xE0, 0x3D, 0xFF, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71,
  0xC0, 0x18, 0x7E, 0xFF, 0x67, 0x07, 0x0F, 0x0E, 0x1C, 0x38, 0x70, 0xFF,
  0xFF, 0x31, 0xFB, 0xFC, 0x70, 0xEF, 0x9F, 0x0F, 0x0F, 0x1F, 0xFF, 0xE0,
  0x0E, 0x0F, 0x07, 0x86, 0xC3, 0x63, 0x33, 0x99, 0xFF, 0xFF, 0x83, 0x01,
  0x80, 0xFD, 0xFB, 0x87, 0x0F, 0xDF, 0xC3, 0x87, 0x8F, 0xFF, 0xF0, 0x0C,
  0xFD, 0xFF, 0x0C, 0x9F, 0xFF, 0xF7, 0xEF, 0xDF, 0xFB, 0xE0, 0xFF, 0xFC,
  0x38, 0x61, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC0, 0x31, 0xFB, 0xFF, 0x7E,
  0xEF, 0x9F, 0x77, 0xC7, 0x9F, 0xFB, 0xE0, 0x18, 0x3E, 0x7F, 0x67, 0xE7,
  0x77, 0x7F, 0x3B, 0x07, 0x0F, 0x7E, 0x7C, 0xFF, 0x80, 0x37, 0xE0, 0x77,
  0x70, 0x00, 0x07, 0x76, 0xE0, 0x02, 0x1C, 0xFF, 0x8E, 0x0F, 0x87, 0x83,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0xC3, 0xE1, 0xF0, 0xEF, 0xBC, 0x60,
  0x19, 0xFF, 0xFA, 0x70, 0xE3, 0x8E, 0x18, 0x00, 0x60, 0xE1, 0xC0, 0x06,
  0x03, 0xFC, 0x70, 0xE6, 0x76, 0xDF, 0xBD, 0x9B, 0xD9, 0xBD, 0x9B, 0xDB,
  0xED, 0xEE, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0x03, 0xE0, 0x6C, 0x1D,
  0x83, 0xB8, 0x77, 0x1F, 0xE3, 0xFE, 0x7F, 0xDE, 0x3B, 0x87, 0x80, 0xFE,
  0xFF, 0xE7, 0xE7, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xFF, 0xFE, 0x0C, 0x3F,
  0x7F, 0xF1, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF3, 0x7F, 0x3F, 0xFE, 0x7F,
  0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xEF, 0x7F, 0xBF, 0x00, 0xFF,
  0xFE, 0x38, 0xFF, 0xFE, 0x38, 0xE3, 0xFF, 0xC0, 0xFF, 0xFE, 0x38, 0xFF,
  0xFF, 0xF8, 0xE3, 0x8E, 0x00, 0x0E, 0x1F, 0xDF, 0xDE, 0x0E, 0x07, 0x7F,
  0xBF, 0xDF, 0xE3, 0xF9, 0xDF, 0xE7, 0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0xFD, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x3B, 0xFF, 0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x7F, 0xFB, 0x00, 0xE3, 0xF3, 0xBB, 0x9D, 0xCF, 0xC7, 0xE3, 0xF9, 0xDC,
  0xE7, 0x73, 0xB8, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xFF, 0xF8, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xF9, 0xBF, 0xDB, 0xED,
  0xBE, 0xF3, 0xEF, 0x3E, 0xF3, 0xE7, 0x30, 0xF1, 0xFE, 0x7F, 0x9F, 0xF7,
  0xFC, 0xFB, 0xBE, 0xEF, 0x9F, 0xE7, 0xF8, 0xFE, 0x3C, 0x0C, 0x1F, 0xC7,
  0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xE7, 0xF8, 0xFC,
  0xFE, 0xFF, 0xE7, 0xE7, 0xEF, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0x0C,
  0x1F, 0xC7, 0xFB, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0xE7,
  0xF8, 0xFC, 0x07, 0x00, 0xE0, 0x3C, 0xFE, 0x7F, 0xB9, 0xDC, 0xEE, 0xF7,
  0xF3, 0xF9, 0xDC, 0xE7, 0x73, 0xB8, 0xE0, 0x18, 0xFF, 0xFF, 0x1E, 0x1F,
  0x1F, 0x0F, 0x0F, 0x9F, 0xF7, 0xC0, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xF7, 0xBF, 0x8F, 0x80, 0xE1, 0xDC, 0x77, 0x39, 0xCE, 0x73,
  0x8E, 0xE3, 0xF0, 0xFC, 0x1F, 0x07, 0x81, 0xE0, 0xE3, 0x8E, 0xC7, 0x1D,
  0xCF, 0x33, 0xBE, 0xE7, 0x6D, 0xC6, 0xDB, 0x8D, 0xB7, 0x1F, 0x7C, 0x3E,
  0x78, 0x7C, 0xF0, 0x71, 0xE0, 0xF3, 0xDC, 0xE3, 0xF0, 0xFC, 0x1E, 0x07,
  0x81, 0xF0, 0xFC, 0x7B, 0x9C, 0xEF, 0x1C, 0xF3, 0xDC, 0xE7, 0x70, 0xFC,
  0x3E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0x3F, 0x81,
  0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x7F, 0xFF, 0xE0, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE1, 0xC1, 0x83, 0x83, 0x06, 0x0E,
  0x0C, 0x1C, 0x38, 0x30, 0x70, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F,
  0xF0, 0x18, 0x0E, 0x0F, 0x06, 0xC6, 0x63, 0x3B, 0x0E, 0xFF, 0xFF, 0xE1,
  0xC0, 0xFC, 0xFD, 0x39, 0xFF, 0xFD, 0xF3, 0xFF, 0xF6, 0xE0, 0xE0, 0xE0,
  0xEE, 0xFE, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xDE, 0x3F, 0xFB, 0x97,
  0x0E, 0x1C, 0x39, 0x7E, 0x7C, 0x07, 0x07, 0x07, 0x77, 0xFF, 0xEF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFF, 0x77, 0x7C, 0xFE, 0xE6, 0xE6, 0xFF, 0xE0, 0xE2,
  0xFE, 0x7E, 0x3C, 0xF7, 0x1F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x77,
  0xFF, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x77, 0x07, 0xFE, 0xFE, 0x78,
  0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x39, 0xC0, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xFF, 0xDC, 0xE0, 0x70, 0x38, 0x1C, 0xFE, 0xF7, 0x73, 0xF1, 0xF8,
  0xFE, 0x77, 0x39, 0xDC, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xDE, 0xF7,
  0xFF, 0xFF, 0xDF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7, 0xE7,
  0x38, 0xDE, 0xFF, 0xF7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0xFE,
  0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0x7C, 0xDE, 0xFE, 0xEF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x77, 0xFF, 0xEF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFF, 0x77, 0x07, 0x07, 0x07, 0x07, 0xCF, 0xFF, 0xF8,
  0xE3, 0x8E, 0x38, 0xE0, 0x7B, 0xFC, 0xBC, 0xF8, 0xF9, 0xFF, 0xF8, 0x30,
  0xC7, 0xFF, 0x71, 0xC7, 0x1C, 0x75, 0xF3, 0xC0, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE3, 0xF1, 0xDD, 0xCE, 0xE3, 0x71, 0xB0,
  0xF8, 0x3C, 0x1C, 0x00, 0xE7, 0x1F, 0x3D, 0xD9, 0xEE, 0xFF, 0x77, 0xDB,
  0x3E, 0xD8, 0xF7, 0xC7, 0x9E, 0x3C, 0xE0, 0xF3, 0xBB, 0x8F, 0xC7, 0xC1,
  0xE1, 0xF1, 0xFC, 0xEE, 0xF3, 0x80, 0xE3, 0xF1, 0xDD, 0xCE, 0xE3, 0x71,
  0xB0, 0xF8, 0x3C, 0x1C, 0x0E, 0x1E, 0x0F, 0x07, 0x00, 0x7E, 0xFC, 0x38,
  0xE3, 0x87, 0x1C, 0x7F, 0xFE, 0x04, 0x73, 0xCE, 0x38, 0xEF, 0xB8, 0xF0,
  0xE3, 0x8E, 0x3C, 0xF0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xCF, 0x0C,
  0x30, 0xC3, 0xC3, 0x3C, 0xC3, 0x0C, 0x73, 0xCE, 0x00, 0xF3, 0xFE, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_Black16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 5, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 10, 11, 10, 0, -11 },
  { 23, 7, 13, 9, 1, -12 },
  { 35, 14, 12, 15, 0, -12 },
  { 56, 12, 12, 12, 0, -12 },
  { 74, 3, 4, 4, 1, -11 },
  { 76, 4, 15, 6, 1, -12 },
  { 84, 5, 15, 6, 0, -12 },
  { 94, 8, 7, 8, 0, -12 },
  { 101, 7, 8, 9, 1, -10 },
  { 108, 4, 4, 5, 0, -2 },
  { 110, 5, 3, 5, 0, -6 },
  { 112, 3, 3, 5, 1, -3 },
  { 114, 7, 12, 7, 0, -12 },
  { 125, 7, 12, 9, 1, -12 },
  { 136, 6, 11, 9, 1, -11 },
  { 145, 8, 12, 9, 0, -12 },
  { 157, 7, 12, 9, 1, -12 },
  { 168, 9, 11, 9, 0, -11 },
  { 181, 7, 11, 9, 1, -11 },
  { 191, 7, 12, 9, 1, -12 },
  { 202, 7, 11, 9, 1, -11 },
  { 212, 7, 12, 9, 1, -12 },
  { 223, 8, 12, 9, 0, -12 },
  { 235, 3, 9, 5, 1, -9 },
  { 239, 4, 11, 5, 0, -9 },
  { 245, 7, 8, 9, 1, -10 },
  { 252, 7, 5, 9, 1, -8 },
  { 257, 7, 8, 9, 1, -10 },
  { 264, 7, 12, 7, 0, -12 },
  { 275, 12, 13, 14, 1, -12 },
  { 295, 11, 11, 11, 0, -11 },
  { 311, 8, 11, 10, 1, -11 },
  { 322, 8, 12, 10, 1, -12 },
  { 334, 9, 11, 11, 1, -11 },
  { 347, 6, 11, 8, 1, -11 },
  { 356, 6, 11, 8, 1, -11 },
  { 365, 9, 12, 11, 1, -12 },
  { 379, 9, 11, 11, 1, -11 },
  { 392, 6, 11, 7, 0, -11 },
  { 401, 5, 15, 5, -1, -11 },
  { 411, 9, 11, 10, 1, -11 },
  { 424, 7, 11, 8, 1, -11 },
  { 434, 12, 11, 15, 1, -11 },
  { 451, 10, 11, 12, 1, -11 },
  { 465, 10, 12, 12, 1, -12 },
  { 480, 8, 11, 9, 1, -11 },
  { 491, 10, 15, 12, 1, -12 },
  { 510, 9, 11, 10, 1, -11 },
  { 523, 7, 12, 9, 1, -12 },
  { 534, 8, 11, 9, 0, -11 },
  { 545, 9, 11, 11, 1, -11 },
  { 558, 10, 11, 10, 0, -11 },
  { 572, 15, 11, 15, 0, -11 },
  { 593, 10, 11, 10, 0, -11 },
  { 607, 10, 11, 10, 0, -11 },
  { 621, 9, 11, 9, 0, -11 },
  { 634, 4, 15, 5, 1, -12 },
  { 642, 7, 12, 7, 0, -12 },
  { 653, 4, 15, 5, 0, -12 },
  { 661, 9, 7, 9, 0, -11 },
  { 669, 8, 2, 8, 0, 1 },
  { 671, 5, 2, 6, 1, -12 },
  { 673, 7, 9, 9, 1, -9 },
  { 681, 8, 12, 10, 1, -12 },
  { 693, 7, 9, 8, 1, -9 },
  { 701, 8, 12, 10, 1, -12 },
  { 713, 8, 9, 9, 1, -9 },
  { 722, 6, 12, 6, 0, -12 },
  { 731, 8, 13, 10, 1, -9 },
  { 744, 8, 12, 10, 1, -12 },
  { 756, 3, 12, 5, 1, -12 },
  { 761, 5, 16, 5, -1, -12 },
  { 771, 9, 12, 10, 1, -12 },
  { 785, 3, 12, 5, 1, -12 },
  { 790, 13, 9, 15, 1, -9 },
  { 805, 8, 9, 10, 1, -9 },
  { 814, 8, 9, 9, 1, -9 },
  { 823, 8, 13, 10, 1, -9 },
  { 836, 8, 13, 10, 1, -9 },
  { 849, 6, 9, 7, 1, -9 },
  { 856, 6, 9, 8, 1, -9 },
  { 863, 6, 11, 7, 0, -11 },
  { 872, 8, 9, 10, 1, -9 },
  { 881, 9, 9, 9, 0, -9 },
  { 892, 13, 9, 14, 0, -9 },
  { 907, 9, 9, 9, 0, -9 },
  { 918, 9, 13, 9, 0, -9 },
  { 933, 7, 9, 7, 0, -9 },
  { 941, 6, 15, 7, 0, -12 },
  { 953, 2, 16, 8, 3, -12 },
  { 957, 6, 15, 7, 0, -12 },
  { 969, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Black16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK16PT7B_H_
