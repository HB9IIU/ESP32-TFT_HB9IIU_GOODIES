#ifndef _NOTOSANS_SEMICONDENSED_BLACK52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BLACK52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Black.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Black52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFD, 0xFF, 0xBF, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x1F, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB,
  0xFF, 0x3F, 0xE3, 0xF8, 0x08, 0x00, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F,
  0xDF, 0xE1, 0xFE, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xE7, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x03,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x81, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xF7,
  0x8F, 0x8F, 0xF3, 0xC0, 0xC7, 0xF9, 0xE0, 0x03, 0xFC, 0xF0, 0x01, 0xFF,
  0x78, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x3F,
  0xE0, 0x07, 0x8F, 0xF0, 0x03, 0xC7, 0xFE, 0x01, 0xE3, 0xFF, 0xE0, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xC0,
  0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x0F, 0xE0, 0x00,
  0xFF, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x87, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F,
  0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0xFE, 0x0F, 0xC0, 0x7F, 0x3F, 0xCF,
  0xF1, 0xFF, 0x83, 0xFD, 0xFC, 0x7F, 0x1F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF9,
  0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF3, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0x1F, 0xC7, 0xF3, 0xF8, 0x1F, 0xF1, 0xFE, 0x7F, 0x9F,
  0xE0, 0x18, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0xFF, 0xF7, 0xFF, 0x1F,
  0xF9, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x40, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0x9F, 0xCF, 0xE7, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0x01, 0xFC, 0x04, 0xF0, 0xFC, 0x1E,
  0x7F, 0x3E, 0x7F, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFC,
  0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0x07, 0xC0, 0x03,
  0x83, 0x80, 0x00, 0x80, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC7, 0xFC, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x3F, 0x81,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x3F, 0xE1,
  0xFF, 0x9F, 0xF0, 0x7F, 0xDF, 0xF8, 0x3F, 0xEF, 0xFC, 0x1F, 0xF7, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F,
  0xF3, 0xFE, 0x1F, 0xF9, 0xFF, 0xDF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFD, 0xFF, 0x9F, 0xCF, 0xFC, 0x7C, 0x7F, 0xE1,
  0xC3, 0xFF, 0x04, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0xC3, 0x80, 0x7F, 0xE1, 0x80, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x0F,
  0xFF, 0x0C, 0x01, 0xFF, 0x84, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFB, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF7, 0xFC, 0x01, 0xFE,
  0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x1E, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xB0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x3E, 0x03, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0xF8,
  0xFF, 0x7F, 0xFE, 0x7F, 0xBF, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x0F, 0xFD, 0xFF, 0xCF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xEF, 0xFE, 0x7F, 0xC1, 0xFF,
  0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xFE, 0xFF,
  0xC3, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xE7, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFB, 0xFE, 0x3F, 0xFD,
  0xFE, 0x07, 0xF8, 0xFF, 0x00, 0x70, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF1, 0x00, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x1F, 0x0F, 0xF9, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F,
  0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x9F, 0xF7, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0x3F, 0xE3, 0xF8, 0x08, 0x00, 0x1F, 0x0F, 0xF9, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0xDF, 0xF3, 0xFE, 0x3F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x8F, 0xF9, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0x3F,
  0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0x07, 0xFE, 0x38, 0x07, 0xFC, 0x40, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x7F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFF, 0xFC, 0xFE, 0x3F, 0x83, 0xFF,
  0xFC, 0x7E, 0x3F, 0x07, 0xFF, 0xFC, 0x7F, 0x7F, 0x0F, 0xFF, 0xFC, 0x7F,
  0x7F, 0x1F, 0xF1, 0xFC, 0x7F, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0xFE, 0x3F,
  0x81, 0xFC, 0x3F, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0xFE, 0x3F, 0x83,
  0xFC, 0x7E, 0xFE, 0x3F, 0x83, 0xFC, 0x7E, 0xFE, 0x3F, 0xCF, 0xFC, 0xFE,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F,
  0xFF, 0x3F, 0xF8, 0x7F, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F,
  0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF,
  0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xC3, 0xFF, 0xC0, 0x38, 0x3F, 0xF8, 0x00,
  0x83, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x43, 0xFF, 0xC0, 0x1C, 0x1F, 0xFF, 0xBF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xE7,
  0xFC, 0x07, 0xFF, 0xBF, 0xE0, 0x1F, 0xFD, 0xFF, 0x00, 0x7F, 0xEF, 0xF8,
  0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01,
  0xFF, 0xBF, 0xE0, 0x1F, 0xFD, 0xFF, 0x01, 0xFF, 0xCF, 0xF8, 0x3F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC7, 0xF0, 0x7F,
  0xF8, 0x00, 0xC0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0x7F, 0xE0, 0x07,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x1F, 0xFD, 0xFF, 0x00, 0xFF, 0xCF, 0xF8,
  0x0F, 0xFE, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x7F,
  0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF, 0x81,
  0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x03, 0xFE,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0xFF,
  0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFF,
  0x1F, 0xF0, 0x1F, 0xFC, 0xFF, 0x80, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xBF,
  0xE0, 0x1F, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0x7F,
  0x01, 0xFD, 0xFF, 0xFF, 0x7F, 0x81, 0xFD, 0xFF, 0xFF, 0x7F, 0x83, 0xFD,
  0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xFF, 0xFF, 0x3F, 0xC3, 0xF9, 0xFF, 0xFF,
  0x3F, 0xC7, 0xF9, 0xFF, 0xFF, 0x3F, 0xC7, 0xF1, 0xFF, 0xFF, 0x1F, 0xC7,
  0xF1, 0xFF, 0xFF, 0x1F, 0xE7, 0xF1, 0xFF, 0xFF, 0x1F, 0xEF, 0xF1, 0xFF,
  0xFF, 0x1F, 0xEF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0x3F,
  0xE0, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x1F,
  0xF8, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0x07,
  0xFC, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F,
  0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F,
  0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x17, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xF3, 0xFF, 0xF0, 0xFF, 0x83, 0xFF,
  0x87, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x07, 0xFC,
  0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x1F, 0xF8,
  0xFF, 0x80, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xFD, 0xFF,
  0x00, 0x7F, 0xEF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xF1, 0xFC, 0xFF, 0xC0,
  0x3C, 0xFF, 0xC0, 0x04, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8,
  0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x7F, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0x07, 0xFE,
  0x7F, 0xC0, 0x3F, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xFC, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFE, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFE, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF0, 0x0F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF0,
  0x0F, 0xF9, 0xFE, 0x7F, 0x1F, 0xF0, 0x0F, 0xF9, 0xFE, 0x7F, 0x1F, 0xF0,
  0x0F, 0xF9, 0xFC, 0x7F, 0xBF, 0xE0, 0x07, 0xF9, 0xFC, 0x3F, 0xBF, 0xE0,
  0x07, 0xF9, 0xFC, 0x3F, 0xBF, 0xE0, 0x07, 0xFF, 0xFC, 0x3F, 0xBF, 0xE0,
  0x07, 0xFF, 0xFC, 0x3F, 0xBF, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xBF, 0xC0,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x07,
  0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF9, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1E, 0x03, 0xFF, 0x04, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xBF, 0xDF, 0xFF, 0x9F, 0xE7, 0xFF, 0x87, 0xF0, 0xFF, 0x83,
  0xF8, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0xFF, 0x8F, 0xFC, 0x3F, 0xE7,
  0xFF, 0x8F, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xEF, 0xFF, 0x8F, 0xF1, 0xFF, 0xC3, 0xFC,
  0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFC, 0xFC, 0x7F, 0xE0, 0x10, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x27, 0xFE, 0x00, 0xCF, 0xFE, 0x0F, 0x9F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xE1, 0xFF,
  0x07, 0xFE, 0x7F, 0xC7, 0xFF, 0xDF, 0xF1, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFD, 0xFF, 0x83, 0xFF, 0x7F, 0xF1, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF,
  0xF0, 0xFF, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0x40, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xBF, 0xF9, 0xFF, 0x83,
  0xFE, 0x7F, 0xC0, 0x7F, 0xBF, 0xF0, 0x1F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x1F, 0xF8, 0x01, 0xC7, 0xFF,
  0xC7, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xCC, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x8F, 0xF0,
  0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xC7, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xDF, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFC, 0x3F, 0xF9, 0xFF,
  0x03, 0xFC, 0x7F, 0xC0, 0x10, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x60, 0x00, 0xFF, 0xDF, 0x80, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0xFF, 0x9F,
  0xFE, 0x3F, 0xEF, 0xFF, 0xCF, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE8, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xF3,
  0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE,
  0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x0F, 0xF9, 0xFF,
  0x80, 0x7F, 0xCF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x9F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x7F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC7, 0xFF, 0x87, 0xFF, 0x8F, 0xF3,
  0xFF, 0xF3, 0xFF, 0xF3, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFE, 0x07, 0xF8,
  0x3F, 0xC7, 0xFF, 0x8F, 0xF3, 0xFF, 0xF3, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x7F,
  0xE0, 0xFF, 0xCF, 0xF8, 0x0F, 0xFB, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xC7, 0xFF, 0x0F, 0xFB, 0xFF, 0xE3,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFE, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFB, 0xFF, 0xE3, 0xFE, 0x7F, 0xF0, 0xFF, 0x8F, 0xF0,
  0x3F, 0xE0, 0x60, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x8F, 0xF0, 0xFF,
  0xF7, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0xDF, 0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFC, 0x3F, 0xF9, 0xFF, 0x03,
  0xFC, 0x7F, 0xC0, 0x10, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x9F, 0xF0, 0x18,
  0xFF, 0x80, 0x47, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC3, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x80, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xEF, 0xF3, 0xFF, 0xF3, 0xFC, 0x7F, 0xFC, 0xFF, 0x07,
  0xFC, 0x1F, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE,
  0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF7, 0xFC, 0x07,
  0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xFF, 0x07,
  0xFC, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0x87, 0xFC,
  0x1F, 0xE1, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0x1F, 0xFF, 0x8F, 0xF8, 0x1F,
  0xF1, 0xFB, 0xF8, 0xFF, 0x81, 0xFF, 0x3F, 0x9F, 0x8F, 0xF8, 0x0F, 0xF3,
  0xF9, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x9F, 0xCF, 0xF0, 0x0F, 0xF3, 0xF9,
  0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0x9F, 0xDF, 0xF0, 0x07, 0xFB, 0xF1, 0xFD,
  0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xDF, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF9,
  0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0x03,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xE3,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0x80, 0x07, 0xFE, 0x40, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Black52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 11, 38, 15, 2, -37 },
  { 54, 21, 13, 26, 3, -37 },
  { 89, 30, 37, 32, 1, -37 },
  { 228, 25, 43, 28, 2, -40 },
  { 363, 45, 38, 47, 1, -38 },
  { 577, 37, 39, 39, 2, -38 },
  { 758, 9, 13, 14, 3, -37 },
  { 773, 15, 46, 18, 2, -38 },
  { 860, 15, 46, 18, 1, -38 },
  { 947, 25, 25, 27, 1, -40 },
  { 1026, 25, 25, 29, 2, -31 },
  { 1105, 11, 15, 15, 2, -8 },
  { 1126, 14, 8, 17, 1, -18 },
  { 1140, 10, 10, 15, 2, -9 },
  { 1153, 23, 39, 23, 0, -38 },
  { 1266, 25, 39, 29, 2, -38 },
  { 1388, 21, 37, 29, 2, -37 },
  { 1486, 25, 38, 29, 1, -38 },
  { 1605, 25, 39, 29, 2, -38 },
  { 1727, 27, 37, 29, 1, -37 },
  { 1852, 24, 38, 29, 2, -37 },
  { 1966, 25, 39, 29, 2, -38 },
  { 2088, 25, 37, 29, 2, -37 },
  { 2204, 25, 39, 29, 2, -38 },
  { 2326, 25, 39, 29, 2, -38 },
  { 2448, 11, 30, 15, 2, -29 },
  { 2490, 11, 36, 15, 2, -29 },
  { 2540, 25, 28, 29, 2, -33 },
  { 2628, 25, 19, 29, 2, -28 },
  { 2688, 25, 28, 29, 2, -33 },
  { 2776, 23, 39, 24, 0, -38 },
  { 2889, 40, 42, 44, 2, -38 },
  { 3099, 35, 37, 35, 0, -37 },
  { 3261, 26, 37, 33, 4, -37 },
  { 3382, 28, 39, 31, 2, -38 },
  { 3519, 29, 37, 35, 4, -37 },
  { 3654, 20, 37, 27, 4, -37 },
  { 3747, 20, 37, 26, 4, -37 },
  { 3840, 31, 39, 36, 2, -38 },
  { 3992, 29, 37, 37, 4, -37 },
  { 4127, 18, 37, 21, 2, -37 },
  { 4211, 17, 49, 17, -4, -37 },
  { 4316, 29, 37, 33, 4, -37 },
  { 4451, 22, 37, 27, 4, -37 },
  { 4553, 40, 37, 47, 4, -37 },
  { 4738, 32, 37, 40, 4, -37 },
  { 4886, 34, 39, 38, 2, -38 },
  { 5052, 25, 37, 31, 4, -37 },
  { 5168, 34, 47, 38, 2, -38 },
  { 5368, 29, 37, 33, 4, -37 },
  { 5503, 24, 39, 28, 2, -38 },
  { 5620, 26, 37, 28, 1, -37 },
  { 5741, 30, 38, 36, 3, -37 },
  { 5884, 34, 37, 34, 0, -37 },
  { 6042, 48, 37, 50, 1, -37 },
  { 6264, 34, 37, 34, 0, -37 },
  { 6422, 32, 37, 32, 0, -37 },
  { 6570, 27, 37, 29, 1, -37 },
  { 6695, 12, 47, 16, 3, -38 },
  { 6766, 22, 39, 23, 0, -38 },
  { 6874, 13, 47, 16, 1, -38 },
  { 6951, 28, 24, 28, 0, -37 },
  { 7035, 26, 7, 26, 0, 3 },
  { 7058, 16, 8, 20, 2, -40 },
  { 7074, 25, 30, 30, 2, -29 },
  { 7168, 26, 41, 31, 3, -40 },
  { 7302, 23, 30, 26, 2, -29 },
  { 7389, 26, 41, 31, 2, -40 },
  { 7523, 26, 30, 30, 2, -29 },
  { 7621, 20, 40, 20, 1, -40 },
  { 7721, 26, 41, 31, 2, -29 },
  { 7855, 26, 40, 32, 3, -40 },
  { 7985, 10, 40, 16, 3, -40 },
  { 8035, 15, 52, 16, -2, -40 },
  { 8133, 29, 40, 32, 3, -40 },
  { 8278, 10, 40, 16, 3, -40 },
  { 8328, 42, 29, 48, 3, -29 },
  { 8481, 26, 29, 32, 3, -29 },
  { 8576, 27, 30, 31, 2, -29 },
  { 8678, 26, 41, 31, 3, -29 },
  { 8812, 26, 41, 31, 2, -29 },
  { 8946, 19, 29, 23, 3, -29 },
  { 9015, 21, 30, 25, 2, -29 },
  { 9094, 20, 36, 22, 1, -35 },
  { 9184, 26, 30, 32, 3, -29 },
  { 9282, 29, 29, 29, 0, -29 },
  { 9388, 44, 29, 44, 0, -29 },
  { 9548, 30, 29, 30, 0, -29 },
  { 9657, 29, 41, 29, 0, -29 },
  { 9806, 22, 29, 24, 1, -29 },
  { 9886, 19, 47, 21, 1, -38 },
  { 9998, 7, 52, 25, 9, -40 },
  { 10044, 19, 47, 21, 1, -38 },
  { 10156, 25, 10, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Black52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Black52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Black52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_BLACK52PT7B_H_
