#ifndef _ROBOTOCONDENSED_BLACK48PT7B_H_
#define _ROBOTOCONDENSED_BLACK48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xE7, 0xF7, 0xFF, 0xFE,
  0xFE, 0x7F, 0x1F, 0x00, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3D, 0xE1, 0xEF,
  0x0F, 0x00, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x7C, 0x00, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x0F, 0x9F, 0x00, 0x3E,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0x9F, 0xE7, 0xF8, 0xFF, 0x3F, 0xC3,
  0xF9, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0, 0xFE,
  0x7F, 0x8F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xDF, 0x83,
  0x81, 0xF1, 0xF0, 0x78, 0x3E, 0x3E, 0x1F, 0x07, 0xC7, 0xC7, 0xC0, 0xF8,
  0xF8, 0xF0, 0x1F, 0x1F, 0x3E, 0x03, 0xE3, 0xE7, 0x80, 0x3E, 0xFD, 0xF0,
  0x07, 0xFF, 0xBC, 0x00, 0xFF, 0xEF, 0x80, 0x0F, 0xF9, 0xE0, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x1E, 0x7F, 0xC0, 0x07, 0xDF, 0xF8, 0x00, 0xF7, 0xFF, 0x80, 0x3E,
  0xFD, 0xF0, 0x07, 0x9F, 0x1F, 0x01, 0xF3, 0xE3, 0xE0, 0x3C, 0x78, 0x7C,
  0x0F, 0x8F, 0x0F, 0x81, 0xE1, 0xE1, 0xF0, 0x7C, 0x3E, 0x3E, 0x0F, 0x07,
  0xEF, 0x80, 0x40, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE7, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0x81, 0xFF, 0xC7, 0xF0, 0x7F, 0xF8, 0xFE, 0x1F, 0xFF, 0x9F, 0xC7, 0xFF,
  0xFB, 0xF0, 0xFE, 0xFF, 0xFE, 0x1F, 0xCF, 0xFF, 0xC7, 0xF8, 0xFF, 0xF8,
  0xFF, 0x1F, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x3F, 0xE7,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF8, 0x00, 0x40, 0x18, 0x07,
  0x81, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x78, 0x06, 0x00, 0x40, 0x20, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F,
  0xC0, 0x78, 0x07, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x01, 0xC3, 0xE1,
  0xDF, 0xCF, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x8F, 0x81, 0xF8, 0x7E, 0x07, 0x81, 0xF0, 0x1C, 0x07, 0x00, 0x00,
  0x20, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xE0, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x3C, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFE, 0x7F, 0x8F, 0xE1, 0xFE, 0x7F, 0x0F, 0xF7, 0xF8, 0x3F, 0xBF, 0xC1,
  0xFD, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF,
  0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xC3, 0xFC, 0xFF, 0x3F, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x3F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE,
  0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xE0, 0x7E,
  0x7F, 0x03, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE1, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF9, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x7E,
  0x07, 0xF7, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFC, 0x7F, 0xBF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xDF, 0xC3, 0xFE, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0x9F, 0xF7, 0xF8, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F,
  0xF7, 0xF0, 0xFF, 0x7F, 0x8F, 0xE3, 0xF9, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0x8F, 0xF7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF9, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x8F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xEF, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xF7, 0xFB,
  0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0x80, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF9, 0xFC, 0xFC, 0xFE, 0x7E, 0x3E, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F,
  0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x0F,
  0xC0, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E, 0x3E, 0x07, 0xFF, 0x87, 0x8F, 0x83,
  0xFF, 0xE1, 0xF3, 0xE0, 0xFF, 0xF8, 0x7D, 0xF0, 0x7E, 0x3E, 0x1F, 0x7C,
  0x1F, 0x0F, 0x87, 0xDF, 0x0F, 0xC3, 0xE1, 0xF7, 0xC3, 0xE0, 0xF8, 0x7D,
  0xF0, 0xF8, 0x3E, 0x1F, 0x7C, 0x7E, 0x0F, 0x87, 0xDF, 0x1F, 0x87, 0xE1,
  0xF7, 0xC7, 0xE1, 0xF8, 0x7D, 0xE1, 0xF8, 0x7C, 0x1F, 0x78, 0x7E, 0x1F,
  0x07, 0x9E, 0x1F, 0x87, 0xC1, 0xE7, 0xC7, 0xE1, 0xF0, 0xF9, 0xF1, 0xF8,
  0xFC, 0x3C, 0x7C, 0x3F, 0xFF, 0x9F, 0x1F, 0x0F, 0xFF, 0xFF, 0x87, 0xC1,
  0xFF, 0xFF, 0xE1, 0xF0, 0x7F, 0x9F, 0xF0, 0x3E, 0x07, 0x83, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x30,
  0x00, 0x1F, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFF,
  0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x00,
  0x7F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0x7F, 0x81,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC3, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xF7,
  0xFE, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xC7, 0xFE, 0x7F, 0x83, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x7F, 0xF3, 0xFE, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0xF3, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xF7, 0xFD, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0xFF, 0xDF, 0xE0, 0x7F, 0xCF,
  0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xF8,
  0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0x7F, 0xC1, 0xFF,
  0xBF, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0x1F,
  0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xF9,
  0xFE, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF,
  0x7C, 0x3F, 0x7F, 0xFF, 0x7E, 0x3F, 0xFF, 0xFF, 0x7E, 0x3E, 0xFF, 0xFF,
  0x7E, 0x7E, 0xFF, 0xFF, 0x3E, 0x7E, 0xFF, 0xFF, 0x3E, 0x7E, 0xFF, 0xFF,
  0x3F, 0x7C, 0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF,
  0x1F, 0xF8, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF,
  0x0F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0xFF,
  0x07, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFB, 0xE3, 0xFF, 0xFD,
  0xF1, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0x9F, 0x3F, 0xFF,
  0xC7, 0xDF, 0xFF, 0xE3, 0xEF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xDF, 0xF8,
  0xFF, 0x83, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F,
  0xF0, 0x7F, 0xCF, 0xFE, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x07,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xDF, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0x80, 0xFF, 0x7F,
  0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xF0, 0x7F, 0xCF, 0xFE, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xFC,
  0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xF1, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0x03, 0xFD, 0xFE,
  0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0xFF,
  0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFB,
  0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFF, 0x3F, 0xF7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFE, 0x7F,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03,
  0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0x83, 0xFB, 0xFC, 0x1F, 0xE1, 0xFE, 0x7F, 0x07, 0xF8, 0x7F,
  0x9F, 0xE3, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0x87, 0xF9, 0xFE, 0x3F, 0xF1,
  0xFE, 0x7F, 0x8F, 0xFC, 0x7F, 0x1F, 0xE3, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF,
  0xCF, 0xF0, 0xFE, 0x7F, 0xF3, 0xFC, 0x3F, 0xDF, 0xFC, 0xFF, 0x0F, 0xF7,
  0xFF, 0xBF, 0xC3, 0xFD, 0xFF, 0xEF, 0xE0, 0xFF, 0x7F, 0xFB, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0xFC, 0x07, 0xFF, 0xDF, 0xFF,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0x3F,
  0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8,
  0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xE3, 0xFE,
  0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF,
  0xE0, 0x07, 0xFB, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF8, 0xFF,
  0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7C, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xE3, 0xE3, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xCF, 0xE7,
  0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F, 0xEF, 0xF1, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xEF,
  0xF0, 0x7C, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x3E, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xEF, 0xFC, 0xFE, 0xFF, 0x8F, 0xE3, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0x8F, 0xE7, 0xF0, 0xFF, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF8, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xF9, 0xFE, 0x1F, 0xEF, 0xF1, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x8F, 0xFB, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xF7, 0xF0, 0x7F, 0xBF, 0xC7, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFC, 0xFE, 0x0F, 0xC7,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x8F, 0xF8, 0x3C, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF3, 0xF8,
  0x7F, 0xDF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0x1F, 0xEF, 0xF0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF,
  0x8F, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFB, 0xF8, 0x1F, 0x9F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x87, 0x07, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x3E, 0x0F,
  0xF7, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x07, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xBF, 0xC7, 0xFC, 0xFF,
  0x1F, 0xF3, 0xFC, 0xFF, 0x8F, 0xF3, 0xFC, 0x3F, 0xDF, 0xF0, 0xFF, 0x7F,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xEF,
  0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xFC, 0xFF, 0x1F,
  0xF3, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0xFF, 0x87, 0xF8, 0xFF,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF,
  0xF8, 0x7F, 0x8F, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xE1, 0xFE, 0x3F, 0xFF,
  0xC3, 0xFC, 0x7F, 0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE,
  0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xC7, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xF0,
  0xFF, 0x1F, 0xFF, 0xE1, 0xFE, 0x3F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0x87,
  0xF8, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0xFE, 0x3F,
  0x0F, 0xE7, 0xF8, 0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x3F, 0xEF, 0xF0, 0xFF,
  0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFB,
  0xF8, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF, 0x9F, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xFE, 0x3E, 0x0F, 0xEF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xF3, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x7F, 0x9F, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x3F,
  0xEF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xC1, 0xFE, 0xFF, 0x1F, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xF7, 0xF8,
  0x1F, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0x3F, 0xDF, 0xC7, 0xFB, 0xF8, 0x7F, 0x7F, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xF7, 0xF1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xFE, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xE7, 0xF0,
  0xFC, 0x7F, 0x7F, 0x87, 0xFD, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xE1,
  0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFC,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0xFE, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x7F, 0xFE, 0x1F, 0x87,
  0xFF, 0xE1, 0xF8, 0xFF, 0x7F, 0x3F, 0xCF, 0xE7, 0xF3, 0xFC, 0xFE, 0x7F,
  0x3F, 0xCF, 0xE7, 0xF3, 0xFC, 0xFE, 0x7F, 0x3F, 0xCF, 0xE7, 0xF7, 0xFE,
  0xFE, 0x3F, 0x7F, 0xEF, 0xC3, 0xF7, 0xFE, 0xFC, 0x3F, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9,
  0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF7,
  0xF8, 0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0x3F, 0xC3, 0xF9, 0xFE, 0x1F, 0xEF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xBF, 0x83, 0xF9, 0xFC, 0x3F, 0xCF, 0xF1, 0xFE, 0x3F, 0x8F, 0xE1, 0xFE,
  0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFD, 0xFE, 0x1F, 0xF7,
  0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xF8, 0xFE, 0x3F, 0xC3, 0xFC,
  0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xCF, 0xF0, 0x7F, 0x3F, 0x81, 0xFD, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x1E, 0x03,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x87, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xE0, 0x1E, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x20, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x7F,
  0x0F, 0xF1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x20, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0x83, 0xF3, 0xFF, 0x0F, 0xDF, 0xFC, 0x3F, 0x7F, 0xFD, 0xFD, 0xFF, 0xFF,
  0xEF, 0xEF, 0xFF, 0xBF, 0x0F, 0xFC, 0xFC, 0x3F, 0xF3, 0xE0, 0x7F, 0x80,
  0x00, 0x78, 0x00,
};

const GFXglyph RobotoCondensed_Black48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 34, 13, 2, -34 },
  { 40, 13, 13, 15, 1, -36 },
  { 62, 22, 34, 25, 1, -34 },
  { 156, 21, 44, 25, 2, -39 },
  { 272, 27, 34, 31, 2, -34 },
  { 387, 27, 34, 29, 1, -34 },
  { 502, 6, 13, 7, 1, -36 },
  { 512, 11, 49, 16, 3, -38 },
  { 580, 12, 49, 16, 1, -38 },
  { 654, 21, 21, 22, 1, -34 },
  { 710, 20, 25, 22, 1, -29 },
  { 773, 9, 15, 13, 1, -6 },
  { 790, 12, 6, 20, 4, -18 },
  { 799, 8, 8, 15, 3, -8 },
  { 807, 14, 37, 15, 0, -34 },
  { 872, 21, 34, 25, 2, -34 },
  { 962, 14, 34, 25, 4, -34 },
  { 1022, 22, 34, 25, 1, -34 },
  { 1116, 22, 34, 25, 1, -34 },
  { 1210, 21, 34, 25, 2, -34 },
  { 1300, 20, 34, 25, 2, -34 },
  { 1385, 21, 34, 25, 2, -34 },
  { 1475, 22, 34, 25, 1, -34 },
  { 1569, 20, 34, 25, 2, -34 },
  { 1654, 20, 34, 25, 2, -34 },
  { 1739, 9, 27, 14, 3, -27 },
  { 1770, 9, 36, 13, 2, -27 },
  { 1811, 18, 23, 22, 1, -26 },
  { 1863, 19, 16, 25, 3, -23 },
  { 1901, 17, 23, 22, 3, -26 },
  { 1950, 19, 34, 22, 1, -34 },
  { 2031, 34, 44, 37, 1, -33 },
  { 2218, 29, 34, 29, 0, -34 },
  { 2342, 23, 34, 27, 2, -34 },
  { 2440, 24, 34, 27, 2, -34 },
  { 2542, 23, 34, 27, 2, -34 },
  { 2640, 21, 34, 23, 2, -34 },
  { 2730, 20, 34, 23, 2, -34 },
  { 2815, 24, 34, 28, 2, -34 },
  { 2917, 25, 34, 29, 2, -34 },
  { 3024, 8, 34, 13, 3, -34 },
  { 3058, 20, 34, 24, 1, -34 },
  { 3143, 25, 34, 27, 2, -34 },
  { 3250, 20, 34, 23, 2, -34 },
  { 3335, 32, 34, 36, 2, -34 },
  { 3471, 25, 34, 29, 2, -34 },
  { 3578, 25, 34, 29, 2, -34 },
  { 3685, 24, 34, 28, 2, -34 },
  { 3787, 25, 40, 29, 2, -34 },
  { 3912, 24, 34, 27, 2, -34 },
  { 4014, 23, 34, 26, 2, -34 },
  { 4112, 24, 34, 27, 1, -34 },
  { 4214, 23, 34, 28, 2, -34 },
  { 4312, 28, 34, 28, 0, -34 },
  { 4431, 34, 34, 36, 1, -34 },
  { 4576, 27, 34, 27, 0, -34 },
  { 4691, 26, 34, 27, 0, -34 },
  { 4802, 23, 34, 26, 1, -34 },
  { 4900, 10, 48, 13, 2, -40 },
  { 4960, 20, 37, 19, 0, -34 },
  { 5053, 9, 48, 13, 1, -40 },
  { 5107, 17, 17, 19, 1, -34 },
  { 5144, 18, 6, 19, 0, 0 },
  { 5158, 13, 7, 16, 1, -36 },
  { 5170, 20, 26, 22, 1, -26 },
  { 5235, 20, 36, 24, 2, -36 },
  { 5325, 20, 26, 22, 1, -26 },
  { 5390, 21, 36, 24, 1, -36 },
  { 5485, 20, 26, 23, 2, -26 },
  { 5550, 14, 36, 16, 1, -36 },
  { 5613, 21, 36, 24, 1, -26 },
  { 5708, 20, 36, 24, 2, -36 },
  { 5798, 8, 37, 13, 2, -37 },
  { 5835, 12, 47, 12, -2, -37 },
  { 5906, 22, 36, 24, 2, -36 },
  { 6005, 8, 36, 13, 2, -36 },
  { 6041, 31, 26, 35, 2, -26 },
  { 6142, 20, 26, 24, 2, -26 },
  { 6207, 21, 26, 24, 1, -26 },
  { 6276, 20, 36, 24, 2, -26 },
  { 6366, 21, 36, 24, 1, -26 },
  { 6461, 14, 26, 17, 2, -26 },
  { 6507, 19, 26, 22, 1, -26 },
  { 6569, 13, 32, 15, 1, -32 },
  { 6621, 20, 26, 24, 2, -26 },
  { 6686, 22, 26, 22, 0, -26 },
  { 6758, 28, 26, 30, 1, -26 },
  { 6849, 21, 26, 22, 1, -26 },
  { 6918, 22, 36, 22, 0, -26 },
  { 7017, 18, 26, 22, 2, -26 },
  { 7076, 12, 45, 14, 1, -37 },
  { 7144, 4, 40, 12, 4, -34 },
  { 7164, 12, 45, 14, 1, -37 },
  { 7232, 22, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_Black48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_BLACK48PT7B_H_
