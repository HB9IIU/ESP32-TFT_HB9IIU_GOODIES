#ifndef _ROBOTOCONDENSED_BLACK61PT7B_H_
#define _ROBOTOCONDENSED_BLACK61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0xFE, 0x3F, 0xEF, 0xFD, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE,
  0x02, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E,
  0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00,
  0x1F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE, 0x7F,
  0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xFB, 0xFF, 0x03,
  0xFE, 0x7F, 0xE0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF8, 0xFF, 0xE7, 0xFF, 0x1F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x08, 0x03,
  0xF9, 0xFC, 0x0F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0,
  0x7E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE1, 0xF0,
  0x0F, 0xC3, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0xF8, 0x03, 0xF9, 0xFC, 0xFC,
  0x01, 0xFF, 0xFE, 0x7C, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x3E,
  0x00, 0x0F, 0xFF, 0x3F, 0x00, 0x01, 0xFF, 0x3F, 0x00, 0x00, 0x18, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x03,
  0xE7, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xE0, 0x01, 0xF3, 0xFF, 0xF0, 0x01,
  0xFB, 0xFF, 0xFC, 0x00, 0xF9, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x3F, 0x00,
  0x7C, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0xFC,
  0x0F, 0x81, 0xFC, 0x7E, 0x01, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF,
  0x87, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xE3, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F,
  0x8F, 0xFD, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF,
  0xFC, 0x3F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFD, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x40, 0x00, 0xE0,
  0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x03,
  0x80, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0x80, 0xF8, 0x04, 0x7C, 0x1F, 0x03, 0xCF, 0xF3,
  0xE3, 0xFB, 0xFF, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0x80, 0x7C, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0x03, 0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFF, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE1, 0xFC, 0x04, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x7F, 0xF7, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC7, 0xFC, 0x1F, 0xFB, 0xFF, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0,
  0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF, 0x03, 0xFE,
  0xFF, 0xC0, 0xFF, 0xBF, 0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0xF9, 0xFF, 0x87,
  0xFC, 0x7F, 0xF7, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x0F, 0xFC, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F,
  0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF,
  0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF3, 0xFF, 0xDF, 0xFC, 0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xDF, 0xF8, 0x03, 0xFB,
  0xFF, 0x00, 0xFE, 0x7F, 0xE0, 0x1F, 0xCF, 0xFC, 0x07, 0xF9, 0xFF, 0x80,
  0xFE, 0x3F, 0xF0, 0x3F, 0xC7, 0xFE, 0x07, 0xF8, 0xFF, 0xC1, 0xFE, 0x1F,
  0xF8, 0x3F, 0xC3, 0xFF, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0x80, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xF8, 0x0E, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD,
  0xFF, 0xCF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xDF, 0xF0,
  0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFC,
  0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFD, 0xFF, 0x07, 0xFE, 0xFF,
  0x83, 0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xF1, 0xFF, 0x8F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x9F, 0xF8, 0xFF,
  0xDF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x3F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFB, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0x83, 0xFF, 0x3F, 0xF0,
  0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF7,
  0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xF8, 0x0F, 0xFD, 0xFF, 0x81,
  0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xE1, 0xFF, 0xCF,
  0xFE, 0x7F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xFC, 0x01,
  0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x07, 0xF1, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7,
  0xF0, 0x10, 0x00, 0x02, 0x01, 0xFC, 0x3F, 0xE3, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF3, 0xFF, 0x3F, 0xE1, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFC,
  0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x03, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xFE, 0x07, 0xE1, 0xFC, 0x03, 0xFF, 0xE0,
  0x7C, 0x3F, 0x00, 0xFF, 0xFE, 0x0F, 0xC7, 0xE0, 0x3F, 0xFF, 0xC1, 0xF9,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x3F, 0x81, 0xFC, 0x3F, 0x07, 0xE7, 0xE0,
  0x7F, 0x07, 0xE0, 0x7C, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0x9F, 0x83, 0xF8,
  0x3F, 0x81, 0xF7, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xDF, 0xC3, 0xFC, 0x1F, 0xC0, 0xFB, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0x7E, 0x0F, 0xE0, 0x7F, 0x03, 0xEF, 0xC1, 0xFC, 0x0F, 0xC0, 0x7D, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0xBF, 0x07, 0xF0, 0x3F, 0x03, 0xF7, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xDF, 0x83, 0xF8, 0x3F,
  0x81, 0xF3, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0xFE, 0x0F,
  0xCF, 0xE1, 0xFE, 0x3F, 0xC3, 0xF1, 0xFC, 0x1F, 0xFF, 0xFC, 0xFE, 0x1F,
  0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0xFB, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0x3F, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xFE, 0x00, 0xFC, 0x01, 0xC0,
  0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x80,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC0, 0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x00,
  0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF,
  0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1, 0xFF, 0xE7, 0xFE,
  0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03,
  0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0,
  0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07,
  0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07,
  0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07,
  0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0x3F, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF,
  0xF8, 0x7F, 0xF7, 0xFE, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF,
  0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0x80, 0xFF,
  0xE3, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xFF, 0xBF, 0x81, 0xFD, 0xFF,
  0xFF, 0xBF, 0xC1, 0xFD, 0xFF, 0xFF, 0xBF, 0xC3, 0xFD, 0xFF, 0xFF, 0xDF,
  0xC3, 0xFD, 0xFF, 0xFF, 0xDF, 0xC3, 0xF9, 0xFF, 0xFF, 0xDF, 0xC3, 0xF9,
  0xFF, 0xFF, 0xDF, 0xE3, 0xF9, 0xFF, 0xFF, 0xCF, 0xE7, 0xFB, 0xFF, 0xFF,
  0xCF, 0xE7, 0xF3, 0xFF, 0xFF, 0xCF, 0xE7, 0xF3, 0xFF, 0xFF, 0xC7, 0xF7,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xBF, 0x0F, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xFE, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0xF1, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFB, 0xFF, 0xFF, 0xC7, 0xF7, 0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x7F, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0xFE, 0x7F, 0xF0,
  0x07, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0B, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x00, 0xFF, 0xEF, 0xFC,
  0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00,
  0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F,
  0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0xC3, 0xFF, 0x07, 0xFF, 0x0F, 0xFC, 0x0F, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xC1, 0xFF, 0xDF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xE0,
  0x7F, 0xF7, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF,
  0xC0, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC,
  0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x3F, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF3, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC7,
  0xFC, 0x1F, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8,
  0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF,
  0xE3, 0xFF, 0x0F, 0xFC, 0x7F, 0xFE, 0x7F, 0xE0, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFC, 0x1F, 0xFB, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0x3F, 0xE0,
  0x7F, 0xEF, 0xFF, 0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0xFD, 0xFF, 0x81, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFB, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F,
  0xFB, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0x01,
  0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x9F, 0xFE, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0xBF, 0xF8,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0xE3, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x1F, 0x81, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x0F,
  0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x7F, 0x01, 0xFF, 0xFC, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF, 0xF0, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFC,
  0xFF, 0xDF, 0xF8, 0x7F, 0xEF, 0xFC, 0x3F, 0xF7, 0xFC, 0x1F, 0xFB, 0xFE,
  0x0F, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xF7, 0xFE, 0x3F, 0xF3, 0xFF, 0x0F, 0xF1, 0xFF, 0x80, 0x40, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF9,
  0xFF, 0x03, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF,
  0xEF, 0xFC, 0x1F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0,
  0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xFE, 0x3F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xBF, 0xFC, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F, 0xE7,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0x7F, 0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x1F, 0xF3, 0xFE, 0x1F, 0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xE7,
  0xF8, 0x3F, 0xE3, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF,
  0x9F, 0xF8, 0x3F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x10, 0x7F, 0xE0, 0x0C, 0x1F, 0xFE, 0x1F, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0xFF, 0xF7, 0xFC,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF,
  0xFC, 0x7F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFE,
  0xFF, 0xC0, 0x08, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x06,
  0x01, 0xFF, 0xC3, 0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0x83, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF8, 0xFF, 0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x1E,
  0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F,
  0xFF, 0x3F, 0xFC, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xF7, 0xFC, 0x1F,
  0xFE, 0xFF, 0x83, 0xFF, 0x9F, 0xF0, 0xFF, 0xE3, 0xFE, 0x1F, 0xFC, 0x7F,
  0xC7, 0xFF, 0x0F, 0xF9, 0xFF, 0xC1, 0xFF, 0x3F, 0xF8, 0x3F, 0xEF, 0xFE,
  0x07, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFE, 0x0F, 0xFC, 0xFF, 0xE1,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0xC7, 0xFC, 0x3F, 0xF8, 0xFF, 0x83,
  0xFF, 0x9F, 0xF0, 0x7F, 0xF3, 0xFE, 0x07, 0xFF, 0x7F, 0xC0, 0xFF, 0xEF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFE, 0x7F, 0xF1, 0xFF, 0xC7, 0xFD, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x00, 0x00,
  0x40, 0x3F, 0xF1, 0xFE, 0x0F, 0xFC, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF3, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x7F, 0xF3, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x0F, 0xFB, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFF, 0xBF, 0xF0, 0x7F, 0xEF, 0xF8, 0x1F,
  0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0xC1, 0xFF, 0xBF, 0xF8,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xE0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xE0, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0xFF,
  0xE7, 0xFC, 0x7F, 0xFD, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF,
  0x07, 0xFC, 0xFF, 0xC0, 0x10, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC7, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xC7, 0xFE, 0x7F, 0xE1, 0xFF, 0xBF, 0xE0,
  0xFF, 0xDF, 0xF0, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xBF, 0xE0, 0xFF, 0xDF, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x18, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD,
  0xFF, 0x83, 0xFF, 0x7F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xE7, 0xFC, 0x1F, 0xE1, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xE0, 0x7F,
  0xEF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xF0, 0x3F, 0xF3, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x3F, 0xDF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xF7, 0xFC,
  0x3F, 0xC3, 0xFF, 0x7F, 0xC3, 0xFC, 0x3F, 0xE7, 0xFC, 0x7F, 0xE3, 0xFE,
  0x7F, 0xC7, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFE,
  0x3F, 0xE3, 0xFC, 0x7F, 0xE3, 0xFC, 0x3F, 0xCF, 0xFF, 0x3F, 0xC3, 0xFE,
  0xFF, 0xF7, 0xFC, 0x3F, 0xEF, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0xF7, 0xFC,
  0x1F, 0xEF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF, 0x80, 0xFF,
  0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x1F, 0xF0, 0x7F, 0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xDF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xF3, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0xFF,
  0xC1, 0xFF, 0xBF, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFE, 0xFF, 0xE0, 0x7F,
  0xF7, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x3F,
  0xF0, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0x9F, 0xF8, 0x0F, 0xFB, 0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC3, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x60, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0x01, 0xFC, 0x7F, 0xF0, 0x3F, 0x9F, 0xFF, 0x07, 0xF7, 0xFF,
  0xE0, 0xFE, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x1F, 0xFF, 0xDF, 0xC1, 0xFF, 0xFB, 0xF8, 0x3F, 0xFE, 0x7F, 0x03,
  0xFF, 0x8F, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Black61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 44, 16, 3, -43 },
  { 62, 17, 17, 19, 1, -46 },
  { 99, 28, 43, 31, 1, -43 },
  { 250, 27, 57, 31, 2, -50 },
  { 443, 33, 45, 39, 3, -44 },
  { 629, 33, 45, 36, 2, -44 },
  { 815, 7, 17, 9, 1, -46 },
  { 830, 15, 61, 20, 3, -48 },
  { 945, 15, 61, 20, 2, -48 },
  { 1060, 27, 27, 28, 1, -43 },
  { 1152, 25, 32, 28, 2, -36 },
  { 1252, 12, 19, 16, 1, -8 },
  { 1281, 16, 8, 26, 5, -23 },
  { 1297, 12, 11, 18, 3, -10 },
  { 1314, 18, 47, 19, 0, -43 },
  { 1420, 26, 45, 31, 3, -44 },
  { 1567, 17, 43, 31, 5, -43 },
  { 1659, 27, 44, 31, 2, -44 },
  { 1808, 27, 45, 31, 2, -44 },
  { 1960, 27, 43, 31, 2, -43 },
  { 2106, 26, 44, 31, 2, -43 },
  { 2249, 27, 44, 31, 2, -43 },
  { 2398, 27, 43, 31, 2, -43 },
  { 2544, 25, 45, 31, 3, -44 },
  { 2685, 27, 44, 31, 2, -44 },
  { 2834, 11, 35, 18, 4, -34 },
  { 2883, 12, 45, 17, 2, -34 },
  { 2951, 22, 29, 27, 2, -33 },
  { 3031, 23, 22, 31, 4, -30 },
  { 3095, 23, 30, 27, 3, -33 },
  { 3182, 25, 45, 28, 1, -44 },
  { 3323, 43, 56, 47, 2, -42 },
  { 3624, 37, 43, 37, 0, -43 },
  { 3823, 29, 43, 35, 3, -43 },
  { 3979, 31, 45, 35, 2, -44 },
  { 4154, 29, 43, 34, 3, -43 },
  { 4310, 26, 43, 30, 3, -43 },
  { 4450, 25, 43, 29, 3, -43 },
  { 4585, 32, 45, 36, 2, -44 },
  { 4765, 31, 43, 37, 3, -43 },
  { 4932, 11, 43, 17, 3, -43 },
  { 4992, 26, 44, 30, 1, -43 },
  { 5135, 32, 43, 34, 3, -43 },
  { 5307, 25, 43, 29, 3, -43 },
  { 5442, 40, 43, 46, 3, -43 },
  { 5657, 31, 43, 37, 3, -43 },
  { 5824, 32, 45, 37, 2, -44 },
  { 6004, 30, 43, 35, 3, -43 },
  { 6166, 33, 52, 37, 2, -44 },
  { 6381, 30, 43, 35, 3, -43 },
  { 6543, 29, 45, 34, 2, -44 },
  { 6707, 31, 43, 34, 1, -43 },
  { 6874, 29, 44, 35, 3, -43 },
  { 7034, 35, 43, 36, 0, -43 },
  { 7223, 43, 43, 45, 1, -43 },
  { 7455, 34, 43, 34, 0, -43 },
  { 7638, 33, 43, 34, 0, -43 },
  { 7816, 29, 43, 33, 2, -43 },
  { 7972, 12, 61, 16, 3, -51 },
  { 8064, 25, 47, 24, 0, -43 },
  { 8211, 12, 61, 16, 1, -51 },
  { 8303, 22, 22, 24, 1, -43 },
  { 8364, 22, 7, 24, 1, 0 },
  { 8384, 16, 9, 21, 2, -45 },
  { 8402, 25, 34, 28, 2, -33 },
  { 8509, 26, 47, 30, 3, -46 },
  { 8662, 24, 34, 28, 2, -33 },
  { 8764, 25, 47, 30, 2, -46 },
  { 8911, 26, 34, 29, 2, -33 },
  { 9022, 19, 47, 20, 1, -47 },
  { 9134, 26, 45, 31, 2, -33 },
  { 9281, 26, 46, 30, 2, -46 },
  { 9431, 10, 45, 16, 3, -45 },
  { 9488, 15, 57, 16, -2, -45 },
  { 9595, 27, 46, 30, 3, -46 },
  { 9751, 10, 46, 16, 3, -46 },
  { 9809, 39, 33, 45, 3, -33 },
  { 9970, 26, 33, 30, 2, -33 },
  { 10078, 26, 34, 30, 2, -33 },
  { 10189, 26, 45, 30, 3, -33 },
  { 10336, 26, 45, 30, 2, -33 },
  { 10483, 17, 33, 21, 3, -33 },
  { 10554, 25, 34, 28, 1, -33 },
  { 10661, 17, 41, 19, 1, -40 },
  { 10749, 26, 33, 30, 2, -32 },
  { 10857, 27, 32, 28, 0, -32 },
  { 10965, 36, 32, 38, 1, -32 },
  { 11109, 27, 32, 28, 1, -32 },
  { 11217, 28, 44, 28, 0, -32 },
  { 11371, 24, 32, 28, 2, -32 },
  { 11467, 15, 59, 18, 1, -48 },
  { 11578, 6, 51, 16, 5, -43 },
  { 11617, 14, 59, 18, 2, -48 },
  { 11721, 27, 14, 33, 3, -25 },
};

const GFXfont RobotoCondensed_Black61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_BLACK61PT7B_H_
