#ifndef _ROBOTOCONDENSED_BLACK45PT7B_H_
#define _ROBOTOCONDENSED_BLACK45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xF9, 0xFF, 0x9F,
  0xF9, 0xFF, 0x9F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1E, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07,
  0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xF0,
  0x03, 0xCF, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x83, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00,
  0x3C, 0xF0, 0x03, 0xE7, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x81, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07,
  0xCF, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x79, 0xE0,
  0x03, 0xCF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF,
  0x87, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xCF, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F,
  0xDF, 0xC3, 0xFB, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x08, 0x0F, 0x9F, 0x07, 0x07, 0xC7, 0x87, 0x83,
  0xE3, 0xC3, 0xC1, 0xF1, 0xE3, 0xC0, 0xF8, 0xF1, 0xE0, 0x7C, 0x79, 0xE0,
  0x3E, 0x7D, 0xF0, 0x0F, 0xFE, 0xF0, 0x07, 0xFE, 0xF8, 0x01, 0xFE, 0x78,
  0x00, 0x7E, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x7E, 0x00, 0x1E, 0x7F, 0x80, 0x0F, 0x7F, 0xE0, 0x0F, 0x7F, 0xF0, 0x0F,
  0xBE, 0x7C, 0x07, 0x9E, 0x3E, 0x07, 0xCF, 0x1F, 0x03, 0xC7, 0x8F, 0x83,
  0xE3, 0xC7, 0xC1, 0xE1, 0xE3, 0xE1, 0xE0, 0xF9, 0xF0, 0x30, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x7E, 0x1F, 0xFE, 0x3F, 0x0F, 0xFF, 0x9F, 0x8F, 0xFF, 0xEF, 0xC7,
  0xF7, 0xFF, 0xE7, 0xFB, 0xFF, 0xF3, 0xFC, 0xFF, 0xF1, 0xFE, 0x3F, 0xF8,
  0xFF, 0x1F, 0xF8, 0x7F, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFC, 0x07, 0xF1,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x70, 0x3C, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE1,
  0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3C, 0x07, 0x00, 0x80, 0x60, 0x07, 0x00, 0x78, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x78, 0x07,
  0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x04, 0x0F, 0x02, 0xF8, 0xF1, 0xEF, 0xEF, 0x7E, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0xBE, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x83, 0xE0, 0xF8,
  0x0C, 0x07, 0x00, 0x40, 0x40, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0xFC,
  0xF8, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC7,
  0xF3, 0xF8, 0xFE, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x0C, 0x01, 0xF0, 0x3F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F,
  0x8F, 0xE7, 0xF0, 0xFF, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x8F, 0xF7, 0xF0, 0xFF,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7D, 0xFC, 0x0F, 0xDF, 0xC0, 0xF9, 0xFC, 0x1F,
  0x9F, 0xC1, 0xF9, 0xFC, 0x3F, 0x1F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7E,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x3F,
  0xC0, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFB, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0xFE, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF1, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0xFF,
  0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFC,
  0x7F, 0x7F, 0x8F, 0xEF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xC7,
  0xF7, 0xF8, 0xFE, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x7F, 0xBF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFE, 0xFC, 0x0F, 0xBF,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3C, 0x3E, 0x3F, 0x9F, 0xFF, 0xF7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE7, 0xE3, 0xE1,
  0xF0, 0x30, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0,
  0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80,
  0x3F, 0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x01, 0xF8, 0x3C, 0x1E,
  0x07, 0xFC, 0x3E, 0x3E, 0x0F, 0xFF, 0x1E, 0x3E, 0x1F, 0xFF, 0x1E, 0x3C,
  0x1F, 0x9E, 0x1E, 0x7C, 0x3E, 0x1E, 0x1F, 0x7C, 0x3E, 0x1E, 0x1F, 0x7C,
  0x7C, 0x3E, 0x0F, 0x78, 0x7C, 0x3E, 0x0F, 0x78, 0x7C, 0x3E, 0x0F, 0x78,
  0x7C, 0x3E, 0x0F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0xFC, 0x3E, 0x1F, 0xF8,
  0xFC, 0x3E, 0x1E, 0xF8, 0xFC, 0x3E, 0x1E, 0xF8, 0x7C, 0x3E, 0x1E, 0x78,
  0x7C, 0x7E, 0x3C, 0x78, 0x7E, 0xFE, 0x7C, 0x78, 0x7F, 0xFF, 0xF8, 0x7C,
  0x3F, 0xFF, 0xF8, 0x7C, 0x1F, 0xCF, 0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x3C, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xF3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1,
  0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC1, 0xFE,
  0xFF, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xE1, 0xFF, 0x3F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFB,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0x3F, 0xC1,
  0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB,
  0xFC, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0xFF, 0x01,
  0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFE, 0xFF,
  0x87, 0xFD, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFF,
  0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xBF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFB, 0xE1, 0xFF, 0xFF, 0xEF, 0x87, 0xDF, 0xFF,
  0xBF, 0x1F, 0x7F, 0xFE, 0xFC, 0xFD, 0xFF, 0xF9, 0xF3, 0xE7, 0xFF, 0xE7,
  0xCF, 0x9F, 0xFF, 0x9F, 0x3E, 0x7F, 0xFE, 0x7F, 0xF9, 0xFF, 0xFC, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0x3F, 0xFF, 0xCF, 0xFC, 0xFF, 0xFF, 0x1F, 0xF3,
  0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0xC7, 0xF8, 0xFF,
  0xFF, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0xFC, 0x3F, 0xFF,
  0xC3, 0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF, 0xBE,
  0x7F, 0xFF, 0x7C, 0xFF, 0xFE, 0x7D, 0xFF, 0xFC, 0xFB, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xC0, 0xFE, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFC, 0xFF,
  0x87, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF,
  0xF0, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x81, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x20, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC1, 0xFE, 0xFF, 0x07,
  0xFB, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE3, 0xFC, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x81, 0xFD, 0xFE, 0x07,
  0xF7, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x0F,
  0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFF,
  0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0xFF, 0x0F, 0xE0, 0xFE, 0xFF, 0x0F, 0xE0,
  0xFE, 0xFF, 0x0F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF1, 0xFE, 0x7F, 0x1F, 0xF1,
  0xFE, 0x7F, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xF1, 0xFC, 0x7F, 0x9F, 0xF9,
  0xFC, 0x7F, 0x9F, 0xF9, 0xFC, 0x3F, 0xBF, 0xF9, 0xFC, 0x3F, 0xBF, 0xFB,
  0xFC, 0x3F, 0xBF, 0xFB, 0xF8, 0x3F, 0xBF, 0xFB, 0xF8, 0x3F, 0xBF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF,
  0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xBF, 0xE0, 0x7F, 0x8F,
  0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3,
  0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x7F, 0x9F, 0xC7, 0xF3,
  0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFE, 0x3F, 0xBF, 0xC7, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF,
  0xC3, 0xFB, 0xFC, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xF7, 0xF8, 0x7C, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF9, 0xF0, 0x7F, 0x7F, 0x8F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFE, 0xFF, 0x1F, 0xCF,
  0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8, 0x7E, 0xFF, 0x0F, 0xDF, 0xC1,
  0xFB, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x3F,
  0x8F, 0xF7, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x3F, 0xBF, 0x87, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x1F, 0xE7, 0xE0, 0xF8, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0x0F,
  0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x18, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xE7, 0xF0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xF7, 0xF0, 0x7E, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x08, 0x0F, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE7, 0xC3, 0xFB, 0xFC, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF8,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xFF, 0xE1, 0xFE, 0xFE, 0x3F, 0xCF, 0xE7,
  0xFC, 0xFE, 0x7F, 0x8F, 0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0x8F, 0xE7, 0xF8,
  0xFE, 0x3F, 0xCF, 0xE3, 0xFC, 0xFE, 0x1F, 0xEF, 0xE1, 0xFE, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3E, 0x0F, 0x87, 0xF7, 0xF8, 0xFF, 0x3F, 0xFF, 0xEF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0x9F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF0, 0xFE,
  0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xE1, 0xFC, 0x3F,
  0xFF, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF8, 0x7F, 0xFE,
  0x1F, 0xC3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFC, 0x3F,
  0x87, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x0F,
  0xFF, 0xC3, 0xF8, 0x7F, 0xFE, 0x3E, 0x3F, 0xBF, 0xCF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x7C,
  0x1F, 0xDF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x3F, 0xBF, 0xC7, 0xF3, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xDF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x3E, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0x7F, 0xFF, 0x9F, 0xCF, 0xF7, 0xE1, 0xFF, 0xF8, 0x7F, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFC, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xDF, 0xCF, 0xF3,
  0xF8, 0x7C, 0x7F, 0xFF, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0x0F, 0xF7, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x1F,
  0x9F, 0xC1, 0xFD, 0xFC, 0x1F, 0xDF, 0xC1, 0xFD, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0x1F, 0xFF, 0x8F, 0xC7, 0xFF, 0xE3, 0xF1,
  0xFF, 0xF8, 0xFC, 0x7F, 0xFE, 0x3F, 0x1F, 0xDF, 0x9F, 0xE7, 0xE7, 0xE7,
  0xF9, 0xF9, 0xF9, 0xFE, 0x7E, 0x7F, 0x7F, 0x9F, 0x9F, 0xDF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF,
  0xC3, 0xFF, 0x3F, 0xF0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF3, 0xFE, 0x07, 0xFC,
  0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xF7,
  0xF8, 0xFF, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x1F, 0xDF, 0xC1, 0xFD, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xDF, 0xC3, 0xFD, 0xFC, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x8F, 0xF7, 0xF0, 0x7F, 0xFF, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC3, 0xFC, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x78, 0x1F, 0x03, 0xF0, 0xFC, 0x3F, 0x87,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x8F, 0xE1, 0xF0, 0x3F, 0x87, 0xF8,
  0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xC0,
  0x78, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x0F,
  0x01, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xF0, 0xFE, 0x07, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x1F, 0x87, 0xF0, 0x7C, 0x0F, 0x00, 0x80, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x1F, 0x3F, 0xE1, 0xF7, 0xFF, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xEF, 0x87, 0xFE, 0xF8, 0x3F, 0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Black45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 32, 12, 2, -32 },
  { 33, 12, 12, 14, 1, -34 },
  { 51, 21, 32, 23, 1, -32 },
  { 135, 19, 41, 23, 2, -37 },
  { 233, 25, 32, 29, 2, -32 },
  { 333, 25, 32, 27, 1, -32 },
  { 433, 5, 13, 7, 1, -34 },
  { 442, 10, 45, 15, 3, -35 },
  { 499, 12, 45, 15, 1, -35 },
  { 567, 20, 20, 21, 1, -32 },
  { 617, 19, 23, 21, 1, -26 },
  { 672, 8, 14, 12, 1, -6 },
  { 686, 11, 6, 19, 4, -17 },
  { 695, 8, 7, 14, 3, -7 },
  { 702, 14, 35, 14, 0, -32 },
  { 764, 19, 32, 23, 2, -32 },
  { 840, 14, 32, 23, 3, -32 },
  { 896, 20, 32, 23, 1, -32 },
  { 976, 20, 32, 23, 1, -32 },
  { 1056, 20, 32, 23, 1, -32 },
  { 1136, 19, 32, 23, 2, -32 },
  { 1212, 20, 32, 23, 2, -32 },
  { 1292, 20, 32, 23, 1, -32 },
  { 1372, 19, 32, 23, 2, -32 },
  { 1448, 19, 32, 23, 2, -32 },
  { 1524, 8, 25, 13, 3, -25 },
  { 1549, 9, 33, 13, 2, -25 },
  { 1587, 17, 21, 20, 1, -24 },
  { 1632, 17, 16, 23, 3, -22 },
  { 1666, 17, 21, 20, 2, -24 },
  { 1711, 18, 32, 21, 1, -32 },
  { 1783, 32, 41, 35, 1, -31 },
  { 1947, 27, 32, 27, 0, -32 },
  { 2055, 22, 32, 26, 2, -32 },
  { 2143, 23, 32, 26, 2, -32 },
  { 2235, 22, 32, 25, 2, -32 },
  { 2323, 19, 32, 22, 2, -32 },
  { 2399, 18, 32, 21, 2, -32 },
  { 2471, 23, 32, 27, 2, -32 },
  { 2563, 23, 32, 27, 2, -32 },
  { 2655, 7, 32, 13, 3, -32 },
  { 2683, 19, 32, 22, 1, -32 },
  { 2759, 24, 32, 25, 2, -32 },
  { 2855, 19, 32, 22, 2, -32 },
  { 2931, 30, 32, 34, 2, -32 },
  { 3051, 23, 32, 27, 2, -32 },
  { 3143, 23, 32, 27, 2, -32 },
  { 3235, 22, 32, 26, 2, -32 },
  { 3323, 24, 38, 27, 2, -32 },
  { 3437, 22, 32, 26, 2, -32 },
  { 3525, 22, 32, 25, 1, -32 },
  { 3613, 23, 32, 25, 1, -32 },
  { 3705, 22, 32, 26, 2, -32 },
  { 3793, 26, 32, 26, 0, -32 },
  { 3897, 32, 32, 33, 1, -32 },
  { 4025, 25, 32, 25, 0, -32 },
  { 4125, 25, 32, 25, 0, -32 },
  { 4225, 22, 32, 24, 1, -32 },
  { 4313, 9, 45, 12, 2, -37 },
  { 4364, 19, 35, 17, 0, -32 },
  { 4448, 9, 45, 12, 1, -37 },
  { 4499, 16, 16, 18, 1, -32 },
  { 4531, 17, 6, 18, 0, 0 },
  { 4544, 12, 7, 15, 1, -34 },
  { 4555, 19, 24, 21, 1, -24 },
  { 4612, 19, 34, 22, 2, -34 },
  { 4693, 19, 24, 21, 1, -24 },
  { 4750, 19, 34, 22, 1, -34 },
  { 4831, 20, 24, 22, 1, -24 },
  { 4891, 14, 34, 15, 0, -34 },
  { 4951, 20, 33, 23, 1, -24 },
  { 5034, 18, 34, 22, 2, -34 },
  { 5111, 8, 34, 12, 2, -34 },
  { 5145, 12, 43, 11, -2, -34 },
  { 5210, 20, 34, 22, 2, -34 },
  { 5295, 8, 34, 12, 2, -34 },
  { 5329, 29, 24, 33, 2, -24 },
  { 5416, 18, 24, 22, 2, -24 },
  { 5470, 20, 24, 22, 1, -24 },
  { 5530, 19, 33, 22, 2, -24 },
  { 5609, 19, 33, 22, 1, -24 },
  { 5688, 13, 24, 16, 2, -24 },
  { 5727, 18, 24, 20, 1, -24 },
  { 5781, 12, 30, 14, 1, -30 },
  { 5826, 19, 24, 22, 2, -24 },
  { 5883, 20, 24, 21, 0, -24 },
  { 5943, 26, 24, 28, 1, -24 },
  { 6021, 20, 24, 21, 0, -24 },
  { 6081, 21, 33, 21, 0, -24 },
  { 6168, 17, 24, 21, 2, -24 },
  { 6219, 11, 43, 13, 1, -35 },
  { 6279, 4, 38, 12, 4, -32 },
  { 6298, 11, 43, 13, 1, -35 },
  { 6358, 20, 10, 24, 2, -18 },
};

const GFXfont RobotoCondensed_Black45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_BLACK45PT7B_H_
