#ifndef _ROBOTOCONDENSED_BLACK58PT7B_H_
#define _ROBOTOCONDENSED_BLACK58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F,
  0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3E,
  0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE3,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xC3, 0xFF, 0x3F,
  0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFE, 0xFF,
  0x83, 0xFF, 0x7F, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x02,
  0x00, 0xFC, 0x7E, 0x07, 0x80, 0xFC, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x0F,
  0x80, 0xFC, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x3F,
  0x00, 0xFC, 0x7E, 0x3E, 0x00, 0xFC, 0x7E, 0x7E, 0x00, 0xFF, 0xFE, 0x7C,
  0x00, 0x7F, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0xF8, 0x00, 0x3F, 0xF9, 0xF8,
  0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0x3F, 0x7F,
  0xFC, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x7C, 0xFC,
  0x7E, 0x00, 0xFC, 0xFC, 0x3F, 0x00, 0xF8, 0xFC, 0x3F, 0x01, 0xF8, 0xFC,
  0x3F, 0x01, 0xF0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC,
  0x3F, 0x07, 0xE0, 0xFC, 0x7E, 0x01, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07,
  0xFC, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0xCF, 0xF3, 0xFE, 0xFF,
  0xDF, 0xE7, 0xFD, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF,
  0xFE, 0x3F, 0xE1, 0xFF, 0xFC, 0x7F, 0xC3, 0xFF, 0xF0, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xDF, 0xBF, 0x7E, 0x00, 0x08, 0x00, 0xE0, 0x07, 0x80,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x20,
  0x40, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0,
  0x3E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x06, 0x03, 0xF0, 0x01, 0xE0, 0xF8, 0x1C, 0x7E, 0x1E, 0x1F, 0xBF,
  0xF7, 0x9F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x0F, 0xC0, 0x0C, 0x01, 0xC0,
  0x01, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3,
  0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0x3E, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x07, 0xF9,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFE, 0x3F, 0x80, 0x80, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x3F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F,
  0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFE,
  0xFF, 0x81, 0xFF, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFF, 0x7F, 0xE0,
  0xFF, 0xBF, 0xF0, 0x7F, 0xDF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0xF1, 0xFF, 0x9F,
  0xF8, 0x3F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xF8, 0x3F, 0xF7, 0xFF, 0x1F, 0xFD,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0x7F, 0xE0, 0x1F, 0xDF, 0xF8, 0x07, 0xF7, 0xFE, 0x03, 0xF9, 0xFF,
  0x80, 0xFE, 0x7F, 0xE0, 0x7F, 0x9F, 0xF8, 0x1F, 0xC7, 0xFE, 0x0F, 0xF1,
  0xFF, 0x83, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F, 0x87, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F,
  0xF8, 0x04, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x3F,
  0xF1, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x7E, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFC, 0x1F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x7F,
  0xC0, 0x7F, 0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xFD, 0xFF, 0x03, 0xFF,
  0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC7, 0xFE, 0xFF, 0xC3, 0xFE,
  0xFF, 0xC3, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0xC3, 0xFE,
  0xFF, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC7, 0xFE, 0x3F, 0xE7, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xC7, 0xFE,
  0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0x3F, 0xF0, 0xFF, 0x9F, 0xF0,
  0x7F, 0xCF, 0xF8, 0x3F, 0xF7, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF,
  0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFE, 0x1F, 0xFB, 0xFF, 0x8F, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x1F, 0x9F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x07, 0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFB, 0xFE, 0x3F, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x3F, 0xCF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xF1, 0xFC, 0x04,
  0x00, 0x0F, 0x83, 0xFC, 0x3F, 0xE7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xE3,
  0xFE, 0x1F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07,
  0xF0, 0xFE, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xE7, 0xFE, 0xFF, 0xC3, 0xFE,
  0xFF, 0xC3, 0xFE, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0xE0,
  0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x3E, 0x3F, 0x01, 0xFF, 0xFC, 0x3E, 0x3F,
  0x03, 0xFF, 0xFC, 0x3F, 0x7E, 0x07, 0xFD, 0xFC, 0x3F, 0x7E, 0x07, 0xF1,
  0xF8, 0x1F, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xFC,
  0x3F, 0x81, 0xF8, 0x3F, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0xFC, 0x3F, 0x83,
  0xF8, 0x3E, 0xFC, 0x3F, 0x83, 0xF8, 0x3E, 0xFC, 0x3F, 0x83, 0xF0, 0x7E,
  0xFC, 0x3F, 0xC7, 0xF0, 0x7E, 0xFC, 0x1F, 0xC7, 0xF8, 0xFC, 0xFC, 0x1F,
  0xFF, 0xFD, 0xFC, 0x7E, 0x0F, 0xFF, 0xFF, 0xF8, 0x7E, 0x0F, 0xFE, 0xFF,
  0xF0, 0x7E, 0x07, 0xFC, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0x00, 0x40, 0x0C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x03, 0xFF,
  0xC3, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xEF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0x7F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x07, 0xFC,
  0xFF, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x03,
  0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0xFF, 0x81, 0xFF, 0xDF, 0xF0, 0x1F, 0xFB, 0xFE, 0x03, 0xFF, 0x7F,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFC, 0x07, 0xFE, 0xFF, 0x81,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFC, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7, 0xFE,
  0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xE3, 0xFF, 0x3F, 0xF1, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xF8, 0x07,
  0xFF, 0x3F, 0xE0, 0x3F, 0xFC, 0xFF, 0x80, 0xFF, 0xE3, 0xFE, 0x07, 0xFF,
  0x8F, 0xF8, 0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0x83,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF,
  0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xEF,
  0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFF, 0x80, 0xFF,
  0xE7, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0,
  0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0x0F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xE0, 0x3F, 0xF8, 0xFF, 0x80, 0xFF, 0xF3, 0xFE, 0x01, 0xFF,
  0xCF, 0xF8, 0x07, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFB, 0xF8, 0x7F, 0x7F, 0xFF, 0xEF, 0xE1, 0xFD, 0xFF, 0xFF, 0xBF, 0x87,
  0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0x9F, 0xFF, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF,
  0xE7, 0xF3, 0xF9, 0xFF, 0xFF, 0x9F, 0xCF, 0xE7, 0xFF, 0xFE, 0x3F, 0x3F,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFC, 0x0F,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xBF, 0x0F, 0xFF, 0xFD, 0xFC, 0x7F, 0xFF, 0xE7, 0xE3, 0xFF, 0xFF, 0x3F,
  0x1F, 0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0xC7, 0xE7, 0xFF, 0xFE, 0x3F, 0xBF,
  0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x87, 0xEF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF,
  0xBF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xF8,
  0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF,
  0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF3,
  0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x05, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC0, 0xFF, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF9, 0xFF,
  0x80, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00,
  0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF,
  0x3F, 0xF0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF3, 0xFF, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x7F,
  0xE0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x03, 0xFF, 0x7F,
  0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F,
  0xEF, 0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xDF, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F,
  0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xF7,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF3, 0xFE, 0x0F, 0xFE, 0x0F, 0xF9, 0xFF, 0x07,
  0xFF, 0x07, 0xFC, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x1F, 0xF0, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0xF0, 0xFF, 0x87,
  0xFC, 0x7F, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xFE, 0x3F, 0xE1, 0xFF, 0x9F,
  0xFF, 0x1F, 0xF0, 0xFF, 0xCF, 0xFF, 0x9F, 0xF8, 0x3F, 0xE7, 0xFF, 0xCF,
  0xF8, 0x1F, 0xF7, 0xFF, 0xF7, 0xFC, 0x0F, 0xFB, 0xFF, 0xFB, 0xFE, 0x07,
  0xFD, 0xFF, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xDF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x07,
  0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07,
  0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE,
  0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9,
  0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E,
  0xFC, 0x03, 0xF7, 0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0,
  0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC0,
  0xFC, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F,
  0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x9F, 0xFC, 0xFF, 0xCF, 0xFC, 0x7F, 0xE7, 0xFC, 0x3F,
  0xF3, 0xFE, 0x1F, 0xFB, 0xFF, 0x0F, 0xFD, 0xFF, 0x87, 0xFE, 0xFF, 0xC3,
  0xFF, 0x3F, 0xF7, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xEF, 0xF8, 0x7F, 0xF7, 0xFC, 0x0F, 0xF3, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xF8, 0xFF, 0x7F, 0xF0,
  0xFF, 0x1F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE7,
  0xFC, 0x3F, 0xFB, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0xFB, 0xFE,
  0x07, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF,
  0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFE, 0x1F,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xE0, 0x7F,
  0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x30, 0x7F, 0xE0, 0x38, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x7F, 0xC3, 0xFF,
  0xBF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFB, 0xFE, 0x07, 0xF9, 0xFF, 0x00, 0x60, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x80, 0x3F, 0xE0, 0xF0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xCF, 0xF0, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0x0F,
  0xF9, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0x9F, 0xF1, 0xFC, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x00, 0x01, 0xF8,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x01,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x83, 0xFF, 0x5F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0xFF, 0xEF, 0xF8, 0x7F, 0xF3, 0xFE, 0x1F, 0xFC, 0xFF, 0x8F,
  0xFE, 0x3F, 0xE3, 0xFF, 0x0F, 0xF9, 0xFF, 0xC3, 0xFE, 0x7F, 0xE0, 0xFF,
  0xBF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xF9, 0xFF, 0x83,
  0xFE, 0x3F, 0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0xF8, 0x7F,
  0xE3, 0xFE, 0x1F, 0xFC, 0xFF, 0x83, 0xFF, 0x3F, 0xE0, 0xFF, 0xEF, 0xF8,
  0x1F, 0xFB, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x07,
  0xF8, 0x7F, 0x03, 0xFC, 0x3F, 0xCF, 0xFC, 0x3F, 0xF1, 0xFF, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x83, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF,
  0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0x83,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x00,
  0x00, 0x80, 0xFF, 0x8F, 0xF0, 0xFF, 0x9F, 0xFC, 0xFF, 0xBF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0x00,
  0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x7F, 0xE3, 0xFF, 0x7F, 0xE0, 0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFE, 0x7F, 0xE3, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0xFF, 0x7F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F, 0xE0, 0xFF, 0x82, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x3F, 0xC3, 0xFF, 0x9F, 0xE3, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF,
  0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F, 0xFB,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC, 0x0F,
  0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xE1,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFB, 0xFE, 0x07, 0xF9, 0xFF, 0x00,
  0x20, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F, 0xC3, 0xFF, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x30, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0x7F,
  0xE3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0x1F, 0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x00,
  0x80, 0x00, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD,
  0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF,
  0x1F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF,
  0x7F, 0x87, 0xF8, 0x7F, 0xDF, 0xE1, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0xC7,
  0xF9, 0xFF, 0x3F, 0xF1, 0xFE, 0x7F, 0xCF, 0xFC, 0xFF, 0x8F, 0xF3, 0xFF,
  0x3F, 0xE3, 0xFC, 0xFF, 0xEF, 0xF0, 0xFF, 0x7F, 0xFB, 0xFC, 0x3F, 0xDF,
  0xFE, 0xFF, 0x0F, 0xF7, 0xFF, 0xBF, 0xC1, 0xFD, 0xFF, 0xEF, 0xF0, 0x7F,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x81,
  0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0x3F, 0xFE,
  0x03, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0,
  0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF,
  0x3F, 0xF0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xF7,
  0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xFC,
  0x1F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xCF,
  0xF8, 0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x8F, 0xF8, 0x1F,
  0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF,
  0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x18, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xE0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x60, 0x01, 0xE0, 0x07,
  0xC0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFC, 0x07, 0xF3, 0xFF, 0x81, 0xFC, 0xFF, 0xF0, 0x7F, 0x7F, 0xFE,
  0x3F, 0xDF, 0xFF, 0xDF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFF, 0xFE, 0xFE,
  0x3F, 0xFF, 0x3F, 0x07, 0xFF, 0xCF, 0xC0, 0xFF, 0xE3, 0xF0, 0x1F, 0xF0,
  0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Black58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 42, 15, 3, -41 },
  { 54, 16, 16, 18, 1, -44 },
  { 86, 27, 41, 30, 1, -41 },
  { 225, 25, 55, 30, 2, -48 },
  { 397, 32, 43, 37, 3, -42 },
  { 569, 31, 43, 35, 2, -42 },
  { 736, 7, 16, 9, 1, -44 },
  { 750, 14, 58, 19, 3, -45 },
  { 852, 14, 58, 19, 2, -45 },
  { 954, 26, 25, 27, 1, -41 },
  { 1036, 23, 30, 27, 2, -34 },
  { 1123, 11, 18, 16, 1, -7 },
  { 1148, 14, 7, 24, 5, -21 },
  { 1161, 11, 10, 18, 3, -9 },
  { 1175, 17, 45, 18, 0, -41 },
  { 1271, 25, 43, 30, 2, -42 },
  { 1406, 17, 41, 30, 4, -41 },
  { 1494, 25, 42, 30, 2, -42 },
  { 1626, 26, 43, 30, 1, -42 },
  { 1766, 26, 41, 30, 2, -41 },
  { 1900, 25, 42, 30, 2, -41 },
  { 2032, 26, 42, 30, 2, -41 },
  { 2169, 25, 41, 30, 2, -41 },
  { 2298, 24, 43, 30, 3, -42 },
  { 2427, 25, 42, 30, 2, -42 },
  { 2559, 11, 33, 17, 3, -32 },
  { 2605, 12, 43, 16, 2, -32 },
  { 2670, 22, 28, 26, 1, -31 },
  { 2747, 22, 19, 30, 4, -27 },
  { 2800, 21, 28, 26, 3, -31 },
  { 2874, 24, 43, 27, 1, -42 },
  { 3003, 40, 53, 44, 2, -40 },
  { 3268, 35, 41, 35, 0, -41 },
  { 3448, 28, 41, 33, 3, -41 },
  { 3592, 30, 43, 33, 2, -42 },
  { 3754, 27, 41, 33, 3, -41 },
  { 3893, 24, 41, 28, 3, -41 },
  { 4016, 23, 41, 28, 3, -41 },
  { 4134, 30, 43, 34, 2, -42 },
  { 4296, 30, 41, 35, 3, -41 },
  { 4450, 10, 41, 16, 3, -41 },
  { 4502, 25, 42, 29, 1, -41 },
  { 4634, 30, 41, 32, 3, -41 },
  { 4788, 23, 41, 28, 3, -41 },
  { 4906, 38, 41, 44, 3, -41 },
  { 5101, 29, 41, 35, 3, -41 },
  { 5250, 31, 43, 35, 2, -42 },
  { 5417, 28, 41, 33, 3, -41 },
  { 5561, 31, 50, 35, 2, -42 },
  { 5755, 29, 41, 33, 3, -41 },
  { 5904, 28, 43, 32, 2, -42 },
  { 6055, 30, 41, 32, 1, -41 },
  { 6209, 28, 42, 34, 3, -41 },
  { 6356, 34, 41, 34, 0, -41 },
  { 6531, 41, 41, 43, 1, -41 },
  { 6742, 32, 41, 33, 0, -41 },
  { 6906, 32, 41, 32, 0, -41 },
  { 7070, 27, 41, 31, 2, -41 },
  { 7209, 11, 58, 16, 3, -48 },
  { 7289, 24, 45, 22, 0, -41 },
  { 7424, 12, 58, 16, 1, -48 },
  { 7511, 21, 21, 23, 1, -41 },
  { 7567, 21, 7, 23, 1, 0 },
  { 7586, 15, 9, 20, 2, -44 },
  { 7603, 25, 33, 27, 1, -32 },
  { 7707, 24, 45, 29, 3, -44 },
  { 7842, 23, 33, 27, 2, -32 },
  { 7937, 25, 45, 29, 1, -44 },
  { 8078, 25, 33, 28, 2, -32 },
  { 8182, 18, 45, 19, 1, -45 },
  { 8284, 25, 44, 29, 2, -32 },
  { 8422, 24, 44, 29, 2, -44 },
  { 8554, 11, 43, 15, 2, -43 },
  { 8614, 15, 55, 15, -2, -43 },
  { 8718, 26, 44, 28, 3, -44 },
  { 8861, 9, 44, 15, 3, -44 },
  { 8911, 37, 32, 43, 3, -32 },
  { 9059, 24, 32, 29, 2, -32 },
  { 9155, 25, 33, 29, 2, -32 },
  { 9259, 24, 44, 29, 3, -32 },
  { 9391, 25, 44, 29, 1, -32 },
  { 9529, 16, 32, 20, 3, -32 },
  { 9593, 24, 33, 26, 1, -32 },
  { 9692, 16, 39, 18, 1, -38 },
  { 9770, 24, 32, 29, 2, -31 },
  { 9866, 26, 31, 27, 0, -31 },
  { 9967, 34, 31, 36, 1, -31 },
  { 10099, 25, 31, 27, 1, -31 },
  { 10196, 27, 43, 27, 0, -31 },
  { 10342, 22, 31, 27, 2, -31 },
  { 10428, 14, 55, 17, 1, -45 },
  { 10525, 5, 49, 15, 5, -41 },
  { 10556, 14, 55, 17, 2, -45 },
  { 10653, 26, 13, 31, 3, -23 },
};

const GFXfont RobotoCondensed_Black58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_BLACK58PT7B_H_
