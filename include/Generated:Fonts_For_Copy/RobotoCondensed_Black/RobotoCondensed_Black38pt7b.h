#ifndef _ROBOTOCONDENSED_BLACK38PT7B_H_
#define _ROBOTOCONDENSED_BLACK38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0x3F, 0x7E, 0xFD, 0xF9,
  0xE0, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0x80, 0x03, 0x9E, 0x01, 0xCF, 0x01, 0xE7, 0x00,
  0xF3, 0x80, 0x79, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0, 0x0E, 0x78, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xE7, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x39,
  0xE0, 0x1C, 0xF0, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0xDE, 0x01,
  0xCF, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0xE0, 0x1E, 0x70,
  0x0F, 0x38, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x86, 0x0F,
  0x3C, 0x78, 0x79, 0xE3, 0x83, 0xCF, 0x3C, 0x1E, 0x79, 0xC0, 0xF3, 0xDE,
  0x07, 0xFE, 0xE0, 0x3F, 0xEF, 0x00, 0xFF, 0x70, 0x03, 0xE7, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xDF, 0x00, 0x3D, 0xFC, 0x01, 0xDF, 0xF0, 0x1E, 0xF7,
  0x80, 0xEF, 0x1E, 0x0F, 0x78, 0xF0, 0x73, 0xC7, 0x87, 0x9E, 0x3C, 0x38,
  0xF1, 0xE1, 0xC3, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x3E, 0x01,
  0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF1,
  0xF0, 0xFF, 0xCF, 0x8F, 0xFE, 0x7C, 0x7F, 0xFB, 0xE7, 0xEF, 0xFF, 0x3F,
  0x3F, 0xF9, 0xF8, 0xFF, 0x8F, 0xC7, 0xFC, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xF8, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x01, 0xC1, 0xE1, 0xF0, 0xF0, 0xF8,
  0x78, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x38, 0x08,
  0x40, 0x18, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x07,
  0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xC0, 0x60, 0x10, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x1E,
  0x38, 0xE7, 0xEF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0xE0, 0x0F, 0x3C, 0x07, 0xCF, 0x83, 0xE1, 0xE0, 0x30, 0x70,
  0x04, 0x08, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x3E,
  0x7D, 0xF3, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D,
  0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0x07, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7E, 0xFC, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7E, 0xFE, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xF0, 0x07, 0xC0, 0x00, 0x60, 0x3C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xFB, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xBF, 0x03, 0xDF,
  0x83, 0xEF, 0xC1, 0xE7, 0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0xF8, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x78, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF3, 0xF3, 0xF8, 0x10, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xF3, 0xF1, 0xF9, 0xFF, 0xFC,
  0x7F, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0xFE,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0x7E, 0x7E, 0x7F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFE, 0x7E, 0xFC,
  0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x0F, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1E,
  0x00, 0x7C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFB, 0xF3, 0xC0, 0x3E, 0x7F, 0x7F, 0x7F,
  0x7F, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x30,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xE0, 0x3E,
  0x00, 0xE0, 0x02, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF,
  0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x01,
  0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x3C,
  0x0F, 0x83, 0xC7, 0x83, 0xFC, 0x79, 0xE0, 0xFF, 0xC7, 0x3C, 0x3F, 0xF8,
  0xE7, 0x8F, 0x8F, 0x1E, 0xF1, 0xE3, 0xE3, 0xFC, 0x3C, 0x78, 0x7F, 0x8F,
  0x8F, 0x0F, 0xF1, 0xF1, 0xE1, 0xFE, 0x3E, 0x3C, 0x3F, 0xC7, 0x87, 0x87,
  0x78, 0xF0, 0xF0, 0xEF, 0x1F, 0x1E, 0x3D, 0xE3, 0xE7, 0xC7, 0xBC, 0x7F,
  0xF9, 0xE3, 0xC7, 0xFF, 0xF8, 0x78, 0x7E, 0xFF, 0x0F, 0x07, 0x8F, 0x80,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x40, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE,
  0x7F, 0x01, 0xFC, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF8, 0xFF, 0xF0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xF1, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xBF,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF0,
  0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F,
  0x7F, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7E, 0xFC, 0x3F, 0xBF, 0x1F, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x3F, 0xBF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0xFE, 0x1F, 0xDF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFC, 0x0F, 0xEF, 0xC1, 0xFE, 0xFC, 0x1F,
  0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xCF,
  0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8,
  0xFC, 0x3F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFE, 0xFC, 0x0F,
  0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3D, 0xFF, 0xEF, 0x1E, 0xFF,
  0xF7, 0x9F, 0x7F, 0xFB, 0xEF, 0xBF, 0xFD, 0xF7, 0x9F, 0xFE, 0x7B, 0xCF,
  0xFF, 0x3F, 0xE7, 0xFF, 0x9F, 0xF3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3, 0xF8,
  0xFF, 0xF1, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F,
  0x0F, 0xFF, 0x0F, 0x87, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFE, 0xF3, 0xFF, 0xDE, 0x7F,
  0xF9, 0xEF, 0xFF, 0x3D, 0xFF, 0xE7, 0xBF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8,
  0xFE, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7F, 0x07, 0xF3, 0xF8, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC7, 0xF1, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7,
  0xF0, 0x7F, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF8, 0x3F, 0xBF, 0x07, 0xF7,
  0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x1F, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x9F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC7, 0xF1, 0xF8, 0x7F, 0x3F,
  0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x1F, 0xDF, 0x83, 0xFB, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0xFE, 0x3F, 0x9F, 0x83, 0xF3, 0xF0, 0x7F, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFB, 0xF8, 0x3F, 0x7F, 0x07, 0xE7,
  0xE0, 0xFC, 0xFE, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xF7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xFE,
  0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x1F, 0x87, 0xF0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F,
  0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xFF, 0x87, 0xE1, 0xFB, 0xF0, 0xFC, 0x3F,
  0x7E, 0x1F, 0x87, 0xEF, 0xE3, 0xF8, 0xFC, 0xFC, 0xFF, 0x3F, 0x9F, 0x9F,
  0xE7, 0xF3, 0xF3, 0xFC, 0xFC, 0x7E, 0x7F, 0x9F, 0x8F, 0xCF, 0xF3, 0xF1,
  0xF9, 0xFF, 0x7E, 0x1F, 0xFF, 0xEF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F,
  0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x03,
  0xFB, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F,
  0xE7, 0xE0, 0x7F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF0,
  0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0xFE, 0x03, 0xFB,
  0xF0, 0x1F, 0x9F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC7,
  0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0xF7, 0x83, 0xDE, 0x0F, 0x7C, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0xBE, 0x1E,
  0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0xFE, 0xFE, 0x7E, 0xFC, 0x7E, 0x00, 0x7E,
  0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E,
  0xFC, 0x7E, 0xFE, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0x3F,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xFC, 0xF9, 0xF0, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0x0F, 0xFE,
  0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC3, 0xFF, 0x87,
  0xFF, 0x9F, 0xBF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0xBF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0x9F, 0x07, 0xF0,
  0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x7E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x0C, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE,
  0x07, 0xF8, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x0F, 0x9F,
  0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xF7, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x40, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xBF, 0x9F, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0xBF, 0x3F, 0xDF, 0x9F, 0xCF,
  0xDF, 0xC7, 0xEF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xF7, 0xF1, 0xF9,
  0xF8, 0xFC, 0xFE, 0x7E, 0x7F, 0x3F, 0x1F, 0xDF, 0x8F, 0xEF, 0xC3, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xF0,
  0x78, 0xFF, 0xFD, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x78,
  0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xF9, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFD,
  0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x3F, 0xDF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xBF, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xEF, 0xE7, 0xFF,
  0x8F, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0x7F, 0xFE, 0xFF, 0xF8,
  0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC7, 0xF8,
  0x7F, 0x07, 0xE0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF8, 0xF1, 0xF0, 0xFE, 0x1F, 0xBF, 0x1F, 0xDF, 0x8F, 0xCF,
  0xC7, 0xE7, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0xFC, 0x1F, 0x7E,
  0x0F, 0xBF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xF8, 0x78, 0xFF, 0xF3, 0xE3, 0xFF, 0xCF, 0x8F, 0xFF, 0x3F, 0x3F, 0xFC,
  0xFC, 0xF9, 0xF3, 0xF3, 0xE7, 0xDF, 0xCF, 0x9F, 0x7F, 0xFE, 0x7D, 0xFF,
  0xF9, 0xF7, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF7, 0xFC, 0x3F, 0xCF, 0xF0,
  0xFF, 0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x7E, 0x1F, 0xBF, 0x1F, 0x8F,
  0xCF, 0xC7, 0xEF, 0xE1, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x7E, 0xFC, 0x3F, 0x3F, 0x3F, 0x9F, 0x9F, 0x8F, 0xEF,
  0xC3, 0xF0, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0x8F, 0xEF, 0xC7, 0xE7, 0xF3,
  0xF1, 0xF9, 0xF8, 0xFD, 0xFC, 0x7E, 0xFC, 0x1F, 0x7E, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x03, 0x83, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x7E,
  0x3E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x0F, 0xC3, 0xE0, 0xE0, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x60, 0x38, 0x3E, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE1,
  0xF1, 0xF9, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x0E, 0x04, 0x00, 0x1E, 0x00, 0x1F, 0x83,
  0xDF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xCF, 0xFB, 0xC7, 0xFD, 0xE1,
  0xFC, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_Black38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 27, 10, 2, -27 },
  { 25, 11, 11, 12, 0, -29 },
  { 41, 17, 27, 20, 1, -27 },
  { 99, 16, 35, 19, 2, -31 },
  { 169, 21, 27, 24, 2, -27 },
  { 240, 21, 27, 23, 1, -27 },
  { 311, 4, 11, 6, 1, -29 },
  { 317, 9, 38, 12, 2, -30 },
  { 360, 10, 38, 12, 1, -30 },
  { 408, 18, 17, 18, 0, -27 },
  { 447, 16, 19, 18, 1, -22 },
  { 485, 7, 12, 10, 1, -5 },
  { 496, 10, 5, 16, 3, -14 },
  { 503, 7, 6, 12, 2, -6 },
  { 509, 11, 29, 12, 0, -27 },
  { 549, 16, 27, 19, 2, -27 },
  { 603, 11, 27, 19, 3, -27 },
  { 641, 17, 27, 19, 1, -27 },
  { 699, 17, 27, 19, 1, -27 },
  { 757, 17, 27, 19, 1, -27 },
  { 815, 17, 27, 19, 1, -27 },
  { 873, 16, 27, 19, 2, -27 },
  { 927, 17, 27, 19, 1, -27 },
  { 985, 16, 27, 19, 2, -27 },
  { 1039, 16, 27, 19, 2, -27 },
  { 1093, 7, 21, 11, 2, -21 },
  { 1112, 8, 28, 11, 1, -21 },
  { 1140, 14, 18, 17, 1, -20 },
  { 1172, 15, 13, 20, 2, -18 },
  { 1197, 14, 18, 17, 2, -20 },
  { 1229, 15, 27, 17, 1, -27 },
  { 1280, 27, 34, 29, 1, -26 },
  { 1395, 23, 27, 23, 0, -27 },
  { 1473, 18, 27, 22, 2, -27 },
  { 1534, 20, 27, 22, 1, -27 },
  { 1602, 18, 27, 21, 2, -27 },
  { 1663, 16, 27, 19, 2, -27 },
  { 1717, 15, 27, 18, 2, -27 },
  { 1768, 19, 27, 22, 2, -27 },
  { 1833, 19, 27, 23, 2, -27 },
  { 1898, 6, 27, 11, 2, -27 },
  { 1919, 16, 27, 19, 1, -27 },
  { 1973, 20, 27, 21, 2, -27 },
  { 2041, 15, 27, 18, 2, -27 },
  { 2092, 25, 27, 29, 2, -27 },
  { 2177, 19, 27, 23, 2, -27 },
  { 2242, 20, 27, 23, 1, -27 },
  { 2310, 18, 27, 22, 2, -27 },
  { 2371, 21, 32, 23, 1, -27 },
  { 2455, 19, 27, 22, 2, -27 },
  { 2520, 19, 27, 21, 1, -27 },
  { 2585, 19, 27, 21, 1, -27 },
  { 2650, 18, 27, 22, 2, -27 },
  { 2711, 22, 27, 22, 0, -27 },
  { 2786, 27, 27, 28, 1, -27 },
  { 2878, 21, 27, 21, 0, -27 },
  { 2949, 21, 27, 21, 0, -27 },
  { 3020, 18, 27, 20, 1, -27 },
  { 3081, 7, 38, 10, 2, -32 },
  { 3115, 16, 29, 15, 0, -27 },
  { 3173, 7, 38, 10, 1, -32 },
  { 3207, 14, 13, 15, 1, -27 },
  { 3230, 15, 5, 15, 0, 0 },
  { 3240, 10, 6, 13, 1, -29 },
  { 3248, 16, 20, 18, 1, -20 },
  { 3288, 16, 29, 19, 2, -29 },
  { 3346, 15, 20, 17, 1, -20 },
  { 3384, 16, 29, 19, 1, -29 },
  { 3442, 16, 20, 18, 1, -20 },
  { 3482, 12, 29, 13, 0, -29 },
  { 3526, 17, 28, 19, 1, -20 },
  { 3586, 16, 29, 19, 1, -29 },
  { 3644, 6, 28, 10, 2, -28 },
  { 3665, 9, 36, 10, -1, -28 },
  { 3706, 17, 29, 19, 2, -29 },
  { 3768, 6, 29, 10, 2, -29 },
  { 3790, 24, 20, 28, 2, -20 },
  { 3850, 16, 20, 19, 1, -20 },
  { 3890, 17, 20, 19, 1, -20 },
  { 3933, 16, 28, 19, 2, -20 },
  { 3989, 16, 28, 19, 1, -20 },
  { 4045, 10, 20, 13, 2, -20 },
  { 4070, 15, 20, 17, 1, -20 },
  { 4108, 11, 25, 12, 0, -25 },
  { 4143, 15, 20, 19, 2, -20 },
  { 4181, 17, 20, 17, 0, -20 },
  { 4224, 22, 20, 24, 1, -20 },
  { 4279, 17, 20, 17, 0, -20 },
  { 4322, 17, 28, 18, 0, -20 },
  { 4382, 15, 20, 17, 1, -20 },
  { 4420, 9, 37, 11, 1, -30 },
  { 4462, 4, 32, 10, 3, -27 },
  { 4478, 9, 37, 11, 1, -30 },
  { 4520, 17, 9, 21, 2, -16 },
};

const GFXfont RobotoCondensed_Black38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_BLACK38PT7B_H_
