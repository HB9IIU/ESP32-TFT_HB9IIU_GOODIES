#ifndef _ROBOTOCONDENSED_BLACK37PT7B_H_
#define _ROBOTOCONDENSED_BLACK37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7,
  0xDF, 0x7C, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0xF9, 0xFF, 0x3F,
  0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0xF1, 0xDE, 0x38, 0x07,
  0x9C, 0x03, 0xCE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x39, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xCF,
  0x00, 0xE7, 0x80, 0x73, 0x80, 0x39, 0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0x87, 0x3C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3, 0x80,
  0x79, 0xC0, 0x3D, 0xE0, 0x1C, 0xF0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xE1,
  0xFF, 0x80, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3E,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x7C, 0x60, 0xF3, 0xC7, 0x0E,
  0x3C, 0xF0, 0xE3, 0xCE, 0x0F, 0x3D, 0xE0, 0xF7, 0xDC, 0x0F, 0xFB, 0xC0,
  0x7F, 0xB8, 0x03, 0xE7, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE7,
  0x80, 0x1D, 0xFE, 0x03, 0xDF, 0xF0, 0x3B, 0xEF, 0x07, 0xBC, 0xF0, 0x73,
  0xCF, 0x0F, 0x3C, 0xF0, 0xE3, 0xCF, 0x1C, 0x3E, 0xF0, 0x41, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0,
  0x3F, 0x7C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE3,
  0xE1, 0xFE, 0x3E, 0x3F, 0xF3, 0xE7, 0xFF, 0xFE, 0xFD, 0xFF, 0xCF, 0xDF,
  0xFC, 0xFC, 0xFF, 0xCF, 0xC7, 0xF8, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x01, 0x81, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C,
  0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x60, 0x10, 0x40, 0x30, 0x3C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x3C, 0x0C,
  0x04, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x06, 0x1E,
  0x13, 0xEE, 0x39, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xEF, 0x01, 0xF3, 0xC0, 0xF1, 0xF0, 0x70, 0x70, 0x08, 0x10,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x79, 0xF3, 0xC1, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7D, 0xFB, 0xFF, 0xF7, 0xC7, 0x00, 0x01,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xDF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xEF, 0xFF, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F,
  0xF0, 0x0F, 0x80, 0x00, 0x60, 0x7C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F,
  0xFF, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0x7E, 0x07, 0xBF, 0x07, 0xDF, 0x83, 0xCF,
  0xC3, 0xE7, 0xE1, 0xF3, 0xF1, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E,
  0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFE, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0xFD, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE,
  0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE3, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xDF, 0x8F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x07,
  0xFF, 0x1F, 0xFF, 0x7E, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xDF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0x1E, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C,
  0x00, 0x7C, 0xFF, 0xFF, 0xF7, 0xC7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x3F, 0xFF, 0xFD, 0xF9, 0xC0, 0x3C, 0x7E, 0x7F, 0x7F, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x30, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0,
  0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0xFF, 0xCF, 0xFE, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xE0,
  0x02, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF,
  0xDF, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x3C, 0x0F, 0x83, 0x8E, 0x0F, 0xF8,
  0xE7, 0x87, 0xFE, 0x3D, 0xE1, 0xF7, 0x8F, 0x78, 0xF1, 0xE3, 0xDC, 0x3C,
  0x78, 0xFF, 0x1F, 0x1E, 0x3F, 0xC7, 0x87, 0x8F, 0xF1, 0xE1, 0xE3, 0xFC,
  0x78, 0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x8F, 0x0E, 0xF1, 0xE3, 0xC7,
  0xBC, 0x7F, 0xF9, 0xC7, 0x0F, 0xFF, 0xF1, 0xE3, 0xFB, 0xF8, 0x78, 0x78,
  0x7C, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFD, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01,
  0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xDF, 0xFF, 0xEF, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFE, 0x1F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7,
  0xF0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xE3, 0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xFF,
  0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF,
  0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F, 0x80, 0xFC, 0x1F,
  0xFF, 0x83, 0xFB, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF, 0xC7, 0xF1, 0xF8, 0xFE,
  0x3F, 0x3F, 0x87, 0xE7, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xDF, 0xC3, 0xF3, 0xF8, 0x7E, 0x3F, 0x8F, 0xC7, 0xF1,
  0xF8, 0x7F, 0x3F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFC, 0x1F, 0xDF, 0x83, 0xFC,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFD, 0xE7, 0xBF, 0xFD, 0xE7, 0xBF, 0xFD, 0xE7,
  0xBF, 0xFD, 0xFF, 0xBF, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0xFF,
  0x3F, 0xFC, 0xFF, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E,
  0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x3C, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFE, 0xF3, 0xFF,
  0xDE, 0x7F, 0xFB, 0xCF, 0xFF, 0x3D, 0xFF, 0xE7, 0xBF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFC, 0x01, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE,
  0x7E, 0x07, 0xE7, 0xE0, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7F,
  0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7F, 0x7E, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07,
  0xF7, 0xF0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0,
  0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x3F, 0x8F,
  0xCF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F, 0x3F, 0x0F, 0xCF, 0xC3, 0xFB, 0xF0,
  0xFE, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F,
  0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7E, 0xFE, 0x1F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3E, 0x00, 0xFB, 0xF0,
  0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x3E, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF1,
  0xFB, 0xF1, 0xFC, 0x7E, 0xFC, 0x7F, 0x1F, 0x9F, 0x9F, 0xC7, 0xE7, 0xE7,
  0xF1, 0xF9, 0xF9, 0xFE, 0x7E, 0x7E, 0x7F, 0xBF, 0x1F, 0xBF, 0xEF, 0xC7,
  0xEF, 0xFB, 0xF0, 0xFB, 0xFE, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x07, 0xFD,
  0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFC, 0x07,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x8F, 0xC3, 0xF8,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0x7F, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x81, 0xF8, 0xFC, 0x1F,
  0xC7, 0xE0, 0xFE, 0x3F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xF7, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x0F, 0x9F, 0x80,
  0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x79, 0xF3, 0xC7, 0x9E, 0x3D, 0xF1, 0xFF,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7E, 0xFE, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x0F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xFE, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC,
  0x7E, 0xFC, 0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x7F, 0x7E, 0x1F, 0x7E, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFD, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB,
  0xEF, 0xE7, 0xCF, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x8F, 0xFF, 0x1F, 0xBF, 0xFF, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0x3F,
  0x3F, 0xBF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xBF,
  0x0F, 0x3F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x0C, 0x7F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x0F, 0xBF, 0x00, 0x3F, 0x00, 0x3F, 0x10, 0x3F, 0x1F, 0xFF,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0xF8, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7F,
  0xFF, 0xFF, 0x7F, 0xBF, 0x9F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x7F,
  0xFC, 0xFE, 0xFC, 0xFC, 0xFD, 0xFC, 0xFD, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xFD, 0xF8, 0xFD, 0xFC, 0xFC, 0xFC, 0xFC, 0xFE, 0xFC, 0x7E, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0xF8, 0xFB, 0xF9, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFC, 0xFE, 0x7E, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC,
  0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC,
  0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC,
  0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC, 0x7E, 0x3F, 0xFC,
  0xF8, 0xFD, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xEF, 0x8F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0x3F, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xF9, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xCF, 0xDF, 0x8F, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFE,
  0x1F, 0xFE, 0x3E, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0x7E, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0x3F,
  0xFE, 0x3F, 0xBF, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF1, 0xF3,
  0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF8, 0xF8, 0xFB, 0xE3, 0xE3,
  0xEF, 0x8F, 0x8F, 0xBF, 0x3E, 0x7E, 0xFC, 0xFD, 0xF9, 0xF7, 0xF7, 0xE7,
  0xDF, 0xDF, 0x1F, 0x7F, 0x7C, 0x7D, 0xFD, 0xF1, 0xFF, 0xFF, 0xC7, 0xFD,
  0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0x7C, 0x07,
  0xC1, 0xF0, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xEF, 0xC1, 0xF7,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0x7E, 0xFC,
  0x3F, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xF0, 0xFE, 0x3F, 0xBF,
  0x1F, 0xDF, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3F, 0x7E, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03, 0x83, 0xE3,
  0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0xFC, 0xFC, 0x7C, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xC0,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x40, 0x38, 0x3E, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xE3, 0xF3,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x1C, 0x08, 0x00, 0x1E, 0x00, 0x7F, 0x0F, 0x7F, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0xF0, 0xFE, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Black37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 11, 10, 12, 0, -28 },
  { 35, 17, 26, 19, 1, -26 },
  { 91, 15, 34, 19, 2, -30 },
  { 155, 20, 26, 24, 2, -26 },
  { 220, 20, 26, 22, 1, -26 },
  { 285, 4, 10, 6, 1, -28 },
  { 290, 9, 37, 12, 2, -29 },
  { 332, 9, 37, 12, 1, -29 },
  { 374, 17, 16, 17, 0, -26 },
  { 408, 15, 19, 17, 1, -22 },
  { 444, 7, 12, 10, 1, -5 },
  { 455, 9, 5, 16, 3, -14 },
  { 461, 7, 6, 11, 2, -6 },
  { 467, 11, 28, 11, 0, -26 },
  { 506, 15, 26, 19, 2, -26 },
  { 555, 11, 26, 19, 3, -26 },
  { 591, 16, 26, 19, 1, -26 },
  { 643, 16, 26, 19, 1, -26 },
  { 695, 17, 26, 19, 1, -26 },
  { 751, 16, 26, 19, 1, -26 },
  { 803, 17, 26, 19, 1, -26 },
  { 859, 16, 26, 19, 1, -26 },
  { 911, 15, 26, 19, 2, -26 },
  { 960, 15, 26, 19, 2, -26 },
  { 1009, 7, 20, 11, 2, -20 },
  { 1027, 8, 27, 10, 1, -20 },
  { 1054, 14, 18, 17, 1, -20 },
  { 1086, 15, 13, 19, 2, -18 },
  { 1111, 14, 18, 17, 2, -20 },
  { 1143, 15, 26, 17, 1, -26 },
  { 1192, 26, 33, 28, 1, -25 },
  { 1300, 22, 26, 22, 0, -26 },
  { 1372, 17, 26, 21, 2, -26 },
  { 1428, 19, 26, 21, 1, -26 },
  { 1490, 17, 26, 21, 2, -26 },
  { 1546, 15, 26, 18, 2, -26 },
  { 1595, 15, 26, 18, 2, -26 },
  { 1644, 18, 26, 22, 2, -26 },
  { 1703, 19, 26, 23, 2, -26 },
  { 1765, 6, 26, 10, 2, -26 },
  { 1785, 15, 26, 18, 1, -26 },
  { 1834, 19, 26, 21, 2, -26 },
  { 1896, 15, 26, 18, 2, -26 },
  { 1945, 24, 26, 28, 2, -26 },
  { 2023, 19, 26, 23, 2, -26 },
  { 2085, 20, 26, 22, 1, -26 },
  { 2150, 18, 26, 21, 2, -26 },
  { 2209, 20, 31, 22, 1, -26 },
  { 2287, 18, 26, 21, 2, -26 },
  { 2346, 18, 26, 20, 1, -26 },
  { 2405, 19, 26, 21, 1, -26 },
  { 2467, 18, 26, 21, 2, -26 },
  { 2526, 21, 26, 22, 0, -26 },
  { 2595, 26, 26, 28, 1, -26 },
  { 2680, 21, 26, 21, 0, -26 },
  { 2749, 20, 26, 20, 0, -26 },
  { 2814, 18, 26, 20, 1, -26 },
  { 2873, 7, 37, 10, 2, -31 },
  { 2906, 15, 28, 14, 0, -26 },
  { 2959, 7, 37, 10, 1, -31 },
  { 2992, 13, 13, 15, 1, -26 },
  { 3014, 14, 5, 15, 0, 0 },
  { 3023, 10, 6, 13, 1, -28 },
  { 3031, 16, 20, 17, 1, -20 },
  { 3071, 15, 28, 18, 2, -28 },
  { 3124, 15, 20, 17, 1, -20 },
  { 3162, 16, 28, 18, 1, -28 },
  { 3218, 16, 20, 18, 1, -20 },
  { 3258, 12, 28, 12, 0, -28 },
  { 3300, 16, 28, 19, 1, -20 },
  { 3356, 16, 28, 18, 1, -28 },
  { 3412, 6, 28, 10, 2, -28 },
  { 3433, 9, 36, 9, -1, -28 },
  { 3474, 16, 28, 18, 2, -28 },
  { 3530, 6, 28, 10, 2, -28 },
  { 3551, 24, 20, 27, 2, -20 },
  { 3611, 16, 20, 18, 1, -20 },
  { 3651, 16, 20, 18, 1, -20 },
  { 3691, 15, 28, 18, 2, -20 },
  { 3744, 16, 28, 18, 1, -20 },
  { 3800, 10, 20, 13, 2, -20 },
  { 3825, 15, 20, 17, 1, -20 },
  { 3863, 11, 24, 12, 0, -24 },
  { 3896, 16, 20, 18, 1, -20 },
  { 3936, 17, 20, 17, 0, -20 },
  { 3979, 22, 20, 23, 1, -20 },
  { 4034, 17, 20, 17, 0, -20 },
  { 4077, 17, 28, 17, 0, -20 },
  { 4137, 14, 20, 17, 1, -20 },
  { 4172, 9, 36, 11, 1, -29 },
  { 4213, 3, 31, 9, 3, -26 },
  { 4225, 9, 36, 11, 1, -29 },
  { 4266, 16, 8, 20, 2, -15 },
};

const GFXfont RobotoCondensed_Black37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_BLACK37PT7B_H_
