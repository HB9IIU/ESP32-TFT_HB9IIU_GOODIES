#ifndef _ROBOTOCONDENSED_BLACK14PT7B_H_
#define _ROBOTOCONDENSED_BLACK14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDD, 0xDD, 0x3C, 0x78, 0xA3, 0xF2, 0x85, 0x3F,
  0x3C, 0x78, 0xB0, 0x21, 0xCF, 0xB7, 0xC3, 0xC3, 0x86, 0xDF, 0xE7, 0x08,
  0xE1, 0x4A, 0xB5, 0x4F, 0x03, 0xCA, 0x95, 0x4A, 0x1C, 0x38, 0x7C, 0x6C,
  0x6C, 0x38, 0x7A, 0xFE, 0xEE, 0x7E, 0x7F, 0xFF, 0x2D, 0x6D, 0xB6, 0xDB,
  0x26, 0x40, 0x44, 0x62, 0x33, 0x33, 0x33, 0x26, 0x44, 0x10, 0x4F, 0xCC,
  0x69, 0x20, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C, 0x6D, 0xE0, 0xFF, 0xF0,
  0x13, 0x32, 0x26, 0x64, 0x4C, 0xC0, 0x73, 0xED, 0xB7, 0xDF, 0x7D, 0xF6,
  0xF9, 0xC0, 0x1F, 0xF3, 0x33, 0x33, 0x33, 0x38, 0xFB, 0xB0, 0x60, 0xC3,
  0x0E, 0x38, 0x7E, 0xFC, 0x38, 0xFB, 0xB0, 0x63, 0xC7, 0x83, 0x77, 0x7C,
  0x70, 0x1C, 0x38, 0xF1, 0xE6, 0xCD, 0xBF, 0xBF, 0x0C, 0x18, 0x7C, 0xF9,
  0x83, 0xC7, 0xC1, 0x83, 0xB6, 0x7C, 0x70, 0x31, 0xCE, 0x3E, 0xFB, 0x7D,
  0xF7, 0xF9, 0xC0, 0xFF, 0xF8, 0x30, 0x61, 0x83, 0x0E, 0x18, 0x30, 0xE0,
  0x73, 0xED, 0xB6, 0xFB, 0xED, 0xB7, 0xF9, 0xC0, 0x73, 0xED, 0xB7, 0xDF,
  0xF7, 0x86, 0x71, 0x80, 0xF0, 0x3C, 0x6C, 0x00, 0xDB, 0xC0, 0x0C, 0xFF,
  0xB8, 0xF8, 0xF0, 0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0x87, 0x3E, 0x3F, 0xF2,
  0x00, 0x79, 0xFE, 0xC3, 0x18, 0xC3, 0x00, 0x30, 0xC0, 0x0F, 0x0C, 0x62,
  0x0D, 0xB9, 0x4B, 0x56, 0xDD, 0xA7, 0x69, 0x5A, 0xD3, 0xE6, 0x00, 0xC0,
  0x1E, 0x00, 0x18, 0x1C, 0x3C, 0x3C, 0x36, 0x76, 0x7E, 0x7F, 0x63, 0xE3,
  0xFB, 0xFC, 0xF3, 0xFF, 0xFC, 0xF3, 0xFF, 0xE0, 0x79, 0xFB, 0x36, 0x7C,
  0x18, 0x33, 0xE6, 0xFC, 0xF0, 0xF3, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF,
  0xC0, 0xFF, 0xFC, 0x30, 0xFB, 0xEC, 0x30, 0xFF, 0xF0, 0xFF, 0xF1, 0x8F,
  0xFF, 0x18, 0xC6, 0x00, 0x79, 0xFB, 0x3E, 0x0D, 0xFB, 0xF3, 0xE7, 0xFE,
  0xF8, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C, 0xFF, 0xFF,
  0xF0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFB, 0x7D, 0xE0, 0xCF, 0xBB, 0x67,
  0xCF, 0x1F, 0x3E, 0x6E, 0xCD, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF,
  0xC0, 0xE3, 0xF1, 0xF9, 0xFE, 0xFF, 0x7F, 0xAF, 0x77, 0xBB, 0xD9, 0xEC,
  0xC0, 0xC7, 0xCF, 0x9F, 0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x9C, 0x79, 0xFB,
  0x3E, 0x7C, 0x78, 0xF3, 0xE7, 0xFC, 0xF0, 0xF9, 0xFB, 0x36, 0x6C, 0xDF,
  0xBE, 0x60, 0xC1, 0x80, 0x79, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE7, 0xFC,
  0xF8, 0x38, 0x20, 0xF9, 0xFB, 0x36, 0x6F, 0xDF, 0x36, 0x6E, 0xCD, 0x98,
  0x3C, 0xFD, 0x9B, 0x07, 0x83, 0xC1, 0xB3, 0x7E, 0x78, 0xFF, 0xFC, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xFD, 0xE0, 0xE7, 0xE7, 0x66, 0x66, 0x76, 0x3E, 0x3C, 0x3C, 0x3C, 0x18,
  0xEC, 0xFB, 0x36, 0xFD, 0xBF, 0x7F, 0x9F, 0xE7, 0xF9, 0xEE, 0x3B, 0x8C,
  0xE0, 0xE6, 0x66, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7E, 0x66, 0xE7, 0xE6,
  0x66, 0x6E, 0x3C, 0x3C, 0x38, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30,
  0xE1, 0x87, 0x0C, 0x38, 0x7F, 0xFC, 0xFF, 0x6D, 0xB6, 0xDB, 0x6F, 0xC0,
  0xC3, 0x86, 0x18, 0x70, 0xC3, 0x0E, 0x18, 0x61, 0xC0, 0xFD, 0xB6, 0xDB,
  0x6D, 0xBF, 0xC0, 0x33, 0x9E, 0xBC, 0x80, 0xFF, 0xC0, 0x63, 0x79, 0xF0,
  0xDF, 0x6F, 0xBF, 0xDF, 0xC3, 0x0C, 0x3E, 0xFB, 0x6D, 0xF7, 0xDB, 0xEF,
  0x80, 0x39, 0xFE, 0xF8, 0xE3, 0xB7, 0xCE, 0x0C, 0x30, 0xDF, 0x7F, 0xBE,
  0xFB, 0xED, 0xF7, 0xC0, 0x39, 0xF6, 0xFB, 0xFD, 0x87, 0xCF, 0x33, 0x99,
  0xEF, 0x31, 0x8C, 0x63, 0x18, 0x7D, 0xFE, 0xFB, 0xEF, 0xB7, 0xDF, 0x0D,
  0xF7, 0x80, 0xC6, 0x31, 0xFF, 0xEF, 0x7B, 0xDE, 0xF6, 0xF3, 0xFF, 0xFC,
  0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC3, 0x0C, 0x37, 0xFB, 0xCF,
  0x3C, 0xFB, 0x6D, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xF6, 0xFB, 0x7D,
  0xBE, 0xDF, 0x6F, 0xB7, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0x38, 0xFB, 0xB7,
  0x7E, 0xFD, 0x9F, 0x1C, 0xFB, 0xED, 0xB7, 0xDF, 0x6F, 0xBE, 0xC3, 0x0C,
  0x00, 0x7D, 0xFE, 0xFB, 0xEF, 0xB7, 0xDF, 0x0C, 0x30, 0xC0, 0xFF, 0xCC,
  0xCC, 0xCC, 0x79, 0xFE, 0x1C, 0x3C, 0x3F, 0xDE, 0x6F, 0xF6, 0x66, 0x67,
  0x70, 0xDE, 0xF7, 0xBD, 0xEF, 0xFF, 0xEF, 0xB6, 0xDE, 0x79, 0xE3, 0x8C,
  0xDB, 0x7D, 0x9F, 0xCF, 0xE7, 0x73, 0xB9, 0xD8, 0x6C, 0xED, 0xF7, 0x8E,
  0x39, 0xE6, 0xFB, 0xEF, 0xB7, 0xDE, 0x78, 0xE3, 0x8C, 0x31, 0xC6, 0x00,
  0x7D, 0xF1, 0x8E, 0x31, 0x87, 0xFF, 0x26, 0x66, 0x6E, 0xC6, 0x66, 0x66,
  0x20, 0xFF, 0xF0, 0x46, 0x66, 0x67, 0x36, 0x66, 0x66, 0x40, 0xEF, 0xF9,
  0x80,
};

const GFXglyph RobotoCondensed_Black14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 4, 0, -11 },
  { 6, 7, 10, 7, 0, -10 },
  { 15, 6, 12, 7, 1, -11 },
  { 24, 7, 10, 9, 1, -10 },
  { 33, 8, 10, 8, 0, -10 },
  { 43, 2, 4, 2, 0, -11 },
  { 44, 3, 14, 5, 1, -11 },
  { 50, 4, 14, 5, 0, -11 },
  { 57, 6, 6, 7, 0, -10 },
  { 62, 6, 8, 7, 0, -9 },
  { 68, 3, 4, 4, 0, -2 },
  { 70, 4, 2, 6, 1, -5 },
  { 71, 2, 2, 4, 1, -2 },
  { 72, 4, 11, 4, 0, -10 },
  { 78, 6, 10, 7, 1, -10 },
  { 86, 4, 10, 7, 1, -10 },
  { 91, 7, 10, 7, 0, -10 },
  { 100, 7, 10, 7, 0, -10 },
  { 109, 7, 10, 7, 0, -10 },
  { 118, 7, 10, 7, 0, -10 },
  { 127, 6, 10, 7, 1, -10 },
  { 135, 7, 10, 7, 0, -10 },
  { 144, 6, 10, 7, 1, -10 },
  { 152, 6, 10, 7, 1, -10 },
  { 160, 2, 7, 4, 1, -7 },
  { 162, 3, 9, 4, 0, -7 },
  { 166, 6, 7, 6, 0, -8 },
  { 172, 5, 5, 7, 1, -7 },
  { 176, 5, 7, 6, 1, -8 },
  { 181, 6, 10, 6, 0, -10 },
  { 189, 10, 13, 11, 0, -10 },
  { 206, 8, 10, 8, 0, -10 },
  { 216, 6, 10, 8, 1, -10 },
  { 224, 7, 10, 8, 1, -10 },
  { 233, 6, 10, 8, 1, -10 },
  { 241, 6, 10, 7, 1, -10 },
  { 249, 5, 10, 7, 1, -10 },
  { 256, 7, 10, 8, 1, -10 },
  { 265, 7, 10, 9, 1, -10 },
  { 274, 2, 10, 4, 1, -10 },
  { 277, 6, 10, 7, 0, -10 },
  { 285, 7, 10, 8, 1, -10 },
  { 294, 5, 10, 7, 1, -10 },
  { 301, 9, 10, 11, 1, -10 },
  { 313, 7, 10, 9, 1, -10 },
  { 322, 7, 10, 8, 1, -10 },
  { 331, 7, 10, 8, 1, -10 },
  { 340, 7, 12, 8, 1, -10 },
  { 351, 7, 10, 8, 1, -10 },
  { 360, 7, 10, 8, 0, -10 },
  { 369, 7, 10, 8, 0, -10 },
  { 378, 6, 10, 8, 1, -10 },
  { 386, 8, 10, 8, 0, -10 },
  { 396, 10, 10, 10, 0, -10 },
  { 409, 8, 10, 8, 0, -10 },
  { 419, 8, 10, 8, 0, -10 },
  { 429, 7, 10, 7, 0, -10 },
  { 438, 3, 14, 4, 1, -12 },
  { 444, 6, 11, 5, 0, -10 },
  { 453, 3, 14, 4, 0, -12 },
  { 459, 5, 5, 6, 0, -10 },
  { 463, 5, 2, 6, 0, 0 },
  { 465, 4, 2, 5, 0, -10 },
  { 466, 6, 8, 7, 0, -8 },
  { 472, 6, 11, 7, 1, -11 },
  { 481, 6, 8, 6, 0, -8 },
  { 487, 6, 11, 7, 0, -11 },
  { 496, 6, 8, 7, 0, -8 },
  { 502, 5, 11, 5, 0, -11 },
  { 509, 6, 11, 7, 0, -8 },
  { 518, 5, 11, 7, 1, -11 },
  { 525, 2, 11, 4, 1, -11 },
  { 528, 4, 14, 4, -1, -11 },
  { 535, 6, 11, 7, 1, -11 },
  { 544, 2, 11, 4, 1, -11 },
  { 547, 9, 8, 10, 1, -8 },
  { 556, 5, 8, 7, 1, -8 },
  { 561, 7, 8, 7, 0, -8 },
  { 568, 6, 11, 7, 1, -8 },
  { 577, 6, 11, 7, 0, -8 },
  { 586, 4, 8, 5, 1, -8 },
  { 590, 6, 8, 6, 0, -8 },
  { 596, 4, 9, 4, 0, -9 },
  { 601, 5, 8, 7, 1, -8 },
  { 606, 6, 8, 6, 0, -8 },
  { 612, 9, 8, 9, 0, -8 },
  { 621, 6, 8, 6, 0, -8 },
  { 627, 6, 11, 6, 0, -8 },
  { 636, 6, 8, 6, 0, -8 },
  { 642, 4, 13, 4, 0, -11 },
  { 649, 1, 12, 4, 1, -10 },
  { 651, 4, 13, 4, 0, -11 },
  { 658, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Black14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_BLACK14PT7B_H_
