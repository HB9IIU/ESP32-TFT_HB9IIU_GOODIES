#ifndef _ROBOTOCONDENSED_BLACK24PT7B_H_
#define _ROBOTOCONDENSED_BLACK24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x70, 0x07, 0xFF, 0x70, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0x80, 0x0C, 0xC1, 0xB8, 0x37, 0x06, 0xC0, 0xD8,
  0xFF, 0xDF, 0xF8, 0xCC, 0x19, 0x83, 0x73, 0xFF, 0xFF, 0xF1, 0xB0, 0x76,
  0x0E, 0xC1, 0x98, 0x37, 0x00, 0x04, 0x01, 0x01, 0xF0, 0xFE, 0x7F, 0xDE,
  0xF7, 0x3D, 0xCF, 0x78, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xFC, 0xFF, 0x3F,
  0xCF, 0x7F, 0xDF, 0xE1, 0xF0, 0x30, 0x0C, 0x00, 0x78, 0x03, 0xE0, 0x3B,
  0x99, 0xDD, 0xCE, 0xEC, 0x77, 0xE1, 0xF6, 0x0F, 0x60, 0x03, 0x00, 0x37,
  0x81, 0xFE, 0x1B, 0xB1, 0xD9, 0x8C, 0xCC, 0xE7, 0x60, 0x3F, 0x00, 0xF0,
  0x1E, 0x01, 0xF8, 0x1F, 0xE0, 0xF7, 0x07, 0x38, 0x3D, 0xC1, 0xFC, 0x07,
  0xC0, 0x3E, 0x73, 0xF7, 0xBF, 0xFD, 0xEF, 0xCF, 0x7E, 0x79, 0xF3, 0xFF,
  0x8F, 0xFE, 0x3E, 0xF0, 0xFF, 0xFC, 0x04, 0x31, 0xCE, 0x39, 0xC7, 0x1C,
  0x73, 0xCE, 0x38, 0xE3, 0x8E, 0x1C, 0x71, 0xC7, 0x0E, 0x38, 0x70, 0xC1,
  0x83, 0x0E, 0x1C, 0x70, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE,
  0x38, 0xE3, 0x9C, 0x73, 0x8C, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x3B, 0x7F,
  0xFE, 0x1E, 0x07, 0xC1, 0xDC, 0x31, 0xC2, 0x30, 0x1C, 0x0E, 0x07, 0x03,
  0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x39, 0xCE,
  0x73, 0xB9, 0xCC, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x0E, 0x1C, 0x38,
  0x61, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1,
  0xC0, 0x1E, 0x0F, 0xE7, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF7, 0xF8, 0xFE, 0x1E, 0x00, 0x06,
  0x3F, 0xFF, 0xFF, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xF3, 0xFC, 0xF0, 0x3C, 0x1E,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x1F, 0xEF, 0xFF, 0xCF, 0xF3, 0xC0, 0xF0, 0x3C, 0x7E, 0x1F, 0x07,
  0xE0, 0x3C, 0x0F, 0xF3, 0xFC, 0xFF, 0xFD, 0xFE, 0x3E, 0x00, 0x07, 0x81,
  0xE0, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF9, 0xDE, 0x77, 0xBD, 0xEF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0x7F, 0xDF, 0xF7, 0xFD,
  0xC0, 0x70, 0x3C, 0x0F, 0xF3, 0xFE, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0xF3,
  0xFC, 0xFF, 0xF9, 0xFE, 0x1E, 0x00, 0x07, 0x03, 0xE0, 0xFC, 0x3E, 0x07,
  0x81, 0xE0, 0x3D, 0xC7, 0xFC, 0xFF, 0xDE, 0x7B, 0xC7, 0x78, 0xFF, 0x1D,
  0xE7, 0x9F, 0xF1, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x00, 0x1F, 0x1F, 0xE7, 0xFB, 0xCF, 0xF3, 0xFC, 0xF7,
  0x3D, 0xFE, 0x3F, 0x1F, 0xEF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFE,
  0x1F, 0x00, 0x1E, 0x0F, 0xC7, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0x7F, 0xDF, 0xF3, 0xFC, 0x0F, 0x03, 0x83, 0xE3, 0xF0, 0xF8, 0x38, 0x00,
  0x77, 0xFE, 0xE0, 0x00, 0x00, 0x03, 0x9E, 0xF7, 0x00, 0x77, 0xFE, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0xE2, 0x00, 0x01, 0x07, 0x1F,
  0x7F, 0xFE, 0xF8, 0xF0, 0xFE, 0x7F, 0x1F, 0x07, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x3E, 0x1F, 0xC3,
  0xF8, 0x7C, 0x3E, 0x7F, 0xFE, 0x7C, 0x38, 0x10, 0x00, 0x1F, 0x0F, 0xE7,
  0xFD, 0xEF, 0xF3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0x07, 0x07, 0x01, 0xC7, 0x00, 0x73, 0x8F, 0x19, 0x8F, 0xCD, 0xCE, 0xE6,
  0xE6, 0x73, 0x67, 0x39, 0xB3, 0x9C, 0xD9, 0xCE, 0x6C, 0xE7, 0x36, 0x73,
  0x9B, 0x3B, 0xDD, 0xCF, 0xFC, 0xE3, 0xBC, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x84, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0xB8, 0x1C, 0xF0, 0xF3, 0xC3,
  0xC7, 0x0F, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0x87, 0xDE, 0x0F, 0xF8, 0x3C,
  0xFF, 0x8F, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0xFE,
  0xFF, 0x8F, 0xFE, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC,
  0xFF, 0x80, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF, 0x3E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF,
  0x3E, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xFE, 0xFF, 0xBF, 0xEF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F,
  0xF3, 0xFE, 0x1F, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF7, 0x9E, 0xF7, 0x9F, 0xF1,
  0xFC, 0x1F, 0x00, 0xF1, 0xF7, 0x8F, 0xBC, 0xF9, 0xE7, 0x8F, 0x3C, 0x7B,
  0xC3, 0xDE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xF7, 0x8F, 0x3C,
  0x79, 0xF3, 0xC7, 0x9E, 0x3E, 0xF0, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xF7,
  0x6F, 0xF7, 0xEF, 0xF7, 0xEF, 0xF3, 0xEF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3,
  0xCF, 0xF1, 0xCF, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0xCF, 0xFC, 0xFF, 0xCF,
  0xFE, 0xFF, 0x6F, 0xF7, 0xFF, 0x7F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xF3, 0xEF,
  0x0F, 0x78, 0x7B, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xEF, 0x0F, 0x3C, 0xF9, 0xFF, 0x87, 0xF8, 0x0F, 0x80, 0xFF, 0x8F, 0xFC,
  0xFF, 0xEF, 0x1E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x81, 0xFE, 0x1F, 0xF8, 0xF3, 0xEF, 0x0F, 0x78, 0x7B, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x3C, 0xF9, 0xFF, 0x87,
  0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x40, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0x1E, 0xF1, 0xFF, 0x0F, 0xF1, 0xEF, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF,
  0x8F, 0x3C, 0xF3, 0xCF, 0x3E, 0xF1, 0xEF, 0x1E, 0xF0, 0xF0, 0x1F, 0x07,
  0xF9, 0xFF, 0xFC, 0xFF, 0x1F, 0xE0, 0x1F, 0x03, 0xF8, 0x3F, 0xC1, 0xF8,
  0x0F, 0xF8, 0xFF, 0x1F, 0xF3, 0xDF, 0xF9, 0xFE, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0xF8, 0x7D, 0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0x7C, 0xF8, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0xF1, 0xE7, 0xBC, 0xF3,
  0xDE, 0x79, 0xEF, 0x3C, 0xF7, 0xBE, 0x7B, 0xDF, 0xBD, 0xEF, 0xFC, 0x77,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xEF, 0xC3, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x00, 0xF8, 0xFB, 0xC7,
  0xDF, 0x3C, 0x7B, 0xE3, 0xDE, 0x0F, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x07, 0xF0, 0x3F, 0xC3, 0xDE, 0x1E, 0x79, 0xF3, 0xCF, 0x1F, 0xF8,
  0x78, 0xF8, 0x7B, 0xC7, 0xDE, 0x3C, 0x71, 0xE3, 0xDE, 0x1E, 0xF0, 0x77,
  0x03, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7F, 0xFF, 0xF0, 0x3C, 0x07, 0x81,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xFF, 0xFF, 0x1C, 0x0F,
  0x07, 0x87, 0xC3, 0xF1, 0xB9, 0xCC, 0xE7, 0x73, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF1, 0xE3, 0x87, 0x3E, 0x1F, 0xCF, 0xFB, 0xDE, 0x07, 0x8F, 0xE7,
  0xFB, 0xDE, 0xE7, 0xB9, 0xEF, 0xFB, 0xFE, 0x7B, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3F, 0xCF, 0xFB, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xC0, 0x3E, 0x3F, 0xBF, 0xFE,
  0x7F, 0x3F, 0x83, 0xC1, 0xE0, 0xF3, 0xF9, 0xFF, 0xEF, 0xE3, 0xE0, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xCE, 0xF7, 0xFF, 0xFF, 0xF3, 0xFC, 0xFE,
  0x3F, 0x8F, 0xE3, 0xFC, 0xFF, 0x3F, 0xFF, 0x7F, 0xCE, 0xF0, 0x3E, 0x1F,
  0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x6F, 0xF9,
  0xFF, 0x1F, 0x00, 0x0F, 0x1F, 0x3F, 0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3D, 0xDF, 0xFF,
  0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF,
  0x3F, 0xC0, 0xF0, 0x3D, 0xFF, 0x7F, 0x8F, 0x80, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3D, 0xCF, 0xFB, 0xFF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xF0, 0x6F, 0xF7, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF3, 0xC7, 0x00, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xEF, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE7, 0xBD, 0xF7, 0xBC, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFF, 0x3D, 0xE7, 0x9E, 0xF3, 0xDE, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x3C, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xF7, 0x3F,
  0xEF, 0xFF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xC0, 0x3E, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0xF9, 0xFE, 0x1E, 0x00, 0xFF, 0x3F, 0xEF, 0xFF,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x3B, 0xDF, 0xFF, 0xFF, 0xCF,
  0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3, 0xFC, 0xFF, 0xFD, 0xFF, 0x3B, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0xF7, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xCF, 0x78,
  0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xDC, 0xF7, 0xFC, 0xFE, 0x1F, 0x00, 0x38,
  0x70, 0xE7, 0xFF, 0xFF, 0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xC7, 0xCF,
  0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0xFD, 0xFF, 0x3B, 0xC0, 0xF1, 0xEE, 0x79, 0xEF, 0x3D, 0xE7,
  0xBC, 0x77, 0x0E, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0xF3, 0x9E, 0xE7, 0x39, 0xCE, 0x73, 0xBE, 0xE7, 0xFF, 0xCF, 0xFF, 0x8F,
  0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE3, 0xC1, 0xC7,
  0x00, 0x79, 0xEF, 0x79, 0xEF, 0x1F, 0xC3, 0xF8, 0x3E, 0x07, 0xC0, 0xFC,
  0x3F, 0x87, 0x71, 0xEF, 0x3D, 0xEF, 0x1E, 0xF1, 0xEF, 0x3D, 0xEF, 0x3D,
  0xE7, 0xBC, 0x77, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x7C, 0x0F, 0x80,
  0xE0, 0x1C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xE1,
  0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3F, 0xFF, 0xFF, 0xF8, 0x19,
  0xCE, 0xF7, 0x39, 0xCE, 0x73, 0xBD, 0xCE, 0x39, 0xCE, 0x73, 0x9C, 0xE3,
  0x9C, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x38, 0xE7, 0x39, 0xCE,
  0x73, 0x9E, 0x73, 0xBD, 0xCE, 0x73, 0x9C, 0xEE, 0x73, 0x00, 0x38, 0xEF,
  0x9D, 0xFB, 0xF7, 0xEE, 0x7D, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_Black24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 7, 7, 8, 0, -18 },
  { 17, 11, 17, 12, 0, -17 },
  { 41, 10, 21, 12, 1, -19 },
  { 68, 13, 17, 15, 1, -17 },
  { 96, 13, 17, 14, 1, -17 },
  { 124, 2, 7, 4, 1, -18 },
  { 126, 6, 24, 8, 1, -19 },
  { 144, 6, 24, 8, 1, -19 },
  { 162, 11, 10, 11, 0, -17 },
  { 176, 9, 12, 11, 1, -13 },
  { 190, 5, 8, 6, 0, -3 },
  { 195, 6, 3, 10, 2, -9 },
  { 198, 5, 4, 7, 1, -4 },
  { 201, 7, 18, 7, 0, -17 },
  { 217, 10, 17, 12, 1, -17 },
  { 239, 7, 17, 12, 2, -17 },
  { 254, 10, 17, 12, 1, -17 },
  { 276, 10, 17, 12, 1, -17 },
  { 298, 10, 17, 12, 1, -17 },
  { 320, 10, 17, 12, 1, -17 },
  { 342, 11, 17, 12, 1, -17 },
  { 366, 10, 17, 12, 1, -17 },
  { 388, 10, 17, 12, 1, -17 },
  { 410, 10, 17, 12, 1, -17 },
  { 432, 5, 13, 7, 1, -13 },
  { 441, 5, 18, 7, 1, -13 },
  { 453, 8, 12, 11, 1, -13 },
  { 465, 10, 8, 12, 1, -11 },
  { 475, 9, 12, 11, 1, -13 },
  { 489, 10, 17, 11, 0, -17 },
  { 511, 17, 22, 18, 1, -17 },
  { 558, 14, 17, 15, 0, -17 },
  { 588, 12, 17, 14, 1, -17 },
  { 614, 12, 17, 14, 1, -17 },
  { 640, 12, 17, 13, 1, -17 },
  { 666, 10, 17, 12, 1, -17 },
  { 688, 10, 17, 11, 1, -17 },
  { 710, 12, 17, 14, 1, -17 },
  { 736, 12, 17, 15, 1, -17 },
  { 762, 4, 17, 7, 1, -17 },
  { 771, 11, 17, 12, 0, -17 },
  { 795, 13, 17, 13, 1, -17 },
  { 823, 10, 17, 12, 1, -17 },
  { 845, 16, 17, 18, 1, -17 },
  { 879, 12, 17, 15, 1, -17 },
  { 905, 13, 17, 14, 1, -17 },
  { 933, 12, 17, 14, 1, -17 },
  { 959, 13, 20, 14, 1, -17 },
  { 992, 12, 17, 14, 1, -17 },
  { 1018, 11, 17, 13, 1, -17 },
  { 1042, 12, 17, 13, 1, -17 },
  { 1068, 12, 17, 14, 1, -17 },
  { 1094, 14, 17, 14, 0, -17 },
  { 1124, 17, 17, 18, 0, -17 },
  { 1161, 13, 17, 14, 0, -17 },
  { 1189, 13, 17, 13, 0, -17 },
  { 1217, 11, 17, 13, 1, -17 },
  { 1241, 5, 24, 6, 1, -20 },
  { 1256, 10, 18, 9, 0, -17 },
  { 1279, 5, 24, 6, 0, -20 },
  { 1294, 9, 9, 10, 0, -17 },
  { 1305, 9, 3, 10, 0, 0 },
  { 1309, 6, 4, 8, 1, -18 },
  { 1312, 10, 13, 11, 1, -13 },
  { 1329, 10, 18, 12, 1, -18 },
  { 1352, 9, 13, 11, 1, -13 },
  { 1367, 10, 18, 12, 1, -18 },
  { 1390, 10, 13, 12, 1, -13 },
  { 1407, 8, 18, 8, 0, -18 },
  { 1425, 10, 18, 12, 1, -13 },
  { 1448, 10, 18, 12, 1, -18 },
  { 1471, 4, 18, 6, 1, -18 },
  { 1480, 6, 23, 6, -1, -18 },
  { 1498, 11, 18, 12, 1, -18 },
  { 1523, 4, 18, 6, 1, -18 },
  { 1532, 16, 13, 18, 1, -13 },
  { 1558, 10, 13, 12, 1, -13 },
  { 1575, 10, 13, 12, 1, -13 },
  { 1592, 10, 18, 12, 1, -13 },
  { 1615, 10, 18, 12, 1, -13 },
  { 1638, 7, 13, 8, 1, -13 },
  { 1650, 10, 13, 11, 0, -13 },
  { 1667, 7, 16, 8, 0, -16 },
  { 1681, 10, 13, 12, 1, -13 },
  { 1698, 11, 13, 11, 0, -13 },
  { 1716, 15, 13, 15, 0, -13 },
  { 1741, 11, 13, 11, 0, -13 },
  { 1759, 11, 18, 11, 0, -13 },
  { 1784, 9, 13, 11, 1, -13 },
  { 1799, 5, 23, 7, 1, -19 },
  { 1814, 2, 20, 6, 2, -17 },
  { 1819, 5, 23, 7, 1, -19 },
  { 1834, 11, 6, 13, 1, -10 },
};

const GFXfont RobotoCondensed_Black24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_BLACK24PT7B_H_
