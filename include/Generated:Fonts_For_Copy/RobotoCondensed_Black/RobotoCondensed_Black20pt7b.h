#ifndef _ROBOTOCONDENSED_BLACK20PT7B_H_
#define _ROBOTOCONDENSED_BLACK20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0xEF, 0x3C, 0xF3, 0xCF, 0x30,
  0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x7F, 0xDF, 0xF1, 0x20, 0x58, 0xFF, 0xBF,
  0xE3, 0x60, 0xD8, 0x36, 0x0D, 0x00, 0x08, 0x08, 0x3C, 0x7E, 0xFF, 0xE7,
  0xF7, 0x70, 0x7C, 0x1E, 0x0F, 0xE7, 0xE7, 0xFF, 0x7F, 0x3E, 0x08, 0x08,
  0x70, 0x1F, 0x03, 0x66, 0x6D, 0x8D, 0xB1, 0xFC, 0x1D, 0x80, 0x6E, 0x0F,
  0xE3, 0x6C, 0x5D, 0x99, 0xB0, 0x3E, 0x03, 0x80, 0x3C, 0x1F, 0x87, 0xE1,
  0x98, 0x76, 0x1F, 0x83, 0xC1, 0xF7, 0xFD, 0xFB, 0xEE, 0xFB, 0xFE, 0xFF,
  0x9F, 0x70, 0xFF, 0xFF, 0x80, 0x08, 0xCC, 0xE6, 0x33, 0x9C, 0xE7, 0x39,
  0xCE, 0x71, 0x8C, 0x71, 0x86, 0x10, 0x86, 0x38, 0xC7, 0x38, 0xC6, 0x39,
  0xCE, 0x73, 0x19, 0xCE, 0x67, 0x31, 0x00, 0x0C, 0x06, 0x03, 0x3F, 0xF3,
  0xF0, 0xE0, 0xD8, 0xE6, 0x22, 0x00, 0x38, 0x38, 0x38, 0x38, 0xFF, 0xFF,
  0xFF, 0x38, 0x38, 0x38, 0x38, 0x77, 0x77, 0x66, 0xFF, 0xFE, 0xFF, 0x60,
  0x0C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x31, 0xC6, 0x18, 0xE3, 0x0C, 0x00,
  0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0x7E, 0x3C, 0x0B, 0xFF, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x3C,
  0x7F, 0xFF, 0xE7, 0xE7, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0xFF, 0xFF,
  0xFF, 0x1E, 0x1F, 0xDF, 0xEE, 0x70, 0x38, 0x3C, 0x7C, 0x3F, 0x03, 0x81,
  0xDC, 0xEF, 0xF7, 0xF8, 0xF0, 0x0E, 0x07, 0x07, 0x87, 0xC3, 0xE3, 0xF1,
  0xB9, 0xDC, 0xFF, 0xFF, 0xFF, 0xE1, 0xC0, 0xE0, 0x70, 0x7F, 0x7F, 0xFF,
  0xE0, 0xE0, 0xFE, 0xFF, 0xEF, 0x07, 0x07, 0xE7, 0xFF, 0x7E, 0x3C, 0x0E,
  0x1F, 0x1F, 0x8E, 0x0E, 0x07, 0x73, 0xFD, 0xFE, 0xE7, 0xF3, 0xF9, 0xFF,
  0xE7, 0xF1, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x78, 0x70, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0x7F, 0x7E,
  0x7F, 0xE7, 0xE7, 0xE7, 0xFF, 0x7F, 0x3C, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7,
  0xE7, 0xF7, 0x7F, 0x3F, 0x07, 0x0F, 0x3E, 0x3C, 0x30, 0xFF, 0x60, 0x00,
  0x00, 0xFF, 0x60, 0xEF, 0x60, 0x00, 0x00, 0x06, 0x66, 0x6E, 0xC0, 0x02,
  0x1C, 0xFF, 0xEF, 0x1E, 0x3F, 0x1F, 0x0E, 0x04, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xC3, 0xE3, 0xF1, 0xE3, 0xDF, 0xFC, 0xE1,
  0x00, 0x3E, 0x7F, 0x7F, 0xF7, 0x07, 0x0F, 0x1E, 0x1C, 0x1C, 0x00, 0x00,
  0x1C, 0x1C, 0x1C, 0x0F, 0xC0, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x63, 0x9B,
  0x1F, 0x6C, 0xCC, 0xF3, 0x33, 0xDC, 0xCF, 0x73, 0x2D, 0xDD, 0xB7, 0x76,
  0xCF, 0xF3, 0x3B, 0xC6, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x39, 0xC3, 0x9C, 0x3F,
  0xC3, 0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xFF, 0x0F, 0xFE, 0x3F, 0xEF, 0xFB,
  0x8E, 0xE3, 0xB9, 0xEF, 0xF3, 0xFE, 0xE3, 0xB8, 0xFE, 0x3B, 0xFE, 0xFF,
  0xBF, 0xC0, 0x1E, 0x1F, 0xE7, 0xFB, 0x8F, 0xE1, 0xF8, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x7E, 0x3F, 0xFE, 0x7F, 0x8F, 0x80, 0xFC, 0x7F, 0xBF, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFF, 0xF7, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x1F, 0xE7, 0xFB, 0xC7, 0xE1, 0xF8, 0x0E,
  0x03, 0x9F, 0xE7, 0xF8, 0x7F, 0x1D, 0xFF, 0x7F, 0xC7, 0xC0, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF9, 0xDD, 0xEF, 0xF7,
  0xF0, 0xF0, 0xE3, 0xF8, 0xEE, 0x7B, 0x9C, 0xEF, 0x3B, 0x8F, 0xE3, 0xF8,
  0xFF, 0x3F, 0xCE, 0x7B, 0x9E, 0xE3, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF7, 0xFD, 0xB7, 0xED,
  0xBF, 0x7D, 0xF9, 0xEF, 0xCE, 0x7E, 0x73, 0xF3, 0x9C, 0xF1, 0xFC, 0x7F,
  0x1F, 0xE7, 0xF9, 0xFF, 0x7E, 0xDF, 0xB7, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F,
  0xE3, 0xF8, 0x70, 0x1E, 0x1F, 0xE7, 0xFF, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF, 0x7F, 0x87, 0x80, 0xFE, 0x3F, 0xEF,
  0xFB, 0x8F, 0xE3, 0xF8, 0xFF, 0xFB, 0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x1E, 0x1F, 0xE7, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7F, 0x3D, 0xFF, 0x7F, 0x87, 0xE0, 0x3C, 0x07, 0x00,
  0x80, 0xFE, 0x3F, 0xEF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEF, 0xFB, 0xFC, 0xFF,
  0x3B, 0xCE, 0x73, 0x9E, 0xE3, 0xB8, 0xF0, 0x3E, 0x3F, 0xBF, 0xFC, 0x7F,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xF1, 0xF8, 0xFF, 0xF7, 0xF9, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xFE, 0x7F, 0x8F,
  0x80, 0xF0, 0xE7, 0x0E, 0x71, 0xE7, 0x9E, 0x79, 0xC3, 0x9C, 0x39, 0xC3,
  0xB8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0xF3, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0xBC, 0xE7, 0x7D, 0xCE, 0xFF, 0x9F, 0xFE, 0x1F,
  0xFC, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xCF, 0x03, 0x8E,
  0x00, 0xF1, 0xEF, 0x39, 0xEF, 0x1D, 0xC3, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x1F, 0x87, 0xF0, 0xEE, 0x3D, 0xE7, 0x9D, 0xE3, 0xC0, 0xF1, 0xEE, 0x39,
  0xC7, 0x1D, 0xC3, 0xB8, 0x77, 0x07, 0xC0, 0xF8, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xF0, 0x70,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xFF, 0xE0, 0xF0, 0x70, 0x70, 0x78,
  0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x07, 0xFF, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0xFF, 0x18, 0x3C, 0x3C, 0x3C,
  0x76, 0x66, 0x66, 0xFF, 0xFF, 0xE3, 0x8E, 0x3E, 0x3F, 0x9D, 0xC0, 0xF3,
  0xFB, 0xFD, 0xDE, 0xEF, 0x77, 0xBF, 0xCE, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFE, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0xFE, 0x3C,
  0xFE, 0xFE, 0xE7, 0xE0, 0xE0, 0xE0, 0xE7, 0xFE, 0xFE, 0x3C, 0x07, 0x07,
  0x07, 0x07, 0x77, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF,
  0x77, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0x3E,
  0x1C, 0xF3, 0xDE, 0xFF, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80,
  0x7F, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0xFF, 0x7F, 0x07,
  0x6F, 0x7E, 0x7C, 0xE0, 0xE0, 0xE0, 0xE0, 0xEE, 0xFF, 0xFF, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x39, 0xCE, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xFC,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x77, 0x7B, 0xB9, 0xF8, 0xFC, 0x7E, 0x3F,
  0x9D, 0xCE, 0xF7, 0x3B, 0x9E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEE,
  0xF7, 0xFF, 0xBF, 0xFF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F, 0x9C, 0xFC, 0xE7,
  0xE7, 0x3F, 0x39, 0xF9, 0xCE, 0xEE, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xFF, 0x7E, 0x3C, 0xFE, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0xFF, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x77, 0xFF, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFF, 0xFF, 0x77, 0x07, 0x07, 0x07, 0x07, 0xEF, 0xFF, 0xF8,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x3E, 0x7F, 0x77, 0x70, 0x78, 0x3E,
  0x1F, 0xE7, 0x77, 0x7F, 0x3E, 0x79, 0xEF, 0xFF, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0xCF, 0x3C, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0xFF, 0x77, 0xF3, 0xBB, 0xDD, 0xCE, 0xE7, 0x71, 0xB8, 0xF8, 0x7C, 0x3E,
  0x0F, 0x07, 0x00, 0xE6, 0x77, 0x77, 0x77, 0x77, 0xF7, 0x7F, 0x67, 0xFE,
  0x7D, 0xE3, 0xDE, 0x3D, 0xE3, 0x9C, 0x39, 0xC0, 0x77, 0xBB, 0x9D, 0xC7,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7E, 0x77, 0x3B, 0xBC, 0xE0, 0xF3, 0xFB, 0xDD,
  0xCE, 0xE7, 0x71, 0xF8, 0xF8, 0x7C, 0x3E, 0x0E, 0x07, 0x03, 0x87, 0xC3,
  0xC1, 0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0xC7, 0x1E, 0x38, 0xFF, 0xFF, 0xF8,
  0x08, 0xCE, 0x63, 0x18, 0xC6, 0x77, 0x3C, 0xE3, 0x18, 0xC6, 0x31, 0xC6,
  0x10, 0xFF, 0xFF, 0x80, 0x8C, 0xEE, 0xEE, 0xE6, 0x73, 0x77, 0xEE, 0xEE,
  0xEE, 0xC8, 0x71, 0xBC, 0xFF, 0xF9, 0xEC, 0x60,
};

const GFXglyph RobotoCondensed_Black20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 6, 6, 0, -15 },
  { 12, 10, 14, 10, 0, -14 },
  { 30, 8, 18, 10, 1, -16 },
  { 48, 11, 14, 13, 1, -14 },
  { 68, 10, 14, 12, 1, -14 },
  { 86, 3, 6, 3, 0, -15 },
  { 89, 5, 20, 7, 1, -16 },
  { 102, 5, 20, 6, 1, -16 },
  { 115, 9, 9, 9, 0, -14 },
  { 126, 8, 11, 9, 1, -12 },
  { 137, 4, 6, 5, 0, -2 },
  { 140, 5, 3, 8, 2, -8 },
  { 142, 4, 3, 6, 1, -3 },
  { 144, 6, 15, 6, 0, -14 },
  { 156, 8, 14, 10, 1, -14 },
  { 170, 5, 14, 10, 2, -14 },
  { 179, 8, 14, 10, 1, -14 },
  { 193, 9, 14, 10, 0, -14 },
  { 209, 9, 14, 10, 1, -14 },
  { 225, 8, 14, 10, 1, -14 },
  { 239, 9, 14, 10, 1, -14 },
  { 255, 8, 14, 10, 1, -14 },
  { 269, 8, 14, 10, 1, -14 },
  { 283, 8, 14, 10, 1, -14 },
  { 297, 4, 11, 6, 1, -11 },
  { 303, 4, 15, 6, 1, -11 },
  { 311, 7, 10, 9, 1, -11 },
  { 320, 8, 8, 10, 1, -10 },
  { 328, 7, 10, 9, 1, -11 },
  { 337, 8, 14, 9, 0, -14 },
  { 351, 14, 18, 15, 1, -14 },
  { 383, 12, 14, 12, 0, -14 },
  { 404, 10, 14, 11, 1, -14 },
  { 422, 10, 14, 11, 1, -14 },
  { 440, 9, 14, 11, 1, -14 },
  { 456, 8, 14, 10, 1, -14 },
  { 470, 8, 14, 10, 1, -14 },
  { 484, 10, 14, 12, 1, -14 },
  { 502, 10, 14, 12, 1, -14 },
  { 520, 3, 14, 6, 1, -14 },
  { 526, 9, 14, 10, 0, -14 },
  { 542, 10, 14, 11, 1, -14 },
  { 560, 8, 14, 10, 1, -14 },
  { 574, 13, 14, 15, 1, -14 },
  { 597, 10, 14, 12, 1, -14 },
  { 615, 10, 14, 12, 1, -14 },
  { 633, 10, 14, 12, 1, -14 },
  { 651, 10, 17, 12, 1, -14 },
  { 673, 10, 14, 11, 1, -14 },
  { 691, 9, 14, 11, 1, -14 },
  { 707, 11, 14, 11, 0, -14 },
  { 727, 10, 14, 12, 1, -14 },
  { 745, 12, 14, 12, 0, -14 },
  { 766, 15, 14, 15, 0, -14 },
  { 793, 11, 14, 11, 0, -14 },
  { 813, 11, 14, 11, 0, -14 },
  { 833, 9, 14, 11, 1, -14 },
  { 849, 4, 20, 5, 1, -17 },
  { 859, 8, 15, 8, 0, -14 },
  { 874, 4, 20, 5, 0, -17 },
  { 884, 8, 7, 8, 0, -14 },
  { 891, 8, 2, 8, 0, 0 },
  { 893, 5, 3, 7, 1, -15 },
  { 895, 9, 11, 9, 0, -11 },
  { 908, 8, 15, 10, 1, -15 },
  { 923, 8, 11, 9, 1, -11 },
  { 934, 8, 15, 10, 1, -15 },
  { 949, 8, 11, 10, 1, -11 },
  { 960, 6, 15, 7, 0, -15 },
  { 972, 8, 15, 10, 1, -11 },
  { 987, 8, 15, 10, 1, -15 },
  { 1002, 3, 15, 5, 1, -15 },
  { 1008, 5, 19, 5, -1, -15 },
  { 1020, 9, 15, 10, 1, -15 },
  { 1037, 3, 15, 5, 1, -15 },
  { 1043, 13, 11, 15, 1, -11 },
  { 1061, 8, 11, 10, 1, -11 },
  { 1072, 8, 11, 10, 1, -11 },
  { 1083, 8, 15, 10, 1, -11 },
  { 1098, 8, 15, 10, 1, -11 },
  { 1113, 6, 11, 7, 1, -11 },
  { 1122, 8, 11, 9, 0, -11 },
  { 1133, 6, 13, 6, 0, -13 },
  { 1143, 8, 11, 10, 1, -11 },
  { 1154, 9, 11, 9, 0, -11 },
  { 1167, 12, 11, 12, 0, -11 },
  { 1184, 9, 11, 9, 0, -11 },
  { 1197, 9, 15, 9, 0, -11 },
  { 1214, 7, 11, 9, 1, -11 },
  { 1224, 5, 20, 6, 0, -16 },
  { 1237, 1, 17, 5, 2, -14 },
  { 1240, 4, 20, 6, 1, -16 },
  { 1250, 9, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_Black20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_BLACK20PT7B_H_
