#ifndef _ROBOTOCONDENSED_BLACK30PT7B_H_
#define _ROBOTOCONDENSED_BLACK30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black30pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x80, 0x01, 0xE7, 0xBF, 0x79, 0xE0, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F,
  0x1F, 0x8D, 0xC6, 0x0E, 0x60, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x06,
  0x71, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0x9C,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03,
  0x38, 0x39, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0x81, 0xFE, 0x1F,
  0xF9, 0xFF, 0xCF, 0x9F, 0x7C, 0xFB, 0xE7, 0xDF, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFE, 0x3F, 0xF1, 0xF7,
  0xCF, 0xBF, 0xFD, 0xFF, 0xC7, 0xFC, 0x0F, 0xC0, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1E, 0xE3, 0x8E, 0x39, 0xC7,
  0x1D, 0xC3, 0xDE, 0xC0, 0xFE, 0xE0, 0x7F, 0x60, 0x1F, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x39, 0xE0, 0x1D, 0xF8, 0x1D, 0xFE, 0x0E, 0xE7, 0x0E,
  0x73, 0x87, 0x39, 0xC7, 0x1C, 0xE1, 0x8F, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3C, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3F, 0x9E,
  0x7F, 0xDE, 0xFF, 0xDE, 0xFB, 0xFE, 0xFB, 0xFC, 0xF9, 0xFC, 0xF8, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0x04,
  0x1C, 0x78, 0xE3, 0xC7, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xF0, 0xE1,
  0xE1, 0xC1, 0x00, 0x41, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x1E, 0x1C, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x1E,
  0x3C, 0x71, 0xE3, 0x8F, 0x1C, 0x10, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x10, 0xE0, 0x7B, 0x39, 0xFF, 0xF3, 0xFF, 0x81, 0xE0, 0x0F, 0xC0, 0x7B,
  0x83, 0xCF, 0x0E, 0x1C, 0x08, 0x40, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7B, 0xDE, 0xF7, 0xBF, 0xDE, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00, 0x03, 0x83, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0x0F,
  0x80, 0xFF, 0x0F, 0xF8, 0xFF, 0xE7, 0xCF, 0x3C, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0x78, 0xFB, 0xE7, 0x9F, 0xFC, 0x7F, 0xC1, 0xFE, 0x07, 0xC0, 0x01,
  0x83, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x9F, 0xFC, 0x7F, 0xE3, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xFF, 0xEF, 0x8F, 0xFC, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xE3, 0xFE, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3,
  0xFE, 0x1D, 0xF1, 0xEF, 0x8E, 0x7C, 0xF3, 0xE7, 0x9F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x78, 0x7F, 0xE7, 0xFF, 0xBF, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0xF8, 0xFF, 0xC7, 0xDF, 0xFC, 0xFF, 0xE3, 0xFE, 0x07, 0xC0,
  0x01, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC3, 0xF0, 0x3F, 0x01, 0xF0, 0x0F,
  0x78, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0x78, 0xFB, 0xE7, 0xDF, 0xFE, 0x7F, 0xE1, 0xFE, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xCF, 0xBE, 0x7D, 0xE3, 0xEF,
  0x9F, 0x7C, 0xF1, 0xFF, 0x87, 0xF8, 0x7F, 0xC7, 0xFF, 0x3E, 0x7B, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xE7, 0xDF, 0xFE, 0xFF, 0xE3, 0xFE, 0x07, 0xE0,
  0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0xCF, 0x7C, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xDF, 0x3E, 0xFF, 0xF7, 0xFF, 0x9F, 0xFC, 0x7B,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x0E, 0x00,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x70, 0x39,
  0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x3D,
  0xE7, 0x9E, 0xF1, 0x80, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xF7, 0xFD, 0xFE,
  0x3F, 0x07, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xF0, 0x0E, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x0F, 0xF8, 0x7F,
  0xC1, 0xF8, 0x3F, 0x3F, 0xFF, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00,
  0x1F, 0x07, 0xFC, 0xFF, 0xEF, 0xFE, 0xF9, 0xFF, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x1E, 0x03, 0x81, 0xC0, 0x0E, 0x1E, 0x00,
  0x38, 0xE1, 0xF1, 0xCE, 0x1F, 0xCE, 0x71, 0xFE, 0x3B, 0x8E, 0x71, 0xFC,
  0xF3, 0x8F, 0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF3, 0xC7, 0x1F, 0x9E, 0x38,
  0xFC, 0xF1, 0xC7, 0xE7, 0x9E, 0x77, 0x1C, 0xF3, 0xB8, 0xFF, 0xF9, 0xC7,
  0xFF, 0xC7, 0x1E, 0x78, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x87, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x1F, 0xFF, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0xFF, 0x03,
  0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x0F,
  0xBE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xF1, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0xFC,
  0x1F, 0x7C, 0x3E, 0xF8, 0xFD, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0x8F, 0xDF, 0x0F,
  0xBE, 0x1F, 0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xF1, 0xFB, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x1E, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF,
  0x9F, 0xF9, 0xFF, 0x9F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xF8, 0x3F,
  0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xF9, 0xF0,
  0xFB, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFD, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C,
  0xF8, 0x7E, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xEF, 0xFB, 0x9E, 0xFF, 0xBD, 0xEF,
  0xFB, 0xDF, 0xFF, 0xBD, 0xDF, 0xF9, 0xDD, 0xFF, 0x9F, 0xDF, 0xF9, 0xF9,
  0xFF, 0x8F, 0x9F, 0xF8, 0xF9, 0xFF, 0x8F, 0x9F, 0xF8, 0xF1, 0xFF, 0x87,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFB, 0x9F, 0xFB, 0x9F, 0xFB, 0xDF, 0xF9,
  0xDF, 0xF9, 0xDF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x08, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87,
  0xDF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFB, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x3E, 0x7C, 0x7C, 0xFC, 0xF8, 0xF9, 0xF1,
  0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFF, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x7F, 0xF1, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xF8, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0x7C, 0x3E, 0xF8, 0xFD, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00,
  0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xE7, 0xE1, 0xF1, 0xF0,
  0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0x81, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7C,
  0x78, 0x7D, 0xF1, 0xE1, 0xF7, 0xC7, 0xCF, 0x9F, 0x3F, 0x3E, 0x7C, 0xFC,
  0xF9, 0xF3, 0xF3, 0xE3, 0xCF, 0xCF, 0x8F, 0xBF, 0xBE, 0x3E, 0xFE, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F,
  0x80, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00,
  0x7C, 0x1F, 0x3F, 0x1F, 0x9F, 0x8F, 0x87, 0xC7, 0xC3, 0xF7, 0xE0, 0xFB,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x1F, 0x3F, 0x0F, 0x8F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF7, 0xE0, 0xF8, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x1E,
  0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFF, 0x1C, 0xE3, 0x9C, 0xF3, 0xDE, 0x3B, 0x87, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0xFF, 0xF9, 0xF0, 0x1F, 0x1F, 0xF7, 0xFF, 0xFF,
  0xFF, 0x9F, 0xF9, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xDF, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x78,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xEF,
  0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFF, 0xF9, 0xFF, 0x9F, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF9, 0xFF, 0x9F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC1,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE3, 0xDF, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFC, 0x7B, 0xE0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0x7C,
  0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x47, 0xFF,
  0x3F, 0xF8, 0xFF, 0xC1, 0xF8, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x3E, 0x0F,
  0x83, 0xE3, 0xFE, 0xFF, 0xBF, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1E, 0xF9,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xDF,
  0x00, 0xF8, 0x07, 0xCF, 0xFC, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x78, 0xFF,
  0xE7, 0xFF, 0xBF, 0xFD, 0xF3, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xE0,
  0x31, 0xEF, 0xBE, 0x78, 0x00, 0x1E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x0C, 0x1E, 0x3F, 0x3E, 0x1E, 0x00,
  0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0xFE, 0xFE, 0xFC, 0xF8, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x3E, 0xF9, 0xFB, 0xE7, 0xCF, 0xBE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0x9F, 0x3E, 0x7C, 0xF9, 0xFB,
  0xE3, 0xEF, 0x8F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xE3, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xF9, 0xF9, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F,
  0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xF8, 0xF1,
  0xFF, 0x8F, 0x1F, 0xF8, 0xF1, 0xFF, 0x8F, 0x1F, 0xFB, 0xC7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xF7, 0xFF, 0x3F, 0xF8, 0xFF, 0x81, 0xF0,
  0xFB, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x9F, 0x78, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0x1E, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF,
  0xE3, 0xDF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0xBE,
  0xF9, 0xFF, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFE, 0x03, 0xFF, 0x1F,
  0xF9, 0xFF, 0xFE, 0x7F, 0xC1, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3F, 0x9F, 0xC7, 0xE1, 0xF0, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1,
  0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE3, 0xDF, 0xF8, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF0, 0xF7, 0xC3, 0xDF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x78,
  0xE3, 0xDE, 0x78, 0xF7, 0x9F, 0x7D, 0xE7, 0xDF, 0x7D, 0xF7, 0x9F, 0x7D,
  0xE3, 0xFF, 0x78, 0xFF, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3, 0xFB, 0xF0,
  0x7C, 0xFC, 0x1F, 0x3F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x7C,
  0xF9, 0xF3, 0xE3, 0xCF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x03,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xF1, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0xF8, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF0,
  0xF7, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x3C, 0x79, 0xE3, 0xC7, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xCF, 0x9E, 0x3C, 0x7C, 0x78, 0xF9, 0xF3, 0xE7,
  0xCF, 0x8F, 0x1E, 0x3C, 0x7C, 0x78, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x41, 0xC3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xE3, 0xE7, 0xC7, 0x9F, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79,
  0xE3, 0xC2, 0x00, 0x1C, 0x00, 0xF8, 0xF7, 0xF3, 0xDF, 0xFF, 0xF3, 0xFB,
  0xC7, 0xE0, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Black30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 22, 8, 1, -22 },
  { 18, 9, 8, 10, 0, -23 },
  { 27, 13, 22, 15, 1, -22 },
  { 63, 13, 28, 15, 1, -25 },
  { 109, 17, 22, 19, 1, -22 },
  { 156, 16, 22, 18, 1, -22 },
  { 200, 3, 8, 5, 1, -23 },
  { 203, 7, 31, 10, 2, -24 },
  { 231, 7, 31, 10, 1, -24 },
  { 259, 14, 13, 14, 0, -22 },
  { 282, 12, 16, 14, 1, -18 },
  { 306, 5, 9, 8, 1, -4 },
  { 312, 8, 4, 13, 2, -11 },
  { 316, 5, 5, 9, 2, -5 },
  { 320, 9, 24, 9, 0, -22 },
  { 347, 13, 22, 15, 1, -22 },
  { 383, 9, 22, 15, 2, -22 },
  { 408, 13, 22, 15, 1, -22 },
  { 444, 13, 22, 15, 1, -22 },
  { 480, 13, 22, 15, 1, -22 },
  { 516, 13, 22, 15, 1, -22 },
  { 552, 13, 22, 15, 1, -22 },
  { 588, 13, 22, 15, 1, -22 },
  { 624, 13, 22, 15, 1, -22 },
  { 660, 13, 22, 15, 1, -22 },
  { 696, 5, 17, 9, 2, -17 },
  { 707, 6, 22, 8, 1, -17 },
  { 724, 11, 14, 13, 1, -16 },
  { 744, 11, 11, 15, 2, -15 },
  { 760, 11, 14, 14, 2, -16 },
  { 780, 12, 22, 14, 1, -22 },
  { 813, 21, 28, 23, 1, -21 },
  { 887, 18, 22, 18, 0, -22 },
  { 937, 15, 22, 17, 1, -22 },
  { 979, 15, 22, 17, 1, -22 },
  { 1021, 15, 22, 17, 1, -22 },
  { 1063, 13, 22, 15, 1, -22 },
  { 1099, 13, 22, 14, 1, -22 },
  { 1135, 16, 22, 18, 1, -22 },
  { 1179, 16, 22, 18, 1, -22 },
  { 1223, 5, 22, 8, 2, -22 },
  { 1237, 12, 22, 15, 1, -22 },
  { 1270, 16, 22, 17, 1, -22 },
  { 1314, 13, 22, 14, 1, -22 },
  { 1350, 20, 22, 23, 1, -22 },
  { 1405, 16, 22, 18, 1, -22 },
  { 1449, 16, 22, 18, 1, -22 },
  { 1493, 15, 22, 17, 1, -22 },
  { 1535, 16, 26, 18, 1, -22 },
  { 1587, 15, 22, 17, 1, -22 },
  { 1629, 14, 22, 17, 1, -22 },
  { 1668, 15, 22, 17, 1, -22 },
  { 1710, 15, 22, 17, 1, -22 },
  { 1752, 17, 22, 18, 0, -22 },
  { 1799, 22, 22, 22, 0, -22 },
  { 1860, 17, 22, 17, 0, -22 },
  { 1907, 16, 22, 17, 0, -22 },
  { 1951, 14, 22, 16, 1, -22 },
  { 1990, 6, 30, 8, 1, -25 },
  { 2013, 12, 24, 12, 0, -22 },
  { 2049, 6, 30, 8, 1, -25 },
  { 2072, 11, 11, 12, 1, -22 },
  { 2088, 12, 4, 12, 0, 0 },
  { 2094, 8, 5, 10, 1, -23 },
  { 2099, 12, 16, 14, 1, -16 },
  { 2123, 13, 23, 15, 1, -23 },
  { 2161, 12, 16, 14, 1, -16 },
  { 2185, 13, 23, 15, 1, -23 },
  { 2223, 13, 16, 15, 1, -16 },
  { 2249, 10, 23, 10, 0, -23 },
  { 2278, 13, 22, 15, 1, -16 },
  { 2314, 13, 23, 15, 1, -23 },
  { 2352, 6, 23, 8, 1, -23 },
  { 2370, 8, 29, 8, -1, -23 },
  { 2399, 14, 23, 15, 1, -23 },
  { 2440, 4, 23, 8, 2, -23 },
  { 2452, 20, 16, 22, 1, -16 },
  { 2492, 13, 16, 15, 1, -16 },
  { 2518, 13, 16, 15, 1, -16 },
  { 2544, 13, 22, 15, 1, -16 },
  { 2580, 13, 22, 15, 1, -16 },
  { 2616, 9, 16, 10, 1, -16 },
  { 2634, 12, 16, 14, 1, -16 },
  { 2658, 9, 20, 9, 0, -20 },
  { 2681, 13, 16, 15, 1, -16 },
  { 2707, 14, 16, 14, 0, -16 },
  { 2735, 18, 16, 19, 0, -16 },
  { 2771, 14, 16, 14, 0, -16 },
  { 2799, 14, 22, 14, 0, -16 },
  { 2838, 12, 16, 14, 1, -16 },
  { 2862, 7, 28, 9, 1, -23 },
  { 2887, 2, 26, 8, 3, -22 },
  { 2894, 7, 28, 9, 1, -23 },
  { 2919, 14, 7, 16, 1, -12 },
};

const GFXfont RobotoCondensed_Black30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_BLACK30PT7B_H_
