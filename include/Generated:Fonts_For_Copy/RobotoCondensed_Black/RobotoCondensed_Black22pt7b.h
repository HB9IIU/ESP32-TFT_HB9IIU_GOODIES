#ifndef _ROBOTOCONDENSED_BLACK22PT7B_H_
#define _ROBOTOCONDENSED_BLACK22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x76, 0x00, 0x6F, 0xF6, 0xEF, 0xDF, 0xB7,
  0x6C, 0xD9, 0x80, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xC1, 0xB0, 0xFF, 0xDF,
  0xF8, 0xD8, 0x1B, 0x1F, 0xFB, 0xFF, 0x19, 0x83, 0x60, 0x6C, 0x0D, 0x81,
  0xB0, 0x0C, 0x06, 0x07, 0x8F, 0xE7, 0xFF, 0x9F, 0xCF, 0xE0, 0x78, 0x3F,
  0x07, 0xC0, 0xF0, 0x3F, 0x1F, 0xCF, 0xFF, 0x7F, 0x1F, 0x03, 0x01, 0x80,
  0x78, 0x0F, 0xC0, 0xCC, 0xCC, 0xDC, 0xCD, 0x8F, 0xF0, 0x7B, 0x00, 0x60,
  0x06, 0x00, 0xDE, 0x0F, 0xF1, 0xB3, 0x1B, 0x33, 0x3B, 0x13, 0xF0, 0x1E,
  0x1E, 0x03, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x03, 0xC0,
  0x7C, 0xEF, 0xEE, 0xEF, 0xEE, 0x7C, 0xE7, 0xCF, 0xFC, 0x7F, 0xE3, 0xDE,
  0xFF, 0xFF, 0xC0, 0x08, 0x63, 0x8C, 0x71, 0xC6, 0x18, 0xE3, 0x8E, 0x38,
  0xE3, 0x86, 0x18, 0x71, 0xC3, 0x0E, 0x18, 0x20, 0x86, 0x38, 0xC7, 0x18,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x33, 0x99, 0xCC, 0x40, 0x0C, 0x03,
  0x00, 0xC1, 0xB7, 0xFF, 0xC7, 0x81, 0xE0, 0xEC, 0x73, 0x80, 0x40, 0x3C,
  0x1E, 0x0F, 0x07, 0x8F, 0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x00,
  0x39, 0xCC, 0x67, 0x39, 0x80, 0xFF, 0xFE, 0x6F, 0xF7, 0x0C, 0x18, 0x30,
  0xE1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC0,
  0x1E, 0x3F, 0x9F, 0xFE, 0xFF, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFE, 0x7F, 0x7B, 0xFD, 0xFC, 0x3C, 0x0C, 0xFF, 0xFF, 0xDC, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3E, 0x3F, 0xBF, 0xFC, 0xFE, 0x38,
  0x3C, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x87, 0xFF, 0xFF, 0xFF,
  0x3E, 0x3F, 0xBF, 0xFC, 0xF0, 0x38, 0x3C, 0x7C, 0x3C, 0x1F, 0x03, 0xC0,
  0xFC, 0x7E, 0x3F, 0xFD, 0xFC, 0x7C, 0x07, 0x07, 0x83, 0xC3, 0xE1, 0xF1,
  0xF8, 0xDC, 0xEE, 0x77, 0x73, 0xBF, 0xFF, 0xFF, 0xF8, 0x38, 0x1C, 0x0E,
  0x7F, 0xBF, 0xDF, 0xFE, 0x0F, 0x07, 0x73, 0xFD, 0xFF, 0x07, 0x81, 0xC0,
  0xFC, 0x7F, 0x7F, 0xFD, 0xFC, 0x7C, 0x0E, 0x07, 0x83, 0xE1, 0xE0, 0x70,
  0x3F, 0xCF, 0xFB, 0xFE, 0xE3, 0xB8, 0xFE, 0x3F, 0x8F, 0xF3, 0x9F, 0xE7,
  0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E,
  0x0F, 0x07, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x3E, 0x3F, 0x9F, 0xFE,
  0xFF, 0x7F, 0xBD, 0xFC, 0x7C, 0x7F, 0x7B, 0xFC, 0xFC, 0x7F, 0x3F, 0xFD,
  0xFC, 0x7C, 0x1E, 0x3F, 0x9F, 0xDE, 0xFF, 0x3F, 0x1F, 0x8F, 0xE7, 0xFF,
  0xBF, 0xCE, 0xE0, 0xF0, 0xF1, 0xF0, 0xF8, 0x70, 0x6F, 0xF7, 0x00, 0x00,
  0x06, 0xFF, 0x70, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x77, 0x77, 0x6E, 0x40,
  0x01, 0x07, 0x1F, 0x7E, 0xF8, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0xF8, 0xFE,
  0x1F, 0x07, 0x1F, 0xFE, 0xF8, 0xE0, 0x80, 0x1E, 0x3F, 0x9F, 0xEE, 0x7F,
  0x38, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0xF0, 0x78,
  0x38, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE1, 0x80, 0x66, 0x3C, 0xCC, 0xFC,
  0xF9, 0x99, 0xE7, 0x33, 0xCC, 0xE7, 0x99, 0xCF, 0x33, 0x9E, 0x67, 0x3C,
  0xEE, 0xD9, 0xFF, 0xB1, 0xDE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0x80, 0x7E, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0E,
  0xE0, 0x77, 0x03, 0xBC, 0x3C, 0xE1, 0xE7, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF,
  0x3C, 0x39, 0xC1, 0xFE, 0x0F, 0xFF, 0x1F, 0xF3, 0xFF, 0x79, 0xEF, 0x1D,
  0xE3, 0xBD, 0xF7, 0xFC, 0xFF, 0xDE, 0x3B, 0xC7, 0xF8, 0xFF, 0x1D, 0xFF,
  0xBF, 0xF7, 0xF8, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0xF8, 0xFF, 0x1E, 0xFF, 0x8F, 0xE0,
  0xF8, 0xFE, 0x1F, 0xF3, 0xFE, 0x79, 0xEF, 0x1D, 0xE3, 0xBC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0x78, 0xEF, 0x3D, 0xFF, 0x3F, 0xE7, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFD, 0xFE, 0xFF, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1F,
  0x07, 0xF9, 0xFF, 0xF8, 0xFF, 0x0F, 0xE0, 0x3C, 0x07, 0x9F, 0xF3, 0xFE,
  0x7F, 0xC7, 0xF8, 0xFF, 0x1E, 0xFF, 0xCF, 0xF0, 0xFC, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xCF, 0x73, 0xDF, 0xE3, 0xF8, 0x78, 0xF1,
  0xEF, 0x3E, 0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x8F, 0x78, 0xF3, 0xCF, 0x3C, 0xF3, 0xEF, 0x1E, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x8F, 0xFB, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xBF,
  0xDF, 0x7F, 0xBE, 0xFF, 0x79, 0xFE, 0xF3, 0xFC, 0xE7, 0xF9, 0xCF, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xF7, 0xF6, 0xFE,
  0xDF, 0xDF, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x8F, 0x1F, 0x07, 0xF9,
  0xFF, 0x78, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0xFF, 0x1E, 0xFF, 0x8F, 0xF0, 0xF8, 0xFF, 0x1F, 0xF3, 0xFF, 0x78,
  0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xDF, 0xF3, 0xFC, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x1F, 0x07, 0xF9, 0xFF, 0x78, 0xFF, 0x1F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x1E, 0xFF,
  0x8F, 0xF0, 0xFE, 0x01, 0xE0, 0x1C, 0x01, 0x00, 0xFF, 0x1F, 0xF3, 0xFF,
  0x78, 0xEF, 0x1F, 0xE3, 0xBC, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0xDE, 0x7B,
  0xCF, 0x3D, 0xE7, 0xBC, 0xF7, 0x8F, 0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xF1,
  0xFC, 0x07, 0xC1, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x87, 0xF3, 0xFF, 0xF7,
  0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1C, 0xFF, 0x9F, 0xE0, 0xF8, 0xF0, 0x7B,
  0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x1C, 0x70, 0xE7, 0x87, 0xBC, 0x3D,
  0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0xF3, 0xCF, 0x73, 0xCF, 0x73, 0xCF, 0x73, 0xCE, 0x7B, 0xCE, 0x7B, 0xEE,
  0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C,
  0x3E, 0x7C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0xF8, 0xF7, 0x9E, 0x79,
  0xE3, 0xDE, 0x3F, 0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F,
  0xC3, 0xDC, 0x3D, 0xE7, 0x9E, 0x79, 0xFF, 0x8F, 0xF0, 0xF7, 0x0E, 0x79,
  0xE3, 0x9E, 0x39, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78,
  0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x80, 0xFF,
  0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDF, 0xFF,
  0xFC, 0x1C, 0x1C, 0x3E, 0x36, 0x36, 0x77, 0x67, 0x63, 0xFF, 0xFF, 0xFF,
  0xF1, 0xC3, 0x80, 0x3E, 0x3F, 0xBF, 0xDC, 0xE0, 0x71, 0xFB, 0xFD, 0xCE,
  0xE7, 0x7F, 0xBF, 0xCE, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFB,
  0xFD, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xFF, 0xFF, 0xEF,
  0x00, 0x3C, 0x3F, 0xBF, 0xDC, 0xEE, 0x7F, 0x03, 0x81, 0xC0, 0xE7, 0xFF,
  0x9F, 0xC7, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7B, 0xFF, 0xFF, 0xFF,
  0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0xFF, 0xFF, 0x7B, 0x80, 0x3E,
  0x3F, 0xBF, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xF1, 0x7F, 0x9F, 0xE7,
  0xC0, 0x1E, 0x7C, 0xF9, 0xC3, 0x9F, 0xFF, 0xFF, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x3B, 0xBF, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xFF, 0xDF, 0xE7, 0x70, 0x7B, 0xFD, 0xFC, 0x7C, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x73, 0xFD, 0xFF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE,
  0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF3, 0xCE, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xBE, 0xF0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3D, 0xEF, 0x7B, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0x3D,
  0xCF, 0x7B, 0xDE, 0xF3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xEF, 0x7B, 0xFF, 0xFF, 0xFF, 0xFD, 0xE7, 0xF7, 0x9F, 0xDE,
  0x7F, 0x79, 0xFD, 0xE7, 0xF7, 0x9F, 0xDE, 0x7F, 0x79, 0xFD, 0xE7, 0xEF,
  0x7F, 0xBF, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xF0, 0x3E, 0x3F, 0xBF, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF,
  0xDF, 0xC7, 0xC0, 0xEF, 0x7F, 0xBF, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xFF, 0xFF, 0xDF, 0xCF, 0x07, 0x83, 0xC1, 0xE0, 0x7B, 0xFF, 0xFF,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xFF, 0xFF, 0xEF, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0xEF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0x1E, 0x3F, 0xDF, 0xEE, 0x77, 0x83, 0xF0, 0x7E, 0x1F, 0xF3, 0xBB, 0xDF,
  0xE3, 0xC0, 0x78, 0xF1, 0xE7, 0xEF, 0xDF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xE7, 0xC7, 0x80, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xE7, 0xFF, 0xFF, 0xEF, 0x70, 0xF3, 0xDC, 0xF7, 0x39, 0xCE, 0x7F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x78, 0xF3, 0x3B, 0xB9,
  0xDD, 0xEE, 0xEF, 0x77, 0x7B, 0xBB, 0xF8, 0xFF, 0xC7, 0xBE, 0x3C, 0xF1,
  0xE7, 0x8F, 0x38, 0x79, 0xC0, 0x73, 0xDE, 0xE7, 0xF8, 0xFC, 0x3F, 0x07,
  0xC1, 0xF0, 0xFC, 0x3F, 0x9F, 0xE7, 0x3B, 0xCF, 0xF3, 0xDC, 0xF7, 0x39,
  0xFE, 0x7F, 0x8F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x1E, 0x3C, 0x38, 0x78,
  0x70, 0xFF, 0xFF, 0xFF, 0x11, 0xDC, 0xE7, 0x39, 0xCE, 0x77, 0x31, 0xCF,
  0x39, 0xCE, 0x73, 0x9C, 0x71, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87,
  0x39, 0xC7, 0x39, 0xCE, 0x73, 0xCE, 0xF7, 0x39, 0xCE, 0x73, 0x39, 0xC8,
  0x00, 0x39, 0xDF, 0x7F, 0xFF, 0xBE, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_Black22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 7, 6, 7, 0, -17 },
  { 15, 11, 16, 11, 0, -16 },
  { 37, 9, 20, 11, 1, -18 },
  { 60, 12, 16, 14, 1, -16 },
  { 84, 12, 16, 13, 1, -16 },
  { 108, 3, 6, 3, 0, -17 },
  { 111, 6, 22, 7, 1, -17 },
  { 128, 5, 22, 7, 1, -17 },
  { 142, 10, 10, 10, 0, -16 },
  { 155, 9, 11, 10, 1, -13 },
  { 168, 5, 7, 6, 0, -3 },
  { 173, 5, 3, 9, 2, -8 },
  { 175, 4, 4, 7, 1, -4 },
  { 177, 7, 17, 7, 0, -16 },
  { 192, 9, 16, 11, 1, -16 },
  { 210, 6, 16, 11, 2, -16 },
  { 222, 9, 16, 11, 1, -16 },
  { 240, 9, 16, 11, 1, -16 },
  { 258, 9, 16, 11, 1, -16 },
  { 276, 9, 16, 11, 1, -16 },
  { 294, 10, 16, 11, 1, -16 },
  { 314, 9, 16, 11, 1, -16 },
  { 332, 9, 16, 11, 1, -16 },
  { 350, 9, 16, 11, 1, -16 },
  { 368, 4, 13, 6, 1, -13 },
  { 375, 4, 17, 6, 1, -13 },
  { 384, 8, 11, 10, 1, -12 },
  { 395, 9, 8, 11, 1, -11 },
  { 404, 8, 11, 10, 1, -12 },
  { 415, 9, 16, 10, 0, -16 },
  { 433, 15, 20, 17, 1, -15 },
  { 471, 13, 16, 13, 0, -16 },
  { 497, 11, 16, 13, 1, -16 },
  { 519, 11, 16, 13, 1, -16 },
  { 541, 11, 16, 12, 1, -16 },
  { 563, 9, 16, 11, 1, -16 },
  { 581, 9, 16, 10, 1, -16 },
  { 599, 11, 16, 13, 1, -16 },
  { 621, 11, 16, 13, 1, -16 },
  { 643, 4, 16, 6, 1, -16 },
  { 651, 10, 16, 11, 0, -16 },
  { 671, 12, 16, 12, 1, -16 },
  { 695, 9, 16, 11, 1, -16 },
  { 713, 15, 16, 17, 1, -16 },
  { 743, 11, 16, 13, 1, -16 },
  { 765, 11, 16, 13, 1, -16 },
  { 787, 11, 16, 13, 1, -16 },
  { 809, 11, 19, 13, 1, -16 },
  { 836, 11, 16, 12, 1, -16 },
  { 858, 10, 16, 12, 1, -16 },
  { 878, 11, 16, 12, 1, -16 },
  { 900, 11, 16, 13, 1, -16 },
  { 922, 13, 16, 13, 0, -16 },
  { 948, 16, 16, 16, 0, -16 },
  { 980, 12, 16, 12, 0, -16 },
  { 1004, 12, 16, 12, 0, -16 },
  { 1028, 10, 16, 12, 1, -16 },
  { 1048, 4, 22, 6, 1, -18 },
  { 1059, 9, 17, 8, 0, -16 },
  { 1079, 5, 22, 6, 0, -18 },
  { 1093, 8, 8, 9, 0, -16 },
  { 1101, 8, 3, 9, 0, 0 },
  { 1104, 6, 3, 7, 1, -16 },
  { 1107, 9, 12, 10, 1, -12 },
  { 1121, 9, 17, 11, 1, -17 },
  { 1141, 9, 12, 10, 1, -12 },
  { 1155, 9, 17, 11, 1, -17 },
  { 1175, 9, 12, 11, 1, -12 },
  { 1189, 7, 17, 7, 0, -17 },
  { 1204, 9, 16, 11, 1, -12 },
  { 1222, 9, 17, 11, 1, -17 },
  { 1242, 4, 17, 6, 1, -17 },
  { 1251, 6, 21, 6, -1, -17 },
  { 1267, 10, 17, 11, 1, -17 },
  { 1289, 4, 17, 6, 1, -17 },
  { 1298, 14, 12, 16, 1, -12 },
  { 1319, 9, 12, 11, 1, -12 },
  { 1333, 9, 12, 11, 1, -12 },
  { 1347, 9, 16, 11, 1, -12 },
  { 1365, 9, 16, 11, 1, -12 },
  { 1383, 6, 12, 8, 1, -12 },
  { 1392, 9, 12, 10, 0, -12 },
  { 1406, 7, 15, 7, 0, -15 },
  { 1420, 9, 12, 11, 1, -12 },
  { 1434, 10, 12, 10, 0, -12 },
  { 1449, 13, 12, 14, 0, -12 },
  { 1469, 10, 12, 10, 0, -12 },
  { 1484, 10, 16, 10, 0, -12 },
  { 1504, 8, 12, 10, 1, -12 },
  { 1516, 5, 21, 6, 1, -17 },
  { 1530, 2, 19, 6, 2, -16 },
  { 1535, 5, 21, 6, 1, -17 },
  { 1549, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_Black22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_BLACK22PT7B_H_
