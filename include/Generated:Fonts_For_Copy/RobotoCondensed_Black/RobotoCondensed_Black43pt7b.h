#ifndef _ROBOTOCONDENSED_BLACK43PT7B_H_
#define _ROBOTOCONDENSED_BLACK43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Black.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Black43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1,
  0xEF, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x79,
  0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0F, 0x3C, 0x01,
  0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xEF, 0xF7, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F,
  0x1F, 0xDF, 0xC7, 0xF7, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0xEF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF,
  0x80, 0x3F, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x80,
  0xF9, 0xF0, 0xE0, 0xF1, 0xF1, 0xE0, 0xF1, 0xF1, 0xE0, 0xF1, 0xF3, 0xC0,
  0xF1, 0xF3, 0xC0, 0xF9, 0xF7, 0x80, 0xFF, 0xE7, 0x80, 0x7F, 0xEF, 0x00,
  0x3F, 0xDF, 0x00, 0x1F, 0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x79, 0xF8, 0x00, 0xF3, 0xFC, 0x00, 0xF7, 0xFE,
  0x01, 0xEF, 0xFE, 0x01, 0xEF, 0x9F, 0x03, 0xCF, 0x1F, 0x03, 0xCF, 0x1F,
  0x07, 0x8F, 0x1F, 0x07, 0x8F, 0x1F, 0x0F, 0x0F, 0x9F, 0x07, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x1F, 0x9F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC,
  0x3F, 0xFC, 0xFC, 0x7F, 0xFE, 0xFC, 0x7E, 0xFE, 0xFC, 0xFE, 0x7F, 0xF8,
  0xFE, 0x7F, 0xF8, 0xFE, 0x3F, 0xF8, 0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0,
  0x7F, 0xBF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFD, 0xFE, 0x07, 0xF0, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBD, 0xE0, 0x00, 0x40, 0x38, 0x0F, 0x03, 0xF0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xC0, 0x38,
  0x01, 0x00, 0x40, 0x0E, 0x01, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0x78, 0x0E, 0x01,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xC3, 0xC1, 0xBE, 0x38, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0x78, 0x07,
  0xCF, 0x81, 0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0x81, 0xC0, 0x00, 0x10, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E,
  0x7C, 0xFC, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E,
  0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE7, 0xE3, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0x7F, 0x3F, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x18, 0x07, 0xC0, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0xFF, 0x7F, 0x9F, 0xC7, 0xF3, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFF, 0x7F, 0x9F, 0xC7, 0xFF, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xEF, 0xF7, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFB, 0xF8, 0x1F, 0x7F, 0x07, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x8F,
  0xC7, 0xF1, 0xF8, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFD, 0xF0, 0x3F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x83, 0xFB, 0xF8, 0x7F, 0x7F, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF9,
  0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xF3, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xF7, 0xE1, 0xF9, 0xFC, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF3, 0xFB, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0xFF, 0xEF, 0xF3, 0xFB, 0xF8, 0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0x9F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x1F, 0x1F, 0xDF, 0xEF,
  0xF7, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF0, 0xF0, 0x18, 0x00, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0xF7, 0xFB, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x0F, 0xC1, 0xE3, 0xE0, 0x7F,
  0x87, 0xCF, 0x07, 0xFF, 0x8F, 0x3C, 0x1F, 0xFC, 0x3D, 0xF0, 0xF8, 0xF0,
  0xF7, 0xC3, 0xE3, 0xC3, 0xDE, 0x1F, 0x0F, 0x0F, 0x78, 0x7C, 0x3C, 0x3D,
  0xE1, 0xF1, 0xF0, 0xF7, 0x8F, 0x87, 0xC3, 0xFE, 0x3E, 0x1F, 0x0F, 0xF8,
  0xF8, 0x7C, 0x3F, 0xE3, 0xE1, 0xF0, 0xFF, 0x8F, 0x87, 0xC3, 0xFE, 0x3E,
  0x1F, 0x1E, 0xF8, 0xF8, 0x7C, 0x79, 0xE3, 0xF3, 0xF3, 0xE7, 0x87, 0xFF,
  0xFF, 0x1E, 0x1F, 0xFF, 0xF8, 0x7C, 0x3F, 0x9F, 0xC1, 0xF0, 0x7C, 0x3E,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x7F,
  0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF8,
  0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xEF, 0xE0, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0x83, 0xFD, 0xFC, 0x0F, 0xEF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xF0, 0x7F,
  0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE, 0x7F,
  0x07, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF8,
  0x7F, 0x9F, 0xC1, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF,
  0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFE, 0x1F,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xBF, 0x83, 0xFC, 0xFE, 0x1F, 0xF3,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF9,
  0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xBF, 0x83, 0xFC, 0xFF, 0x0F, 0xF3,
  0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF,
  0x3F, 0x83, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7D,
  0xFF, 0xFB, 0xE3, 0xEF, 0xFF, 0xDF, 0x1F, 0x7F, 0xFE, 0xF9, 0xFB, 0xFF,
  0xF7, 0xCF, 0x9F, 0xFF, 0x9F, 0x7C, 0xFF, 0xFC, 0xFB, 0xE7, 0xFF, 0xE7,
  0xDE, 0x7F, 0xFF, 0x3F, 0xF3, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xC7, 0xFC,
  0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0x87, 0xF1, 0xFF,
  0xFC, 0x3F, 0x8F, 0xFF, 0xE1, 0xF8, 0x7F, 0xFF, 0x07, 0xC3, 0xFF, 0xF8,
  0x3E, 0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFE, 0xF1, 0xFF, 0xFB, 0xE7, 0xFF, 0xEF, 0x9F, 0xFF, 0x9E, 0x7F, 0xFE,
  0x7D, 0xFF, 0xF8, 0xF7, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F,
  0xBF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F,
  0x87, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF8,
  0x1F, 0xDF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F,
  0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F,
  0x87, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x40, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x07, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0x3F, 0x83, 0xFD, 0xFC, 0x1F,
  0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFD, 0xFE, 0x1F, 0xEF, 0xF0, 0x7F, 0x7F, 0x03, 0xFB, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F,
  0x7F, 0x87, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFC,
  0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x0F, 0xC1, 0xFF,
  0xF8, 0x3F, 0x07, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0x87, 0xF8, 0x7F, 0xFE,
  0x1F, 0xE3, 0xF9, 0xFC, 0x7F, 0x8F, 0xE7, 0xF1, 0xFE, 0x3F, 0x9F, 0xC7,
  0xF8, 0xFE, 0x7F, 0x3F, 0xE3, 0xF9, 0xFC, 0xFF, 0xCF, 0xE7, 0xF3, 0xFF,
  0x3F, 0x0F, 0xCF, 0xFD, 0xFC, 0x3F, 0xBF, 0xF7, 0xF0, 0xFE, 0xFF, 0xDF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xF8, 0x1F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x03, 0xFF,
  0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F,
  0xE7, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x3F,
  0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07,
  0xEF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC,
  0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x1F,
  0x7C, 0x3E, 0xF8, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC3, 0xFF, 0x07,
  0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF,
  0x9F, 0xCF, 0xE7, 0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xCF, 0xEF, 0xE3, 0xFB, 0xF8,
  0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xDF,
  0xCF, 0xF7, 0xF0, 0xF9, 0xFC, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xBF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xCF, 0xDF, 0xE3, 0xF3, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xE1, 0xFB, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE1, 0xFF, 0xF8, 0x7F, 0x7E, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC1, 0xF7, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFB, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF7, 0xFB, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE, 0xFC, 0x1F, 0x3F, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xC3, 0xF3, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFC, 0x7F, 0xD1, 0xFC, 0x07, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xE7, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE1,
  0x03, 0xFC, 0x38, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x9F, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xF8, 0xFE, 0xFE, 0x1F, 0xBF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC0, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xE7, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF, 0x7F, 0x3F, 0xCF, 0xE7, 0xF9,
  0xFD, 0xFE, 0x3F, 0xBF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xCF, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xCF,
  0xE3, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0x1F, 0x0F, 0xEF, 0xE3, 0xFC, 0xFF, 0xFF, 0x7F, 0xCF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3F,
  0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x7F,
  0xFE, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0x87, 0xFF, 0xE3,
  0xF8, 0x7F, 0xFE, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0x87,
  0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE,
  0x3F, 0x87, 0xFF, 0xE3, 0xF8, 0x7F, 0xFE, 0x3F, 0x87, 0xF0, 0xFC, 0x7C,
  0x3F, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF,
  0xE3, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0x7F, 0x9F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0x7F, 0x0F, 0xEF, 0xF7, 0xF9, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x3F,
  0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xEF,
  0x83, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xCF, 0xC7,
  0xFB, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xEF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xDF,
  0xEF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7D,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x7F, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xDF, 0xFF,
  0xEF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xF3, 0xFF, 0x3F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x7E, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xF7, 0xF1, 0xF1, 0xFC, 0xFF, 0x0F, 0xEF, 0xE1, 0xFD,
  0xFC, 0x3F, 0xBF, 0x8F, 0xE3, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1,
  0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0xFC, 0x3E, 0x1F, 0xFE, 0x1F, 0x1F, 0xFF, 0x1F, 0x8F, 0xFF,
  0xCF, 0xE7, 0xFF, 0xE7, 0xF3, 0xF3, 0xF3, 0xF9, 0xF9, 0xF9, 0xFC, 0xFC,
  0xFD, 0xFE, 0x7E, 0x7E, 0xFF, 0xBF, 0x3F, 0x7F, 0xFF, 0x0F, 0xBF, 0xFF,
  0x87, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xE1, 0xFF, 0xBF, 0xF0, 0xFF, 0xDF,
  0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x7F, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x7F, 0x1F, 0xCF, 0xE1,
  0xF9, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F,
  0xCF, 0xE3, 0xF9, 0xFC, 0xFE, 0x1F, 0xDF, 0xC3, 0xF8, 0xFF, 0x0F, 0xF7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F, 0x1F, 0xC3, 0xF9, 0xFC,
  0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x1F, 0xBF, 0x81, 0xFB, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x80, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F,
  0x0F, 0xCF, 0xE3, 0xF8, 0xF8, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x0F,
  0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7F,
  0x87, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0xFC, 0x3F, 0x03, 0xE0, 0x78, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0xF0,
  0x7D, 0xFF, 0x0F, 0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x3F,
  0xF7, 0xC3, 0xFE, 0xF8, 0x3F, 0x80, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Black43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 31, 11, 2, -31 },
  { 32, 12, 12, 14, 1, -32 },
  { 50, 20, 31, 22, 1, -31 },
  { 128, 18, 39, 22, 2, -35 },
  { 216, 24, 31, 28, 2, -31 },
  { 309, 24, 31, 26, 1, -31 },
  { 402, 5, 12, 7, 1, -32 },
  { 410, 11, 43, 14, 2, -34 },
  { 470, 11, 43, 14, 1, -34 },
  { 530, 19, 19, 20, 1, -31 },
  { 576, 18, 22, 20, 1, -25 },
  { 626, 8, 14, 12, 1, -5 },
  { 640, 11, 5, 18, 3, -15 },
  { 647, 8, 7, 13, 2, -7 },
  { 654, 13, 34, 13, 0, -31 },
  { 710, 18, 31, 22, 2, -31 },
  { 780, 13, 31, 22, 3, -31 },
  { 831, 19, 31, 22, 1, -31 },
  { 905, 19, 31, 22, 1, -31 },
  { 979, 19, 31, 22, 1, -31 },
  { 1053, 19, 31, 22, 1, -31 },
  { 1127, 19, 31, 22, 2, -31 },
  { 1201, 19, 31, 22, 1, -31 },
  { 1275, 18, 31, 22, 2, -31 },
  { 1345, 18, 31, 22, 2, -31 },
  { 1415, 7, 24, 13, 3, -24 },
  { 1436, 9, 33, 12, 1, -24 },
  { 1474, 16, 21, 19, 1, -23 },
  { 1516, 16, 14, 22, 3, -20 },
  { 1544, 16, 21, 19, 2, -23 },
  { 1586, 17, 31, 20, 1, -31 },
  { 1652, 30, 40, 33, 1, -30 },
  { 1802, 26, 31, 26, 0, -31 },
  { 1903, 21, 31, 24, 2, -31 },
  { 1985, 22, 31, 25, 2, -31 },
  { 2071, 21, 31, 24, 2, -31 },
  { 2153, 18, 31, 21, 2, -31 },
  { 2223, 18, 31, 20, 2, -31 },
  { 2293, 22, 31, 25, 2, -31 },
  { 2379, 22, 31, 26, 2, -31 },
  { 2465, 8, 31, 12, 2, -31 },
  { 2496, 18, 31, 21, 1, -31 },
  { 2566, 22, 31, 24, 2, -31 },
  { 2652, 18, 31, 21, 2, -31 },
  { 2722, 29, 31, 33, 2, -31 },
  { 2835, 22, 31, 26, 2, -31 },
  { 2921, 22, 31, 26, 2, -31 },
  { 3007, 21, 31, 25, 2, -31 },
  { 3089, 22, 37, 26, 2, -31 },
  { 3191, 21, 31, 24, 2, -31 },
  { 3273, 21, 31, 24, 1, -31 },
  { 3355, 22, 31, 24, 1, -31 },
  { 3441, 21, 31, 25, 2, -31 },
  { 3523, 25, 31, 25, 0, -31 },
  { 3620, 30, 31, 32, 1, -31 },
  { 3737, 24, 31, 24, 0, -31 },
  { 3830, 24, 31, 24, 0, -31 },
  { 3923, 21, 31, 23, 1, -31 },
  { 4005, 9, 43, 12, 2, -36 },
  { 4054, 18, 34, 17, 0, -31 },
  { 4131, 8, 43, 12, 1, -36 },
  { 4174, 15, 15, 17, 1, -31 },
  { 4203, 17, 5, 17, 0, 0 },
  { 4214, 12, 7, 15, 1, -33 },
  { 4225, 18, 23, 20, 1, -23 },
  { 4277, 18, 32, 21, 2, -32 },
  { 4349, 18, 23, 20, 1, -23 },
  { 4401, 18, 32, 21, 1, -32 },
  { 4473, 19, 23, 21, 1, -23 },
  { 4528, 14, 32, 14, 0, -32 },
  { 4584, 19, 32, 22, 1, -23 },
  { 4660, 18, 32, 21, 2, -32 },
  { 4732, 7, 32, 11, 2, -32 },
  { 4760, 11, 41, 11, -2, -32 },
  { 4817, 19, 32, 21, 2, -32 },
  { 4893, 7, 32, 11, 2, -32 },
  { 4921, 28, 23, 32, 2, -23 },
  { 5002, 18, 23, 21, 2, -23 },
  { 5054, 19, 23, 21, 1, -23 },
  { 5109, 18, 32, 21, 2, -23 },
  { 5181, 18, 32, 21, 1, -23 },
  { 5253, 12, 23, 15, 2, -23 },
  { 5288, 17, 23, 19, 1, -23 },
  { 5337, 12, 28, 13, 1, -28 },
  { 5379, 18, 23, 21, 2, -23 },
  { 5431, 19, 23, 20, 0, -23 },
  { 5486, 25, 23, 27, 1, -23 },
  { 5558, 19, 23, 20, 0, -23 },
  { 5613, 20, 32, 20, 0, -23 },
  { 5693, 16, 23, 20, 2, -23 },
  { 5739, 10, 42, 13, 1, -34 },
  { 5792, 3, 37, 11, 4, -31 },
  { 5806, 11, 42, 13, 1, -34 },
  { 5864, 19, 10, 23, 2, -18 },
};

const GFXfont RobotoCondensed_Black43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Black43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Black43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_BLACK43PT7B_H_
