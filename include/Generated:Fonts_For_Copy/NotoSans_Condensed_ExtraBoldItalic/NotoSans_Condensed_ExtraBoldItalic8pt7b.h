#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x57, 0x20, 0xB8, 0x31, 0xDC, 0xCF, 0x50, 0x27, 0x43, 0xAE, 0x69,
  0xAB, 0x57, 0x2D, 0x30, 0x32, 0x98, 0xFB, 0x78, 0xC0, 0x29, 0x49, 0x30,
  0x24, 0x92, 0xF0, 0x5F, 0x20, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x24,
  0xC8, 0x25, 0xDB, 0xAE, 0x7B, 0x25, 0x80, 0x65, 0x36, 0x4E, 0x65, 0x26,
  0x2E, 0x13, 0x6A, 0xF2, 0x74, 0x63, 0x2E, 0x34, 0x6F, 0xB6, 0x71, 0x22,
  0x4C, 0x75, 0x76, 0xBE, 0x65, 0xD7, 0x2C, 0x42, 0x42, 0x80, 0x16, 0xE1,
  0xFF, 0x86, 0x3C, 0x74, 0xA1, 0x80, 0x39, 0x17, 0xED, 0xBA, 0x07, 0x00,
  0x33, 0x55, 0xF9, 0x75, 0x57, 0xDE, 0x37, 0x4C, 0xC6, 0x72, 0x96, 0xAD,
  0x70, 0x74, 0x46, 0xCE, 0x74, 0x46, 0xC8, 0x3B, 0x51, 0xED, 0x38, 0x4A,
  0xDE, 0xED, 0x48, 0x6D, 0x25, 0x80, 0x32, 0x22, 0x64, 0x48, 0x5A, 0x98,
  0xCE, 0x58, 0x49, 0x2D, 0xC0, 0x65, 0xB6, 0xDD, 0xBA, 0xA0, 0x6B, 0x5A,
  0xDB, 0x48, 0x32, 0xD7, 0xBD, 0x38, 0x75, 0x57, 0xC8, 0x32, 0xD3, 0xBD,
  0x38, 0xC0, 0x75, 0x56, 0xEB, 0x75, 0x46, 0x2E, 0xEB, 0x49, 0x00, 0x4A,
  0xD4, 0xAD, 0x30, 0x9A, 0xAC, 0xCC, 0xA6, 0xAE, 0xBE, 0xF2, 0xC0, 0x5A,
  0x98, 0xC6, 0x58, 0xBA, 0xCC, 0x88, 0x73, 0x24, 0xCE, 0x69, 0x29, 0x30,
  0xAA, 0x90, 0x32, 0x22, 0x22, 0xC0, 0x26, 0x69, 0xE0, 0xC0, 0x7D, 0xBE,
  0x44, 0x75, 0xFE, 0x7C, 0x8E, 0x11, 0x7D, 0xAE, 0x7E, 0x8E, 0x32, 0x72,
  0x64, 0x4C, 0x7D, 0xBE, 0x2C, 0x44, 0x75, 0xBA, 0x45, 0xE0, 0x20, 0x96,
  0x96, 0x44, 0x76, 0xEB, 0x55, 0xE0, 0x7D, 0x5B, 0xEA, 0x75, 0xBA, 0x7D,
  0xBE, 0x75, 0xFE, 0x88, 0x7D, 0xAE, 0x22, 0x6A, 0x40, 0xE8, 0xF0, 0x5D,
  0x6C, 0x5D, 0xBE, 0xF6, 0x64, 0xFF, 0xED, 0xB4, 0x76, 0x6A, 0x79, 0x8C,
  0x42, 0x60, 0x6B, 0x70, 0x2D, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20, 0x5B,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 5, 6, 4, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 6, 6, 6, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 2, 1, -6 },
  { 21, 3, 7, 2, 0, -6 },
  { 24, 3, 7, 2, -1, -6 },
  { 27, 3, 4, 4, 1, -6 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 2, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 4, 6, 3, 0, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 3, 6, 4, 1, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 6, 4, 0, -6 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 5, 2, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 4, 2, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -5 },
  { 75, 3, 6, 3, 0, -6 },
  { 78, 6, 7, 6, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 4, 6, 4, 0, -6 },
  { 93, 5, 6, 5, 0, -6 },
  { 97, 4, 6, 4, 0, -6 },
  { 100, 4, 6, 4, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 3, 6, 3, 0, -6 },
  { 114, 4, 8, 2, -1, -6 },
  { 118, 5, 6, 4, 0, -6 },
  { 122, 3, 6, 3, 0, -6 },
  { 125, 6, 6, 6, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 5, 7, 5, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 3, 6, 4, 1, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 4, 6, 4, 1, -6 },
  { 162, 6, 6, 6, 1, -6 },
  { 167, 5, 6, 4, 0, -6 },
  { 171, 4, 6, 4, 1, -6 },
  { 174, 4, 6, 4, 0, -6 },
  { 177, 3, 7, 2, 0, -6 },
  { 180, 2, 6, 3, 1, -6 },
  { 182, 4, 7, 2, -1, -6 },
  { 186, 4, 4, 4, 0, -6 },
  { 188, 3, 1, 3, -1, 0 },
  { 189, 2, 1, 3, 1, -6 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 4, 6, 4, 0, -6 },
  { 195, 4, 4, 3, 0, -4 },
  { 197, 4, 6, 4, 0, -6 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 8, 3, -1, -6 },
  { 206, 4, 6, 4, 0, -4 },
  { 209, 4, 6, 4, 0, -6 },
  { 212, 2, 6, 2, 0, -6 },
  { 214, 3, 8, 2, -1, -6 },
  { 217, 4, 6, 4, 0, -6 },
  { 220, 2, 6, 2, 0, -6 },
  { 222, 6, 4, 6, 0, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 4, 4, 0, -4 },
  { 229, 4, 6, 4, 0, -4 },
  { 232, 4, 6, 4, 0, -4 },
  { 235, 3, 4, 3, 0, -4 },
  { 237, 3, 4, 3, 0, -4 },
  { 239, 3, 5, 3, 0, -5 },
  { 241, 4, 4, 4, 0, -4 },
  { 243, 4, 4, 4, 0, -4 },
  { 245, 6, 4, 6, 0, -4 },
  { 248, 4, 4, 4, 0, -4 },
  { 250, 5, 6, 4, -1, -4 },
  { 254, 3, 4, 3, 0, -4 },
  { 256, 3, 7, 3, 0, -6 },
  { 259, 1, 8, 3, 1, -6 },
  { 260, 3, 7, 3, 0, -6 },
  { 263, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC8PT7B_H_
