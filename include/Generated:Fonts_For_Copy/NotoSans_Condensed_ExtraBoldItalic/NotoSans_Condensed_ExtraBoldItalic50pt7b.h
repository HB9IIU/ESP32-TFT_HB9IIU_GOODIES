#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC50PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x7F,
  0x9F, 0xEF, 0xF3, 0xFD, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE,
  0x3F, 0x1F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFE, 0x3F, 0x9F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3E,
  0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xF6, 0x3C, 0x0F, 0xE6, 0x08,
  0x0F, 0xEE, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x33, 0xF8, 0x00, 0x73, 0xF8, 0x40, 0x73, 0xF8,
  0xF0, 0x77, 0xF0, 0xFC, 0x6F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x0F, 0x80,
  0x3F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0x80, 0x7E, 0x7C, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0xF8, 0x03, 0xF1, 0xF8,
  0x3F, 0x00, 0x7C, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC1, 0xF0, 0x03, 0xF0,
  0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE3, 0xF0, 0x01,
  0xF0, 0xFC, 0xFC, 0x00, 0x3E, 0x1F, 0x1F, 0x0F, 0xC7, 0xC7, 0xE7, 0xE3,
  0xFC, 0xF8, 0xF9, 0xF8, 0xFF, 0xDF, 0xFF, 0x3F, 0x3F, 0xFB, 0xFF, 0xCF,
  0xCF, 0xFF, 0xBF, 0xF1, 0xF3, 0xFB, 0xF7, 0xFC, 0x7E, 0x7E, 0x7E, 0x3F,
  0x1F, 0x8F, 0x87, 0xC0, 0x03, 0xF3, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x3F,
  0x00, 0x1F, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x1F, 0x00, 0x3F, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1, 0xF8, 0xFC, 0x01, 0xF0,
  0x3F, 0x1F, 0x80, 0x7E, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0xFF, 0xFC, 0x03,
  0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0xF0,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFC, 0x3F, 0x83, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xE7, 0xF8,
  0xFF, 0x7F, 0x9F, 0xC3, 0xF8, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xF8, 0x7F,
  0x07, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x3F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x02, 0x0F,
  0xC0, 0x3C, 0x7E, 0x01, 0xFB, 0xF0, 0x2F, 0xFF, 0x3E, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xBF, 0x03, 0xF9, 0xFC, 0x07,
  0xC7, 0xE0, 0x1C, 0x3F, 0x80, 0x41, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F,
  0xC0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x10,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x7F, 0x83,
  0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF,
  0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F, 0xC0,
  0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xF8, 0x1F,
  0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x83, 0xFC,
  0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFE, 0x0F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xFE, 0xFE, 0x3F, 0xBF, 0xC3, 0xE7, 0xF8, 0x38, 0xFE, 0x06,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xEF, 0xFC, 0x03, 0xE0, 0xFF, 0x00, 0xF0, 0x3F, 0xC0, 0x10, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xF1, 0xFF, 0x01, 0x80,
  0xFF, 0x01, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x80, 0x0F, 0xF8, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xEF, 0xF0,
  0x03, 0xF7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF0, 0xFE,
  0x01, 0xF8, 0xFF, 0x01, 0xF8, 0x7F, 0x00, 0xF8, 0x3F, 0x80, 0xFC, 0x1F,
  0xC0, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xF3, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x10, 0x00, 0xFF,
  0x0C, 0x00, 0xFF, 0x87, 0xC1, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0x04, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC2, 0x00, 0x3F, 0x9F, 0xC0, 0x7F,
  0xBF, 0xE0, 0x7F, 0x7F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0xC1, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x8F, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF3,
  0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x9F, 0xE1, 0xFF, 0x3F,
  0xC7, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0x7F, 0x03, 0xFC, 0xFE, 0x01, 0xE3, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x10, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC0,
  0xFE, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x81,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x01, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0x1F, 0xF1, 0xC0, 0xFF, 0x10, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x07,
  0xC0, 0x7C, 0x1F, 0x03, 0xFF, 0x8F, 0x87, 0xE1, 0xFF, 0xF1, 0xF1, 0xF8,
  0x7F, 0xFE, 0x3E, 0x3E, 0x0F, 0xFF, 0xC7, 0xC7, 0xC3, 0xF1, 0xF8, 0xF9,
  0xF0, 0xFC, 0x3E, 0x1F, 0x3E, 0x1F, 0x07, 0xC3, 0xE7, 0xC7, 0xE1, 0xF8,
  0x7D, 0xF0, 0xF8, 0x3F, 0x0F, 0xBE, 0x1F, 0x07, 0xC1, 0xF7, 0xC7, 0xE0,
  0xF8, 0x7C, 0xF8, 0xFC, 0x3F, 0x0F, 0x9F, 0x1F, 0x07, 0xE1, 0xF3, 0xE3,
  0xE0, 0xF8, 0x7C, 0xFC, 0x7C, 0x3F, 0x0F, 0x9F, 0x8F, 0xCF, 0xE3, 0xE3,
  0xF1, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0x07, 0xC3, 0xFE, 0xFF,
  0xC0, 0xF8, 0x3F, 0x8F, 0xE0, 0x1F, 0x00, 0x80, 0x20, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x7F,
  0x00, 0x1C, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0x7F, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xF0, 0x18, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x20, 0x1F, 0xF8, 0x78, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x3F, 0xC7, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0x18, 0x0F, 0xFC, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFF, 0xC7, 0xF8, 0x3F,
  0xFC, 0x7F, 0x87, 0xFF, 0x8F, 0xF0, 0x7F, 0xF8, 0xFF, 0x07, 0xFF, 0x8F,
  0xF0, 0x7F, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF8,
  0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFF, 0x00,
  0x0F, 0xE7, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFD,
  0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFB, 0xF8, 0x07, 0xEF,
  0xC3, 0xFF, 0xF8, 0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x0F, 0xEF, 0xC3, 0xF7,
  0xF0, 0x0F, 0xEF, 0xC7, 0xE7, 0xF0, 0x0F, 0xEF, 0xC7, 0xE7, 0xF0, 0x1F,
  0xEF, 0xCF, 0xCF, 0xF0, 0x1F, 0xCF, 0xCF, 0xCF, 0xE0, 0x1F, 0xCF, 0xDF,
  0x8F, 0xE0, 0x1F, 0xCF, 0xDF, 0x8F, 0xE0, 0x1F, 0xCF, 0xFF, 0x9F, 0xE0,
  0x3F, 0x8F, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F,
  0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xFC, 0x3F,
  0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xE0, 0x0F, 0xE0, 0x3F, 0xF0, 0x07, 0xF0,
  0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0x00, 0xFF, 0xF8, 0x3F, 0x80, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0xFE, 0x0F,
  0xE0, 0x3F, 0xFF, 0x0F, 0xF0, 0x1F, 0xDF, 0x87, 0xF0, 0x0F, 0xCF, 0xE3,
  0xF8, 0x0F, 0xE7, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0xFE, 0x03, 0xF9, 0xFC,
  0xFE, 0x01, 0xFC, 0x7F, 0x7F, 0x01, 0xFE, 0x3F, 0xBF, 0x80, 0xFE, 0x1F,
  0xDF, 0xC0, 0x7F, 0x0F, 0xEF, 0xE0, 0x3F, 0x87, 0xF7, 0xE0, 0x1F, 0xC1,
  0xFF, 0xF0, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0,
  0x3F, 0xFE, 0x03, 0xF8, 0x0F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0x01, 0xFC,
  0x03, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xC0, 0x3F,
  0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F,
  0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00,
  0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0x83, 0xFE, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F,
  0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0x1F,
  0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00,
  0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x1F, 0xC3, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x83, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81,
  0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF8, 0x38,
  0x07, 0xF8, 0x04, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x08,
  0x01, 0xFE, 0x0F, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F,
  0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0,
  0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xEF, 0xF0,
  0x1F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0xFF, 0x81,
  0xFE, 0x7F, 0x01, 0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFF, 0xE1, 0xFE, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x3F,
  0x87, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0xFE, 0x3F, 0x7E,
  0x7F, 0x81, 0xFC, 0x7E, 0xFC, 0xFF, 0x03, 0xF9, 0xF9, 0xF9, 0xFC, 0x07,
  0xF3, 0xF3, 0xF7, 0xF8, 0x0F, 0xEF, 0xE7, 0xEF, 0xE0, 0x1F, 0xDF, 0x8F,
  0xDF, 0xC0, 0x3F, 0xBF, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x7D, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC3,
  0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xE0,
  0x3F, 0xCF, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x0F,
  0xF7, 0xF8, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x20, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xF9,
  0xF8, 0x03, 0xF9, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xFC, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFE, 0x3F, 0x00,
  0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x8F, 0xF0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0x1F, 0xC0, 0xFF, 0xCF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8,
  0x7F, 0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x87, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFB, 0xF0, 0x0F, 0xF9, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0xF0, 0x07,
  0xFB, 0xFC, 0x07, 0xF7, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFD, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F,
  0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFE,
  0xFF, 0xE0, 0xFC, 0xFF, 0xC0, 0xFC, 0x7F, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xE7, 0x83, 0xFC, 0x04, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x10, 0x7F, 0xC1, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x01, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xF7, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF3,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFB, 0xF0, 0x03, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7,
  0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0xDF, 0xE3,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x01, 0x07, 0xFC, 0x7C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8,
  0x40, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x0C, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xF9, 0xFC, 0x03, 0xFF, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xC0, 0x0F, 0xF0, 0x1F, 0x07,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x07, 0xFB, 0xFC, 0x07, 0xF7,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFE, 0x07, 0xF0, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0x3F, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF3,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x00, 0x10, 0xF8, 0x0F, 0x80, 0x3F, 0x1F, 0xE1, 0xFF, 0x01, 0xF9,
  0xFF, 0x9F, 0xFC, 0x0F, 0xDF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0x1F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0,
  0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x81,
  0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0x10, 0xF8, 0x03, 0xE3, 0xFC, 0x07, 0xE7, 0xFE, 0x07, 0xEF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC1,
  0xFE, 0x7F, 0x83, 0xFC, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F,
  0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x8F,
  0xE1, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xF3, 0xFF, 0x00, 0x7E, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xE7, 0xF8, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF1,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0x3F, 0xE0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x10,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x9F, 0xC0, 0xFF, 0xEF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xCF, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F,
  0x8F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xC0,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x21, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x9F,
  0x81, 0xFD, 0xFC, 0x0F, 0xDF, 0xE0, 0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0x83, 0x83, 0xFC, 0x08, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x88, 0x03, 0xFC, 0x70, 0x3F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x7F, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC2, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x02, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE1, 0xFF, 0x0F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x1F, 0xF3, 0xF0,
  0x07, 0xF1, 0xF8, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFE,
  0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x81,
  0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F,
  0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x83, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF,
  0x83, 0xFB, 0xF8, 0x7F, 0xE1, 0xFE, 0xFE, 0x1F, 0xF8, 0x7F, 0x3F, 0x87,
  0xFE, 0x1F, 0xCF, 0xE3, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF, 0xE3, 0xF8, 0xFE,
  0x7F, 0xF9, 0xFC, 0x3F, 0x9F, 0xFE, 0x7F, 0x0F, 0xE7, 0xDF, 0x9F, 0xC3,
  0xFB, 0xF7, 0xEF, 0xE0, 0xFE, 0xFD, 0xFB, 0xF8, 0x3F, 0xBE, 0x7D, 0xFC,
  0x0F, 0xFF, 0x9F, 0x7F, 0x03, 0xF7, 0xC7, 0xDF, 0x80, 0xFD, 0xF1, 0xF7,
  0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x3F,
  0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xF8,
  0x0F, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x80,
  0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 37, 13, 0, -36 },
  { 71, 19, 13, 22, 5, -36 },
  { 102, 28, 36, 27, 0, -36 },
  { 228, 24, 41, 24, 1, -38 },
  { 351, 35, 36, 39, 3, -36 },
  { 509, 30, 37, 30, 0, -36 },
  { 648, 9, 13, 12, 5, -36 },
  { 663, 18, 44, 15, 1, -36 },
  { 762, 18, 45, 15, -4, -37 },
  { 864, 21, 22, 23, 4, -38 },
  { 922, 22, 24, 26, 2, -30 },
  { 988, 12, 14, 13, -3, -7 },
  { 1009, 14, 7, 15, 1, -17 },
  { 1022, 9, 9, 13, 0, -8 },
  { 1033, 27, 36, 20, -3, -36 },
  { 1155, 23, 37, 24, 1, -36 },
  { 1262, 19, 36, 24, 4, -36 },
  { 1348, 26, 36, 24, -2, -36 },
  { 1465, 24, 37, 24, 0, -36 },
  { 1576, 25, 36, 24, -1, -36 },
  { 1689, 25, 37, 24, 0, -36 },
  { 1805, 24, 37, 24, 2, -36 },
  { 1916, 26, 36, 24, 1, -36 },
  { 2033, 25, 37, 24, 0, -36 },
  { 2149, 23, 37, 24, 1, -36 },
  { 2256, 13, 29, 13, 0, -28 },
  { 2304, 16, 35, 13, -3, -28 },
  { 2374, 22, 26, 26, 2, -31 },
  { 2446, 22, 17, 26, 2, -26 },
  { 2493, 22, 26, 26, 2, -31 },
  { 2565, 20, 37, 19, 2, -36 },
  { 2658, 35, 40, 37, 1, -36 },
  { 2833, 27, 36, 27, -3, -36 },
  { 2955, 27, 36, 27, 0, -36 },
  { 3077, 26, 37, 25, 2, -36 },
  { 3198, 28, 36, 29, 0, -36 },
  { 3324, 25, 36, 23, 0, -36 },
  { 3437, 25, 36, 22, 0, -36 },
  { 3550, 28, 37, 29, 2, -36 },
  { 3680, 31, 36, 30, 0, -36 },
  { 3820, 23, 36, 18, -2, -36 },
  { 3924, 24, 47, 14, -8, -36 },
  { 4065, 31, 36, 27, 0, -36 },
  { 4205, 19, 36, 22, 0, -36 },
  { 4291, 40, 36, 39, 0, -36 },
  { 4471, 33, 36, 32, 0, -36 },
  { 4620, 28, 37, 31, 2, -36 },
  { 4750, 27, 36, 26, 0, -36 },
  { 4872, 28, 45, 31, 2, -36 },
  { 5030, 26, 36, 26, 0, -36 },
  { 5147, 25, 37, 23, 0, -36 },
  { 5263, 22, 36, 23, 4, -36 },
  { 5362, 29, 37, 29, 2, -36 },
  { 5497, 27, 36, 26, 4, -36 },
  { 5619, 39, 36, 39, 4, -36 },
  { 5795, 33, 36, 26, -3, -36 },
  { 5944, 25, 36, 25, 4, -36 },
  { 6057, 28, 36, 22, -2, -36 },
  { 6183, 21, 44, 15, -2, -36 },
  { 6299, 12, 36, 20, 5, -36 },
  { 6353, 21, 44, 15, -4, -36 },
  { 6469, 24, 23, 24, 0, -36 },
  { 6538, 20, 4, 19, -5, 4 },
  { 6548, 11, 8, 16, 7, -38 },
  { 6559, 25, 29, 26, 1, -28 },
  { 6650, 24, 39, 26, 0, -38 },
  { 6767, 21, 29, 21, 1, -28 },
  { 6844, 27, 39, 26, 1, -38 },
  { 6976, 22, 29, 24, 1, -28 },
  { 7056, 28, 50, 16, -6, -38 },
  { 7231, 27, 40, 26, -1, -28 },
  { 7366, 24, 38, 26, 0, -38 },
  { 7480, 15, 38, 13, 0, -38 },
  { 7552, 21, 50, 13, -6, -38 },
  { 7684, 27, 38, 25, 0, -38 },
  { 7813, 15, 38, 13, 0, -38 },
  { 7885, 37, 28, 38, 0, -28 },
  { 8015, 24, 28, 26, 0, -28 },
  { 8099, 23, 29, 25, 1, -28 },
  { 8183, 27, 40, 26, -3, -28 },
  { 8318, 25, 40, 26, 1, -28 },
  { 8443, 21, 28, 18, 0, -28 },
  { 8517, 21, 29, 20, 0, -28 },
  { 8594, 17, 34, 18, 2, -33 },
  { 8667, 25, 28, 26, 1, -27 },
  { 8755, 23, 27, 23, 3, -27 },
  { 8833, 34, 27, 35, 3, -27 },
  { 8948, 29, 27, 23, -3, -27 },
  { 9046, 29, 39, 23, -3, -27 },
  { 9188, 23, 27, 20, -2, -27 },
  { 9266, 21, 44, 17, 0, -36 },
  { 9382, 6, 49, 22, 8, -38 },
  { 9419, 20, 44, 17, -3, -36 },
  { 9529, 22, 9, 26, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC50PT7B_H_
