#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xE3,
  0xFE, 0x7F, 0x8F, 0xF8, 0xFF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F,
  0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x0F, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC3, 0xF8, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xEE, 0xFC, 0x03, 0xFE,
  0xF0, 0xE0, 0x1F, 0xE7, 0x02, 0x00, 0xFF, 0x38, 0x00, 0x07, 0xF9, 0xC0,
  0x00, 0x3F, 0xCE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x7F, 0xC0,
  0x00, 0x3B, 0xFE, 0x00, 0x01, 0xCF, 0xF0, 0x40, 0x1E, 0x7F, 0x83, 0x00,
  0xE3, 0xFC, 0x1C, 0x07, 0x3F, 0xE0, 0xFC, 0x3B, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF9, 0xFC, 0x1F, 0xC3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xFE, 0x7F, 0x1F, 0xCF, 0xE3, 0xFF, 0xCF, 0xFF, 0xF1, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x3F, 0xFF, 0x9F, 0xFF, 0x9F, 0xC7, 0xFF,
  0xF1, 0xFF, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1,
  0xFE, 0x1F, 0x8F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0xFE, 0x00, 0x0F, 0xE1,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xFC,
  0x3F, 0xE0, 0x7F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF,
  0xFF, 0xE7, 0xFC, 0x3F, 0xF3, 0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xC1, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0xE7, 0xFC, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x04, 0x07, 0xF0, 0x01, 0xC1, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0xDF, 0x81, 0x9F, 0xFF, 0xE7, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xDF, 0xC0, 0x3F, 0xE7, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFC,
  0x3F, 0x80, 0x1E, 0x0F, 0xF0, 0x03, 0x83, 0xF0, 0x00, 0x40, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x07,
  0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0x8F, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0x3F,
  0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF1, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xFC, 0x0F, 0xF9, 0xFF, 0x01, 0xFF,
  0x3F, 0xE0, 0x3F, 0xEF, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xBF, 0xE0,
  0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7,
  0xFC, 0x03, 0xFE, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03,
  0xFE, 0x7F, 0xC0, 0xFF, 0xCF, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F,
  0xC0, 0xFF, 0xC7, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x0F, 0xFB, 0xFE, 0x0F, 0xC7, 0xFC, 0x0F, 0x0F, 0xF0, 0x1C, 0x3F, 0xE0,
  0x10, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0x07, 0xFE, 0x00, 0xF8, 0x0F, 0xFC, 0x00, 0xE0, 0x1F, 0xF8, 0x01, 0x80,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0x00, 0xF0, 0x1F, 0xF8, 0x02,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x84, 0x00, 0x0F, 0xFC, 0x38, 0x00, 0xFF, 0xE1, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x7F, 0xC0, 0x01,
  0xFD, 0xFE, 0x00, 0x07, 0xEF, 0xF8, 0x00, 0x3F, 0xBF, 0xE0, 0x01, 0xFC,
  0xFF, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x1F, 0xF0, 0x01, 0xFC, 0x7F,
  0xC0, 0x0F, 0xE1, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x0F, 0xE0, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x88, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x30, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xE0, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x04,
  0x00, 0x1F, 0xF8, 0x38, 0x03, 0xFF, 0x81, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x60, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF3, 0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFB, 0xFF,
  0x80, 0x7F, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFF,
  0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x07,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0xF3, 0xFF, 0x03,
  0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3,
  0xFF, 0x9F, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xC0, 0x7F, 0xE7, 0xF8,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC3, 0xFF, 0x0F,
  0x01, 0xFF, 0x0C, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0xFF, 0x1F, 0x83, 0xF8, 0x1F, 0xFF, 0xC7,
  0xF0, 0xFC, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0x1F,
  0x83, 0xFC, 0x7E, 0x0F, 0xCF, 0xE1, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0x7E,
  0x0F, 0xE1, 0xFD, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x9F, 0x87, 0xF0, 0x3F, 0x07, 0xE7, 0xE1, 0xF8, 0x1F, 0xC1, 0xFB,
  0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0x3F, 0x0F,
  0xE0, 0x7E, 0x0F, 0xCF, 0xC3, 0xF8, 0x3F, 0x83, 0xF3, 0xF0, 0xFE, 0x0F,
  0xE1, 0xF8, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF,
  0x8F, 0xFC, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x07, 0xFC,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xF3,
  0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0xFF, 0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0,
  0x70, 0x07, 0xFF, 0x80, 0x10, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x02, 0x00, 0x7F, 0xF0, 0x0E, 0x00, 0x7F, 0xFE, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3C, 0x03, 0xFF, 0x80, 0x04, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFC,
  0x0F, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xF1, 0xFF,
  0x83, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xFC, 0x3F,
  0xE0, 0x83, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x04, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x87,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x03,
  0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xEF,
  0xF0, 0x03, 0xFD, 0xFC, 0x1F, 0xEF, 0xF0, 0x07, 0xFD, 0xFC, 0x1F, 0xDF,
  0xF0, 0x07, 0xFD, 0xFC, 0x3F, 0xDF, 0xF0, 0x07, 0xF9, 0xFC, 0x3F, 0x9F,
  0xE0, 0x07, 0xF9, 0xFC, 0x3F, 0x9F, 0xE0, 0x07, 0xF9, 0xFC, 0x7F, 0xBF,
  0xE0, 0x0F, 0xF9, 0xFC, 0x7F, 0x3F, 0xE0, 0x0F, 0xF9, 0xFC, 0xFF, 0x3F,
  0xE0, 0x0F, 0xF1, 0xFC, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFD, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF1, 0xFD, 0xFC, 0x7F, 0xC0, 0x1F, 0xF1, 0xFF, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F,
  0x80, 0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF,
  0x80, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x07,
  0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x03,
  0xFF, 0xFE, 0x0F, 0xF8, 0x03, 0xFD, 0xFE, 0x0F, 0xF8, 0x03, 0xFD, 0xFE,
  0x0F, 0xF0, 0x03, 0xFD, 0xFE, 0x0F, 0xF0, 0x07, 0xFD, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0x1F, 0xF0, 0x07, 0xF8,
  0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x9F, 0xE0, 0x0F, 0xF8, 0xFF, 0x9F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xBF, 0xE0, 0x0F, 0xF0, 0x7F, 0xBF, 0xE0, 0x0F,
  0xF0, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x17, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xE0,
  0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x83, 0xE0, 0x0F, 0xFC, 0x03, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x40, 0x01,
  0xFF, 0x01, 0xC0, 0x0F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xC3, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0x0F, 0xF8, 0x1F, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFF, 0xF0, 0x7F, 0xC0,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xC3, 0xFE, 0x03,
  0xFC, 0x3F, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x7F, 0x1F, 0xF0, 0x0F,
  0xF1, 0xFE, 0xFE, 0x3F, 0xE0, 0x1F, 0xE3, 0xFD, 0xFC, 0x7F, 0xC0, 0x3F,
  0xC7, 0xF3, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE7, 0xF3, 0xFE, 0x00, 0xFF,
  0x3F, 0x8F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x1F, 0xDF, 0xF0, 0x03, 0xFD,
  0xFE, 0x3F, 0xBF, 0xE0, 0x07, 0xFB, 0xF8, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFD, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0x9F,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFE,
  0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xFE, 0x3F, 0xC0, 0x7F, 0xFD, 0xFE, 0x03, 0xFF, 0xF7,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE,
  0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xEF, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x1F, 0xF8, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0xFF, 0x9F, 0xC0, 0x07, 0xF9, 0xFF,
  0x80, 0x7F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xF8, 0x0F, 0xF3, 0xFF,
  0x80, 0x7F, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFC, 0x1C,
  0x1F, 0xF8, 0x08, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x20,
  0xFF, 0x80, 0x60, 0xFF, 0xC1, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xEF, 0xF0,
  0x01, 0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xDF, 0xC0, 0x01, 0xFF, 0xCF, 0xE0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFC, 0x7F, 0xE0, 0xFF, 0x1F, 0xF0,
  0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFE, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x7F,
  0xC1, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x08, 0x3F, 0xE0, 0x0E, 0x0F, 0xFE, 0x1F, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0x00, 0x3F, 0xFD, 0xFE, 0x00,
  0x7F, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x7F, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0x40, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x20, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xFB,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF1, 0xFF, 0x83,
  0xFF, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0xCF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x03,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x3F, 0xE7, 0xFE, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xF0, 0x01, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x04, 0x00, 0x1F,
  0xC3, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFF, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x83,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x87, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x00, 0x04, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x3F, 0xF8, 0x07,
  0xFB, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0x01, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFE,
  0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x1F, 0xE7, 0xFE, 0x03, 0xFE,
  0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF7, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x0F,
  0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x3F, 0x9F, 0xFC, 0x00, 0x7F, 0xBF, 0xFC, 0x00, 0x7F, 0xBF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0x80, 0x1F,
  0xF3, 0xFF, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF0, 0x60, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xFE, 0x3F, 0xC0, 0x3F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01,
  0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0x7F, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x30,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFD, 0xFC, 0x0F, 0xF8, 0x1C, 0x07, 0xFC, 0x02, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x60, 0x07, 0xFC, 0x3C,
  0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC2, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFE, 0xFF, 0x01, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0x3F, 0x80,
  0x1F, 0xE1, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF7,
  0xF8, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xE7, 0xF8, 0x07, 0xFC, 0x7F, 0x80,
  0xFF, 0xC7, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF0,
  0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8,
  0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x8F, 0xF8,
  0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xBF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xBF, 0xC0, 0xFF, 0xE0, 0x7F, 0xDF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xCF, 0xF0, 0x7F, 0xF8, 0x3F, 0xE7, 0xF8, 0x3F, 0xFC, 0x1F, 0xE3, 0xFC,
  0x1F, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xFF,
  0x87, 0xF8, 0x7F, 0x8F, 0xFF, 0xC7, 0xFC, 0x3F, 0xC7, 0xFF, 0xC3, 0xFC,
  0x1F, 0xE3, 0xF7, 0xE3, 0xFE, 0x0F, 0xF3, 0xFB, 0xF1, 0xFE, 0x07, 0xF9,
  0xFD, 0xF8, 0xFF, 0x03, 0xFC, 0xFC, 0xFC, 0xFF, 0x81, 0xFE, 0xFE, 0x7E,
  0x7F, 0x80, 0xFF, 0x7F, 0x7F, 0x7F, 0xC0, 0x7F, 0xFF, 0x3F, 0xBF, 0xC0,
  0x3F, 0xBF, 0x9F, 0xDF, 0xE0, 0x1F, 0xDF, 0x8F, 0xEF, 0xE0, 0x0F, 0xEF,
  0xC7, 0xFF, 0xF0, 0x07, 0xFF, 0xE3, 0xFF, 0xF8, 0x03, 0xFF, 0xE1, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x27, 0xFF, 0xC0, 0x0D, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xD0, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 44, 16, 0, -43 },
  { 106, 23, 16, 26, 6, -43 },
  { 152, 34, 43, 33, 0, -43 },
  { 335, 29, 49, 29, 1, -46 },
  { 513, 43, 44, 47, 3, -43 },
  { 750, 36, 44, 36, 0, -43 },
  { 948, 11, 16, 15, 6, -43 },
  { 970, 22, 52, 18, 1, -43 },
  { 1113, 22, 53, 18, -5, -44 },
  { 1259, 26, 27, 28, 4, -46 },
  { 1347, 26, 29, 31, 3, -36 },
  { 1442, 14, 16, 16, -3, -8 },
  { 1470, 16, 8, 18, 1, -20 },
  { 1486, 11, 11, 16, 0, -10 },
  { 1502, 32, 43, 24, -3, -43 },
  { 1674, 27, 44, 29, 2, -43 },
  { 1823, 23, 43, 29, 5, -43 },
  { 1947, 31, 43, 29, -2, -43 },
  { 2114, 29, 44, 29, 0, -43 },
  { 2274, 30, 43, 29, -1, -43 },
  { 2436, 29, 44, 29, 1, -43 },
  { 2596, 29, 45, 29, 2, -44 },
  { 2760, 30, 43, 29, 2, -43 },
  { 2922, 29, 44, 29, 1, -43 },
  { 3082, 28, 45, 29, 1, -44 },
  { 3240, 16, 34, 16, 0, -33 },
  { 3308, 19, 41, 16, -3, -33 },
  { 3406, 27, 30, 31, 2, -37 },
  { 3508, 26, 20, 31, 3, -31 },
  { 3573, 26, 30, 31, 3, -37 },
  { 3671, 24, 44, 23, 2, -43 },
  { 3803, 42, 48, 44, 2, -43 },
  { 4055, 33, 43, 33, -4, -43 },
  { 4233, 32, 43, 32, 0, -43 },
  { 4405, 32, 44, 30, 2, -43 },
  { 4581, 34, 43, 34, 0, -43 },
  { 4764, 30, 43, 27, 0, -43 },
  { 4926, 30, 43, 26, 0, -43 },
  { 5088, 33, 44, 35, 3, -43 },
  { 5270, 37, 43, 36, 0, -43 },
  { 5469, 28, 43, 22, -2, -43 },
  { 5620, 28, 56, 17, -9, -43 },
  { 5816, 37, 43, 32, 0, -43 },
  { 6015, 23, 43, 26, 0, -43 },
  { 6139, 48, 43, 46, 0, -43 },
  { 6397, 40, 43, 38, 0, -43 },
  { 6612, 34, 45, 37, 2, -44 },
  { 6804, 32, 43, 31, 0, -43 },
  { 6976, 34, 54, 37, 2, -44 },
  { 7206, 32, 43, 32, 0, -43 },
  { 7378, 30, 44, 27, 0, -43 },
  { 7543, 26, 43, 27, 5, -43 },
  { 7683, 34, 44, 35, 3, -43 },
  { 7870, 32, 43, 31, 5, -43 },
  { 8042, 47, 43, 47, 5, -43 },
  { 8295, 39, 43, 31, -4, -43 },
  { 8505, 30, 43, 30, 5, -43 },
  { 8667, 33, 43, 27, -2, -43 },
  { 8845, 25, 53, 18, -2, -43 },
  { 9011, 14, 43, 24, 6, -43 },
  { 9087, 25, 53, 18, -4, -43 },
  { 9253, 28, 27, 29, 0, -43 },
  { 9348, 24, 5, 22, -6, 5 },
  { 9363, 12, 10, 19, 9, -46 },
  { 9378, 30, 35, 31, 1, -34 },
  { 9510, 29, 47, 31, 0, -46 },
  { 9681, 24, 35, 25, 2, -34 },
  { 9786, 33, 47, 31, 1, -46 },
  { 9980, 26, 34, 29, 2, -33 },
  { 10091, 33, 60, 19, -7, -46 },
  { 10339, 32, 48, 31, -1, -34 },
  { 10531, 29, 46, 31, 0, -46 },
  { 10698, 18, 46, 16, 0, -46 },
  { 10802, 26, 60, 16, -8, -46 },
  { 10997, 33, 46, 30, 0, -46 },
  { 11187, 19, 46, 16, 0, -46 },
  { 11297, 44, 34, 46, 0, -34 },
  { 11484, 29, 34, 31, 0, -34 },
  { 11608, 27, 35, 30, 2, -34 },
  { 11727, 32, 48, 31, -3, -34 },
  { 11919, 30, 48, 31, 1, -34 },
  { 12099, 25, 34, 22, 0, -34 },
  { 12206, 25, 35, 24, 0, -34 },
  { 12316, 21, 41, 21, 2, -40 },
  { 12424, 29, 34, 31, 2, -33 },
  { 12548, 28, 33, 27, 3, -33 },
  { 12664, 41, 33, 41, 4, -33 },
  { 12834, 34, 33, 28, -3, -33 },
  { 12975, 35, 47, 27, -4, -33 },
  { 13181, 27, 33, 24, -2, -33 },
  { 13293, 25, 52, 21, 0, -43 },
  { 13456, 8, 60, 26, 9, -46 },
  { 13516, 23, 52, 21, -3, -43 },
  { 13666, 27, 10, 31, 2, -26 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC60PT7B_H_
