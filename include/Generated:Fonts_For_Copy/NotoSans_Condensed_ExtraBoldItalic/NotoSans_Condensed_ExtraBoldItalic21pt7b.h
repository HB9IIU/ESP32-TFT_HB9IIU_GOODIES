#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC21PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x71, 0xC0, 0x00, 0xF3, 0xCE,
  0x00, 0x77, 0x67, 0xE6, 0xEE, 0xEE, 0x07, 0x60, 0x66, 0x0E, 0xE0, 0xCC,
  0x3F, 0xF3, 0xFF, 0x5D, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xC3, 0x30,
  0x77, 0x06, 0x60, 0x66, 0x00, 0x01, 0x00, 0xC0, 0xFC, 0x7F, 0x3A, 0x8E,
  0x83, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x7A, 0x2E, 0x6F, 0xBF, 0xC7, 0xE0,
  0x60, 0x10, 0x00, 0x3C, 0x18, 0xFC, 0x61, 0xB9, 0xC3, 0x73, 0x0E, 0xEE,
  0x1D, 0x98, 0x33, 0x6F, 0x7F, 0xDF, 0x7B, 0x76, 0x0E, 0xCC, 0x1B, 0xB8,
  0x67, 0x71, 0xCE, 0xC3, 0x0F, 0x8C, 0x1E, 0x00, 0x07, 0x80, 0x7E, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0F, 0xC0, 0x7C, 0x07, 0xCF, 0x7F, 0x73, 0xBF,
  0x39, 0xF9, 0xC7, 0x8F, 0x7C, 0x3F, 0xF1, 0xFF, 0x80, 0x76, 0xEE, 0xE0,
  0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0xF0,
  0x1C, 0x1C, 0xD8, 0xFF, 0x7F, 0x3D, 0x7C, 0xEE, 0x4E, 0x1C, 0x0E, 0x07,
  0x03, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3B, 0x9C,
  0xEE, 0x70, 0x7D, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x00, 0x1F, 0x1F, 0xCF, 0xEE, 0x77, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE7, 0xF3, 0xB9, 0xDD, 0xEF, 0xE7, 0xE1, 0xE0, 0x0F, 0x1E, 0x3E,
  0x7E, 0xEE, 0x5E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x78,
  0x07, 0xC3, 0xFC, 0x7F, 0x84, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0xF8, 0xFF, 0x3F, 0xE0, 0x1F, 0x8F, 0xF1,
  0xFC, 0x47, 0x01, 0xC0, 0xE1, 0xF0, 0x7C, 0x1F, 0x80, 0xE0, 0x3A, 0x1E,
  0xFF, 0x3F, 0xCF, 0xC0, 0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x87, 0xE1,
  0xB8, 0xCE, 0x77, 0x3F, 0xFF, 0xFB, 0xFE, 0x07, 0x03, 0x80, 0xE0, 0x1F,
  0xC7, 0xF1, 0xFC, 0x70, 0x38, 0x0F, 0x83, 0xF0, 0xFE, 0x03, 0x80, 0xE0,
  0x3A, 0x1E, 0xFF, 0x3F, 0xCF, 0xC0, 0x07, 0xC7, 0xE3, 0xE8, 0xE0, 0x70,
  0x1F, 0x8F, 0xF3, 0xFC, 0xE7, 0xB9, 0xEE, 0x73, 0x9C, 0xFF, 0x3F, 0x87,
  0xC0, 0x3F, 0xDF, 0xF7, 0xFC, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x00, 0x0F, 0x87, 0xF3, 0xDC,
  0xE7, 0x39, 0xCF, 0xE1, 0xF0, 0x7C, 0x3F, 0x9C, 0xEE, 0x3B, 0x8E, 0xF7,
  0x9F, 0xC3, 0xE0, 0x0F, 0x87, 0xF3, 0xFC, 0xE7, 0x79, 0xDC, 0x77, 0x3D,
  0xFF, 0x3F, 0x8E, 0xE0, 0x38, 0x1C, 0xDF, 0x3F, 0x8F, 0x80, 0x18, 0xF3,
  0x8E, 0x00, 0x00, 0x00, 0x03, 0xCF, 0x38, 0x0C, 0x3C, 0x70, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x71, 0xC3, 0x87, 0x1C, 0x38, 0x00, 0x00, 0x81, 0xC3,
  0xE7, 0xEF, 0xC7, 0x03, 0xF0, 0x7E, 0x0F, 0x80, 0xC0, 0x20, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x0F, 0xC1, 0xF8,
  0x1C, 0x7E, 0xFC, 0xF8, 0x60, 0x20, 0x00, 0x3E, 0x7F, 0x7F, 0x47, 0x07,
  0x0E, 0x1C, 0x38, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x03, 0xF0,
  0x3F, 0xE1, 0xC1, 0xCC, 0x03, 0x73, 0xED, 0x9F, 0xBE, 0xCC, 0xF3, 0x33,
  0xDC, 0xCF, 0x67, 0x6D, 0xDD, 0xB7, 0xFC, 0xC4, 0x63, 0x80, 0x07, 0x0C,
  0x0F, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x6E, 0x1D,
  0xC3, 0xB8, 0xE7, 0x1C, 0xE7, 0xFC, 0xFF, 0xBF, 0xF7, 0x0F, 0xE1, 0xF8,
  0x38, 0x1F, 0xC3, 0xFC, 0x7F, 0x8E, 0x73, 0x8E, 0x73, 0xCF, 0xF1, 0xFC,
  0x7B, 0xCE, 0x39, 0xC7, 0x39, 0xE7, 0xFD, 0xFF, 0x3F, 0x80, 0x0F, 0xC3,
  0xFC, 0xFF, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xFE, 0x1F, 0xE1,
  0xCF, 0x3C, 0xF3, 0x8F, 0x38, 0xF3, 0x8F, 0x78, 0xE7, 0x0E, 0x71, 0xE7,
  0x3C, 0x7F, 0x8F, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C,
  0x0E, 0x03, 0xF8, 0xFE, 0x7F, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0x3F, 0xCF,
  0xE0, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x3C, 0x0E, 0x03, 0xF8, 0xFC, 0x7F,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x00, 0x07, 0xF1, 0xFE, 0x3F,
  0xE3, 0x80, 0x78, 0x07, 0x00, 0xF3, 0xEF, 0x7C, 0xE7, 0xCE, 0x1C, 0xE1,
  0xCF, 0x3C, 0xFF, 0x87, 0xF8, 0x3F, 0x80, 0x1E, 0x38, 0xE3, 0xC7, 0x1E,
  0x38, 0xE3, 0xC7, 0x1C, 0x38, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xC7, 0x1C,
  0x38, 0xE3, 0xC7, 0x1C, 0x78, 0xE3, 0x87, 0x00, 0x1F, 0xC7, 0xF0, 0x70,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x1F, 0x8F, 0xE0, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x3C,
  0x3E, 0x0F, 0x81, 0x00, 0x1C, 0x78, 0xE7, 0x87, 0x38, 0x3B, 0xC3, 0xBC,
  0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xFC, 0x1C, 0xE0, 0xE7, 0x07,
  0x38, 0x79, 0xE3, 0x8F, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38,
  0x38, 0x78, 0x70, 0x70, 0x70, 0x7F, 0xFF, 0xFE, 0x1E, 0x0F, 0x8F, 0x07,
  0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF3, 0xF1, 0xF9, 0xB8, 0xFD, 0xF8, 0x7E,
  0xFC, 0x77, 0xEE, 0x3B, 0xF7, 0x1D, 0xF7, 0x8E, 0xFB, 0x87, 0x79, 0xC7,
  0x3C, 0xE3, 0x9C, 0xF0, 0x1E, 0x1C, 0x78, 0x71, 0xE3, 0x87, 0xCE, 0x3F,
  0x38, 0xFC, 0xE3, 0xF3, 0x8E, 0xFC, 0x73, 0xF1, 0xCF, 0xC7, 0x3F, 0x1C,
  0xFC, 0x71, 0xE3, 0x87, 0x8E, 0x1E, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE7,
  0x8E, 0x78, 0xF7, 0x0F, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE,
  0x3C, 0xFF, 0x87, 0xF8, 0x3E, 0x00, 0x1F, 0xC3, 0xFC, 0x7F, 0x8E, 0x73,
  0xCE, 0x71, 0xCE, 0x79, 0xFE, 0x7F, 0x8F, 0xE1, 0xC0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE7, 0x8E, 0x78, 0xF7, 0x0F,
  0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xF8,
  0x3E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x83, 0xF8, 0x7F,
  0x8E, 0x73, 0x8E, 0x73, 0xCE, 0x71, 0xFE, 0x7F, 0x0E, 0xE1, 0xDE, 0x39,
  0xC7, 0x39, 0xE7, 0xB8, 0xF0, 0x0F, 0xC7, 0xF3, 0xFC, 0xE1, 0x38, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7A, 0x1C, 0xFF, 0x3F, 0x8F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x03, 0x80, 0x38, 0xF3, 0x8E, 0x38, 0xE7, 0x8E, 0x70,
  0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38, 0xFF,
  0x8F, 0xF0, 0x7E, 0x00, 0xE1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x39, 0xCE,
  0x39, 0xC7, 0x70, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C,
  0x00, 0xE3, 0x87, 0xE3, 0x8F, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x9C, 0xEF,
  0x9C, 0xEF, 0x9C, 0xED, 0xB8, 0xFD, 0xB8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9,
  0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0x1E, 0x38, 0x73, 0x83, 0xBC,
  0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x77, 0x87, 0x9C, 0x38, 0xE3, 0xC7, 0x80, 0xE1, 0xF8, 0xEE, 0x7B,
  0xDC, 0x7F, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x7F, 0x8F, 0xF8,
  0xFF, 0x80, 0x0F, 0x87, 0xC3, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x7C, 0x00, 0xE7,
  0x38, 0xC6, 0x39, 0xCE, 0x73, 0x8C, 0x63, 0x9C, 0xE0, 0x0F, 0x87, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0xE0, 0x70, 0x38, 0x7C, 0x7C, 0x00, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x1F,
  0x8E, 0xE3, 0x19, 0xC6, 0x61, 0xF8, 0x70, 0xFF, 0xFF, 0xF7, 0x30, 0x0C,
  0xE3, 0xDC, 0xFF, 0x1C, 0xE7, 0x1C, 0xE3, 0x9C, 0xF3, 0x9C, 0xF3, 0x8E,
  0xF1, 0xFE, 0x3D, 0x80, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3B, 0x8F, 0xF3,
  0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCF, 0x73, 0xBD, 0xEF, 0xF3, 0xB8,
  0x0E, 0x3F, 0x7F, 0x71, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFC, 0xFC, 0x7C,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x0C, 0xE1, 0xEE, 0x3F, 0xC3, 0x9C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x38, 0xF3, 0x87, 0x78, 0x7F, 0x87, 0xB0,
  0x0E, 0x1F, 0x9F, 0xEE, 0x7E, 0x7F, 0xFB, 0xF9, 0xC0, 0xE0, 0x71, 0x3F,
  0x8F, 0xC0, 0x01, 0xE0, 0x7C, 0x1F, 0x03, 0x80, 0x7C, 0x3F, 0x87, 0xE0,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x03, 0xE0, 0x78, 0x0E, 0x00, 0x0E, 0xE3, 0xDC, 0xFF, 0x1C,
  0xE7, 0x1C, 0xE3, 0x9C, 0xF3, 0x9C, 0xF3, 0x8E, 0xF1, 0xFE, 0x3F, 0x80,
  0x70, 0x0E, 0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3B, 0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCE, 0x73, 0xBC,
  0xEE, 0x3B, 0x9E, 0x1C, 0x71, 0xC0, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C,
  0x73, 0xCE, 0x38, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x3E,
  0x1F, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x8E, 0x73, 0xCE,
  0xF1, 0xDC, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0x71, 0xEE, 0x39, 0xE7,
  0x1C, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x73, 0xCE,
  0x38, 0x3B, 0x8C, 0x7F, 0xFC, 0xFF, 0xF9, 0xCF, 0x73, 0x9C, 0xEE, 0x39,
  0xDC, 0xF3, 0xB9, 0xC7, 0x73, 0x9D, 0xE7, 0x3B, 0x8E, 0x77, 0x38, 0xE0,
  0x39, 0x8F, 0xF3, 0xFC, 0xE7, 0x39, 0xDC, 0x77, 0x1D, 0xCE, 0x73, 0xBC,
  0xEE, 0x3B, 0x9E, 0x0E, 0x1F, 0x9F, 0xEE, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF,
  0xE7, 0x77, 0xBF, 0x8F, 0x80, 0x1D, 0xC3, 0xFC, 0x7F, 0x8E, 0x71, 0xCE,
  0x71, 0xCE, 0x39, 0xCF, 0x39, 0xCF, 0xF9, 0xFE, 0x3B, 0x87, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0xE3, 0xDC, 0xFF, 0x1C, 0xE7, 0x1C,
  0xE3, 0x9C, 0x73, 0x9C, 0xF3, 0x8E, 0xF1, 0xFE, 0x3F, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x00, 0x3B, 0x9F, 0x8F, 0xC7, 0xE3, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x00, 0x0E, 0x1F, 0xDF, 0xCE, 0x27,
  0x81, 0xE0, 0xF8, 0x1C, 0x0E, 0x6F, 0x3F, 0x9F, 0x80, 0x18, 0x70, 0xFF,
  0xFF, 0xEE, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x4F, 0x9F, 0x00, 0x71, 0xDC,
  0x77, 0x39, 0xCE, 0xF3, 0xB8, 0xEE, 0x7B, 0x9C, 0xE7, 0x3B, 0xCF, 0xF3,
  0xD8, 0xE3, 0xF8, 0xEE, 0x3B, 0x9C, 0xE7, 0x1B, 0x86, 0xE1, 0xF0, 0x7C,
  0x1E, 0x07, 0x81, 0xC0, 0xE3, 0x8F, 0xCF, 0x3B, 0x9E, 0x77, 0x3D, 0xCE,
  0xDB, 0x9D, 0xB7, 0x3F, 0x7C, 0x7D, 0xF8, 0xFB, 0xE1, 0xF7, 0xC3, 0xCF,
  0x07, 0x9E, 0x00, 0x3C, 0xF1, 0xCE, 0x1D, 0xC1, 0xDC, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xB8, 0x73, 0x8F, 0x38, 0x38, 0xF3, 0x8E,
  0x38, 0xE3, 0x9C, 0x19, 0xC1, 0xB8, 0x1B, 0x81, 0xB0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x00, 0x1F,
  0xC7, 0xF3, 0xF8, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1F, 0xC7,
  0xF3, 0xFC, 0x07, 0x87, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0xF8,
  0x78, 0x1E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E,
  0x0E, 0x1C, 0x0E, 0x0F, 0x0F, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0x78, 0xF0,
  0xE0, 0xF8, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 6, 0, -15 },
  { 13, 8, 5, 9, 2, -15 },
  { 18, 12, 15, 11, 0, -15 },
  { 41, 10, 17, 10, 0, -16 },
  { 63, 15, 15, 17, 1, -15 },
  { 92, 13, 15, 13, 0, -15 },
  { 117, 4, 5, 5, 2, -15 },
  { 120, 8, 18, 6, 0, -15 },
  { 138, 8, 18, 6, -2, -15 },
  { 156, 8, 9, 10, 2, -16 },
  { 165, 9, 11, 11, 1, -13 },
  { 178, 5, 6, 6, -1, -3 },
  { 182, 6, 3, 6, 0, -7 },
  { 185, 4, 3, 6, 0, -3 },
  { 187, 11, 15, 8, -1, -15 },
  { 208, 9, 15, 10, 1, -15 },
  { 225, 8, 15, 10, 2, -15 },
  { 240, 11, 15, 10, -1, -15 },
  { 261, 10, 15, 10, 0, -15 },
  { 280, 10, 15, 10, 0, -15 },
  { 299, 10, 15, 10, 0, -15 },
  { 318, 10, 15, 10, 1, -15 },
  { 337, 10, 15, 10, 1, -15 },
  { 356, 10, 15, 10, 0, -15 },
  { 375, 10, 15, 10, 0, -15 },
  { 394, 6, 12, 6, 0, -12 },
  { 403, 7, 15, 6, -1, -12 },
  { 417, 9, 11, 11, 1, -13 },
  { 430, 9, 7, 11, 1, -11 },
  { 438, 9, 11, 11, 1, -13 },
  { 451, 8, 15, 8, 1, -15 },
  { 466, 14, 17, 15, 1, -15 },
  { 496, 11, 15, 11, -1, -15 },
  { 517, 11, 15, 11, 0, -15 },
  { 538, 11, 15, 11, 1, -15 },
  { 559, 12, 15, 12, 0, -15 },
  { 582, 10, 15, 9, 0, -15 },
  { 601, 10, 15, 9, 0, -15 },
  { 620, 12, 15, 12, 1, -15 },
  { 643, 13, 15, 12, 0, -15 },
  { 668, 10, 15, 8, -1, -15 },
  { 687, 10, 20, 6, -3, -15 },
  { 712, 13, 15, 11, 0, -15 },
  { 737, 8, 15, 9, 0, -15 },
  { 752, 17, 15, 16, 0, -15 },
  { 784, 14, 15, 13, 0, -15 },
  { 811, 12, 15, 13, 1, -15 },
  { 834, 11, 15, 11, 0, -15 },
  { 855, 12, 19, 13, 1, -15 },
  { 884, 11, 15, 11, 0, -15 },
  { 905, 10, 15, 10, 0, -15 },
  { 924, 9, 15, 9, 2, -15 },
  { 941, 12, 15, 12, 1, -15 },
  { 964, 11, 15, 11, 2, -15 },
  { 985, 16, 15, 16, 2, -15 },
  { 1015, 13, 15, 11, -1, -15 },
  { 1040, 10, 15, 10, 2, -15 },
  { 1059, 12, 15, 9, -1, -15 },
  { 1082, 9, 18, 6, -1, -15 },
  { 1103, 5, 15, 8, 2, -15 },
  { 1113, 9, 18, 6, -2, -15 },
  { 1134, 10, 10, 10, 0, -15 },
  { 1147, 8, 2, 8, -2, 2 },
  { 1149, 4, 3, 7, 3, -16 },
  { 1151, 11, 12, 11, 0, -12 },
  { 1168, 10, 16, 11, 0, -16 },
  { 1188, 8, 12, 9, 1, -12 },
  { 1200, 12, 16, 11, 0, -16 },
  { 1224, 9, 12, 10, 1, -12 },
  { 1238, 11, 21, 7, -2, -16 },
  { 1267, 11, 17, 11, 0, -12 },
  { 1291, 10, 16, 11, 0, -16 },
  { 1311, 6, 16, 5, 0, -16 },
  { 1323, 9, 21, 5, -3, -16 },
  { 1347, 11, 16, 10, 0, -16 },
  { 1369, 6, 16, 5, 0, -16 },
  { 1381, 15, 12, 16, 0, -12 },
  { 1404, 10, 12, 11, 0, -12 },
  { 1419, 9, 12, 11, 1, -12 },
  { 1433, 11, 17, 11, -1, -12 },
  { 1457, 11, 17, 11, 0, -12 },
  { 1481, 9, 12, 8, 0, -12 },
  { 1495, 9, 12, 9, 0, -12 },
  { 1509, 7, 14, 7, 1, -14 },
  { 1522, 10, 12, 11, 1, -12 },
  { 1537, 10, 12, 10, 1, -12 },
  { 1552, 15, 12, 15, 1, -12 },
  { 1575, 12, 12, 10, -1, -12 },
  { 1593, 12, 17, 10, -1, -12 },
  { 1619, 10, 12, 8, -1, -12 },
  { 1634, 9, 18, 7, 0, -15 },
  { 1655, 3, 21, 9, 3, -16 },
  { 1663, 8, 18, 7, -1, -15 },
  { 1681, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC21PT7B_H_
