#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC68PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xFC, 0xFF,
  0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xF1, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x02, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0xE3,
  0xF0, 0x07, 0xFC, 0x70, 0x30, 0x03, 0xFE, 0x78, 0x08, 0x03, 0xFF, 0x3C,
  0x00, 0x01, 0xFF, 0x9E, 0x00, 0x00, 0xFF, 0xCE, 0x00, 0x00, 0x7F, 0xF7,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xDF, 0xFC, 0x00, 0x00, 0xE7, 0xFE, 0x00,
  0x00, 0xF3, 0xFF, 0x04, 0x00, 0x79, 0xFF, 0x83, 0x00, 0x3C, 0xFF, 0xC1,
  0xC0, 0x1C, 0x7F, 0xC0, 0xF8, 0x1E, 0x7F, 0xE0, 0x7F, 0x8F, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF1, 0xFE,
  0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0xFC, 0x1F, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC,
  0x7F, 0xFC, 0xFF, 0x3F, 0xC7, 0xF8, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xF1,
  0xFF, 0xFE, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xC7, 0xFC, 0xFF, 0x3F, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x80, 0x3F,
  0xC7, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF, 0xEF, 0xFE, 0x7F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0xF1, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x3F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x08, 0x07, 0xF8, 0x00, 0x60, 0x3F,
  0xC0, 0x07, 0xC1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFF, 0x7F, 0x01,
  0x9F, 0xFF, 0xF9, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xEF, 0xF0, 0x0F,
  0xFE, 0x7F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x01, 0xF0,
  0x7F, 0xE0, 0x07, 0x01, 0xFC, 0x00, 0x18, 0x0F, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0x81, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x07,
  0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F,
  0xE7, 0xFF, 0x00, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFF,
  0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF1,
  0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0x0F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE1, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF3, 0xFF, 0xDF, 0xF0, 0xFF, 0xDF, 0xF8, 0x3F, 0xCF, 0xFC, 0x1F,
  0x87, 0xFE, 0x07, 0x87, 0xFF, 0x01, 0x83, 0xFF, 0x00, 0x81, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC,
  0x00, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x7F, 0xF0, 0x01, 0xC0, 0x0F,
  0xFC, 0x00, 0x10, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3E, 0x03, 0xFF, 0xC0, 0x0C, 0x00, 0xFF,
  0xE0, 0x04, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC2, 0x00, 0x01, 0xFF, 0xC1, 0xC0, 0x01, 0xFF, 0xE0,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xFE, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x3F, 0xF0, 0x00, 0x3F, 0xCF, 0xFC, 0x00,
  0x1F, 0xE3, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0xE0,
  0x01, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0x81, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x0F,
  0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFD,
  0xFF, 0xFC, 0x00, 0x20, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x04, 0x00, 0x07, 0xFF, 0x02,
  0x00, 0x07, 0xFF, 0x81, 0xC0, 0x07, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFA, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x3E, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x1F, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF8,
  0x03, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0,
  0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFE,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF,
  0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x9F, 0xF8,
  0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xE0,
  0x3F, 0xF0, 0xE0, 0x0F, 0xFC, 0x20, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0xFE,
  0x07, 0xF8, 0x07, 0xFF, 0xF8, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0xFE,
  0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x7E,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0x7E,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFE,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE,
  0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC,
  0x7E, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF8,
  0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0xFE, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xFF, 0xDF, 0xFF, 0x80,
  0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x0F,
  0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xF8,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0,
  0x0F, 0xFF, 0x80, 0x18, 0x03, 0xFF, 0xE0, 0x01, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x20, 0x03, 0xFF, 0xC0, 0x1C, 0x00, 0x7F,
  0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x0F, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFF,
  0x00, 0x1C, 0x01, 0xFF, 0xF0, 0x00, 0x10, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x31, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xF8,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x03,
  0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xC0, 0x0F, 0xF9, 0xFE, 0x0F, 0xFB, 0xFF,
  0x00, 0x3F, 0xE7, 0xF8, 0x3F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xE1, 0xFF,
  0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x87, 0xF9, 0xFF, 0x80, 0x1F, 0xF9, 0xFE,
  0x1F, 0xE7, 0xFE, 0x00, 0x7F, 0xE7, 0xF8, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x9F, 0xF3, 0xFF, 0x00,
  0x3F, 0xF1, 0xFE, 0x7F, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFB, 0xFE, 0x3F,
  0xF0, 0x03, 0xFF, 0x1F, 0xEF, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xFC, 0x3F, 0xF0,
  0x03, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xDF, 0xF0,
  0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x87, 0xFE,
  0x00, 0x7F, 0xC7, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xF1, 0xFF, 0x00,
  0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0xFF, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0x07, 0xFE,
  0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0xFF, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x3F, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0xBF,
  0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x1F, 0xFF, 0x80,
  0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC7,
  0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0x7F,
  0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFE,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x1F,
  0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xC0, 0x0F, 0xFE, 0x00, 0x30, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x80, 0x00, 0x7F, 0xF0, 0x18, 0x00, 0x3F, 0xF8,
  0x07, 0x80, 0x0F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7A, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC,
  0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xC3, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00,
  0x7F, 0xDF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0xFC, 0x3F,
  0xDF, 0xE1, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x7F, 0x87, 0xFE, 0x00, 0x7F,
  0xC7, 0xFD, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x1F, 0xE7, 0xF8, 0xFF, 0xC0,
  0x07, 0xFC, 0xFF, 0x9F, 0xE3, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x7F, 0x9F,
  0xF8, 0x00, 0x7F, 0xCF, 0xF1, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xC7,
  0xFB, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x1F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x1F, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFE, 0x3F,
  0xE0, 0x3F, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFF, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0xF0,
  0x07, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x01,
  0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xDF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F,
  0xFE, 0x1F, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xBF, 0xFF, 0xC0, 0x7F, 0xCF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0xC0, 0x1F,
  0xE0, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x38, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x40, 0xFF, 0xE0,
  0x1C, 0x0F, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xDF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFF,
  0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xE7, 0xFC, 0x00, 0x1F, 0xFC,
  0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x0F,
  0xF8, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0x03, 0xFF, 0x80, 0x1C, 0x0F, 0xFF, 0x83, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF9, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0x9F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0xFB, 0xFE,
  0x00, 0x3F, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0x80,
  0x07, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x00, 0x30, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x08, 0x00, 0x0F, 0xFE, 0x00,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x01,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x39, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xC3, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xF3, 0xFF, 0xE1, 0xFF, 0xF0, 0x07, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x01,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x87, 0xFE, 0x00, 0x7F, 0xCF, 0xFF, 0x80, 0x3F, 0xCF, 0xFF,
  0xE0, 0x1F, 0xE7, 0xFF, 0xF0, 0x0F, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE1,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE,
  0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF7, 0xFF, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x0F,
  0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xCF, 0xFC,
  0x07, 0xFF, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x87,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xFC,
  0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xFF, 0x00,
  0x0F, 0xF7, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x3F, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x7F, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xF0, 0x00, 0xFF,
  0xCF, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x38, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xFE, 0x3F, 0xE0, 0x1F,
  0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xDF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0,
  0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x0F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xDF, 0xF8, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x0F,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0xFF,
  0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFE,
  0x0F, 0x80, 0xFF, 0xE0, 0x18, 0x0F, 0xFC, 0x00, 0x80, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x08, 0x00, 0x7F, 0xF0, 0xC0, 0x07, 0xFF, 0x0F,
  0x80, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x10, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0x9F, 0xF0,
  0x07, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE,
  0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x07,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFF,
  0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFB, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xE7, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xCF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0x07, 0xFE,
  0x3F, 0xF0, 0x7F, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xF8, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x3F, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x7F, 0x7F, 0x0F, 0xF8, 0x1F, 0xF1, 0xFE, 0xFE, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFD, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xF3, 0xF9, 0xFF, 0x80, 0xFF,
  0x9F, 0xEF, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0x9F, 0xE7, 0xFC, 0x03, 0xFE,
  0xFF, 0x3F, 0xDF, 0xF8, 0x07, 0xFD, 0xFE, 0x7F, 0xBF, 0xE0, 0x0F, 0xFB,
  0xF8, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x67, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x17, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE8, 0x00, 0x1F, 0xFF, 0x20, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 21, 50, 18, 0, -49 },
  { 133, 26, 18, 29, 6, -49 },
  { 192, 39, 49, 37, 0, -49 },
  { 431, 33, 56, 33, 1, -52 },
  { 662, 48, 50, 54, 4, -49 },
  { 962, 41, 50, 41, 0, -49 },
  { 1219, 13, 18, 17, 6, -49 },
  { 1249, 25, 60, 20, 1, -49 },
  { 1437, 24, 61, 20, -5, -50 },
  { 1620, 29, 31, 31, 5, -52 },
  { 1733, 30, 32, 35, 3, -40 },
  { 1853, 17, 18, 18, -4, -9 },
  { 1892, 19, 9, 21, 1, -23 },
  { 1914, 12, 12, 18, 0, -11 },
  { 1932, 37, 50, 27, -4, -49 },
  { 2164, 31, 50, 33, 2, -49 },
  { 2358, 25, 49, 33, 6, -49 },
  { 2512, 35, 49, 33, -2, -49 },
  { 2727, 33, 50, 33, 0, -49 },
  { 2934, 34, 49, 33, -1, -49 },
  { 3143, 33, 50, 33, 1, -49 },
  { 3350, 33, 50, 33, 2, -49 },
  { 3557, 34, 48, 33, 2, -48 },
  { 3761, 33, 50, 33, 1, -49 },
  { 3968, 32, 50, 33, 1, -49 },
  { 4168, 18, 39, 18, 0, -38 },
  { 4256, 22, 47, 18, -4, -38 },
  { 4386, 30, 35, 35, 3, -42 },
  { 4518, 30, 22, 35, 3, -35 },
  { 4601, 30, 35, 35, 3, -42 },
  { 4733, 26, 50, 26, 3, -49 },
  { 4896, 48, 55, 50, 2, -49 },
  { 5226, 37, 49, 37, -4, -49 },
  { 5453, 37, 49, 36, 0, -49 },
  { 5680, 35, 50, 34, 3, -49 },
  { 5899, 38, 49, 39, 0, -49 },
  { 6132, 34, 49, 31, 0, -49 },
  { 6341, 34, 49, 30, 0, -49 },
  { 6550, 38, 50, 40, 3, -49 },
  { 6788, 42, 49, 40, 0, -49 },
  { 7046, 32, 49, 25, -3, -49 },
  { 7242, 32, 64, 20, -11, -49 },
  { 7498, 42, 49, 36, 0, -49 },
  { 7756, 26, 49, 29, 0, -49 },
  { 7916, 54, 49, 52, 0, -49 },
  { 8247, 45, 49, 43, 0, -49 },
  { 8523, 38, 50, 41, 3, -49 },
  { 8761, 37, 49, 35, 0, -49 },
  { 8988, 38, 61, 41, 3, -49 },
  { 9278, 36, 49, 36, 0, -49 },
  { 9499, 34, 50, 31, 0, -49 },
  { 9712, 31, 49, 31, 5, -49 },
  { 9902, 38, 50, 39, 3, -49 },
  { 10140, 36, 49, 36, 6, -49 },
  { 10361, 54, 49, 53, 5, -49 },
  { 10692, 44, 49, 35, -4, -49 },
  { 10962, 34, 49, 34, 6, -49 },
  { 11171, 38, 49, 31, -3, -49 },
  { 11404, 29, 60, 21, -3, -49 },
  { 11622, 16, 50, 27, 7, -49 },
  { 11722, 28, 60, 21, -5, -49 },
  { 11932, 32, 31, 32, 0, -49 },
  { 12056, 26, 6, 25, -6, 5 },
  { 12076, 14, 11, 22, 10, -52 },
  { 12096, 33, 39, 35, 2, -38 },
  { 12257, 33, 53, 35, 0, -52 },
  { 12476, 28, 39, 28, 2, -38 },
  { 12613, 36, 53, 35, 2, -52 },
  { 12852, 30, 39, 33, 2, -38 },
  { 12999, 37, 68, 22, -7, -52 },
  { 13314, 36, 54, 35, -1, -38 },
  { 13557, 33, 52, 35, 0, -52 },
  { 13772, 21, 52, 18, 0, -52 },
  { 13909, 30, 68, 18, -9, -52 },
  { 14164, 37, 52, 34, 0, -52 },
  { 14405, 21, 52, 18, 0, -52 },
  { 14542, 50, 38, 52, 0, -38 },
  { 14780, 33, 38, 35, 0, -38 },
  { 14937, 30, 39, 34, 2, -38 },
  { 15084, 37, 54, 35, -4, -38 },
  { 15334, 33, 54, 35, 2, -38 },
  { 15557, 28, 38, 25, 0, -38 },
  { 15690, 28, 39, 28, 0, -38 },
  { 15827, 23, 46, 24, 3, -45 },
  { 15960, 33, 38, 35, 2, -37 },
  { 16117, 31, 37, 31, 4, -37 },
  { 16261, 47, 37, 47, 4, -37 },
  { 16479, 39, 37, 32, -4, -37 },
  { 16660, 40, 53, 31, -5, -37 },
  { 16925, 31, 37, 27, -2, -37 },
  { 17069, 28, 60, 24, 0, -49 },
  { 17279, 9, 68, 30, 10, -52 },
  { 17356, 27, 60, 24, -4, -49 },
  { 17559, 30, 12, 35, 3, -30 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC68PT7B_H_
