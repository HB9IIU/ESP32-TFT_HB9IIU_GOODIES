#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC22PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC0, 0x02,
  0x1E, 0x3C, 0x70, 0x77, 0xBB, 0x9D, 0xDC, 0xEE, 0x67, 0x70, 0x07, 0x70,
  0x3B, 0x81, 0x98, 0x0C, 0xC0, 0xEE, 0x9F, 0xF9, 0xFF, 0xC3, 0xB8, 0x19,
  0x87, 0xFF, 0x3F, 0xF9, 0xFF, 0xC3, 0x30, 0x3B, 0x81, 0xDC, 0x0C, 0xC0,
  0x01, 0x00, 0x20, 0x3F, 0x0F, 0xF3, 0xFC, 0x74, 0x8E, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE4, 0xFC, 0xFF, 0x3F, 0xE3, 0xF0, 0x08, 0x03,
  0x00, 0x1C, 0x1C, 0x3E, 0x18, 0x76, 0x38, 0x66, 0x30, 0xE6, 0x60, 0xEE,
  0xE0, 0xEE, 0xCC, 0xED, 0xDE, 0xFF, 0xBF, 0x73, 0x77, 0x07, 0x77, 0x06,
  0x67, 0x0E, 0x66, 0x1C, 0x6E, 0x18, 0x7C, 0x38, 0x38, 0x07, 0x80, 0x7E,
  0x07, 0xF8, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x7E, 0x03, 0xE7, 0x3F, 0x3B,
  0xFB, 0x9D, 0xFD, 0xE7, 0xCF, 0x3E, 0x7F, 0xF1, 0xFF, 0x8F, 0xDE, 0x77,
  0x7E, 0xEE, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x0E, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0xF0, 0x0C, 0x0E, 0x37, 0x1F, 0xBF, 0xF8, 0xFD, 0xF1,
  0xFC, 0x6F, 0x12, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF,
  0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3B, 0xDC, 0xEE, 0x70, 0x7F, 0xFF,
  0xC0, 0x2F, 0xFE, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x0F, 0x07, 0xE3, 0xF9, 0xEF, 0x73, 0xDC, 0xFF, 0x3F,
  0x8E, 0xE3, 0xB8, 0xEE, 0x7B, 0x9C, 0xE7, 0x3F, 0x8F, 0xE1, 0xF0, 0x07,
  0x0F, 0x1F, 0x7E, 0xFE, 0x6E, 0x4E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x03, 0xC0, 0xFE, 0x1F, 0xE0, 0xCF, 0x08, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFC,
  0x7F, 0xCF, 0xF8, 0x0F, 0x87, 0xF8, 0x7F, 0x88, 0xF0, 0x1E, 0x03, 0x81,
  0xE0, 0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x01, 0xC8, 0x39, 0xFF, 0x3F, 0xC7,
  0xF0, 0x01, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x1B, 0x87, 0xE1, 0xDC,
  0x33, 0x8C, 0x73, 0xFF, 0x7F, 0xEF, 0xFC, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0xE3, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x70, 0x0F, 0xC1, 0xFC, 0x3F, 0x80,
  0x78, 0x0F, 0x01, 0xC8, 0x79, 0xFF, 0x3F, 0xC7, 0xF0, 0x07, 0xC3, 0xF1,
  0xFC, 0xF0, 0x78, 0x1C, 0x07, 0xF3, 0xFE, 0xF7, 0xB8, 0xEE, 0x3B, 0x9E,
  0xE7, 0x3F, 0xCF, 0xE1, 0xF0, 0x3F, 0xEF, 0xFD, 0xFF, 0x01, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0,
  0x3C, 0x07, 0x00, 0x07, 0x83, 0xF8, 0x7F, 0x9E, 0x73, 0x8E, 0x7B, 0x87,
  0xF0, 0xF8, 0x3F, 0x8F, 0x71, 0xCF, 0x79, 0xEE, 0x39, 0xEF, 0x1F, 0xC1,
  0xF0, 0x07, 0x83, 0xF8, 0xFF, 0x1C, 0xE3, 0x9E, 0xF3, 0xDE, 0x73, 0xDE,
  0x7F, 0xC7, 0xB8, 0x6E, 0x01, 0xC0, 0x71, 0xFE, 0x3F, 0x87, 0xE0, 0x3C,
  0xF3, 0x84, 0x00, 0x00, 0x00, 0x23, 0xCF, 0x38, 0x0E, 0x3C, 0x70, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0x00, 0x00, 0xC0,
  0xF0, 0xF8, 0xF8, 0xF8, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x70, 0x04,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x3C, 0x0F,
  0xC0, 0xFC, 0x07, 0xC1, 0xF1, 0xF9, 0xF8, 0xF0, 0x30, 0x08, 0x00, 0x1E,
  0x7F, 0x7F, 0x47, 0x07, 0x07, 0x1E, 0x3C, 0x38, 0x70, 0x70, 0x00, 0x20,
  0xF0, 0xF0, 0xE0, 0x01, 0xE0, 0x0F, 0xF0, 0x78, 0x71, 0xC0, 0x73, 0x1F,
  0x6C, 0xFC, 0xD9, 0x99, 0xF7, 0x33, 0xCC, 0xE7, 0x99, 0x9B, 0x73, 0x36,
  0xEE, 0xCC, 0xFF, 0x98, 0x84, 0x38, 0x00, 0x38, 0x60, 0x3F, 0xC0, 0x1E,
  0x00, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE1, 0xCE, 0x3F, 0xE3, 0xFE, 0x78, 0xE7, 0x0F, 0xF0, 0xFE,
  0x0F, 0x1F, 0x81, 0xFE, 0x1F, 0xF1, 0xCF, 0x1C, 0xF3, 0xCE, 0x39, 0xE3,
  0xFC, 0x3F, 0xC7, 0x9C, 0x79, 0xE7, 0x1E, 0x71, 0xC7, 0xFC, 0xFF, 0x8F,
  0xF0, 0x07, 0xC1, 0xFC, 0x7F, 0x9E, 0x27, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x78, 0x0F, 0x09, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F,
  0x81, 0xFE, 0x1F, 0xF1, 0xCF, 0x1C, 0x73, 0xC7, 0x38, 0x73, 0x87, 0x38,
  0xF7, 0x8F, 0x78, 0xE7, 0x1E, 0x73, 0xC7, 0xFC, 0xFF, 0x8F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xFE, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xFC, 0x3F, 0x8F, 0xF1, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0x1F, 0xF3,
  0xC2, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x3E, 0xF3, 0xEF, 0x7E, 0xE1, 0xEF,
  0x1C, 0xF1, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x1E, 0x3C, 0x78, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x78, 0xF1, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0x1F,
  0xC7, 0xF0, 0xF8, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x0F, 0x0F, 0xE3, 0xF8, 0x01, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x0F, 0x0F, 0xC3, 0xE0, 0xE0, 0x00, 0x1E, 0x3C,
  0x71, 0xE1, 0xCF, 0x07, 0x38, 0x1D, 0xE0, 0xFF, 0x03, 0xB8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C,
  0x3C, 0x70, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78,
  0x78, 0x70, 0x70, 0x7F, 0xFF, 0xFF, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF3, 0xF0, 0xFC, 0xDC,
  0x3F, 0x77, 0x1F, 0xDB, 0xC7, 0x7E, 0xE1, 0xDF, 0xB8, 0x77, 0xCE, 0x1C,
  0xF3, 0x8E, 0x39, 0xE3, 0x8E, 0x70, 0x1E, 0x0E, 0x3C, 0x38, 0x7C, 0x70,
  0xF8, 0xE1, 0xF1, 0xC7, 0xE7, 0x8E, 0xEE, 0x1D, 0xDC, 0x3B, 0xB8, 0xF7,
  0x71, 0xCE, 0xC3, 0x8F, 0x87, 0x1F, 0x0E, 0x3E, 0x38, 0x7C, 0x70, 0xF0,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x78, 0x77, 0x87, 0x70, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xF0,
  0x1F, 0x81, 0xFE, 0x1F, 0xE1, 0xCF, 0x1C, 0xF3, 0xCF, 0x38, 0xE3, 0x9E,
  0x3F, 0xC7, 0xF8, 0x7E, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x78, 0x77, 0x87, 0x70, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xEE, 0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x1F, 0x81, 0xFE, 0x1F, 0xE1, 0xCF,
  0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0xFE, 0x3F, 0xC7, 0xF8, 0x7B, 0x87, 0x38,
  0x73, 0x87, 0x3C, 0xF3, 0xCF, 0x1C, 0x07, 0xC3, 0xFC, 0x7F, 0x1E, 0x23,
  0x80, 0x78, 0x0F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xC8, 0x79,
  0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xEF, 0xF8, 0x70, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0x3C, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x1E,
  0x71, 0xEF, 0x1C, 0xF1, 0xCE, 0x1C, 0xF3, 0xCF, 0xF8, 0x7F, 0x83, 0xE0,
  0xE0, 0xFC, 0x3F, 0x87, 0x70, 0xEE, 0x3D, 0xC7, 0x39, 0xE7, 0x38, 0xEF,
  0x1D, 0xC3, 0xB8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xE1, 0xC3,
  0xF0, 0xE3, 0xF8, 0xF1, 0xDC, 0x79, 0xEE, 0x7C, 0xE7, 0x3E, 0x73, 0x9F,
  0x79, 0xDF, 0xB8, 0xED, 0xDC, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0x3F, 0x0F,
  0x9F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x1E, 0x3C, 0x38, 0xE0,
  0xE7, 0x83, 0xBC, 0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xC1, 0xE7, 0x07, 0x1E, 0x3C, 0x78,
  0xE1, 0xFE, 0x3B, 0xCF, 0x3B, 0xC7, 0x70, 0xFE, 0x1F, 0x83, 0xF0, 0x7C,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0x0F, 0xF1,
  0xFF, 0x1F, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0xFC, 0xFF, 0x8F, 0xF8, 0x0F, 0x87,
  0xC3, 0xE1, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x3E, 0x3E, 0x1F, 0x00, 0xE7, 0x18, 0xE7,
  0x39, 0xCE, 0x71, 0x8E, 0x73, 0x9C, 0xE7, 0x0F, 0xC3, 0xE0, 0xF8, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x1F, 0x07, 0xC3, 0xE0, 0x03, 0x01, 0xC0, 0x70,
  0x3E, 0x0F, 0x87, 0x63, 0x98, 0xC7, 0x71, 0xF8, 0x30, 0xFF, 0xFF, 0x80,
  0xF3, 0x8C, 0x70, 0x3D, 0xDF, 0xF7, 0xFF, 0xCF, 0xF3, 0xB8, 0xEE, 0x3B,
  0x9E, 0xE7, 0x3F, 0xCF, 0xF1, 0xDC, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x7F, 0x8F, 0xF1, 0xEF, 0x39, 0xE7, 0x3D, 0xC7, 0xB8, 0xE7, 0x1C,
  0xE7, 0xBF, 0xE7, 0xFC, 0xEF, 0x00, 0x1F, 0x9F, 0x9E, 0xDE, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE2, 0x7F, 0x3F, 0x8F, 0x80, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x7B, 0x8F, 0xF3, 0xFE, 0xF3, 0xDE, 0x73, 0x8E, 0x71,
  0xCE, 0x39, 0xCE, 0x3F, 0xC7, 0xF8, 0x77, 0x00, 0x1F, 0x1F, 0xDE, 0xFE,
  0x7E, 0x7F, 0xFB, 0xF9, 0xC0, 0xE0, 0x79, 0x3F, 0x8F, 0xC0, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x78, 0x07, 0x00, 0xFC, 0x1F, 0xC1, 0xFC, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x1E, 0xE3, 0xFC, 0xFF, 0xBC,
  0xF7, 0x9C, 0xE3, 0x9C, 0x73, 0x9E, 0xF3, 0x8F, 0xF1, 0xFE, 0x3D, 0xC0,
  0x78, 0x0E, 0x33, 0xC7, 0xF0, 0xFC, 0x00, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x7F, 0x8F, 0xF9, 0xFF, 0x39, 0xE7, 0x39, 0xE7, 0x38, 0xE7,
  0x1C, 0xE7, 0xBC, 0xE7, 0x9C, 0xE3, 0x80, 0x0C, 0x3C, 0x70, 0x40, 0x07,
  0x8E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x3C, 0x78, 0xE0, 0x01, 0x80,
  0xF0, 0x38, 0x04, 0x00, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC3, 0xF0, 0xF8,
  0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xCF, 0x39,
  0xE3, 0xBC, 0x3B, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x78, 0xF7,
  0x8E, 0x38, 0xE3, 0xC0, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38,
  0x71, 0xE3, 0x87, 0x0E, 0x3C, 0x78, 0xE0, 0x3B, 0xDF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x39, 0xE7, 0x39, 0xC7, 0x79, 0xCF, 0x71, 0xCE, 0x73, 0xCE, 0x73,
  0x8E, 0xF3, 0x8E, 0xF3, 0x9E, 0xE3, 0x9C, 0x3B, 0xC7, 0xFC, 0xFF, 0x9C,
  0xF3, 0x9C, 0xF3, 0x9C, 0x73, 0x8E, 0x73, 0xDE, 0x73, 0xCE, 0x71, 0xC0,
  0x1F, 0x1F, 0xDE, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xFF, 0xBF,
  0x8F, 0x80, 0x1D, 0xE1, 0xFE, 0x1E, 0xF1, 0xCF, 0x1C, 0xF3, 0x8F, 0x38,
  0xE3, 0x8E, 0x39, 0xE7, 0xFC, 0x7F, 0xC7, 0x78, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x00, 0x1F, 0xCF, 0xF7, 0xFD, 0xCF, 0xF3, 0xB8, 0xEE,
  0x3B, 0x8E, 0xE7, 0x3F, 0xCF, 0xF3, 0xDC, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x1E, 0x00, 0x3B, 0x9F, 0xCF, 0xC7, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0x70,
  0x78, 0x3C, 0x1C, 0x00, 0x1F, 0x9F, 0xDE, 0x4F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x7F, 0xBF, 0x9F, 0x80, 0x1C, 0x30, 0xE3, 0xFF, 0xFF, 0xDC,
  0x38, 0x71, 0xE3, 0x87, 0x0F, 0x9F, 0x1E, 0x00, 0x79, 0xDC, 0x77, 0x1D,
  0xCF, 0xF3, 0xBC, 0xEE, 0x3B, 0x9E, 0xE7, 0xBF, 0xCF, 0xF3, 0xDC, 0xE1,
  0xF8, 0xFE, 0x3B, 0xDE, 0x77, 0x1F, 0xC7, 0xE1, 0xB8, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0xE3, 0xCF, 0xCF, 0x9F, 0x9E, 0x77, 0x3C, 0xEE, 0xFB, 0x9D,
  0xB7, 0x3B, 0x6E, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xC7, 0x87, 0x8E,
  0x00, 0x1C, 0xF1, 0xCE, 0x1F, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x0F, 0x01,
  0xF8, 0x3F, 0x83, 0xB8, 0x73, 0x8F, 0x3C, 0x1E, 0x38, 0xF3, 0xC7, 0x9C,
  0x1D, 0xE0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0xC7, 0xF3, 0xFC, 0x1E, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x1F, 0xC7,
  0xF3, 0xFC, 0x01, 0x83, 0xC3, 0xE1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x7C,
  0x78, 0x3C, 0x0F, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x3E, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x0F, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x83, 0x83, 0xC3, 0xC3, 0xC1,
  0xC0, 0xE0, 0x70, 0x78, 0x78, 0x3C, 0x00, 0x70, 0x7F, 0xBF, 0xFE, 0x3E,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 9, 6, 9, 2, -16 },
  { 22, 13, 16, 12, 0, -16 },
  { 48, 11, 18, 11, 0, -17 },
  { 73, 16, 16, 17, 1, -16 },
  { 105, 13, 16, 13, 0, -16 },
  { 131, 4, 6, 5, 2, -16 },
  { 134, 8, 19, 7, 0, -16 },
  { 153, 8, 19, 7, -2, -16 },
  { 172, 9, 10, 10, 2, -17 },
  { 184, 10, 11, 11, 1, -13 },
  { 198, 5, 6, 6, -1, -3 },
  { 202, 6, 3, 7, 0, -7 },
  { 205, 4, 4, 6, 0, -4 },
  { 207, 12, 16, 9, -1, -16 },
  { 231, 10, 16, 11, 1, -16 },
  { 251, 8, 16, 11, 2, -16 },
  { 267, 12, 16, 11, -1, -16 },
  { 291, 11, 16, 11, 0, -16 },
  { 313, 11, 16, 11, 0, -16 },
  { 335, 11, 16, 11, 0, -16 },
  { 357, 10, 16, 11, 1, -16 },
  { 377, 11, 16, 11, 1, -16 },
  { 399, 11, 16, 11, 0, -16 },
  { 421, 11, 16, 11, 0, -16 },
  { 443, 6, 12, 6, 0, -12 },
  { 452, 7, 15, 6, -1, -12 },
  { 466, 10, 11, 11, 1, -13 },
  { 480, 10, 7, 11, 1, -11 },
  { 489, 10, 11, 11, 1, -13 },
  { 503, 8, 16, 9, 1, -16 },
  { 519, 15, 18, 16, 1, -16 },
  { 553, 12, 16, 12, -1, -16 },
  { 577, 12, 16, 12, 0, -16 },
  { 601, 11, 16, 11, 1, -16 },
  { 623, 12, 16, 13, 0, -16 },
  { 647, 11, 16, 10, 0, -16 },
  { 669, 11, 16, 10, 0, -16 },
  { 691, 12, 16, 13, 1, -16 },
  { 715, 14, 16, 13, 0, -16 },
  { 743, 10, 16, 8, -1, -16 },
  { 763, 10, 21, 6, -3, -16 },
  { 790, 14, 16, 12, 0, -16 },
  { 818, 8, 16, 9, 0, -16 },
  { 834, 18, 16, 17, 0, -16 },
  { 870, 15, 16, 14, 0, -16 },
  { 900, 12, 16, 13, 1, -16 },
  { 924, 12, 16, 11, 0, -16 },
  { 948, 12, 20, 13, 1, -16 },
  { 978, 12, 16, 12, 0, -16 },
  { 1002, 11, 16, 10, 0, -16 },
  { 1024, 10, 16, 10, 2, -16 },
  { 1044, 12, 16, 13, 1, -16 },
  { 1068, 11, 16, 12, 2, -16 },
  { 1090, 17, 16, 17, 2, -16 },
  { 1124, 14, 16, 11, -1, -16 },
  { 1152, 11, 16, 11, 2, -16 },
  { 1174, 12, 16, 10, -1, -16 },
  { 1198, 9, 20, 7, -1, -16 },
  { 1221, 5, 16, 9, 2, -16 },
  { 1231, 10, 20, 7, -2, -16 },
  { 1256, 10, 10, 11, 0, -16 },
  { 1269, 9, 2, 8, -2, 2 },
  { 1272, 5, 4, 7, 3, -17 },
  { 1275, 10, 12, 11, 1, -12 },
  { 1290, 11, 17, 11, 0, -17 },
  { 1314, 9, 12, 9, 1, -12 },
  { 1328, 11, 17, 11, 1, -17 },
  { 1352, 9, 12, 11, 1, -12 },
  { 1366, 12, 22, 7, -2, -17 },
  { 1399, 11, 17, 11, 0, -12 },
  { 1423, 11, 17, 11, 0, -17 },
  { 1447, 7, 17, 6, 0, -17 },
  { 1462, 10, 22, 6, -3, -17 },
  { 1490, 12, 17, 11, 0, -17 },
  { 1516, 7, 17, 6, 0, -17 },
  { 1531, 16, 12, 17, 0, -12 },
  { 1555, 11, 12, 11, 0, -12 },
  { 1572, 9, 12, 11, 1, -12 },
  { 1586, 12, 17, 11, -1, -12 },
  { 1612, 10, 17, 11, 1, -12 },
  { 1634, 9, 12, 8, 0, -12 },
  { 1648, 9, 12, 9, 0, -12 },
  { 1662, 7, 15, 8, 1, -15 },
  { 1676, 10, 12, 11, 1, -12 },
  { 1691, 10, 12, 10, 1, -12 },
  { 1706, 15, 12, 15, 1, -12 },
  { 1729, 12, 12, 10, -1, -12 },
  { 1747, 13, 17, 10, -2, -12 },
  { 1775, 10, 12, 9, -1, -12 },
  { 1790, 9, 19, 8, 0, -16 },
  { 1812, 3, 22, 10, 3, -17 },
  { 1821, 9, 19, 8, -1, -16 },
  { 1843, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC22PT7B_H_
