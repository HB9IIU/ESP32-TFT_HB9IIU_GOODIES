#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x01,
  0x80, 0x00, 0x3F, 0xC7, 0xFD, 0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0x9F, 0xE1,
  0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0xFF, 0x1F, 0xC3, 0xFC,
  0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFD, 0xC7, 0xC0, 0x7F, 0x9C, 0x18, 0x07, 0xF9, 0xC0, 0x00,
  0x7F, 0x9C, 0x00, 0x07, 0xFB, 0xC0, 0x00, 0x7F, 0xB8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xEF, 0xF8, 0x00, 0x1E, 0xFF, 0x80, 0x01, 0xC7, 0xF8, 0x40,
  0x1C, 0xFF, 0x87, 0x01, 0xCF, 0xF0, 0x7C, 0x1D, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xF8,
  0x03, 0xF0, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x87, 0xE3, 0xF8, 0x3E, 0x0F, 0xE3, 0xF8, 0xFC, 0x3F, 0xE3, 0xF8,
  0xFE, 0x7F, 0x1F, 0xFC, 0xFE, 0x7F, 0x3F, 0x8F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xE7, 0xFF, 0xE7, 0xFF, 0xE7, 0xF3, 0xFF, 0xFD, 0xFF, 0xF1, 0xF8, 0xFE,
  0x7F, 0x3F, 0xF8, 0xFE, 0x7F, 0x1F, 0xC7, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0,
  0x7C, 0x1F, 0xC7, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x03,
  0xF0, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x3F,
  0x80, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC3, 0xF0, 0x01,
  0xFC, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF,
  0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xC3,
  0xFF, 0xFF, 0xDF, 0xF0, 0xFF, 0xDF, 0xFB, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF,
  0x87, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F,
  0xFF, 0x87, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0xE7, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xDF, 0x87, 0xBF, 0xFF,
  0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x01, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFD, 0xFE, 0x03, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0xC0, 0x3E, 0x1F, 0xF0, 0x0F, 0x07, 0xF0, 0x03, 0x03, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x02, 0x07,
  0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC,
  0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF,
  0xF8, 0x1F, 0xF7, 0xFC, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x7F, 0xC0, 0x7F,
  0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFC, 0xFF,
  0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8,
  0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0xFF, 0xC3, 0xFE, 0x7F,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xDF, 0xF0, 0xFE, 0x7F, 0x83, 0xF3, 0xFE, 0x07, 0x0F, 0xF8, 0x08,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xF8, 0x1F,
  0xF0, 0x07, 0x80, 0x7F, 0xC0, 0x0C, 0x01, 0xFF, 0x00, 0x20, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xF8,
  0x3F, 0xF8, 0x07, 0x00, 0xFF, 0xC0, 0x10, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x84, 0x00, 0x0F, 0xFC, 0x30, 0x00, 0xFF, 0xC1,
  0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x7F,
  0x7F, 0x80, 0x01, 0xFB, 0xFE, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x7F, 0x3F,
  0xC0, 0x01, 0xF8, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x7F, 0x1F, 0xF0,
  0x03, 0xF8, 0x7F, 0xC0, 0x0F, 0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x03,
  0xF8, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xDF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x80, 0x03, 0xFF, 0x0C, 0x00, 0xFF, 0xE0, 0xF8, 0x1F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x1F, 0x00, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0xE0, 0x3F, 0xDF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xF8, 0xFF, 0xE0, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFF,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F,
  0xE7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF,
  0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x8F,
  0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00,
  0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xE1, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xF1, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x3F, 0xE0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x7F, 0xF3,
  0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xF0, 0x1F, 0xFB, 0xFE, 0x01,
  0xFE, 0x7F, 0xC0, 0x04, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x60, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x83, 0xFE, 0x1C, 0x03, 0xFC, 0x20, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x70,
  0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xC3, 0xF8, 0x7F, 0x03, 0xFF, 0xF8, 0xFC,
  0x3F, 0x03, 0xFF, 0xF8, 0x7E, 0x3F, 0x83, 0xFF, 0xFC, 0x3F, 0x1F, 0x83,
  0xFF, 0xFE, 0x1F, 0x9F, 0xC3, 0xF8, 0x7F, 0x0F, 0xCF, 0xC1, 0xF8, 0x3F,
  0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0x83, 0xF7, 0xE0, 0xFC, 0x0F, 0xC1, 0xFB,
  0xF0, 0xFE, 0x0F, 0xE1, 0xF9, 0xF8, 0x7E, 0x07, 0xE0, 0xFD, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x7E, 0x1F, 0x81, 0xFC,
  0x1F, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x9F, 0x87, 0xE0, 0x7E, 0x0F, 0xCF,
  0xC3, 0xF0, 0x7F, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0x87, 0xE3, 0xF0, 0xFE,
  0x3F, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF0, 0x7E, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0x07, 0xFE, 0x3F, 0xF0, 0x1F,
  0x80, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x18, 0x01, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xE1, 0xF0, 0x07,
  0xFF, 0x00, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x04, 0x01,
  0xFF, 0xC0, 0x38, 0x03, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x04, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0xE0, 0x06, 0x01, 0xFF, 0xC0, 0x01,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xC0, 0xFF, 0xFC, 0x3F, 0xE0,
  0xFF, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x41,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x3F, 0xBF, 0xC0, 0x1F, 0xEF, 0xE0, 0xFF, 0x7F, 0x80, 0x3F, 0xDF,
  0xE1, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xC7, 0xFB, 0xFE, 0x00, 0xFF, 0x7F,
  0x8F, 0xE7, 0xF8, 0x03, 0xFE, 0xFF, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE,
  0x7F, 0x3F, 0xE0, 0x0F, 0xF3, 0xFD, 0xFE, 0x7F, 0xC0, 0x1F, 0xE3, 0xFB,
  0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xF7, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xFF,
  0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xF8,
  0x7F, 0x80, 0x3F, 0xE1, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xC3,
  0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xFE, 0x0F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0xFF, 0x07, 0xF8, 0x03, 0xFD, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF3, 0xFC, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x7F, 0x80, 0x3F, 0xCF,
  0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xE7, 0xFC,
  0x03, 0xFE, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0x7F, 0x9F, 0xE0, 0x0F, 0xF0,
  0xFF, 0xBF, 0xC0, 0x1F, 0xE0, 0xFF, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0xFF,
  0x00, 0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE1,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x07,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x80,
  0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x80,
  0x7F, 0xE1, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x07, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0x87, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x03,
  0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xCF, 0xE0, 0x1F,
  0xF8, 0x0E, 0x01, 0xFF, 0x80, 0x10, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x40, 0x03,
  0xFF, 0x03, 0x00, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xC0, 0x1F, 0xF8, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0xC1,
  0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0x0F, 0xF0, 0x1F, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xF8, 0x7F, 0xC0,
  0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xBF, 0x8F, 0xF8, 0x0F,
  0xF0, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFF, 0xF8, 0xFF, 0x00, 0xFF,
  0x1F, 0xDF, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0x7F, 0x9F, 0xF0, 0x0F, 0xF3,
  0xFD, 0xFC, 0xFF, 0x80, 0x3F, 0xCF, 0xE7, 0xF3, 0xFE, 0x00, 0xFF, 0x7F,
  0x9F, 0xCF, 0xF0, 0x03, 0xFD, 0xFC, 0x7F, 0x7F, 0xC0, 0x0F, 0xFF, 0xF1,
  0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xC7, 0xF7, 0xF8, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x00, 0xFF, 0xCF,
  0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFB, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x0F,
  0xFC, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0x1F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xFE,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE,
  0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F,
  0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xC0, 0x3F, 0xF9,
  0xFE, 0x03, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFC,
  0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFB,
  0xFF, 0xF0, 0x3F, 0xDF, 0xFF, 0x01, 0xFE, 0x7F, 0xF0, 0x0F, 0xE1, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xF8, 0x08, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x40, 0xFF, 0xC1, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x07, 0xF8, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0xEF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x3F,
  0xFC, 0xFE, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x3F, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF8,
  0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFE, 0x3F, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x08, 0x7F, 0xC0, 0x1C,
  0x3F, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x58,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x88, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0xFF, 0xE7, 0xF8, 0x03, 0xFF,
  0xEF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x81, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x7F,
  0xC0, 0x30, 0x01, 0xFF, 0x80, 0x7E, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE1, 0xF0,
  0x00, 0xFF, 0x3F, 0xE0, 0x0F, 0xFB, 0xFF, 0x80, 0x7F, 0xBF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0x3F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xE0, 0x07,
  0xFC, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F,
  0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3F, 0x8F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE3, 0xFF, 0x8F,
  0xFF, 0x01, 0xFC, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0xFE, 0x3F, 0xF8, 0x07, 0xF3, 0xFF, 0xE0, 0x3F, 0xBF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F,
  0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xF7, 0xFF, 0x1F, 0xF0, 0x7F,
  0xCF, 0xFC, 0x1F, 0xF3, 0xFE, 0x07, 0xFD, 0xFF, 0x81, 0xFF, 0x7F, 0xC0,
  0x7F, 0xDF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE,
  0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F,
  0xFC, 0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x7F, 0x9F, 0xFC, 0x00, 0x7F,
  0xBF, 0xFC, 0x00, 0x7F, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7,
  0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x1F, 0xE0,
  0x60, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF,
  0x1F, 0xC0, 0x3F, 0xF9, 0xFE, 0x03, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFE, 0x0F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xF8, 0x03, 0xFF,
  0x7F, 0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x08, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x01, 0xFC, 0x7F, 0x03, 0xFC, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFE,
  0x03, 0xFB, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0x84, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x3C,
  0x0F, 0xF8, 0x08, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x80, 0x1F, 0xF8, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x20, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x10, 0x00, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF,
  0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F,
  0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0x9F, 0xC0, 0x3F, 0xF1, 0xFC, 0x01, 0xFE,
  0x1F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF,
  0x03, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x80,
  0x7F, 0x9F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFF,
  0x03, 0xFC, 0xFF, 0x07, 0xFF, 0x07, 0xFC, 0xFF, 0x07, 0xFF, 0x07, 0xF8,
  0xFF, 0x0F, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0xFF, 0x1F,
  0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xFF, 0x1F,
  0xE0, 0xFF, 0x3F, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0x7F, 0x3F, 0xC0, 0xFF,
  0x7F, 0x7F, 0x3F, 0xC0, 0xFF, 0x7F, 0x7F, 0x7F, 0xC0, 0xFE, 0x7E, 0x7F,
  0x7F, 0x80, 0xFE, 0xFE, 0x7F, 0x7F, 0x80, 0xFE, 0xFE, 0x7F, 0xFF, 0x00,
  0xFE, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x7E, 0xFF, 0x00, 0xFF, 0xF8,
  0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xFD, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x04, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x80, 0x0D, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xD0, 0x00, 0x3F, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 18, 43, 16, 0, -42 },
  { 98, 22, 15, 25, 6, -42 },
  { 140, 34, 42, 32, 0, -42 },
  { 319, 28, 48, 28, 1, -45 },
  { 487, 42, 44, 46, 3, -43 },
  { 718, 35, 44, 36, 0, -43 },
  { 911, 11, 15, 14, 6, -42 },
  { 932, 21, 52, 18, 1, -43 },
  { 1069, 21, 52, 18, -4, -43 },
  { 1206, 25, 27, 27, 4, -45 },
  { 1291, 26, 28, 30, 3, -35 },
  { 1382, 14, 16, 15, -3, -8 },
  { 1410, 16, 8, 18, 1, -20 },
  { 1426, 10, 11, 15, 0, -10 },
  { 1440, 32, 43, 24, -3, -43 },
  { 1612, 26, 44, 28, 2, -43 },
  { 1755, 22, 42, 29, 5, -42 },
  { 1871, 30, 43, 28, -2, -43 },
  { 2033, 29, 44, 28, 0, -43 },
  { 2193, 30, 42, 29, -1, -42 },
  { 2351, 28, 43, 28, 1, -42 },
  { 2502, 28, 44, 28, 2, -43 },
  { 2656, 30, 42, 28, 2, -42 },
  { 2814, 28, 44, 28, 1, -43 },
  { 2968, 27, 44, 28, 1, -43 },
  { 3117, 16, 34, 16, 0, -33 },
  { 3185, 19, 41, 16, -3, -33 },
  { 3283, 27, 30, 30, 2, -36 },
  { 3385, 26, 19, 30, 3, -30 },
  { 3447, 26, 30, 30, 3, -36 },
  { 3545, 23, 44, 23, 2, -43 },
  { 3672, 41, 48, 43, 2, -43 },
  { 3918, 33, 42, 32, -4, -42 },
  { 4092, 32, 42, 32, 0, -42 },
  { 4260, 31, 44, 30, 2, -43 },
  { 4431, 33, 42, 34, 0, -42 },
  { 4605, 29, 42, 27, 0, -42 },
  { 4758, 29, 42, 26, 0, -42 },
  { 4911, 33, 44, 34, 2, -43 },
  { 5093, 37, 42, 35, 0, -42 },
  { 5288, 27, 42, 21, -2, -42 },
  { 5430, 28, 55, 17, -9, -42 },
  { 5623, 37, 42, 31, 0, -42 },
  { 5818, 22, 42, 25, 0, -42 },
  { 5934, 47, 42, 45, 0, -42 },
  { 6181, 39, 42, 38, 0, -42 },
  { 6386, 33, 44, 36, 2, -43 },
  { 6568, 32, 42, 30, 0, -42 },
  { 6736, 33, 53, 36, 2, -43 },
  { 6955, 31, 42, 31, 0, -42 },
  { 7118, 29, 44, 27, 0, -43 },
  { 7278, 26, 42, 27, 5, -42 },
  { 7415, 33, 43, 34, 3, -42 },
  { 7593, 31, 42, 31, 5, -42 },
  { 7756, 46, 42, 46, 5, -42 },
  { 7998, 38, 42, 31, -3, -42 },
  { 8198, 29, 42, 29, 5, -42 },
  { 8351, 32, 42, 26, -2, -42 },
  { 8519, 24, 53, 18, -2, -43 },
  { 8678, 14, 43, 24, 6, -43 },
  { 8754, 24, 53, 18, -4, -43 },
  { 8913, 28, 27, 28, 0, -42 },
  { 9008, 24, 5, 22, -6, 5 },
  { 9023, 13, 9, 19, 8, -45 },
  { 9038, 29, 34, 30, 1, -33 },
  { 9162, 29, 46, 30, 0, -45 },
  { 9329, 24, 34, 24, 2, -33 },
  { 9431, 32, 46, 30, 1, -45 },
  { 9615, 25, 34, 28, 2, -33 },
  { 9722, 32, 59, 19, -6, -45 },
  { 9958, 31, 47, 30, -1, -33 },
  { 10141, 29, 45, 30, 0, -45 },
  { 10305, 18, 45, 15, 0, -45 },
  { 10407, 26, 59, 15, -8, -45 },
  { 10599, 32, 45, 29, 0, -45 },
  { 10779, 18, 45, 15, 0, -45 },
  { 10881, 43, 33, 45, 0, -33 },
  { 11059, 29, 33, 30, 0, -33 },
  { 11179, 26, 34, 30, 2, -33 },
  { 11290, 32, 47, 30, -3, -33 },
  { 11478, 29, 47, 30, 1, -33 },
  { 11649, 24, 33, 21, 0, -33 },
  { 11748, 24, 34, 24, 0, -33 },
  { 11850, 20, 40, 21, 2, -39 },
  { 11950, 28, 33, 30, 2, -32 },
  { 12066, 27, 32, 27, 3, -32 },
  { 12174, 40, 32, 41, 4, -32 },
  { 12334, 33, 32, 28, -3, -32 },
  { 12466, 34, 46, 27, -4, -32 },
  { 12662, 27, 32, 23, -2, -32 },
  { 12770, 25, 51, 20, 0, -42 },
  { 12930, 7, 58, 26, 9, -45 },
  { 12981, 23, 51, 20, -3, -42 },
  { 13128, 27, 10, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC59PT7B_H_
