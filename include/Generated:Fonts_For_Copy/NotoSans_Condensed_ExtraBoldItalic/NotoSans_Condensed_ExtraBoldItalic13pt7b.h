#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x66, 0x0C, 0xC0, 0x7E, 0xF4, 0x1E, 0x29, 0xFB, 0xF2,
  0xDF, 0xDA, 0x2C, 0xD0, 0x08, 0xF7, 0xDC, 0x70, 0xE1, 0xEB, 0xF8, 0x82,
  0x00, 0x73, 0x7B, 0x2D, 0x15, 0xEF, 0xF8, 0xBC, 0xD6, 0x4A, 0x67, 0x00,
  0x3C, 0x34, 0x3C, 0x38, 0x7B, 0xDE, 0xCE, 0xFC, 0x76, 0x7B, 0x00, 0x19,
  0x98, 0xC4, 0x63, 0x18, 0xC6, 0x10, 0x30, 0x86, 0x31, 0x8C, 0x46, 0x31,
  0x19, 0x80, 0x35, 0xBE, 0xFD, 0x2C, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x6D,
  0xE0, 0xF0, 0xF0, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0xC0, 0x3C,
  0xF6, 0xDB, 0x6F, 0x3D, 0xBE, 0x70, 0x3B, 0xF4, 0xE3, 0x18, 0xCC, 0x60,
  0x3D, 0xB0, 0xC3, 0x18, 0xC6, 0x3E, 0xF8, 0x7C, 0xB0, 0xCE, 0x38, 0x70,
  0xFE, 0xF0, 0x0C, 0x73, 0xCB, 0x7B, 0x6F, 0xC6, 0x30, 0x3C, 0xC6, 0x1E,
  0x7C, 0x31, 0xFE, 0xF0, 0x1E, 0x61, 0x83, 0xE7, 0xDD, 0xB3, 0x3C, 0x78,
  0x7E, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0xE0, 0x3D, 0xB6, 0xCF, 0x39,
  0xBC, 0xF6, 0x78, 0x3D, 0xB6, 0xDB, 0x7D, 0xB1, 0xBE, 0xF0, 0x6C, 0x01,
  0xB0, 0x33, 0x00, 0x06, 0x64, 0xC0, 0x09, 0xFD, 0x87, 0x0C, 0x20, 0xFF,
  0xC1, 0xFF, 0x80, 0x87, 0x1E, 0x3F, 0x62, 0x00, 0xF4, 0xC4, 0xE6, 0x60,
  0x18, 0xC0, 0x1F, 0x18, 0x5B, 0xAB, 0x55, 0x2E, 0xB7, 0x7D, 0x94, 0x62,
  0x1F, 0x00, 0x0E, 0x1C, 0x78, 0xF3, 0x67, 0xDF, 0xB3, 0xE6, 0x3E, 0x6D,
  0x9B, 0xE7, 0xCD, 0x9B, 0x7E, 0xF8, 0x3D, 0x9C, 0x30, 0xC3, 0x0C, 0x3C,
  0xF0, 0x3C, 0x7D, 0x9B, 0x36, 0x6C, 0xDB, 0x7E, 0xF8, 0x3C, 0xC6, 0x1F,
  0x79, 0x86, 0x3E, 0xF8, 0x3C, 0xC6, 0x18, 0x79, 0x86, 0x30, 0xC0, 0x3E,
  0xEB, 0x86, 0x0D, 0xD9, 0xB3, 0x7C, 0x78, 0x33, 0x33, 0x66, 0x7E, 0x7E,
  0x66, 0x66, 0xCC, 0xCC, 0x3E, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0xF8,
  0x0C, 0x31, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xCF, 0x38, 0x37, 0x36, 0x6C,
  0x78, 0x78, 0x78, 0x7C, 0xCC, 0xCC, 0x31, 0x98, 0xC6, 0x31, 0x9F, 0xF8,
  0x39, 0xCE, 0x77, 0xBD, 0xEF, 0x7F, 0x9F, 0xE5, 0xDB, 0x76, 0xDB, 0x00,
  0x31, 0x9D, 0x9E, 0xCF, 0x67, 0xB3, 0x71, 0x39, 0x9C, 0xCE, 0x00, 0x3C,
  0xDF, 0x1E, 0x3C, 0xF9, 0xB3, 0x7C, 0xF0, 0x3E, 0x6D, 0x9B, 0x37, 0xCF,
  0x18, 0x60, 0xC0, 0x3C, 0xDF, 0x1E, 0x3C, 0x79, 0xB3, 0x7C, 0xF0, 0x60,
  0x60, 0x3C, 0x6D, 0x9B, 0x77, 0xCF, 0x1E, 0x66, 0xCC, 0x3D, 0xD6, 0x1C,
  0x38, 0x61, 0xBE, 0xF0, 0xFC, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xC0, 0x66,
  0xCF, 0x36, 0x6C, 0xD9, 0xB6, 0x7C, 0xF0, 0xC7, 0x9B, 0x36, 0xCD, 0x9E,
  0x3C, 0x70, 0xE0, 0xCC, 0xF3, 0x3D, 0xDB, 0x76, 0xFF, 0x3F, 0xCE, 0xF3,
  0xB8, 0xCE, 0x00, 0x3B, 0x8F, 0x87, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0xCC,
  0xE6, 0x00, 0xCF, 0xB9, 0xE3, 0x87, 0x0C, 0x18, 0x30, 0xC0, 0x3F, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0x30, 0x7C, 0xFC, 0x1C, 0x43, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x8F, 0x00, 0xC9, 0x36, 0xDB, 0x20, 0x38, 0xC6, 0x31, 0x18,
  0xC6, 0x31, 0x38, 0x18, 0x63, 0x9B, 0x4F, 0x10, 0xF8, 0xCC, 0x3E, 0xD9,
  0xB6, 0x6C, 0xDF, 0x1A, 0x00, 0x30, 0xC2, 0x1F, 0x6D, 0xB6, 0xF3, 0xFB,
  0xE0, 0x3D, 0xA6, 0x30, 0xC3, 0xE7, 0x80, 0x06, 0x0C, 0x19, 0xF6, 0xCD,
  0xB3, 0x66, 0xF8, 0xD0, 0x3D, 0xB6, 0xFE, 0xC3, 0xA7, 0x80, 0x0E, 0x38,
  0x61, 0xE3, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x87, 0x0C, 0x00, 0x3E, 0xD9,
  0xB6, 0x6C, 0xDF, 0x1E, 0x0C, 0xB9, 0xE0, 0x30, 0xC2, 0x1F, 0x7D, 0xB6,
  0xF3, 0xCF, 0x60, 0x33, 0x06, 0x66, 0x64, 0xCC, 0x0C, 0x30, 0x06, 0x18,
  0x61, 0x84, 0x30, 0xC3, 0x3C, 0xE0, 0x30, 0x60, 0x83, 0x76, 0xCF, 0x1E,
  0x7C, 0xD9, 0xB8, 0x33, 0x36, 0x66, 0x6C, 0xCC, 0x7F, 0x9F, 0xF6, 0xD9,
  0xB6, 0xCD, 0xB2, 0x6D, 0x98, 0x7D, 0xF6, 0xDB, 0x4F, 0x3D, 0x80, 0x3D,
  0xB6, 0xF3, 0xCF, 0xE7, 0x80, 0x3E, 0x6C, 0xD9, 0xB2, 0x6F, 0xDF, 0x30,
  0x61, 0x80, 0x3E, 0xD9, 0xB6, 0x6C, 0xDF, 0x1E, 0x0C, 0x18, 0x30, 0x7B,
  0xD8, 0xCC, 0x63, 0x00, 0x7B, 0x58, 0xE3, 0xFB, 0xC0, 0x26, 0xFC, 0xCC,
  0xCE, 0xE0, 0x66, 0xD9, 0xB3, 0x6C, 0xDF, 0x9A, 0x00, 0xDF, 0x6F, 0x3C,
  0xE3, 0x8C, 0x00, 0xD9, 0xED, 0xBE, 0xDD, 0xCE, 0xE6, 0x63, 0x70, 0x37,
  0x36, 0x1C, 0x18, 0x3C, 0x6C, 0xEC, 0x37, 0x36, 0x34, 0x3C, 0x38, 0x38,
  0x30, 0x30, 0xE0, 0xE0, 0x7C, 0x63, 0x1C, 0x63, 0xCF, 0x00, 0x19, 0x8C,
  0x66, 0x61, 0x8C, 0x63, 0x18, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xC6, 0x21,
  0x8C, 0xC6, 0x27, 0x38, 0xCF, 0xE4,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 5, 3, 6, 1, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 6, 11, 6, 0, -10 },
  { 25, 9, 9, 10, 1, -9 },
  { 36, 8, 9, 8, 0, -9 },
  { 45, 3, 3, 3, 1, -9 },
  { 47, 5, 11, 4, 0, -9 },
  { 54, 5, 12, 4, -1, -10 },
  { 62, 5, 6, 6, 1, -10 },
  { 66, 5, 7, 7, 1, -8 },
  { 71, 3, 4, 3, -1, -2 },
  { 73, 4, 1, 4, 0, -4 },
  { 74, 2, 2, 3, 0, -2 },
  { 75, 7, 9, 5, -1, -9 },
  { 83, 6, 9, 6, 0, -9 },
  { 90, 5, 9, 6, 1, -9 },
  { 96, 6, 9, 6, 0, -9 },
  { 103, 6, 9, 6, 0, -9 },
  { 110, 6, 9, 6, 0, -9 },
  { 117, 6, 9, 6, 0, -9 },
  { 124, 7, 9, 6, 0, -9 },
  { 132, 7, 9, 6, 0, -9 },
  { 140, 6, 9, 6, 0, -9 },
  { 147, 6, 9, 6, 0, -9 },
  { 154, 3, 7, 3, 0, -7 },
  { 157, 4, 9, 3, -1, -7 },
  { 162, 5, 7, 7, 1, -8 },
  { 167, 5, 5, 7, 1, -7 },
  { 171, 5, 7, 7, 1, -8 },
  { 176, 5, 9, 5, 1, -9 },
  { 182, 9, 10, 10, 0, -9 },
  { 194, 7, 9, 7, -1, -9 },
  { 202, 7, 9, 7, 0, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 7, 9, 7, 0, -9 },
  { 225, 6, 9, 6, 0, -9 },
  { 232, 6, 9, 6, 0, -9 },
  { 239, 7, 9, 8, 1, -9 },
  { 247, 8, 9, 8, 0, -9 },
  { 256, 7, 9, 5, -1, -9 },
  { 264, 6, 12, 4, -2, -9 },
  { 273, 8, 9, 7, 0, -9 },
  { 282, 5, 9, 6, 0, -9 },
  { 288, 10, 9, 10, 0, -9 },
  { 300, 9, 9, 8, 0, -9 },
  { 311, 7, 9, 8, 1, -9 },
  { 319, 7, 9, 7, 0, -9 },
  { 327, 7, 11, 8, 1, -9 },
  { 337, 7, 9, 7, 0, -9 },
  { 345, 6, 9, 6, 0, -9 },
  { 352, 6, 9, 6, 1, -9 },
  { 359, 7, 9, 8, 1, -9 },
  { 367, 7, 9, 7, 1, -9 },
  { 375, 10, 9, 10, 1, -9 },
  { 387, 9, 9, 7, -1, -9 },
  { 398, 7, 9, 6, 1, -9 },
  { 406, 8, 9, 6, -1, -9 },
  { 415, 6, 11, 4, -1, -9 },
  { 424, 3, 9, 5, 1, -9 },
  { 428, 5, 11, 4, -1, -9 },
  { 435, 6, 6, 6, 0, -9 },
  { 440, 5, 1, 5, -1, 1 },
  { 441, 3, 2, 4, 2, -10 },
  { 442, 7, 7, 7, 0, -7 },
  { 449, 6, 10, 7, 0, -10 },
  { 457, 6, 7, 5, 0, -7 },
  { 463, 7, 10, 7, 0, -10 },
  { 472, 6, 7, 6, 0, -7 },
  { 478, 7, 13, 4, -1, -10 },
  { 490, 7, 10, 7, 0, -7 },
  { 499, 6, 10, 7, 0, -10 },
  { 507, 4, 10, 3, 0, -10 },
  { 512, 6, 13, 3, -2, -10 },
  { 522, 7, 10, 6, 0, -10 },
  { 531, 4, 10, 3, 0, -10 },
  { 536, 10, 7, 10, 0, -7 },
  { 545, 6, 7, 7, 0, -7 },
  { 551, 6, 7, 7, 0, -7 },
  { 557, 7, 10, 7, -1, -7 },
  { 566, 7, 10, 7, 0, -7 },
  { 575, 5, 7, 5, 0, -7 },
  { 580, 5, 7, 5, 0, -7 },
  { 585, 4, 9, 5, 1, -9 },
  { 590, 7, 7, 7, 0, -7 },
  { 597, 6, 7, 6, 1, -7 },
  { 603, 9, 7, 9, 1, -7 },
  { 611, 8, 7, 6, -1, -7 },
  { 618, 8, 10, 6, -1, -7 },
  { 628, 6, 7, 5, 0, -7 },
  { 634, 5, 11, 5, 0, -9 },
  { 641, 2, 13, 6, 2, -10 },
  { 645, 5, 11, 5, -1, -9 },
  { 652, 5, 3, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC13PT7B_H_
