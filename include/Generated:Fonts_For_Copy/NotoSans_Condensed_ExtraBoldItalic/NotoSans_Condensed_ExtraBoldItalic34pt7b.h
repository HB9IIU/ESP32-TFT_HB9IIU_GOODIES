#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x00,
  0x00, 0x00, 0x40, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0xFB,
  0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x9F, 0x3C, 0xFB, 0xE7, 0x9E, 0x3C, 0xF1,
  0xE0, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1E,
  0x78, 0x03, 0x8F, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x38,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x03, 0xCF, 0x00, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3E, 0xCC, 0x1F, 0x60, 0x0F, 0xB0, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xDF,
  0x10, 0x6F, 0x8C, 0x37, 0xC7, 0xDF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF,
  0xE0, 0x0F, 0x80, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x1F, 0x80, 0x78, 0x3F, 0xC0, 0xF0, 0x3F, 0xC0, 0xE0, 0x79, 0xE1,
  0xE0, 0x79, 0xE3, 0xC0, 0xF1, 0xE3, 0xC0, 0xF1, 0xC7, 0x80, 0xF3, 0xC7,
  0x00, 0xF3, 0xCF, 0x00, 0xF3, 0xDE, 0x3C, 0xF7, 0x9E, 0xFE, 0xFF, 0xBD,
  0xFF, 0xFF, 0x79, 0xFF, 0x7E, 0x7B, 0xCF, 0x18, 0xF3, 0xCF, 0x00, 0xF3,
  0x8F, 0x01, 0xE7, 0x8F, 0x03, 0xC7, 0x8E, 0x03, 0xC7, 0x9E, 0x07, 0x87,
  0x9E, 0x07, 0x87, 0xBC, 0x0F, 0x07, 0xFC, 0x1E, 0x03, 0xF8, 0x3E, 0x01,
  0xF0, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07, 0xDF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF1, 0xF1, 0xFF, 0x1F,
  0x3F, 0xFB, 0xE7, 0xEF, 0xBE, 0x7C, 0xFF, 0xCF, 0xC7, 0xFC, 0xF8, 0x7F,
  0x8F, 0x83, 0xF0, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x78, 0xF0,
  0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x19, 0xE0, 0xF7, 0x83, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0x0F, 0xFC, 0x7F, 0x07, 0xFC, 0x3F, 0x78, 0x79, 0xE0, 0xC7, 0xC1, 0x0C,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C,
  0x7C, 0x78, 0x78, 0xF0, 0x7F, 0xDF, 0xE7, 0xFB, 0xFE, 0x11, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x60, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xCF, 0xCF,
  0x9F, 0x1F, 0x3E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xF1, 0xFB, 0xE3, 0xE7, 0xC7,
  0xCF, 0x9F, 0x1F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0x81, 0xFC, 0x1F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x8F, 0x7C, 0x73,
  0xE1, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x00, 0x18, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3C, 0x7C, 0x18, 0x3E, 0x04, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x30, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x90,
  0x0F, 0x8C, 0x1F, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xBE, 0x03, 0x9F, 0x03, 0xDF,
  0x03, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE1, 0xE1, 0xF1, 0xFF, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x60, 0x0F,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x20, 0x3F, 0x1C, 0x3F, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0xF0, 0x7D, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0xFE, 0x7C, 0xFC,
  0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFD,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xF8, 0x7C,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x0F, 0x9F, 0x07, 0xDF, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0x7C, 0xF8, 0x7C, 0x3E,
  0x3E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0xC7, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3E, 0xF8,
  0x7D, 0xF1, 0xFB, 0xE3, 0xF7, 0xFF, 0xEF, 0xFF, 0xCF, 0xFF, 0x1F, 0xBE,
  0x0C, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x88, 0x7E, 0x1F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x81, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3E, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x80,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x87,
  0xF8, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0xC3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC,
  0x41, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x1F, 0xCF, 0x3C,
  0x7F, 0xCF, 0x3C, 0xFF, 0xCF, 0x78, 0xF3, 0xCF, 0x79, 0xE3, 0x8F, 0x71,
  0xC3, 0x8E, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x1E, 0xE3,
  0x8F, 0x1C, 0xE3, 0xCF, 0x3C, 0xE3, 0xFF, 0xF8, 0xF3, 0xFF, 0xF0, 0xF1,
  0xF3, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x81,
  0xF7, 0xC0, 0x7F, 0xF0, 0x1F, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F,
  0x8F, 0x87, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFE, 0x0F, 0xDF,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xF1,
  0xF1, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0,
  0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x38, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0xFE, 0x1F, 0x0F, 0xC3, 0xE1,
  0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83,
  0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F,
  0x87, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x0C, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xC1, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x1F, 0xE7, 0xC3, 0xFC, 0xF8, 0xFF, 0x1F, 0x1F, 0xE7, 0xE0,
  0x7C, 0xFC, 0x0F, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xF1,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x8F, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0xC1, 0xF8, 0x3E, 0x1F, 0x81, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xF8, 0xFC, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01, 0xF7,
  0xE0, 0x1F, 0xFE, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFF, 0xF7, 0xFF, 0xBF, 0xFB, 0xFF, 0xDF, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xBE, 0x0F,
  0xF8, 0xF7, 0xC1, 0xEF, 0x3D, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xBD, 0xE7,
  0xC1, 0xF7, 0xFC, 0xF8, 0x3E, 0xFF, 0x9F, 0x07, 0x9F, 0xE7, 0xC1, 0xF3,
  0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0xE3, 0xE0, 0xF0, 0xF8, 0x78,
  0x3E, 0x1F, 0x1F, 0x07, 0xC3, 0xC3, 0xE0, 0x07, 0xE0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x1F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x07, 0xC1, 0xFE, 0x0F,
  0x03, 0xFE, 0x3E, 0x07, 0xFC, 0x7C, 0x1F, 0xF8, 0xF8, 0x3E, 0xF1, 0xF0,
  0x7D, 0xE3, 0xC0, 0xF3, 0xEF, 0x81, 0xE7, 0xDF, 0x07, 0xCF, 0xBE, 0x0F,
  0x8F, 0x7C, 0x1F, 0x1F, 0xF0, 0x3E, 0x3F, 0xE0, 0x78, 0x7F, 0xC1, 0xF0,
  0xFF, 0x83, 0xE0, 0xFE, 0x07, 0xC1, 0xFC, 0x0F, 0x03, 0xF8, 0x3E, 0x07,
  0xF0, 0x7C, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x3F,
  0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x7E, 0xF8,
  0x0F, 0xDF, 0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0,
  0x7E, 0x3E, 0x0F, 0xC7, 0xE7, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87,
  0xC7, 0xC3, 0xF1, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F,
  0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F,
  0xBF, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xFF, 0xE0, 0x3E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xE7, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x8F, 0xC3,
  0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC7, 0xE1, 0xF3,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFB, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xC7, 0xE1, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0xC3, 0xF3, 0xE0, 0xFC, 0x00, 0x70, 0x01, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC, 0x30, 0x7E, 0x08, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x18, 0x1F,
  0x8F, 0x3F, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0xF0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7E,
  0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xEF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x0F, 0xFE,
  0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xC0,
  0xF9, 0xF0, 0x1E, 0xFC, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xF8, 0x1E, 0x07, 0xFF, 0x07, 0xC0, 0xFB, 0xE0, 0xF8,
  0x3E, 0x7C, 0x1F, 0x07, 0xCF, 0x87, 0xE1, 0xF9, 0xF0, 0xFC, 0x3E, 0x3E,
  0x3F, 0x87, 0xC7, 0xC7, 0xF1, 0xF0, 0xF9, 0xFE, 0x3E, 0x1F, 0x3F, 0xC7,
  0xC3, 0xE7, 0xF9, 0xF0, 0x7D, 0xEF, 0x3E, 0x0F, 0xBD, 0xEF, 0x81, 0xFF,
  0xBD, 0xF0, 0x3D, 0xE7, 0xBE, 0x07, 0xBC, 0xFF, 0x80, 0xFF, 0x1F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0xFC, 0x01,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x3F,
  0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E,
  0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0x9F, 0x0F,
  0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xFB, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x08, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xF8, 0x78,
  0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E,
  0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0x3C,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0xF9, 0xF1, 0xE1, 0xE0, 0x07, 0x8F,
  0x87, 0xF7, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xF7, 0xF3, 0xF1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xBE, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x78, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFB, 0xF1, 0xF1, 0xF8, 0xF8, 0xFC, 0xF8, 0x7E, 0x7C,
  0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3,
  0xF3, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8, 0x79, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0x31, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC6, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x1F, 0x7C, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFD, 0xFC,
  0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0x78, 0x0F, 0x9E, 0x00, 0x01, 0xF0, 0x0F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xF3, 0xE3, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x3E, 0xFF,
  0xFD, 0xFF, 0xF3, 0xFF, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x04,
  0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xE4, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x02, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x01, 0x3F, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE7, 0xC1, 0xFD, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xBF, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E,
  0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F,
  0x87, 0xCF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xF7, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x0C, 0x1F, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x0F,
  0x7F, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xF7, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8,
  0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x9F, 0x8F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x02, 0x7C, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x3F, 0x0F, 0x8F, 0xC3, 0xE3, 0xF0, 0x7C,
  0x7C, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x3D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC0, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x00, 0x0F, 0x3E, 0x1E, 0x07, 0xBF, 0xBF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFD, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C,
  0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x8F, 0x87, 0xC7,
  0xC7, 0xC3, 0xE7, 0xC3, 0xE3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF1, 0xF8, 0xF8,
  0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F,
  0x00, 0x0F, 0x3E, 0x07, 0xBF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC7, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0xFC,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF3, 0xF7, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x1F, 0xBE, 0x3E, 0x7F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0x00, 0x03, 0xCF, 0x00, 0x7B, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xE7, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xDF,
  0xC0, 0xFB, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x7F, 0x7E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0xFC, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x3E,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x3C, 0x3D, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0x21, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3E, 0x18,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xCC, 0x3F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0xF3, 0xFF, 0x7F, 0xE7,
  0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80,
  0x1F, 0x0F, 0x8F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F,
  0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x3F, 0xBC, 0x1F, 0x9E, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3,
  0xEF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xE0, 0xF7, 0xC1,
  0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xF8, 0x7C, 0x3F, 0xF1, 0xF8, 0x7F, 0xE3,
  0xF1, 0xF7, 0xC7, 0xE3, 0xEF, 0x9F, 0xC7, 0xDF, 0x3F, 0x9F, 0x3E, 0xFF,
  0x3E, 0x7D, 0xFE, 0x78, 0xFB, 0xFD, 0xF1, 0xFF, 0x7B, 0xC3, 0xFE, 0xFF,
  0x87, 0xB9, 0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0xFC, 0x3F, 0x00,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9F, 0x00, 0xF7, 0xC0,
  0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0xFC, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFC,
  0x07, 0xE0, 0x07, 0x80, 0xFE, 0x07, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xFC, 0x0F, 0xE0,
  0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 24, 9, 0, -24 },
  { 34, 13, 9, 15, 3, -24 },
  { 49, 19, 24, 19, 0, -24 },
  { 106, 17, 28, 16, 0, -26 },
  { 166, 24, 25, 27, 2, -25 },
  { 241, 20, 25, 21, 0, -25 },
  { 304, 7, 9, 8, 3, -24 },
  { 312, 12, 30, 10, 1, -25 },
  { 357, 13, 30, 10, -3, -25 },
  { 406, 14, 15, 16, 3, -26 },
  { 433, 15, 16, 17, 1, -20 },
  { 463, 8, 9, 9, -2, -4 },
  { 472, 10, 4, 10, 0, -11 },
  { 477, 6, 6, 9, 0, -6 },
  { 482, 18, 25, 14, -2, -25 },
  { 539, 15, 25, 16, 1, -25 },
  { 586, 13, 24, 17, 3, -24 },
  { 625, 17, 25, 16, -1, -25 },
  { 679, 17, 25, 16, 0, -25 },
  { 733, 17, 24, 17, 0, -24 },
  { 784, 17, 24, 16, 0, -24 },
  { 835, 16, 25, 16, 1, -25 },
  { 885, 17, 24, 16, 1, -24 },
  { 936, 17, 25, 16, 0, -25 },
  { 990, 15, 25, 16, 1, -25 },
  { 1037, 9, 19, 9, 0, -19 },
  { 1059, 11, 24, 9, -2, -19 },
  { 1092, 15, 17, 17, 1, -21 },
  { 1124, 15, 11, 17, 1, -17 },
  { 1145, 16, 17, 17, 1, -21 },
  { 1179, 14, 25, 13, 1, -25 },
  { 1223, 24, 28, 25, 1, -25 },
  { 1307, 18, 24, 19, -2, -24 },
  { 1361, 18, 24, 18, 0, -24 },
  { 1415, 18, 25, 17, 1, -25 },
  { 1472, 19, 24, 19, 0, -24 },
  { 1529, 17, 24, 15, 0, -24 },
  { 1580, 17, 24, 15, 0, -24 },
  { 1631, 19, 25, 20, 1, -25 },
  { 1691, 21, 24, 20, 0, -24 },
  { 1754, 16, 24, 12, -1, -24 },
  { 1802, 16, 31, 10, -5, -24 },
  { 1864, 21, 24, 18, 0, -24 },
  { 1927, 13, 24, 15, 0, -24 },
  { 1966, 27, 24, 26, 0, -24 },
  { 2047, 23, 24, 22, 0, -24 },
  { 2116, 19, 25, 21, 1, -25 },
  { 2176, 18, 24, 17, 0, -24 },
  { 2230, 19, 31, 21, 1, -25 },
  { 2304, 18, 24, 18, 0, -24 },
  { 2358, 17, 25, 16, 0, -25 },
  { 2412, 15, 24, 15, 3, -24 },
  { 2457, 20, 24, 20, 1, -24 },
  { 2517, 18, 24, 18, 3, -24 },
  { 2571, 27, 24, 26, 3, -24 },
  { 2652, 22, 24, 18, -2, -24 },
  { 2718, 17, 24, 17, 3, -24 },
  { 2769, 18, 24, 15, -1, -24 },
  { 2823, 14, 31, 10, -1, -25 },
  { 2878, 8, 25, 14, 3, -25 },
  { 2903, 14, 31, 10, -2, -25 },
  { 2958, 16, 15, 16, 0, -24 },
  { 2988, 13, 3, 13, -3, 3 },
  { 2993, 7, 5, 11, 5, -26 },
  { 2998, 17, 19, 17, 1, -19 },
  { 3039, 17, 26, 17, 0, -26 },
  { 3095, 14, 19, 14, 1, -19 },
  { 3129, 18, 26, 17, 1, -26 },
  { 3188, 15, 19, 16, 1, -19 },
  { 3224, 19, 34, 11, -4, -26 },
  { 3305, 18, 27, 17, 0, -19 },
  { 3366, 17, 26, 18, 0, -26 },
  { 3422, 10, 26, 9, 0, -26 },
  { 3455, 14, 34, 9, -4, -26 },
  { 3515, 19, 26, 17, 0, -26 },
  { 3577, 11, 26, 9, 0, -26 },
  { 3613, 25, 19, 26, 0, -19 },
  { 3673, 17, 19, 18, 0, -19 },
  { 3714, 15, 19, 17, 1, -19 },
  { 3750, 19, 27, 17, -2, -19 },
  { 3815, 16, 27, 17, 1, -19 },
  { 3869, 14, 19, 12, 0, -19 },
  { 3903, 14, 19, 14, 0, -19 },
  { 3937, 12, 23, 12, 1, -23 },
  { 3972, 17, 19, 17, 1, -19 },
  { 4013, 15, 19, 16, 2, -19 },
  { 4049, 23, 19, 24, 2, -19 },
  { 4104, 20, 19, 16, -2, -19 },
  { 4152, 19, 27, 16, -2, -19 },
  { 4217, 15, 19, 14, -1, -19 },
  { 4253, 14, 29, 12, 0, -24 },
  { 4304, 4, 34, 15, 5, -26 },
  { 4321, 14, 29, 12, -2, -24 },
  { 4372, 16, 6, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC34PT7B_H_
