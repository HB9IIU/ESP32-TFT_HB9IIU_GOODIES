#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC6PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x7F, 0xE0, 0x2D, 0x3C, 0xD7, 0x8A, 0xA0, 0x65, 0xEE,
  0x80, 0x6A, 0x80, 0x56, 0x80, 0x5D, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x2A, 0x40, 0x76, 0xE0, 0xEA, 0x65, 0x60, 0x68, 0xE0, 0x6F, 0xA0, 0x78,
  0xE0, 0x7E, 0xE0, 0x69, 0x40, 0x6A, 0xE0, 0x75, 0xE0, 0xC8, 0xCA, 0x39,
  0x80, 0xFC, 0x8F, 0x00, 0xEA, 0x40, 0x7F, 0xFE, 0x6F, 0xD0, 0x6E, 0xF0,
  0x72, 0x70, 0x6E, 0xE0, 0x6E, 0x60, 0x6E, 0x40, 0x78, 0xAE, 0x56, 0xAA,
  0x69, 0x60, 0x25, 0x2C, 0x74, 0xAA, 0x5B, 0x5A, 0xBD, 0x60, 0x5D, 0xAA,
  0x79, 0xAE, 0x6F, 0x40, 0x79, 0xAE, 0x20, 0x6F, 0x50, 0x69, 0x60, 0xE9,
  0x20, 0x5A, 0xAE, 0xFA, 0x40, 0xAD, 0x7D, 0xE0, 0x74, 0x4A, 0xF2, 0x40,
  0x6A, 0x60, 0x6A, 0x80, 0xF0, 0x56, 0x80, 0x54, 0xE0, 0x80, 0xF7, 0x00,
  0x49, 0xDC, 0xF3, 0x00, 0x27, 0xDC, 0xFB, 0x00, 0x32, 0x64, 0x4C, 0xF7,
  0x60, 0x49, 0xDA, 0x5A, 0x80, 0x25, 0x25, 0x80, 0x4A, 0xEA, 0x5A, 0x80,
  0x7B, 0xF0, 0x76, 0x80, 0xF7, 0x00, 0x77, 0x40, 0xF7, 0x20, 0x68, 0xDC,
  0x7B, 0xF7, 0x00, 0xB9, 0x00, 0xBF, 0xE0, 0xEB, 0x00, 0xB9, 0x40, 0xEB,
  0x00, 0x6A, 0x4C, 0xFC, 0xD6, 0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 1, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 3, 4, 2, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 1, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 2, 3, 2, 0, -3 },
  { 46, 2, 4, 2, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 2, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 4, 2, 0, -4 },
  { 54, 4, 4, 4, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 3, 4, 2, 0, -4 },
  { 74, 3, 5, 2, -1, -4 },
  { 76, 4, 4, 3, 0, -4 },
  { 78, 2, 4, 3, 0, -4 },
  { 79, 5, 4, 5, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 4, 5, 4, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 4, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 1, -4 },
  { 101, 5, 4, 5, 0, -4 },
  { 104, 4, 4, 3, 0, -4 },
  { 106, 3, 4, 3, 1, -4 },
  { 108, 3, 4, 3, 0, -4 },
  { 110, 2, 5, 2, 0, -4 },
  { 112, 1, 4, 2, 1, -4 },
  { 113, 2, 5, 2, 0, -4 },
  { 115, 3, 2, 3, 0, -4 },
  { 116, 3, 1, 2, -1, 0 },
  { 117, 1, 1, 2, 1, -5 },
  { 118, 3, 3, 3, 0, -3 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 3, 3, 2, 0, -3 },
  { 124, 3, 5, 3, 0, -5 },
  { 126, 3, 3, 3, 0, -3 },
  { 128, 4, 6, 2, -1, -5 },
  { 131, 3, 4, 3, 0, -3 },
  { 133, 3, 5, 3, 0, -5 },
  { 135, 2, 5, 2, 0, -5 },
  { 137, 3, 6, 2, -1, -5 },
  { 140, 3, 5, 3, 0, -5 },
  { 142, 2, 5, 2, 0, -5 },
  { 144, 4, 3, 5, 0, -3 },
  { 146, 3, 3, 3, 0, -3 },
  { 148, 3, 3, 3, 0, -3 },
  { 150, 3, 4, 3, 0, -3 },
  { 152, 3, 4, 3, 0, -3 },
  { 154, 2, 3, 2, 0, -3 },
  { 155, 2, 3, 2, 0, -3 },
  { 156, 2, 4, 2, 0, -4 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 4, 3, 4, 0, -3 },
  { 163, 3, 3, 3, 0, -3 },
  { 165, 3, 4, 3, 0, -3 },
  { 167, 3, 3, 2, 0, -3 },
  { 169, 3, 5, 2, 0, -4 },
  { 171, 1, 6, 3, 1, -5 },
  { 172, 2, 5, 2, 0, -4 },
  { 174, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC6PT7B_H_
