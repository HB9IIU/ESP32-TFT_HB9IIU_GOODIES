#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC11PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x36, 0xDF, 0xB0, 0x14, 0xF7, 0xCA, 0x7B, 0xF5, 0x3C,
  0x13, 0xDC, 0xE3, 0xDF, 0xCC, 0x40, 0x65, 0x5A, 0xA7, 0xBD, 0xE5, 0x5A,
  0xE6, 0x38, 0x51, 0xA1, 0x97, 0x5B, 0xB6, 0x7E, 0xF8, 0x32, 0x64, 0x4C,
  0xCC, 0xC4, 0x31, 0x11, 0x33, 0x22, 0x4C, 0xAF, 0x7F, 0x20, 0x31, 0xBF,
  0xF3, 0x18, 0x78, 0xFC, 0xF0, 0x04, 0x31, 0x84, 0x30, 0x86, 0x30, 0x3B,
  0xDA, 0x9D, 0xEF, 0x4E, 0x37, 0xF2, 0x26, 0x66, 0x3B, 0xC6, 0x33, 0x33,
  0x1E, 0x3B, 0xC2, 0x67, 0x0E, 0xFE, 0x08, 0xCE, 0xF5, 0x7C, 0xC6, 0x3B,
  0xD8, 0xE5, 0x8E, 0xDE, 0x1C, 0xD6, 0x1E, 0xDB, 0x6D, 0x9C, 0x7D, 0xF1,
  0x84, 0x30, 0x86, 0x30, 0x3B, 0x5A, 0xE7, 0x6F, 0x6E, 0x3B, 0xD2, 0xB7,
  0x8C, 0xDC, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x06, 0xC0, 0x08, 0xDD, 0xC1,
  0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0x72, 0xC6, 0x66, 0x01,
  0x18, 0x1E, 0x23, 0x4D, 0x55, 0xE5, 0xAE, 0xD6, 0x44, 0x38, 0x0C, 0x71,
  0x4D, 0x35, 0xF6, 0x71, 0x39, 0xF6, 0xDE, 0x79, 0x2D, 0xBC, 0x1C, 0xF6,
  0x18, 0x43, 0x06, 0x9E, 0x39, 0xF6, 0xDB, 0x4D, 0x3F, 0xBC, 0x3B, 0xD8,
  0xF7, 0x23, 0x1E, 0x3B, 0xD8, 0xF7, 0x23, 0x18, 0x1E, 0x79, 0x83, 0x65,
  0xD9, 0x9B, 0x3C, 0x26, 0xCD, 0x93, 0xE7, 0xC9, 0xB2, 0x6C, 0x79, 0x88,
  0xC6, 0x31, 0x1C, 0x08, 0xC6, 0x31, 0x88, 0xC6, 0x37, 0x00, 0x26, 0xD9,
  0xE3, 0x87, 0x0B, 0x36, 0x6C, 0x26, 0x66, 0x44, 0xCF, 0x33, 0xB9, 0x9D,
  0xCE, 0xE5, 0xF2, 0xDB, 0x69, 0xAC, 0x32, 0xED, 0xDA, 0xB5, 0xCB, 0xB7,
  0x66, 0x1C, 0x79, 0x9B, 0x34, 0x59, 0x9F, 0x3C, 0x39, 0xF6, 0xDB, 0x79,
  0x0C, 0x30, 0x1C, 0x79, 0x9B, 0x34, 0x59, 0x9F, 0x3C, 0x18, 0x30, 0x39,
  0xF6, 0xDA, 0x79, 0x4D, 0xB6, 0x3B, 0xD8, 0xE3, 0x0A, 0xDE, 0xFF, 0x98,
  0xC4, 0x63, 0x18, 0x26, 0xC9, 0x93, 0x64, 0xC9, 0xB6, 0x3C, 0xCF, 0x6D,
  0xB4, 0xF3, 0x8E, 0x30, 0xD9, 0xED, 0xB6, 0xD5, 0x4A, 0xE7, 0x63, 0x31,
  0xB8, 0x37, 0x36, 0x1C, 0x18, 0x18, 0x38, 0x6C, 0xCC, 0xDE, 0xFC, 0xC6,
  0x21, 0x18, 0x7D, 0xE1, 0x8C, 0x61, 0x8C, 0x3C, 0x36, 0x64, 0x4C, 0xCC,
  0x8C, 0xDB, 0x24, 0x93, 0x38, 0x84, 0x23, 0x18, 0x84, 0x27, 0x00, 0x11,
  0x8E, 0xBC, 0x80, 0xF0, 0xC0, 0x7D, 0xEC, 0xB6, 0xD9, 0xC0, 0x23, 0x1E,
  0xD4, 0xAF, 0x7E, 0x3B, 0x71, 0x8D, 0x38, 0x0C, 0x37, 0xDE, 0x4B, 0x6D,
  0x9C, 0x3B, 0x7F, 0xCC, 0xB8, 0x1C, 0x43, 0x9C, 0x30, 0x86, 0x18, 0x63,
  0x08, 0x00, 0x7D, 0xED, 0xB6, 0xD9, 0xC1, 0x3C, 0xE0, 0x23, 0x1E, 0xD4,
  0xAF, 0x7B, 0x61, 0xB4, 0xB6, 0x30, 0x33, 0x22, 0x66, 0x6C, 0x80, 0x21,
  0x86, 0xDE, 0x71, 0xCD, 0x36, 0x2D, 0xB4, 0xB6, 0x7F, 0x6F, 0x4B, 0x5B,
  0xDA, 0xD2, 0x7B, 0x52, 0xBD, 0xEC, 0x3B, 0x73, 0xBD, 0xB8, 0x3C, 0xD2,
  0x4B, 0x6D, 0xE6, 0x10, 0xC0, 0x7D, 0xE4, 0xB6, 0xD9, 0xC1, 0x0C, 0x30,
  0x7B, 0x90, 0x8C, 0x60, 0x7A, 0x98, 0x6B, 0x70, 0x27, 0xE4, 0x4C, 0x60,
  0x6D, 0xA4, 0xB6, 0xD9, 0xC0, 0x9D, 0xA9, 0xCC, 0x60, 0xB7, 0x6E, 0xD6,
  0xED, 0x9B, 0x00, 0x36, 0x78, 0xE1, 0xC7, 0x9D, 0x00, 0x26, 0x58, 0xA1,
  0xC3, 0x06, 0x0C, 0x70, 0xC0, 0x79, 0x88, 0xCC, 0x78, 0x19, 0x88, 0x4E,
  0x61, 0x08, 0x63, 0x00, 0xFF, 0xE0, 0x31, 0x84, 0x61, 0x9C, 0x8C, 0xE6,
  0x00, 0x6D, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 5, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 7, 8, 9, 1, -8 },
  { 25, 7, 8, 7, 0, -8 },
  { 32, 2, 3, 3, 1, -8 },
  { 33, 4, 10, 3, 0, -8 },
  { 38, 4, 10, 3, -1, -8 },
  { 43, 4, 5, 5, 1, -8 },
  { 46, 5, 6, 6, 0, -7 },
  { 50, 3, 2, 3, -1, -1 },
  { 51, 3, 2, 3, 0, -4 },
  { 52, 2, 2, 3, 0, -2 },
  { 53, 6, 8, 4, -1, -8 },
  { 59, 5, 8, 5, 0, -8 },
  { 64, 4, 8, 5, 1, -8 },
  { 68, 5, 8, 5, 0, -8 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 5, 8, 5, 0, -8 },
  { 83, 5, 8, 5, 0, -8 },
  { 88, 6, 8, 5, 0, -8 },
  { 94, 6, 8, 5, 0, -8 },
  { 100, 5, 8, 5, 0, -8 },
  { 105, 5, 8, 5, 0, -8 },
  { 110, 3, 6, 3, 0, -6 },
  { 113, 4, 7, 3, -1, -6 },
  { 117, 5, 6, 6, 0, -7 },
  { 121, 5, 4, 6, 0, -6 },
  { 124, 5, 6, 6, 0, -7 },
  { 128, 5, 8, 4, 0, -8 },
  { 133, 8, 9, 8, 0, -8 },
  { 142, 6, 8, 6, -1, -8 },
  { 148, 6, 8, 6, 0, -8 },
  { 154, 6, 8, 6, 0, -8 },
  { 160, 6, 8, 6, 0, -8 },
  { 166, 5, 8, 5, 0, -8 },
  { 171, 5, 8, 5, 0, -8 },
  { 176, 7, 8, 6, 0, -8 },
  { 183, 7, 8, 7, 0, -8 },
  { 190, 5, 8, 4, 0, -8 },
  { 195, 5, 10, 3, -2, -8 },
  { 202, 7, 8, 6, 0, -8 },
  { 209, 4, 8, 5, 0, -8 },
  { 213, 9, 8, 8, 0, -8 },
  { 222, 7, 8, 7, 0, -8 },
  { 229, 7, 8, 7, 0, -8 },
  { 236, 6, 8, 6, 0, -8 },
  { 242, 7, 10, 7, 0, -8 },
  { 251, 6, 8, 6, 0, -8 },
  { 257, 5, 8, 5, 0, -8 },
  { 262, 5, 8, 5, 1, -8 },
  { 267, 7, 8, 6, 0, -8 },
  { 274, 6, 8, 6, 1, -8 },
  { 280, 9, 8, 9, 1, -8 },
  { 289, 8, 8, 6, -1, -8 },
  { 297, 5, 8, 5, 1, -8 },
  { 302, 6, 8, 5, 0, -8 },
  { 308, 4, 10, 3, 0, -8 },
  { 313, 3, 8, 4, 1, -8 },
  { 316, 5, 10, 3, -1, -8 },
  { 323, 5, 5, 5, 0, -8 },
  { 327, 4, 1, 4, -1, 1 },
  { 328, 2, 1, 4, 2, -8 },
  { 329, 6, 6, 6, 0, -6 },
  { 334, 5, 8, 6, 0, -8 },
  { 339, 5, 6, 5, 0, -6 },
  { 343, 6, 8, 6, 0, -8 },
  { 349, 5, 6, 5, 0, -6 },
  { 353, 6, 11, 4, -1, -8 },
  { 362, 6, 9, 6, 0, -6 },
  { 369, 5, 8, 6, 0, -8 },
  { 374, 3, 8, 3, 0, -8 },
  { 377, 4, 11, 3, -1, -8 },
  { 383, 6, 8, 5, 0, -8 },
  { 389, 3, 8, 3, 0, -8 },
  { 392, 8, 6, 8, 0, -6 },
  { 398, 5, 6, 6, 0, -6 },
  { 402, 5, 6, 6, 0, -6 },
  { 406, 6, 9, 6, -1, -6 },
  { 413, 6, 9, 6, 0, -6 },
  { 420, 5, 6, 4, 0, -6 },
  { 424, 5, 6, 4, 0, -6 },
  { 428, 4, 7, 4, 0, -7 },
  { 432, 6, 6, 6, 0, -6 },
  { 437, 5, 6, 5, 1, -6 },
  { 441, 7, 6, 8, 1, -6 },
  { 447, 7, 6, 5, -1, -6 },
  { 453, 7, 9, 5, -1, -6 },
  { 461, 5, 6, 4, 0, -6 },
  { 465, 5, 10, 4, 0, -8 },
  { 472, 1, 11, 5, 2, -8 },
  { 474, 5, 10, 4, -1, -8 },
  { 481, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC11PT7B_H_
