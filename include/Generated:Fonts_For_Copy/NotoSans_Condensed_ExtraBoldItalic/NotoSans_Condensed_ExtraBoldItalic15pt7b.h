#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x80, 0x07, 0x30, 0x6D, 0xB6, 0xF6, 0x0B,
  0x0D, 0x86, 0x8F, 0xF7, 0xF1, 0xB3, 0xFD, 0xFC, 0x6C, 0x34, 0x36, 0x00,
  0x04, 0x7C, 0xFB, 0x47, 0x87, 0x87, 0x0F, 0xDD, 0xF8, 0x81, 0x00, 0x31,
  0x9C, 0x4D, 0xB3, 0x48, 0xB6, 0xBF, 0x7E, 0xB4, 0x6D, 0x12, 0xCC, 0xB6,
  0x38, 0x0E, 0x0F, 0x0D, 0x86, 0xC3, 0xC1, 0xCD, 0xFD, 0xDE, 0xCE, 0x7F,
  0x1F, 0xC0, 0x6D, 0xE0, 0x1C, 0x63, 0x0C, 0x61, 0x86, 0x30, 0xC3, 0x0C,
  0x30, 0x60, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x8C, 0xCC, 0x00, 0x20,
  0x65, 0x3F, 0x37, 0xE4, 0xC0, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x00, 0x76,
  0x6C, 0xFF, 0xF8, 0x03, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x60, 0xE0, 0x1C, 0x7C, 0xDB, 0xB6, 0x6C, 0xD9, 0xF7, 0xEC, 0xF9, 0xE0,
  0x0C, 0x77, 0xBE, 0x58, 0x63, 0x8C, 0x30, 0xC7, 0x00, 0x1C, 0xFC, 0x98,
  0x30, 0xE1, 0x86, 0x18, 0x61, 0xFB, 0xF0, 0x1C, 0x7C, 0x98, 0x30, 0xC7,
  0x07, 0x06, 0x8D, 0xFB, 0xE0, 0x06, 0x1C, 0x38, 0xB3, 0xCD, 0x93, 0x7F,
  0xFE, 0x30, 0x60, 0x3E, 0x7C, 0xC1, 0x87, 0xCF, 0x83, 0x87, 0x8D, 0xFB,
  0xE0, 0x0F, 0x1E, 0x38, 0x70, 0x6C, 0x7E, 0x66, 0xEE, 0x6C, 0x7C, 0x78,
  0x3F, 0x3F, 0x46, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x1C,
  0x7C, 0xD9, 0xB3, 0xE7, 0x1F, 0x77, 0xCD, 0xF9, 0xE0, 0x1C, 0x7D, 0xDB,
  0x36, 0x6F, 0xDD, 0x86, 0x0D, 0xF3, 0xC0, 0x77, 0x00, 0x00, 0xEC, 0x39,
  0xC0, 0x00, 0x01, 0xCC, 0x66, 0x00, 0x04, 0x77, 0xB0, 0xF0, 0xF0, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x3F, 0xC8, 0x00, 0x7F, 0xE6,
  0x33, 0xB9, 0x90, 0x06, 0x30, 0x07, 0x83, 0xF8, 0xC1, 0x93, 0xF6, 0xD6,
  0xB6, 0xD6, 0xDE, 0xDA, 0xDF, 0x88, 0x01, 0x84, 0x1F, 0x80, 0x07, 0x0F,
  0x0F, 0x1F, 0x1B, 0x1B, 0x33, 0x3F, 0x7F, 0x63, 0xE3, 0x3E, 0x3F, 0x33,
  0x33, 0x76, 0x7C, 0x66, 0x66, 0x66, 0xFE, 0xFC, 0x1E, 0x7D, 0xCF, 0x0E,
  0x18, 0x30, 0x60, 0xC1, 0xF1, 0xE0, 0x3C, 0x3F, 0x37, 0x33, 0x73, 0x73,
  0x63, 0x67, 0x6E, 0xFC, 0xF8, 0x3E, 0x7C, 0xC1, 0x87, 0xCF, 0x98, 0x30,
  0x61, 0xFB, 0xE0, 0x3E, 0x7C, 0xC1, 0x87, 0x0F, 0x9F, 0x30, 0x61, 0xC3,
  0x00, 0x1E, 0x3F, 0x72, 0xE0, 0xE0, 0xCE, 0xDE, 0xC6, 0xCE, 0xFC, 0x7C,
  0x39, 0x98, 0xCC, 0x66, 0x77, 0xF3, 0xF9, 0x8C, 0xCE, 0x67, 0x73, 0x31,
  0x80, 0x1E, 0x7C, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x30, 0xF3, 0xE0, 0x0E,
  0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xE1, 0x8F, 0x1C, 0x00,
  0x39, 0x99, 0x8D, 0xC6, 0xC7, 0xC3, 0xE1, 0xF0, 0xD8, 0x6E, 0x77, 0x31,
  0x80, 0x38, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0xFF, 0x80, 0x38, 0x73,
  0x8F, 0x38, 0xE3, 0x9E, 0x69, 0xE6, 0xB6, 0x6F, 0xE6, 0xEC, 0x6E, 0xCC,
  0xCC, 0xCD, 0xC0, 0x38, 0xCE, 0x33, 0x9C, 0xF6, 0x6D, 0x9B, 0x66, 0xD9,
  0xBC, 0x67, 0x31, 0xCC, 0x70, 0x1C, 0x3E, 0x77, 0xE3, 0xE3, 0xC7, 0xC7,
  0xC6, 0xCE, 0xFC, 0x78, 0x3C, 0x3F, 0x37, 0x33, 0x77, 0x7E, 0x7C, 0x60,
  0x60, 0xE0, 0xC0, 0x1C, 0x3E, 0x77, 0xE3, 0xE3, 0xC7, 0xC7, 0xC6, 0xCE,
  0xFC, 0x78, 0x18, 0x1C, 0x1C, 0x3C, 0x3F, 0x37, 0x37, 0x77, 0x7E, 0x7C,
  0x6C, 0x6C, 0xEE, 0xC6, 0x1E, 0x7D, 0xCB, 0x87, 0x07, 0x07, 0x06, 0x8D,
  0xFB, 0xE0, 0x7F, 0xFC, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x80,
  0x73, 0x63, 0x67, 0x66, 0xE6, 0xE6, 0xCE, 0xCE, 0xCC, 0xFC, 0x78, 0xE3,
  0xE7, 0xE6, 0xEE, 0xEC, 0x6C, 0x78, 0x78, 0x70, 0x70, 0x70, 0xE6, 0x3C,
  0x67, 0xCE, 0x6C, 0xEE, 0xDE, 0xCD, 0xEC, 0xDF, 0xCF, 0x78, 0xF7, 0x8E,
  0x70, 0xE7, 0x00, 0x19, 0xC6, 0x61, 0xB0, 0x7C, 0x0E, 0x03, 0x81, 0xE0,
  0xF8, 0x36, 0x1D, 0x8E, 0x70, 0xE7, 0x66, 0x6C, 0x6C, 0x78, 0x78, 0x70,
  0x70, 0x60, 0x60, 0x60, 0x1F, 0x9F, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x3F, 0x3F, 0x80, 0x1E, 0x38, 0x60, 0xC3, 0x06, 0x0C, 0x18,
  0x60, 0xC1, 0x83, 0x0F, 0x00, 0x9B, 0x6D, 0xB2, 0x6D, 0x80, 0x1C, 0xF0,
  0xC6, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0xE0, 0x08, 0x38, 0x71, 0xE2,
  0x4C, 0xF1, 0x80, 0xFF, 0xE0, 0xEC, 0x3B, 0x7E, 0x66, 0x66, 0xE6, 0xEE,
  0xFC, 0x7C, 0x38, 0x60, 0xC1, 0xF7, 0xEC, 0xD9, 0xB3, 0xEF, 0xFB, 0xE0,
  0x3E, 0xF9, 0x83, 0x0E, 0x1C, 0x1E, 0x3C, 0x03, 0x03, 0x03, 0x3F, 0x7E,
  0x66, 0x66, 0xE6, 0xEC, 0xFC, 0x7C, 0x3E, 0xED, 0x9B, 0xEF, 0x1C, 0x1F,
  0x3E, 0x07, 0x87, 0x83, 0x43, 0xC1, 0xE0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x07, 0x81, 0x00, 0x3B, 0x7E, 0x66, 0x66, 0xEE, 0xEC,
  0xFC, 0x7C, 0x0C, 0x9C, 0xF8, 0x60, 0x38, 0x60, 0xC1, 0xF7, 0xEC, 0xD9,
  0xB3, 0xEF, 0xDB, 0x30, 0x11, 0xCC, 0x03, 0x39, 0x8C, 0x67, 0x39, 0x80,
  0x04, 0x1C, 0x30, 0x00, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x0E,
  0x38, 0x60, 0x38, 0x30, 0x30, 0x37, 0x7E, 0x6C, 0x78, 0x7C, 0xEC, 0xCC,
  0xCE, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0xE7, 0x30, 0x2F, 0xEF, 0xFD, 0x99,
  0xB3, 0x36, 0x6D, 0xDD, 0xB3, 0x36, 0x66, 0x2E, 0xFD, 0x9B, 0x36, 0x7D,
  0xFB, 0x66, 0x3E, 0xFD, 0x9B, 0x3E, 0x7D, 0xDF, 0x3C, 0x17, 0x3B, 0x33,
  0x33, 0x33, 0x77, 0x7E, 0x6C, 0x60, 0x60, 0xE0, 0xC0, 0x3B, 0x7E, 0x66,
  0x66, 0xE6, 0xEC, 0xFC, 0x7C, 0x0C, 0x1C, 0x18, 0x18, 0x3D, 0xF7, 0x18,
  0x63, 0x8E, 0x30, 0x7D, 0x96, 0x1E, 0x38, 0x6F, 0xBC, 0x23, 0x3F, 0xEE,
  0x63, 0x18, 0xE7, 0x00, 0x37, 0x76, 0x66, 0x66, 0x6E, 0xEE, 0xFC, 0x7C,
  0xCF, 0x9B, 0x66, 0xCF, 0x1E, 0x38, 0x70, 0xDC, 0xF7, 0x6D, 0xDB, 0xF6,
  0xFF, 0x3B, 0xCE, 0xE3, 0xB8, 0x3B, 0x8F, 0x87, 0x83, 0x81, 0xC1, 0xE1,
  0xF9, 0xCC, 0x33, 0x99, 0x8D, 0x86, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x30,
  0x18, 0x38, 0x18, 0x00, 0x3E, 0x7C, 0x30, 0xC3, 0x86, 0x1F, 0x7E, 0x0C,
  0x71, 0x8E, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x70, 0xFF, 0xFF, 0xFF,
  0xF0, 0x10, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x30, 0xC3, 0x18, 0xE0, 0x47,
  0xF9, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 6, 4, 6, 1, -11 },
  { 11, 9, 11, 8, 0, -11 },
  { 24, 7, 12, 7, 0, -11 },
  { 35, 10, 11, 12, 1, -11 },
  { 49, 9, 11, 9, 0, -11 },
  { 62, 3, 4, 4, 1, -11 },
  { 64, 6, 13, 4, 0, -11 },
  { 74, 5, 13, 5, -1, -11 },
  { 83, 6, 7, 7, 1, -12 },
  { 89, 6, 7, 8, 1, -9 },
  { 95, 4, 4, 4, -1, -2 },
  { 97, 4, 2, 5, 0, -5 },
  { 98, 3, 2, 4, 0, -2 },
  { 99, 8, 11, 6, -1, -11 },
  { 110, 7, 11, 7, 0, -11 },
  { 120, 6, 11, 7, 1, -11 },
  { 129, 7, 11, 7, 0, -11 },
  { 139, 7, 11, 7, 0, -11 },
  { 149, 7, 11, 7, 0, -11 },
  { 159, 7, 11, 7, 0, -11 },
  { 169, 8, 11, 7, 0, -11 },
  { 180, 8, 11, 7, 0, -11 },
  { 191, 7, 11, 7, 0, -11 },
  { 201, 7, 11, 7, 0, -11 },
  { 211, 4, 8, 4, 0, -8 },
  { 215, 5, 10, 4, -1, -8 },
  { 222, 6, 7, 8, 1, -9 },
  { 228, 6, 5, 8, 1, -8 },
  { 232, 6, 7, 8, 1, -9 },
  { 238, 5, 11, 6, 1, -11 },
  { 245, 11, 12, 11, 0, -11 },
  { 262, 8, 11, 8, -1, -11 },
  { 273, 8, 11, 8, 0, -11 },
  { 284, 7, 11, 8, 1, -11 },
  { 294, 8, 11, 9, 0, -11 },
  { 305, 7, 11, 7, 0, -11 },
  { 315, 7, 11, 7, 0, -11 },
  { 325, 8, 11, 9, 1, -11 },
  { 336, 9, 11, 9, 0, -11 },
  { 349, 7, 11, 5, -1, -11 },
  { 359, 7, 14, 4, -2, -11 },
  { 372, 9, 11, 8, 0, -11 },
  { 385, 6, 11, 6, 0, -11 },
  { 394, 12, 11, 12, 0, -11 },
  { 411, 10, 11, 10, 0, -11 },
  { 425, 8, 11, 9, 1, -11 },
  { 436, 8, 11, 8, 0, -11 },
  { 447, 8, 14, 9, 1, -11 },
  { 461, 8, 11, 8, 0, -11 },
  { 472, 7, 11, 7, 0, -11 },
  { 482, 7, 11, 7, 1, -11 },
  { 492, 8, 11, 9, 1, -11 },
  { 503, 8, 11, 8, 1, -11 },
  { 514, 12, 11, 12, 1, -11 },
  { 531, 10, 11, 8, -1, -11 },
  { 545, 8, 11, 7, 1, -11 },
  { 556, 9, 11, 7, -1, -11 },
  { 569, 7, 13, 5, -1, -11 },
  { 581, 3, 11, 6, 2, -11 },
  { 586, 6, 13, 5, -1, -11 },
  { 596, 7, 7, 7, 0, -11 },
  { 603, 6, 2, 6, -1, 1 },
  { 605, 3, 2, 5, 2, -11 },
  { 606, 8, 8, 8, 0, -8 },
  { 614, 7, 11, 8, 0, -11 },
  { 624, 7, 8, 6, 0, -8 },
  { 631, 8, 11, 8, 0, -11 },
  { 642, 7, 8, 7, 0, -8 },
  { 649, 9, 15, 5, -2, -11 },
  { 666, 8, 12, 8, 0, -8 },
  { 678, 7, 11, 8, 0, -11 },
  { 688, 5, 12, 4, 0, -12 },
  { 696, 7, 16, 4, -2, -12 },
  { 710, 8, 11, 7, 0, -11 },
  { 721, 5, 11, 4, 0, -11 },
  { 728, 11, 8, 11, 0, -8 },
  { 739, 7, 8, 8, 0, -8 },
  { 746, 7, 8, 8, 0, -8 },
  { 753, 8, 12, 8, -1, -8 },
  { 765, 8, 12, 8, 0, -8 },
  { 777, 6, 8, 5, 0, -8 },
  { 783, 6, 8, 6, 0, -8 },
  { 789, 5, 10, 5, 1, -10 },
  { 796, 8, 8, 8, 0, -8 },
  { 804, 7, 8, 7, 1, -8 },
  { 811, 10, 8, 10, 1, -8 },
  { 821, 9, 8, 7, -1, -8 },
  { 830, 9, 12, 7, -1, -8 },
  { 844, 7, 8, 6, -1, -8 },
  { 851, 6, 13, 5, 0, -11 },
  { 861, 2, 14, 7, 2, -11 },
  { 865, 6, 13, 5, -1, -11 },
  { 875, 6, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC15PT7B_H_
