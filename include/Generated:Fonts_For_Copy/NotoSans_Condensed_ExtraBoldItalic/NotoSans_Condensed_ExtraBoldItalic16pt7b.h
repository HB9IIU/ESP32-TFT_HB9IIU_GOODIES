#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC16PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x80, 0x47, 0x38, 0x6E, 0xD9, 0xB6, 0x60,
  0x0D, 0x8D, 0x86, 0xCF, 0xF1, 0x61, 0xB3, 0xFD, 0xFE, 0x6C, 0x36, 0x16,
  0x00, 0x04, 0x1F, 0x3F, 0x3A, 0x78, 0x38, 0x1E, 0x0E, 0x96, 0xFE, 0xFC,
  0x10, 0x20, 0x30, 0x4F, 0x13, 0x66, 0x6D, 0x8D, 0xB1, 0xAD, 0xFF, 0x7A,
  0x7B, 0x1B, 0x62, 0x6C, 0xCF, 0x30, 0xE0, 0x04, 0x07, 0xC3, 0xB0, 0xCC,
  0x3E, 0x07, 0x13, 0xD9, 0xB6, 0xEF, 0x39, 0xCF, 0xF1, 0xEE, 0xFB, 0x40,
  0x0C, 0x63, 0x8C, 0x31, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xE1, 0x86, 0x00,
  0x18, 0x61, 0x86, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x0C, 0x61, 0x8C, 0x00,
  0x18, 0xB3, 0xF9, 0xF7, 0x8D, 0x8A, 0x00, 0x30, 0x60, 0xC7, 0xFF, 0xE6,
  0x0C, 0x18, 0x76, 0x6C, 0xFF, 0x80, 0x5F, 0x80, 0x01, 0x81, 0x81, 0xC0,
  0xC0, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00, 0x0C, 0x1E,
  0x3F, 0x37, 0x77, 0x67, 0x66, 0x66, 0xEE, 0xEC, 0x7C, 0x78, 0x1C, 0xFF,
  0xD7, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x00, 0x06, 0x0F, 0x8F, 0xE2, 0x70,
  0x30, 0x38, 0x38, 0x18, 0x18, 0x18, 0x1F, 0x9F, 0xC0, 0x0C, 0x3E, 0x3F,
  0x07, 0x06, 0x3C, 0x3C, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8, 0x07, 0x0E, 0x1E,
  0x16, 0x3E, 0x6E, 0xCC, 0xFE, 0xFE, 0x1C, 0x1C, 0x3F, 0x3F, 0x30, 0x30,
  0x7C, 0x7E, 0x0E, 0x0E, 0x8E, 0xFC, 0xF8, 0x0E, 0x7D, 0xEB, 0x0E, 0x9F,
  0xBF, 0x66, 0xCD, 0xBB, 0xE7, 0x80, 0x3F, 0x9F, 0x81, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x38, 0x00, 0x0C, 0x3F, 0x37, 0x33, 0x36,
  0x3C, 0x3C, 0x6E, 0xE6, 0xE6, 0xFC, 0x7C, 0x0C, 0x3E, 0x3F, 0x77, 0x67,
  0x67, 0x7E, 0x36, 0x0E, 0x0C, 0xF8, 0xF0, 0x37, 0x30, 0x00, 0x4E, 0xE0,
  0x19, 0xC6, 0x00, 0x00, 0x0E, 0x63, 0x30, 0x02, 0x1C, 0xF7, 0x8E, 0x0F,
  0x07, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x81, 0x83, 0xC1, 0xE0, 0xEF,
  0xB8, 0x40, 0x33, 0xF7, 0xC3, 0x18, 0xE6, 0x18, 0x01, 0x0C, 0x30, 0x01,
  0x00, 0xFC, 0x18, 0x63, 0x33, 0x67, 0xB6, 0xDB, 0x59, 0x25, 0xB2, 0xDB,
  0x6C, 0xDC, 0x40, 0x06, 0x10, 0x3F, 0x00, 0x07, 0x07, 0x83, 0xC3, 0xE1,
  0xB0, 0xDC, 0xFE, 0x7F, 0x73, 0xB1, 0xF8, 0xE0, 0x3F, 0x1F, 0xCC, 0xE6,
  0x67, 0xE3, 0xF1, 0x9C, 0xCE, 0x67, 0x7F, 0x3F, 0x00, 0x0C, 0x3F, 0x7E,
  0x70, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE4, 0xFC, 0x7C, 0x3F, 0x1F, 0xCC,
  0xE6, 0x77, 0x3B, 0x9D, 0x8E, 0xCE, 0x6F, 0x7F, 0x3E, 0x00, 0x3F, 0x3F,
  0x30, 0x30, 0x7E, 0x7C, 0x60, 0x60, 0x60, 0xFC, 0xFC, 0x3F, 0x3E, 0x30,
  0x30, 0x7E, 0x7C, 0x7C, 0x60, 0x60, 0xE0, 0xE0, 0x06, 0x1F, 0xDF, 0xCE,
  0x0E, 0x07, 0x7B, 0x3D, 0x9C, 0xC6, 0x73, 0x3F, 0x8F, 0xC0, 0x39, 0xCE,
  0x73, 0x18, 0xC6, 0x7F, 0x9F, 0xE6, 0x31, 0x8C, 0x63, 0x39, 0xCE, 0x70,
  0x1F, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x78, 0xFC, 0x07,
  0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x78,
  0xF0, 0x39, 0xCC, 0xE3, 0x70, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0x6E,
  0x39, 0x8E, 0x70, 0x38, 0xE3, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0xFF, 0xC0,
  0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE7, 0xDF, 0x36, 0xF1, 0xBD, 0x8D,
  0xEC, 0x6E, 0x67, 0x77, 0x33, 0x30, 0x38, 0xE7, 0x98, 0xF3, 0x1E, 0x67,
  0xDC, 0xDF, 0x19, 0xE3, 0x3C, 0x67, 0x9C, 0xF3, 0x1C, 0x00, 0x0C, 0x1F,
  0x9F, 0xCC, 0x7E, 0x3F, 0x1F, 0x0D, 0x8E, 0xC7, 0x67, 0x3F, 0x8F, 0x00,
  0x3F, 0x1F, 0x8C, 0xE6, 0x77, 0x73, 0xF9, 0xF0, 0xC0, 0x60, 0x70, 0x38,
  0x00, 0x0C, 0x1F, 0x9F, 0xCC, 0x7E, 0x3F, 0x1F, 0x0D, 0x8E, 0xC7, 0x67,
  0x3F, 0x8F, 0x01, 0xC0, 0xE0, 0x38, 0x3F, 0x3F, 0x33, 0x33, 0x77, 0x7E,
  0x7C, 0x6E, 0x6E, 0xE6, 0xE7, 0x0C, 0x3F, 0x3E, 0x70, 0x70, 0x38, 0x3C,
  0x1C, 0x0E, 0x8C, 0xFC, 0xF8, 0x7F, 0xFC, 0xE1, 0x83, 0x06, 0x1C, 0x38,
  0x60, 0xC3, 0x80, 0x73, 0xB1, 0x98, 0xCC, 0xEE, 0x77, 0x33, 0x19, 0x8C,
  0xCE, 0x7E, 0x1E, 0x00, 0xE3, 0xF3, 0x99, 0x8C, 0xC6, 0xE3, 0x61, 0xF0,
  0xF0, 0x78, 0x38, 0x1C, 0x00, 0xE7, 0x3F, 0x39, 0xBB, 0xDD, 0xDE, 0xCE,
  0xF6, 0x7D, 0xF3, 0x6F, 0x1E, 0x78, 0xF3, 0x87, 0x9C, 0x38, 0xC0, 0x19,
  0xC7, 0x61, 0xF8, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0xF8, 0x37, 0x1D, 0xCE,
  0x30, 0xE7, 0x66, 0x6E, 0x6C, 0x78, 0x78, 0x30, 0x70, 0x70, 0x60, 0x60,
  0x1F, 0x9F, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x3F, 0x3F,
  0x80, 0x1E, 0x3C, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x06,
  0x0E, 0x3C, 0x00, 0xDB, 0x6D, 0xBB, 0x6D, 0xB0, 0x1C, 0x72, 0xC3, 0x1C,
  0x61, 0x86, 0x18, 0xE3, 0x0C, 0x33, 0xCE, 0x00, 0x0C, 0x1C, 0x1E, 0x36,
  0x66, 0x66, 0xC3, 0x7F, 0xFC, 0xE7, 0x1B, 0x3F, 0x77, 0x67, 0x66, 0xE6,
  0xEE, 0x7E, 0x7C, 0x38, 0x38, 0x30, 0x36, 0x3F, 0x77, 0x67, 0x67, 0x66,
  0xEE, 0xFE, 0xDC, 0x1E, 0x7D, 0xCB, 0x06, 0x1C, 0x39, 0x3E, 0x78, 0x03,
  0x81, 0xC0, 0xC3, 0x63, 0xF3, 0xB9, 0x9C, 0xCC, 0xE6, 0x77, 0x1F, 0x8F,
  0x80, 0x1E, 0x7D, 0xDB, 0x37, 0xDC, 0x38, 0x3E, 0x7C, 0x07, 0x83, 0x83,
  0x81, 0xE1, 0xF0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81,
  0x83, 0xC1, 0xC0, 0x1B, 0x3F, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xFE, 0x7C,
  0x0C, 0x9C, 0xF8, 0xF0, 0x38, 0x38, 0x30, 0x36, 0x3F, 0x77, 0x77, 0x66,
  0x66, 0xE6, 0xEE, 0xCE, 0x39, 0xC0, 0x63, 0x39, 0xCC, 0x63, 0x39, 0x80,
  0x0E, 0x1C, 0x00, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x0E,
  0x3C, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x73, 0x73, 0xF1, 0xB0, 0xF8, 0x7C,
  0x76, 0x3B, 0x99, 0xC0, 0x39, 0xCC, 0x63, 0x39, 0xCC, 0x67, 0x39, 0x80,
  0x3E, 0x63, 0xFF, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0xE6, 0x6E, 0xEE,
  0xCC, 0xE0, 0x36, 0x3F, 0x77, 0x77, 0x66, 0x66, 0x66, 0xEE, 0xCE, 0x1C,
  0x3E, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0x7C, 0x78, 0x1F, 0x0F, 0xCE, 0xE6,
  0x73, 0x39, 0x99, 0xCC, 0xFE, 0x6E, 0x30, 0x18, 0x1C, 0x0E, 0x00, 0x1B,
  0x3F, 0x77, 0x67, 0x66, 0xE6, 0xEE, 0xFE, 0x7C, 0x0C, 0x0C, 0x1C, 0x1C,
  0x36, 0x79, 0xF3, 0x86, 0x0C, 0x38, 0x70, 0xC0, 0x3E, 0xF9, 0x93, 0x83,
  0x83, 0xA7, 0x7C, 0xF8, 0x31, 0x9F, 0xF6, 0x73, 0x18, 0xC7, 0xBC, 0x33,
  0x33, 0x77, 0x67, 0x66, 0x66, 0xEE, 0x7E, 0x74, 0xC7, 0x9F, 0x36, 0xED,
  0x9F, 0x3C, 0x78, 0xE0, 0xCE, 0xF9, 0xDB, 0x7B, 0x6F, 0xEF, 0x79, 0xEB,
  0x39, 0xC7, 0x38, 0xE6, 0x00, 0x3B, 0x9D, 0x87, 0xC3, 0xC1, 0xC0, 0xE0,
  0xF8, 0xEC, 0xE6, 0x00, 0x31, 0x99, 0xCC, 0xC6, 0xE3, 0x61, 0xB0, 0xF0,
  0x38, 0x18, 0x1C, 0x0C, 0x1E, 0x0E, 0x00, 0x3F, 0x3F, 0x0E, 0x0C, 0x18,
  0x38, 0x30, 0x7C, 0xFC, 0x1E, 0x38, 0x61, 0xC3, 0x9E, 0x30, 0x70, 0x70,
  0xC1, 0x83, 0x87, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF1, 0xC6,
  0x18, 0x70, 0xCF, 0x30, 0xC3, 0x1C, 0xE2, 0x00, 0xF3, 0xFE, 0x30,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 7, 4, 7, 1, -11 },
  { 12, 9, 11, 9, 0, -11 },
  { 25, 8, 13, 8, 0, -12 },
  { 38, 11, 12, 13, 1, -12 },
  { 55, 10, 12, 10, 0, -12 },
  { 70, 3, 4, 4, 2, -11 },
  { 72, 6, 15, 5, 0, -12 },
  { 84, 6, 15, 5, -1, -12 },
  { 96, 7, 7, 7, 1, -12 },
  { 103, 7, 8, 8, 1, -10 },
  { 110, 4, 4, 4, -1, -2 },
  { 112, 5, 2, 5, 0, -5 },
  { 114, 3, 3, 4, 0, -3 },
  { 116, 9, 12, 6, -1, -12 },
  { 130, 8, 12, 8, 0, -12 },
  { 142, 6, 11, 8, 1, -11 },
  { 151, 9, 12, 8, -1, -12 },
  { 165, 8, 12, 8, 0, -12 },
  { 177, 8, 11, 8, 0, -11 },
  { 188, 8, 11, 8, 0, -11 },
  { 199, 7, 12, 8, 1, -12 },
  { 210, 9, 11, 8, 0, -11 },
  { 223, 8, 12, 8, 0, -12 },
  { 235, 8, 12, 8, 0, -12 },
  { 247, 4, 9, 4, 0, -9 },
  { 252, 5, 11, 4, -1, -9 },
  { 259, 7, 8, 8, 1, -10 },
  { 266, 7, 5, 8, 1, -8 },
  { 271, 7, 8, 8, 1, -10 },
  { 278, 6, 12, 6, 1, -12 },
  { 287, 12, 13, 12, 0, -12 },
  { 307, 9, 11, 9, -1, -11 },
  { 320, 9, 11, 9, 0, -11 },
  { 333, 8, 12, 8, 1, -12 },
  { 345, 9, 11, 9, 0, -11 },
  { 358, 8, 11, 7, 0, -11 },
  { 369, 8, 11, 7, 0, -11 },
  { 380, 9, 12, 9, 1, -12 },
  { 394, 10, 11, 10, 0, -11 },
  { 408, 8, 11, 6, -1, -11 },
  { 419, 8, 14, 5, -3, -11 },
  { 433, 10, 11, 9, 0, -11 },
  { 447, 6, 11, 7, 0, -11 },
  { 456, 13, 11, 12, 0, -11 },
  { 474, 11, 11, 10, 0, -11 },
  { 490, 9, 12, 10, 1, -12 },
  { 504, 9, 11, 8, 0, -11 },
  { 517, 9, 15, 10, 1, -12 },
  { 534, 8, 11, 8, 0, -11 },
  { 545, 8, 12, 7, 0, -12 },
  { 557, 7, 11, 7, 1, -11 },
  { 567, 9, 11, 9, 1, -11 },
  { 580, 9, 11, 8, 1, -11 },
  { 593, 13, 11, 12, 1, -11 },
  { 611, 10, 11, 8, -1, -11 },
  { 625, 8, 11, 8, 1, -11 },
  { 636, 9, 11, 7, -1, -11 },
  { 649, 7, 15, 5, -1, -12 },
  { 663, 3, 12, 6, 2, -12 },
  { 668, 6, 15, 5, -1, -12 },
  { 680, 8, 7, 8, 0, -11 },
  { 687, 7, 2, 6, -2, 1 },
  { 689, 4, 2, 5, 2, -12 },
  { 690, 8, 9, 8, 0, -9 },
  { 699, 8, 12, 8, 0, -12 },
  { 711, 7, 9, 7, 0, -9 },
  { 719, 9, 12, 8, 0, -12 },
  { 733, 7, 9, 8, 0, -9 },
  { 741, 9, 16, 5, -2, -12 },
  { 759, 8, 13, 8, 0, -9 },
  { 772, 8, 12, 8, 0, -12 },
  { 784, 5, 12, 4, 0, -12 },
  { 792, 7, 16, 4, -2, -12 },
  { 806, 9, 12, 8, 0, -12 },
  { 820, 5, 12, 4, 0, -12 },
  { 828, 12, 9, 12, 0, -9 },
  { 842, 8, 9, 8, 0, -9 },
  { 851, 8, 9, 8, 0, -9 },
  { 860, 9, 13, 8, -1, -9 },
  { 875, 8, 13, 8, 0, -9 },
  { 888, 7, 9, 6, 0, -9 },
  { 896, 7, 9, 7, 0, -9 },
  { 904, 5, 11, 6, 1, -11 },
  { 911, 8, 9, 8, 0, -9 },
  { 920, 7, 9, 7, 1, -9 },
  { 928, 11, 9, 11, 1, -9 },
  { 941, 9, 9, 7, -1, -9 },
  { 952, 9, 13, 7, -1, -9 },
  { 967, 8, 9, 6, -1, -9 },
  { 976, 7, 14, 6, 0, -11 },
  { 989, 2, 16, 7, 2, -12 },
  { 993, 6, 14, 6, -1, -11 },
  { 1004, 7, 3, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC16PT7B_H_
