#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC29PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x30, 0x3C, 0x3E, 0x1F, 0x0F,
  0x00, 0x7B, 0xEF, 0x7B, 0xCF, 0x79, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x3C,
  0x01, 0xCF, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x1C,
  0xE4, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0x9C, 0x03, 0x9E, 0x01,
  0xCE, 0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x39, 0xC0, 0x38, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x3C, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x1F, 0x81, 0xFF, 0x0F, 0xFC, 0x7F, 0xE1, 0xE8, 0x87, 0xA0, 0x1E,
  0x80, 0x7E, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x90,
  0xDE, 0x62, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xF8, 0x3F, 0x80, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x1E, 0x03, 0xC3, 0xF0, 0x38, 0x7F, 0x87, 0x07, 0x78,
  0xF0, 0xF3, 0x8E, 0x0E, 0x79, 0xE0, 0xE7, 0x9C, 0x0E, 0x73, 0x80, 0xE7,
  0x79, 0xCE, 0xF7, 0x3E, 0xFE, 0xF7, 0xFF, 0xCE, 0xF7, 0x79, 0xCE, 0x70,
  0x3D, 0xE7, 0x03, 0x9C, 0x70, 0x79, 0xCF, 0x07, 0x1C, 0xE0, 0xE1, 0xCE,
  0x1E, 0x1F, 0xE1, 0xC1, 0xFC, 0x38, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x07, 0xF1, 0xE7, 0xFD, 0xF7, 0xFE, 0xF3,
  0xCF, 0xFB, 0xE7, 0xF9, 0xF1, 0xFC, 0xF8, 0xFC, 0x7E, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFB, 0xF0, 0x7B, 0xDF, 0xEF, 0x7B, 0x9C, 0x03, 0xC1,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x70, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x47, 0x87, 0x70, 0x7F, 0xFF,
  0xFF, 0x1F, 0xF1, 0xF1, 0x3F, 0x87, 0xFC, 0x3B, 0xC1, 0x1E, 0x01, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x3C, 0xF9, 0xE3, 0xCF, 0x1E, 0x78, 0x7F, 0x7F, 0x7F, 0xFF, 0x33, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x7F, 0x83,
  0xFC, 0x3F, 0xF3, 0xE7, 0x9E, 0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE1, 0xEF, 0x0F, 0x78, 0xFB, 0xC7, 0xDE, 0x3C, 0xF3, 0xE7,
  0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x7F,
  0x7F, 0xFF, 0xEF, 0x79, 0x9E, 0x4F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x01, 0xF0,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xE3, 0xE0, 0x87, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF, 0x08, 0x7C, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xFC, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x81, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF0, 0xFF, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x0E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0E, 0x3C,
  0x79, 0xF3, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x06,
  0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x81, 0xF3, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFE,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x20, 0x7B, 0xE1, 0xFF, 0xCF, 0xFF,
  0x3F, 0x3C, 0xF8, 0xF3, 0xE3, 0xCF, 0x1F, 0x3C, 0x7C, 0xF1, 0xE3, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0x3F, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xDE,
  0x0F, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xFC, 0x3F, 0xF1, 0xE3, 0xC7, 0x8F,
  0xBE, 0x3E, 0xF8, 0xF3, 0xE7, 0xC7, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x03,
  0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0x1E, 0x7C, 0xF8, 0xF3, 0xC7, 0xCF,
  0x1F, 0x3C, 0x7C, 0xF3, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0x78, 0x3B, 0xC0,
  0x0F, 0x00, 0x7C, 0x03, 0xE3, 0xBF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFE, 0x00,
  0x0E, 0x1F, 0x1F, 0x1E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x78, 0xF8, 0xF8, 0xF0, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x83, 0xE0, 0xF0,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x3E, 0x07, 0xF0,
  0xFF, 0x1F, 0xE3, 0xFC, 0x1F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00,
  0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x03, 0xF8,
  0x7F, 0x8F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x83,
  0xFE, 0x7F, 0xE3, 0xFE, 0x21, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07,
  0xFF, 0xC0, 0xF8, 0x1E, 0x1E, 0x00, 0xF1, 0xC1, 0x87, 0x38, 0xFF, 0x73,
  0x9F, 0xE7, 0x73, 0xCE, 0x77, 0x38, 0xE7, 0xE7, 0x9C, 0x7E, 0x71, 0xC7,
  0xE7, 0x1C, 0xEE, 0x71, 0xCE, 0xE7, 0x3D, 0xCE, 0x7F, 0xFC, 0xE7, 0xFF,
  0x8E, 0x18, 0x60, 0xF0, 0x00, 0x07, 0x00, 0x40, 0x7C, 0x3C, 0x03, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xEE, 0x01, 0xEE, 0x01, 0xEE, 0x03, 0xCF, 0x03, 0xCF, 0x07, 0xCF,
  0x07, 0x8F, 0x07, 0x8F, 0x0F, 0x8F, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0x0F, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E,
  0x1E, 0x3E, 0x1E, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C,
  0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1,
  0xF0, 0xC7, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x20,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0x87, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE0, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0x1F, 0x86, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xFE,
  0x78, 0xFE, 0xF8, 0xFE, 0xF9, 0xFC, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C,
  0xFC, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xC3,
  0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x3E, 0x07, 0xDF, 0x01, 0xF7,
  0xC0, 0x7B, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0x7C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x1E,
  0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xE0, 0xF8, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E,
  0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE7, 0xF8, 0x3F, 0xCE, 0xF0, 0xF7, 0xBD, 0xE1, 0xEF, 0x7B,
  0xC3, 0xDF, 0xEF, 0x87, 0xBF, 0xDE, 0x1F, 0x7F, 0x3C, 0x3C, 0xFE, 0x78,
  0x79, 0xF9, 0xF0, 0xF3, 0xF3, 0xC1, 0xE7, 0xC7, 0x87, 0xCF, 0x8F, 0x0F,
  0x1E, 0x3E, 0x00, 0x0F, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F, 0x07, 0x87, 0xE0,
  0xF0, 0xFC, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1F, 0xE7,
  0xC3, 0xFC, 0xF0, 0xF3, 0xDE, 0x1E, 0x7B, 0xC3, 0xCF, 0x78, 0x79, 0xEF,
  0x1F, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE1, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0x7C,
  0x0F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0x3E, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x3E, 0x0F, 0x7C, 0x0F, 0x7C, 0x0F, 0x7C,
  0x0F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x7E, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x1F,
  0x1E, 0x3E, 0x3D, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFE, 0x07, 0xBE, 0x1F,
  0x7C, 0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xF1, 0xE3, 0xE7, 0xC3, 0xCF, 0x87,
  0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x18, 0x78, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0xC1, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF0,
  0x7F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x1F, 0x0F, 0x8F, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x87, 0x87, 0x83, 0xC3, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8,
  0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x3F,
  0xE0, 0xFB, 0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x78,
  0xF0, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x78, 0x3C, 0x1E, 0xF0, 0xF8, 0x7D, 0xE1, 0xF0, 0xF3, 0xC3,
  0xE3, 0xEF, 0x8F, 0xC7, 0xDF, 0x1F, 0x8F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFE,
  0x78, 0xF9, 0xFC, 0xF1, 0xF7, 0xFB, 0xC3, 0xCE, 0xF7, 0x87, 0xBD, 0xDF,
  0x0F, 0x7B, 0xBC, 0x1E, 0xE7, 0x78, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xE7,
  0xC0, 0x3C, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF8,
  0x3E, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0xBE, 0x7C,
  0xF9, 0xE3, 0xEF, 0x87, 0xBC, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1,
  0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xE0, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0x9C, 0x1E, 0x78, 0xF1, 0xE3, 0x87, 0x9E, 0x0E, 0xF0, 0x3C,
  0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0xF9, 0xE3, 0xCF, 0x0F, 0x3C, 0x7E, 0xF3,
  0xFF, 0x9F, 0xFE, 0x7C, 0xF9, 0xE3, 0xEF, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x1F, 0x3C, 0x7C, 0xFB, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0x78,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xEF,
  0x87, 0xFE, 0x1F, 0xFC, 0x7D, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1,
  0xF7, 0xC7, 0xDF, 0x1E, 0x78, 0x79, 0xF3, 0xE7, 0xDF, 0x3F, 0xFC, 0xFF,
  0xE3, 0xDF, 0x00, 0x07, 0xE1, 0xFF, 0x3F, 0xE3, 0xEC, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xFB, 0x8F, 0xF8,
  0x7F, 0x83, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x83, 0xCF, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3,
  0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xE3,
  0xC3, 0xEF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xBC, 0x00, 0x07, 0xE1, 0xFF,
  0x3F, 0xF3, 0xCF, 0x78, 0x77, 0x8F, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0x80,
  0xF0, 0x0F, 0x00, 0xF8, 0x4F, 0xFC, 0x7F, 0xC3, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x07, 0xDE, 0x1F, 0xBC, 0x7F,
  0xF0, 0xFF, 0xE3, 0xE7, 0xC7, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x01, 0xE0, 0x03, 0xC2, 0x0F, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xEF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF3, 0xE3, 0xCF, 0x8F,
  0x3C, 0x7C, 0xF1, 0xF7, 0xC7, 0x9F, 0x1E, 0x78, 0x79, 0xE3, 0xE7, 0x8F,
  0x3E, 0x3C, 0xF8, 0xF3, 0xC7, 0xC0, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0x00,
  0x00, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x07,
  0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x1E,
  0x7C, 0x1E, 0xF8, 0x3E, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0, 0x79, 0xF0, 0xF9, 0xF0, 0xF8,
  0xF0, 0xF0, 0xF8, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C,
  0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E,
  0x1F, 0x0F, 0x87, 0x80, 0x1E, 0xF8, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xE3, 0xC7, 0x9F, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7, 0x8F,
  0x1F, 0x3C, 0x78, 0xF3, 0xE3, 0xC7, 0x9E, 0x3E, 0x3C, 0xF1, 0xF1, 0xE7,
  0x8F, 0x1F, 0x7C, 0x78, 0xF3, 0xE3, 0xC7, 0x9E, 0x3E, 0x3C, 0x1E, 0xF8,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3E, 0x3C, 0xF8, 0xF3, 0xC7, 0xCF, 0x1F,
  0x3C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xF3, 0xE3, 0xCF, 0x8F,
  0x3C, 0x7C, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x7F, 0xF7, 0xCF, 0xBC, 0x7F,
  0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xEF, 0xBE, 0x7F,
  0xE1, 0xFF, 0x07, 0xE0, 0x07, 0xBE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xDF,
  0x0F, 0x8F, 0x0F, 0x8F, 0x0F, 0x0F, 0x0F, 0x1F, 0x0F, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1F, 0x3E, 0x1F, 0x7C, 0x3F, 0xFC, 0x3D, 0xF8, 0x3D, 0xF0,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x0F, 0xBC, 0x7E, 0xF3, 0xFF, 0x8F, 0xFE, 0x7C, 0xF9, 0xE3,
  0xEF, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0x78, 0xFB,
  0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0xF1, 0xFF, 0x1F, 0xE1,
  0xFE, 0x3F, 0x23, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xE3,
  0xC6, 0x3C, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7C, 0x07, 0xC8,
  0x3C, 0xE7, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x0F, 0x03, 0x81, 0xE0, 0xFF,
  0x7F, 0xFF, 0xEF, 0xF8, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E,
  0x0F, 0x83, 0xE8, 0xFE, 0x3F, 0x87, 0xE0, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7,
  0x9F, 0x1E, 0x7C, 0x79, 0xE1, 0xE7, 0x8F, 0x9E, 0x3C, 0xF8, 0xF3, 0xC3,
  0xCF, 0x1F, 0x3C, 0x7C, 0xFB, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0x78, 0xF0,
  0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x3E, 0x79, 0xE3, 0xCF, 0x1E, 0xF0,
  0xF7, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x01, 0xF0, 0x0F,
  0x00, 0xF1, 0xF1, 0xFF, 0x1F, 0x1E, 0xF3, 0xF3, 0xEF, 0x3F, 0x3C, 0xF3,
  0xF3, 0xCF, 0x77, 0x78, 0xF7, 0xF7, 0x8F, 0xFF, 0xF0, 0xFE, 0xFF, 0x0E,
  0xEF, 0xF0, 0xFE, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x87, 0xCF, 0x81, 0xE7, 0x80,
  0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xEF, 0x81, 0xF3, 0xC0, 0xF1,
  0xE1, 0xF8, 0xF8, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0,
  0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07,
  0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xF0, 0x7E,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x07, 0xE0,
  0x7C, 0x0F, 0x80, 0xFC, 0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x7C, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0,
  0xF8, 0x08, 0x00, 0x3C, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 11, 8, 12, 3, -21 },
  { 36, 17, 21, 16, 0, -21 },
  { 81, 14, 24, 14, 0, -22 },
  { 123, 20, 21, 23, 2, -21 },
  { 176, 17, 21, 18, 0, -21 },
  { 221, 5, 8, 7, 3, -21 },
  { 226, 10, 26, 9, 1, -21 },
  { 259, 10, 26, 9, -2, -21 },
  { 292, 12, 13, 13, 2, -22 },
  { 312, 13, 14, 15, 1, -17 },
  { 335, 7, 8, 8, -2, -4 },
  { 342, 8, 4, 9, 0, -10 },
  { 346, 5, 5, 8, 0, -5 },
  { 350, 16, 21, 12, -2, -21 },
  { 392, 13, 21, 14, 1, -21 },
  { 427, 10, 21, 14, 3, -21 },
  { 454, 15, 21, 14, -1, -21 },
  { 494, 14, 21, 14, 0, -21 },
  { 531, 14, 21, 14, 0, -21 },
  { 568, 14, 21, 14, 0, -21 },
  { 605, 14, 21, 14, 1, -21 },
  { 642, 15, 21, 14, 1, -21 },
  { 682, 14, 21, 14, 0, -21 },
  { 719, 14, 21, 14, 0, -21 },
  { 756, 8, 16, 8, 0, -16 },
  { 772, 10, 20, 8, -2, -16 },
  { 797, 13, 15, 15, 1, -18 },
  { 822, 13, 9, 15, 1, -15 },
  { 837, 13, 15, 15, 1, -18 },
  { 862, 12, 21, 11, 1, -21 },
  { 894, 20, 23, 21, 1, -21 },
  { 952, 16, 21, 16, -2, -21 },
  { 994, 16, 21, 15, 0, -21 },
  { 1036, 15, 21, 15, 1, -21 },
  { 1076, 16, 21, 17, 0, -21 },
  { 1118, 14, 21, 13, 0, -21 },
  { 1155, 14, 21, 13, 0, -21 },
  { 1192, 16, 21, 17, 1, -21 },
  { 1234, 18, 21, 17, 0, -21 },
  { 1282, 13, 21, 10, -1, -21 },
  { 1317, 14, 27, 8, -5, -21 },
  { 1365, 18, 21, 15, 0, -21 },
  { 1413, 11, 21, 13, 0, -21 },
  { 1442, 23, 21, 22, 0, -21 },
  { 1503, 19, 21, 19, 0, -21 },
  { 1553, 16, 21, 18, 1, -21 },
  { 1595, 16, 21, 15, 0, -21 },
  { 1637, 16, 26, 18, 1, -21 },
  { 1689, 15, 21, 15, 0, -21 },
  { 1729, 14, 21, 13, 0, -21 },
  { 1766, 13, 21, 13, 2, -21 },
  { 1801, 17, 21, 17, 1, -21 },
  { 1846, 15, 21, 15, 3, -21 },
  { 1886, 23, 21, 23, 2, -21 },
  { 1947, 19, 21, 15, -2, -21 },
  { 1997, 14, 21, 14, 3, -21 },
  { 2034, 16, 21, 13, -1, -21 },
  { 2076, 12, 26, 9, -1, -21 },
  { 2115, 7, 21, 12, 3, -21 },
  { 2134, 12, 26, 9, -2, -21 },
  { 2173, 14, 13, 14, 0, -21 },
  { 2196, 12, 3, 11, -3, 2 },
  { 2201, 6, 4, 9, 4, -22 },
  { 2204, 14, 16, 15, 1, -16 },
  { 2232, 14, 22, 15, 0, -22 },
  { 2271, 12, 16, 12, 1, -16 },
  { 2295, 15, 22, 15, 1, -22 },
  { 2337, 12, 16, 14, 1, -16 },
  { 2361, 16, 29, 9, -3, -22 },
  { 2419, 15, 23, 15, 0, -16 },
  { 2463, 14, 22, 15, 0, -22 },
  { 2502, 9, 22, 8, 0, -22 },
  { 2527, 13, 29, 8, -4, -22 },
  { 2575, 16, 22, 14, 0, -22 },
  { 2619, 9, 22, 8, 0, -22 },
  { 2644, 21, 16, 22, 0, -16 },
  { 2686, 14, 16, 15, 0, -16 },
  { 2714, 13, 16, 15, 1, -16 },
  { 2740, 16, 23, 15, -2, -16 },
  { 2786, 14, 23, 15, 1, -16 },
  { 2827, 12, 16, 11, 0, -16 },
  { 2851, 12, 16, 12, 0, -16 },
  { 2875, 10, 19, 10, 1, -19 },
  { 2899, 14, 16, 15, 1, -16 },
  { 2927, 13, 16, 13, 2, -16 },
  { 2953, 20, 16, 20, 2, -16 },
  { 2993, 17, 16, 14, -2, -16 },
  { 3027, 17, 23, 13, -2, -16 },
  { 3076, 13, 16, 12, -1, -16 },
  { 3102, 12, 26, 10, 0, -21 },
  { 3141, 4, 29, 13, 4, -22 },
  { 3156, 12, 26, 10, -2, -21 },
  { 3195, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC29PT7B_H_
