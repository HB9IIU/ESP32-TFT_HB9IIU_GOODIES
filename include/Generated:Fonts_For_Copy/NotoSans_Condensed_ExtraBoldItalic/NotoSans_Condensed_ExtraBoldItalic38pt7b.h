#ifndef _NOTOSANS_CONDENSED_EXTRABOLDITALIC38PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRABOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0xFD, 0xF3, 0xF7, 0xCF, 0xBF,
  0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0x3C, 0x7C, 0xF1, 0xF3, 0xC7, 0x80,
  0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0x3E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x7F,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xB1,
  0x81, 0xF6, 0x00, 0x3E, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x6F, 0xC4, 0x0D, 0xF8, 0xC1, 0xBE, 0x1E, 0x6F, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xE0,
  0x7F, 0x80, 0x78, 0x1F, 0xF8, 0x1E, 0x03, 0xFF, 0x07, 0xC0, 0xF9, 0xE0,
  0xF0, 0x1E, 0x3C, 0x3C, 0x03, 0xC7, 0x87, 0x80, 0xF8, 0xF1, 0xE0, 0x1F,
  0x3E, 0x7C, 0x03, 0xC7, 0xCF, 0x00, 0x78, 0xF3, 0xC3, 0x0F, 0x3E, 0xF9,
  0xFD, 0xF7, 0x9E, 0x7F, 0xBF, 0xF7, 0xDF, 0xFB, 0xFC, 0xF3, 0xDF, 0x3F,
  0x3C, 0xF1, 0xE1, 0x0F, 0x9E, 0x3C, 0x01, 0xE7, 0xC7, 0x80, 0x7C, 0xF9,
  0xF0, 0x0F, 0x1E, 0x3E, 0x03, 0xC3, 0xC7, 0x80, 0xF8, 0x78, 0xF0, 0x1E,
  0x0F, 0x3E, 0x07, 0xC1, 0xFF, 0x80, 0xF0, 0x3F, 0xF0, 0x3C, 0x03, 0xFC,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xC3, 0xFE, 0x1F, 0x0F,
  0xFE, 0x7E, 0x3F, 0xFC, 0xFC, 0xFC, 0xFF, 0xF1, 0xF9, 0xFF, 0xE3, 0xE1,
  0xFF, 0x8F, 0xC3, 0xFE, 0x1F, 0x83, 0xFC, 0x3F, 0x07, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x1F,
  0xC0, 0x7E, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF1, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x43, 0xE0, 0x73, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0x7E, 0xF0, 0x7C, 0xF8, 0x3C, 0xFC,
  0x18, 0x70, 0x00, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xEF,
  0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xF8, 0x7F, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x3F, 0x0F, 0x9F, 0x87,
  0xCF, 0x83, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xCF, 0xC7, 0xE7,
  0xE3, 0xF3, 0xF3, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x0F, 0xFE, 0x7F, 0xFC, 0x7D, 0xF8, 0x73, 0xF0, 0xC7, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xE1, 0xF8, 0x18,
  0x3F, 0x02, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xC1, 0xF7, 0xF0, 0x60, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC8, 0x07, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7B, 0xF0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF3, 0xF0, 0x3E,
  0x7E, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xBF, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0x80,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFE, 0x20, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF3, 0x80, 0xFB, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFC, 0xFC, 0xFE, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x0F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC1, 0xF9, 0xF8, 0x3F, 0x7E,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x07, 0xE7, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0xCF, 0xC1, 0xF9,
  0xF8, 0x3E, 0x3F, 0x07, 0xC3, 0xF3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x30, 0x01, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0xFC, 0x7E, 0x7E, 0x1F, 0x3E, 0x0F,
  0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE3, 0xFB, 0xF9, 0xFD, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xDF, 0x81, 0x8F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE1, 0xDF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x7F, 0x1F, 0xC3,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xC3,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0xF7, 0xF2, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0xF8, 0x7F, 0xCE,
  0x1E, 0x1F, 0xF1, 0xE7, 0x87, 0xFE, 0x3C, 0xF1, 0xF3, 0xC7, 0xBC, 0x7C,
  0x78, 0xF7, 0x8F, 0x1E, 0x1C, 0xF3, 0xE3, 0xC7, 0x9C, 0x78, 0x78, 0xF7,
  0x8F, 0x0F, 0x1E, 0xF1, 0xE3, 0xE3, 0x9E, 0x3C, 0x78, 0xF3, 0xC7, 0x9F,
  0x3C, 0x78, 0xFF, 0xFF, 0x8F, 0x1F, 0xFF, 0xE1, 0xE1, 0xFB, 0xF8, 0x3C,
  0x1C, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x08,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00,
  0xF9, 0xF0, 0x0F, 0x9F, 0x01, 0xF9, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0,
  0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7E, 0x1F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0, 0x3F, 0x3F, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F,
  0x0F, 0x8F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0xFC, 0x3E, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x21,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x83, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x1F, 0xC3, 0xE1, 0xFC, 0x3F, 0x1F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0x81, 0x87, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE3, 0xFE, 0x7E, 0x1F, 0xF3,
  0xF0, 0xFF, 0x9F, 0x8F, 0xFC, 0xFC, 0x7F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0xFE, 0x07, 0xE1, 0xFC,
  0x07, 0xE1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xF0, 0x0F, 0xC7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xBF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC7, 0xDF, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC, 0x7B,
  0xF0, 0x7D, 0xF3, 0xEF, 0x81, 0xF7, 0xCF, 0x3E, 0x07, 0xDF, 0x7D, 0xF8,
  0x3F, 0x7D, 0xE7, 0xE0, 0xFD, 0xFF, 0x9F, 0x83, 0xE7, 0xFE, 0x7C, 0x0F,
  0x9F, 0xF1, 0xF0, 0x3E, 0x7F, 0xCF, 0xC1, 0xF8, 0xFE, 0x3F, 0x07, 0xC3,
  0xF8, 0xF8, 0x1F, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F, 0x0F, 0x83, 0xF0, 0xF8,
  0x7E, 0x0F, 0xC3, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0x81, 0xFC, 0x07,
  0xC1, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xF0, 0x7F, 0x81, 0xF0, 0x3F, 0xE0,
  0xF8, 0x3F, 0xF0, 0xFC, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3E, 0x07, 0xFF,
  0x1F, 0x03, 0xFF, 0x8F, 0x83, 0xF7, 0xCF, 0xC1, 0xF3, 0xE7, 0xE0, 0xF9,
  0xF3, 0xE0, 0x7C, 0xFD, 0xF0, 0x3E, 0x3E, 0xF8, 0x3F, 0x1F, 0x7C, 0x1F,
  0x8F, 0xFE, 0x0F, 0x87, 0xFE, 0x07, 0xC3, 0xFF, 0x03, 0xE0, 0xFF, 0x83,
  0xF0, 0x7F, 0xC1, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F,
  0x0F, 0xC7, 0xF0, 0x7F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0xFC, 0x7E, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7E, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xF1, 0xF8, 0x7E, 0x1F, 0x9F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x0F, 0xC7,
  0xF0, 0x7F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC,
  0x7E, 0x0F, 0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF3, 0xE0, 0x3F, 0x3F, 0x03, 0xF3,
  0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x60,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE1, 0x00, 0xFC, 0x38,
  0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8,
  0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1,
  0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07,
  0xE1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7,
  0xC0, 0xFC, 0x7C, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xC3, 0xF0,
  0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xFC,
  0x07, 0xDF, 0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0,
  0x3F, 0x03, 0xEF, 0xC0, 0xFC, 0x1F, 0xBF, 0x07, 0xF0, 0x7E, 0xFC, 0x1F,
  0xC3, 0xF3, 0xF0, 0xFE, 0x0F, 0xCF, 0xC3, 0xF8, 0x3E, 0x3F, 0x0F, 0xE1,
  0xF8, 0xFC, 0x7F, 0x87, 0xE3, 0xF1, 0xFE, 0x3F, 0x0F, 0xCF, 0xF8, 0xFC,
  0x3F, 0x3F, 0xE3, 0xE0, 0xFC, 0xF7, 0x9F, 0x83, 0xE7, 0xDE, 0x7E, 0x0F,
  0x9E, 0x79, 0xF0, 0x3E, 0xF9, 0xEF, 0xC0, 0xFB, 0xE7, 0xBE, 0x03, 0xFF,
  0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87,
  0xFC, 0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0xFB,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xEF,
  0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xEF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E,
  0x0F, 0x9F, 0x81, 0xF3, 0xF0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83,
  0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x7C, 0x3E,
  0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xC0, 0x79, 0xF0, 0x1F, 0xF8, 0x07, 0xC0,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x7E, 0x3E, 0x3F, 0x1F, 0x0F,
  0x03, 0xE3, 0xE1, 0xFE, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3,
  0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7,
  0xE3, 0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0xC1, 0xFE, 0xF8, 0x3F, 0xDE, 0x03,
  0xE3, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xDF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x07, 0xE3, 0xE0, 0xFC, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xFC, 0x7F,
  0x7F, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7D, 0xFE, 0x0F, 0x9F, 0x80, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0x04, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xE7, 0xC0, 0x7F, 0x7C, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFB, 0xC0, 0x3F, 0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF9, 0xF9, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3E, 0x7D,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x08, 0xFE, 0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0xF8, 0x0F, 0xEF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xBE, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0xC0, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xDF, 0x83, 0xEF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xC7, 0xF3, 0xF1, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x9F, 0x87, 0xE7, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x00,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xE1, 0xF8, 0x1F, 0x1F, 0x81,
  0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xBE, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03, 0xE1, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x9F, 0x87, 0xC0, 0xFB, 0xFD, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFC,
  0xFE, 0x3F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x0F, 0xC3,
  0xE3, 0xF0, 0xFC, 0x3E, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3E,
  0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0x7C, 0x7E, 0x1F, 0x87, 0xC7, 0xE1, 0xF0,
  0xFC, 0x7C, 0x3F, 0x0F, 0xC7, 0xC3, 0xF0, 0xF8, 0xFC, 0x3F, 0x0F, 0x8F,
  0xC3, 0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x80, 0x0F, 0x9F, 0x83, 0xEF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xF1, 0xF1, 0xF8, 0x7C, 0x7E,
  0x1F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x0F,
  0x8F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x0F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F,
  0x7E, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xF7, 0xE1,
  0xFB, 0xF0, 0xFD, 0xF8, 0xFC, 0xFE, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0x7F, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xBF, 0x03, 0xF8, 0xF8, 0x1F, 0x87, 0xE0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE0,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0xDF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xF7, 0xE0, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE3, 0xE0, 0xFE, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E,
  0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xF0,
  0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xE3,
  0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xE7,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x0F,
  0x9F, 0x0F, 0xBE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xFE, 0x3F, 0x9C, 0x3F, 0x04, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x81,
  0xF8, 0xF3, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xFD, 0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F,
  0x80, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xDE,
  0x03, 0xF3, 0xC0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF,
  0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0xFC,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0xFC, 0x3F, 0x07, 0xFF, 0x0F, 0xC3, 0xFF, 0xC7, 0xF0, 0xFB, 0xF1, 0xFC,
  0x7E, 0xFC, 0xFF, 0x1F, 0x3F, 0x3F, 0xC7, 0xCF, 0xCF, 0xF3, 0xF3, 0xF7,
  0xBC, 0xF8, 0xF9, 0xEF, 0x7E, 0x3E, 0xFB, 0xDF, 0x0F, 0xBC, 0xF7, 0xC3,
  0xEF, 0x3F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xE7, 0xFE, 0x0F, 0xF9, 0xFF,
  0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC,
  0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0x7C, 0x03, 0xF1,
  0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E,
  0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80,
  0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x3C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFA, 0x01,
  0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 27, 10, 0, -27 },
  { 42, 14, 10, 16, 4, -27 },
  { 60, 22, 27, 21, 0, -27 },
  { 135, 19, 31, 18, 0, -29 },
  { 209, 27, 28, 30, 2, -28 },
  { 304, 23, 28, 23, 0, -28 },
  { 385, 7, 10, 9, 4, -27 },
  { 394, 13, 34, 11, 1, -28 },
  { 450, 14, 34, 11, -3, -28 },
  { 510, 16, 17, 18, 3, -29 },
  { 544, 16, 19, 19, 2, -23 },
  { 582, 9, 10, 10, -2, -5 },
  { 594, 11, 5, 12, 0, -13 },
  { 601, 7, 6, 10, 0, -6 },
  { 607, 20, 27, 15, -2, -27 },
  { 675, 17, 28, 18, 1, -28 },
  { 735, 15, 27, 18, 3, -27 },
  { 786, 19, 28, 18, -1, -28 },
  { 853, 18, 28, 18, 0, -28 },
  { 916, 19, 27, 18, 0, -27 },
  { 981, 19, 27, 18, 0, -27 },
  { 1046, 18, 28, 18, 1, -28 },
  { 1109, 19, 27, 18, 1, -27 },
  { 1174, 19, 28, 18, 0, -28 },
  { 1241, 17, 28, 18, 1, -28 },
  { 1301, 10, 21, 10, 0, -21 },
  { 1328, 12, 26, 10, -2, -21 },
  { 1367, 16, 19, 19, 2, -23 },
  { 1405, 16, 13, 19, 2, -20 },
  { 1431, 17, 19, 19, 2, -23 },
  { 1472, 14, 28, 15, 2, -28 },
  { 1521, 27, 30, 28, 1, -27 },
  { 1623, 20, 27, 21, -2, -27 },
  { 1691, 20, 27, 20, 0, -27 },
  { 1759, 19, 28, 19, 2, -28 },
  { 1826, 21, 27, 22, 0, -27 },
  { 1897, 19, 27, 17, 0, -27 },
  { 1962, 19, 27, 17, 0, -27 },
  { 2027, 21, 28, 22, 2, -28 },
  { 2101, 24, 27, 23, 0, -27 },
  { 2182, 17, 27, 14, -1, -27 },
  { 2240, 18, 35, 11, -6, -27 },
  { 2319, 24, 27, 20, 0, -27 },
  { 2400, 14, 27, 16, 0, -27 },
  { 2448, 30, 27, 29, 0, -27 },
  { 2550, 25, 27, 24, 0, -27 },
  { 2635, 21, 28, 23, 2, -28 },
  { 2709, 20, 27, 20, 0, -27 },
  { 2777, 21, 34, 23, 2, -28 },
  { 2867, 20, 27, 20, 0, -27 },
  { 2935, 19, 28, 17, 0, -28 },
  { 3002, 17, 27, 17, 3, -27 },
  { 3060, 21, 27, 22, 2, -27 },
  { 3131, 20, 27, 20, 3, -27 },
  { 3199, 30, 27, 30, 3, -27 },
  { 3301, 24, 27, 20, -2, -27 },
  { 3382, 19, 27, 19, 3, -27 },
  { 3447, 21, 27, 17, -1, -27 },
  { 3518, 15, 34, 12, -1, -28 },
  { 3582, 9, 27, 15, 4, -27 },
  { 3613, 16, 34, 12, -3, -28 },
  { 3681, 18, 17, 18, 0, -27 },
  { 3720, 15, 3, 14, -4, 3 },
  { 3726, 8, 6, 12, 5, -29 },
  { 3732, 19, 21, 19, 1, -21 },
  { 3782, 19, 29, 19, 0, -29 },
  { 3851, 16, 21, 16, 1, -21 },
  { 3893, 20, 29, 19, 1, -29 },
  { 3966, 17, 21, 18, 1, -21 },
  { 4011, 20, 38, 12, -4, -29 },
  { 4106, 21, 30, 19, -1, -21 },
  { 4185, 18, 29, 20, 0, -29 },
  { 4251, 11, 29, 10, 0, -29 },
  { 4291, 17, 38, 10, -5, -29 },
  { 4372, 21, 29, 19, 0, -29 },
  { 4449, 12, 29, 10, 0, -29 },
  { 4493, 28, 21, 29, 0, -21 },
  { 4567, 18, 21, 20, 0, -21 },
  { 4615, 17, 21, 19, 1, -21 },
  { 4660, 21, 30, 19, -2, -21 },
  { 4739, 19, 30, 19, 1, -21 },
  { 4811, 16, 21, 14, 0, -21 },
  { 4853, 16, 21, 15, 0, -21 },
  { 4895, 12, 25, 13, 2, -25 },
  { 4933, 19, 21, 20, 1, -21 },
  { 4983, 17, 21, 17, 2, -21 },
  { 5028, 26, 21, 26, 2, -21 },
  { 5097, 22, 21, 18, -2, -21 },
  { 5155, 23, 30, 17, -3, -21 },
  { 5242, 17, 21, 15, -1, -21 },
  { 5287, 16, 33, 13, 0, -27 },
  { 5353, 4, 38, 17, 6, -29 },
  { 5372, 15, 33, 13, -2, -27 },
  { 5434, 17, 7, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_ExtraBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_EXTRABOLDITALIC38PT7B_H_
