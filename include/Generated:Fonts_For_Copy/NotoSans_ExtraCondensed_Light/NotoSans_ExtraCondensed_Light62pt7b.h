#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0xCF, 0xFF, 0xFE, 0xF0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xCC, 0x06, 0x00, 0x70, 0x18, 0x00, 0x38,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x30, 0x00,
  0x70, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x30, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xEE, 0x3E, 0x3C, 0x70,
  0x23, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x00, 0x0F, 0xB8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xEF, 0xC0, 0x07, 0x1F, 0x00, 0x38, 0x78, 0x01, 0xC1, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70,
  0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0xF0, 0x0E, 0x1E, 0xE0, 0x71,
  0xE7, 0xF3, 0xBF, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x0F,
  0xF8, 0x00, 0xC0, 0x0E, 0x1C, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x03,
  0x03, 0x80, 0x30, 0x03, 0x81, 0xC0, 0x38, 0x01, 0xC0, 0x60, 0x1C, 0x00,
  0xE0, 0x38, 0x0C, 0x00, 0x70, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x07, 0x00,
  0x1C, 0x07, 0x03, 0x00, 0x0E, 0x03, 0x83, 0x80, 0x07, 0x01, 0xC1, 0xC0,
  0x03, 0x80, 0xE0, 0xC0, 0x01, 0xC0, 0x70, 0xE0, 0x00, 0xE0, 0x38, 0x70,
  0x00, 0x70, 0x1C, 0x30, 0x00, 0x38, 0x0E, 0x38, 0x3E, 0x1C, 0x07, 0x1C,
  0x7F, 0x8E, 0x03, 0x0C, 0x39, 0xE7, 0x03, 0x8E, 0x38, 0x71, 0x81, 0xC7,
  0x18, 0x1C, 0xE0, 0xC3, 0x1C, 0x0E, 0x78, 0xE3, 0x8E, 0x07, 0x1F, 0xE1,
  0xC7, 0x03, 0x87, 0xF1, 0xC3, 0x80, 0xC1, 0xE0, 0xE1, 0x80, 0x70, 0x00,
  0x70, 0xC0, 0x38, 0x00, 0x70, 0x60, 0x1C, 0x00, 0x38, 0x70, 0x0E, 0x00,
  0x1C, 0x38, 0x07, 0x00, 0x1C, 0x1C, 0x03, 0x80, 0x0E, 0x06, 0x01, 0xC0,
  0x07, 0x03, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x30,
  0x01, 0xC0, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x1C, 0x00, 0xE0, 0x1C, 0x0E,
  0x00, 0x70, 0x06, 0x07, 0x00, 0x70, 0x03, 0x87, 0x00, 0x38, 0x01, 0xE7,
  0x80, 0x1C, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x1C, 0x07, 0x0E, 0x0F,
  0x03, 0x8F, 0x03, 0x81, 0xC7, 0x01, 0xE0, 0xE7, 0x80, 0x70, 0x73, 0xC0,
  0x3C, 0x79, 0xC0, 0x0F, 0x38, 0xE0, 0x03, 0x9C, 0x70, 0x01, 0xFE, 0x38,
  0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xF8, 0x78, 0x03, 0xFC, 0x1E, 0x07, 0xCF,
  0x0F, 0xFF, 0xC3, 0x83, 0xFF, 0xC1, 0xE0, 0xFF, 0x80, 0x78, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x04, 0x0E, 0x07, 0xC7, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x71, 0xC0, 0x70, 0x70, 0x78,
  0x3C, 0x78, 0x0E, 0x08, 0x06, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x38, 0x71, 0xE3,
  0x87, 0x0E, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x67, 0xBF, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xF1,
  0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x78,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC7,
  0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x81, 0xE0, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x8F, 0xBC, 0xF9, 0xEF, 0x8F, 0xF8,
  0x7B, 0x83, 0xC8, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x03, 0x80, 0x3C, 0x10,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x8F, 0x00, 0x3C, 0x30, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x80, 0x03, 0xE7, 0x00, 0x3E, 0x3F,
  0xCF, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0x60, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0D, 0xE0, 0x00, 0x1D,
  0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x71,
  0xE0, 0x00, 0x71, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xE1, 0xE0, 0x01, 0xC1,
  0xE0, 0x01, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x01,
  0xE0, 0x07, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01,
  0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x3F, 0x00, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x78, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC8, 0x00, 0x78, 0xC0, 0x0F, 0x8F, 0xEF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0x0C, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x02, 0x00, 0xE1, 0xFE, 0x0E, 0x3F, 0xF0, 0xE7, 0xFF, 0x8E, 0xE0,
  0x7C, 0xEC, 0x03, 0xCF, 0x80, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F,
  0x70, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x01, 0xE3, 0x80, 0x1E, 0x3C, 0x03,
  0xC1, 0xE0, 0x7C, 0x0F, 0x9F, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0x0F, 0x81, 0xE0, 0x1E, 0x1E, 0x00,
  0x70, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x03, 0x9E,
  0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03,
  0xC7, 0x80, 0x1C, 0x1E, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xE1, 0xE0, 0x0F,
  0xBE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7B, 0xE0,
  0x0F, 0x8F, 0x80, 0xF8, 0x1E, 0x07, 0x80, 0x78, 0x78, 0x01, 0xC7, 0x80,
  0x0F, 0x3C, 0x00, 0x3D, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3D, 0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x07,
  0xE3, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF8, 0xF8, 0x1E, 0x03, 0xC3, 0xC0,
  0x3C, 0x38, 0x01, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xF7, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x38, 0x01, 0xF3, 0xC0, 0x3F, 0x1E, 0x07,
  0x71, 0xFF, 0xE7, 0x0F, 0xFC, 0x70, 0x3F, 0x87, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x30, 0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0x7F,
  0xFF, 0xF0, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xE1, 0xC7, 0x8E, 0x1C,
  0x38, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0xF0, 0xFF, 0xF8, 0xF8, 0x7C, 0x40, 0x3E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x61, 0xC0, 0x0F,
  0xE0, 0x38, 0xE0, 0x1F, 0xF8, 0x1C, 0xE0, 0x1F, 0x1C, 0x0E, 0x70, 0x0E,
  0x0E, 0x07, 0x38, 0x0E, 0x07, 0x01, 0xDC, 0x07, 0x03, 0x80, 0xEE, 0x07,
  0x01, 0xC0, 0x76, 0x03, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x70, 0x1F, 0x80,
  0xE0, 0x38, 0x0F, 0xC0, 0xE0, 0x1C, 0x07, 0xE0, 0x70, 0x0E, 0x03, 0xF0,
  0x38, 0x0F, 0x01, 0xF8, 0x1C, 0x07, 0x80, 0xFC, 0x0E, 0x03, 0xC0, 0x7E,
  0x07, 0x01, 0xC0, 0x3F, 0x03, 0x80, 0xE0, 0x1B, 0x80, 0xC0, 0x70, 0x1D,
  0xC0, 0x70, 0x38, 0x0E, 0xE0, 0x38, 0x36, 0x07, 0x38, 0x1C, 0x1B, 0x07,
  0x1C, 0x07, 0x1D, 0xC3, 0x8E, 0x03, 0xFC, 0x7F, 0x87, 0x00, 0xFE, 0x3F,
  0x83, 0x80, 0x3C, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x0C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0xC0,
  0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x71, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x3E, 0x70, 0x00, 0xF3, 0x80, 0x03,
  0x9C, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0,
  0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x3C,
  0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x01, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x83, 0x80, 0x7E, 0x1C, 0x00, 0x78, 0xE0, 0x01, 0xE7,
  0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x07,
  0x9C, 0x00, 0x7C, 0xE0, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFE,
  0x1F, 0x07, 0xC0, 0x08, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x30, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x38, 0x03, 0xF0, 0xE0, 0x07, 0xC3, 0x80,
  0x07, 0x8E, 0x00, 0x1F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0x80, 0x01,
  0xEE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C,
  0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8E, 0x00, 0x3E, 0x38, 0x01, 0xF0, 0xE0,
  0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0x18, 0x0F,
  0x80, 0x01, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xF3, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xEF, 0xFD, 0xFF, 0x3F, 0xC0,
  0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x38, 0x00, 0x79, 0xC0, 0x07, 0x8E, 0x00,
  0x38, 0x70, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x1E, 0x07,
  0x00, 0xF0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x80, 0x70, 0x78,
  0x03, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x38,
  0xE0, 0x01, 0xCF, 0x00, 0x0E, 0xFC, 0x00, 0x77, 0xE0, 0x03, 0xF7, 0x00,
  0x1F, 0xBC, 0x00, 0xF8, 0xE0, 0x07, 0x87, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xF0, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xC0, 0x0F, 0x0E, 0x00,
  0x78, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x3C, 0xE0, 0x01, 0xE7,
  0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xDF, 0xF8, 0x00, 0x00, 0xEF, 0xDC, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00,
  0x73, 0xF7, 0x00, 0x00, 0x39, 0xF9, 0xC0, 0x00, 0x1C, 0xFC, 0xE0, 0x00,
  0x1E, 0x7E, 0x70, 0x00, 0x0E, 0x3F, 0x1C, 0x00, 0x07, 0x1F, 0x8E, 0x00,
  0x03, 0x8F, 0xC7, 0x00, 0x03, 0x87, 0xE3, 0x80, 0x01, 0xC3, 0xF0, 0xE0,
  0x00, 0xE1, 0xF8, 0x70, 0x00, 0xF0, 0xFC, 0x38, 0x00, 0x70, 0x7E, 0x0E,
  0x00, 0x38, 0x3F, 0x07, 0x00, 0x3C, 0x1F, 0x83, 0x80, 0x1C, 0x0F, 0xC1,
  0xE0, 0x0E, 0x07, 0xE0, 0x70, 0x07, 0x03, 0xF0, 0x38, 0x07, 0x01, 0xF8,
  0x1C, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xC0, 0x7E, 0x03, 0x81, 0xE0, 0x3F,
  0x01, 0xC0, 0xE0, 0x1F, 0x80, 0x70, 0x70, 0x0F, 0xC0, 0x38, 0x38, 0x07,
  0xE0, 0x1C, 0x38, 0x03, 0xF0, 0x0F, 0x1C, 0x01, 0xF8, 0x03, 0x8E, 0x00,
  0xFC, 0x01, 0xCF, 0x00, 0x7E, 0x00, 0xE7, 0x00, 0x3F, 0x00, 0x3B, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x78,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xEE,
  0x00, 0x0F, 0xEF, 0x00, 0x0F, 0xE7, 0x00, 0x0F, 0xE7, 0x00, 0x0F, 0xE3,
  0x80, 0x0F, 0xE3, 0x80, 0x0F, 0xE3, 0xC0, 0x0F, 0xE1, 0xC0, 0x0F, 0xE1,
  0xE0, 0x0F, 0xE0, 0xE0, 0x0F, 0xE0, 0xF0, 0x0F, 0xE0, 0x70, 0x0F, 0xE0,
  0x70, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0,
  0x1C, 0x0F, 0xE0, 0x1E, 0x0F, 0xE0, 0x0E, 0x0F, 0xE0, 0x0E, 0x0F, 0xE0,
  0x0F, 0x0F, 0xE0, 0x07, 0x0F, 0xE0, 0x07, 0x8F, 0xE0, 0x03, 0x8F, 0xE0,
  0x03, 0xCF, 0xE0, 0x01, 0xCF, 0xE0, 0x01, 0xEF, 0xE0, 0x01, 0xEF, 0xE0,
  0x00, 0xEF, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x0F, 0xCE,
  0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x70,
  0x01, 0xEE, 0x00, 0x79, 0xC0, 0x1F, 0x38, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF,
  0xF8, 0x1F, 0xF8, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x0E,
  0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xC0, 0x3F, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C,
  0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x0F,
  0x0E, 0x00, 0xF8, 0x70, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0x03, 0x80, 0x38, 0x1E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x00,
  0x78, 0x38, 0x01, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xB8, 0x00,
  0x3D, 0xC0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xF1,
  0xFC, 0x7E, 0x1E, 0x00, 0x63, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x80, 0x03, 0xEF, 0x00,
  0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B,
  0x80, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0x1E,
  0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0x8E, 0x00, 0x0F, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xF0, 0x00, 0x78,
  0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x3C, 0x00, 0x3B, 0x80, 0x07, 0x0F, 0x00,
  0x0E, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xCE,
  0x00, 0x3C, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x07, 0x80, 0x1C, 0xF0, 0x03,
  0x81, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x87, 0x00, 0x78, 0x0E,
  0x00, 0xE1, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x83, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0xE0,
  0x3C, 0x01, 0xC0, 0x70, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x70, 0x78, 0x00, 0xE0,
  0xE0, 0x1C, 0x1E, 0x00, 0x38, 0x38, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x01,
  0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x00, 0x70, 0xE0, 0x0E, 0x3C,
  0x00, 0x1C, 0x70, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x01,
  0xE7, 0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x00, 0x0E, 0x70,
  0x01, 0xDE, 0x00, 0x03, 0x9C, 0x00, 0x77, 0x80, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00,
  0x01, 0xF8, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x78, 0x01,
  0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x03, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xE0, 0x0F, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x73,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xF0, 0x0F, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xF0, 0x38, 0x03,
  0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x70,
  0x00, 0xF3, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x3D, 0xC0, 0x00, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x78,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x03, 0xC0, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xC3,
  0x80, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x7C, 0x7E,
  0x18, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF0, 0x73, 0xE0, 0x1C, 0xF0, 0x07,
  0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x07, 0xDC, 0x01, 0xF7, 0x80,
  0xDC, 0xF8, 0x77, 0x1F, 0xF9, 0xC3, 0xFC, 0x30, 0x18, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x08, 0x03, 0xC7,
  0xFC, 0x1E, 0x7F, 0xF0, 0xF7, 0xCF, 0xC7, 0xB0, 0x1E, 0x3B, 0x00, 0x79,
  0xD0, 0x01, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x01, 0xDE, 0x00,
  0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x78,
  0x00, 0x3B, 0xC0, 0x01, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xE7, 0xC0, 0x07,
  0x3B, 0x00, 0x79, 0xDC, 0x07, 0x8E, 0x7C, 0xFC, 0x71, 0xFF, 0xC3, 0x87,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xCF,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0x1F, 0xCF, 0x0F, 0xFF, 0x03, 0xFE,
  0x00, 0x20, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x0C,
  0x07, 0x07, 0xF8, 0x70, 0xFF, 0xE7, 0x1F, 0x9E, 0x73, 0xE0, 0x77, 0x3C,
  0x03, 0xF7, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x3C,
  0x01, 0xF3, 0xC0, 0x37, 0x1F, 0x0E, 0x70, 0xFF, 0xE3, 0x07, 0xF8, 0x30,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x8F, 0x81,
  0xE0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xF3, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x87, 0x80, 0x30, 0x7E, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xE0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC7,
  0x0F, 0xFE, 0x71, 0xF9, 0xF7, 0x3E, 0x03, 0x73, 0xC0, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x70, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x37, 0x3E, 0x07,
  0x71, 0xF9, 0xE7, 0x0F, 0xFC, 0x70, 0x7F, 0x87, 0x00, 0xC0, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x40, 0x03, 0xC7,
  0x81, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x60, 0x3C, 0x7F, 0x87, 0x9F, 0xF8,
  0xF7, 0xDF, 0x9D, 0xC0, 0xFB, 0xB0, 0x0F, 0x7C, 0x00, 0xEF, 0x80, 0x1D,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x78, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x9E, 0xFC, 0xFC,
  0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3B, 0xC0,
  0x1C, 0xF0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x38,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0x70, 0x0F,
  0x3C, 0x03, 0xCF, 0x00, 0xE7, 0xC0, 0x3B, 0xF8, 0x0E, 0xEE, 0x03, 0xF3,
  0xC0, 0xF8, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x3C,
  0x3C, 0x07, 0x0F, 0x01, 0xE3, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0xCF,
  0x00, 0x73, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x20, 0x00, 0xC0, 0xE1, 0xFC, 0x07, 0xF8, 0xE3, 0xFE, 0x0F, 0xFC, 0xE7,
  0x9F, 0x1E, 0xFC, 0xEE, 0x07, 0x38, 0x1E, 0xEC, 0x07, 0xB0, 0x1E, 0xF8,
  0x03, 0xE0, 0x0E, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x38, 0x1C, 0x3F, 0xC3, 0x8F, 0xFC, 0x73, 0xC7,
  0xCE, 0xE0, 0x7D, 0xD8, 0x07, 0xBE, 0x00, 0x77, 0xC0, 0x0E, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3C,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x3F, 0x03, 0xE0,
  0x3C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0xF0,
  0x01, 0xC3, 0x80, 0x1E, 0x1E, 0x00, 0xE0, 0x78, 0x0F, 0x03, 0xF3, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x30, 0x07, 0x0F,
  0xF0, 0x38, 0xFF, 0xE1, 0xCF, 0x9F, 0x8E, 0x60, 0x3C, 0x76, 0x00, 0xF3,
  0xA0, 0x03, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x03, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0,
  0x00, 0x77, 0x80, 0x03, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xCE, 0xC0, 0x1E,
  0x76, 0x00, 0xF3, 0xD8, 0x0F, 0x1E, 0xFB, 0xF0, 0xF3, 0xFF, 0x87, 0x8F,
  0xF0, 0x3C, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC7, 0x0F, 0xFE,
  0x71, 0xFD, 0xF7, 0x3E, 0x07, 0x73, 0xC0, 0x3F, 0x78, 0x01, 0xF7, 0x80,
  0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x80, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x37, 0x3E, 0x07, 0x71, 0xF9,
  0xE7, 0x0F, 0xFC, 0x70, 0x7F, 0x87, 0x00, 0xC0, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x27, 0x0F, 0xF8,
  0xFF, 0xCF, 0xFE, 0x70, 0x77, 0x03, 0xB0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3E,
  0x78, 0x02, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1E, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF0,
  0x07, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x3F, 0xF7, 0xFF, 0xBF, 0xFC, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3E, 0x61, 0xFF, 0x07, 0xF8, 0x06, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xB8, 0x01, 0x77, 0x80, 0x6E, 0xF0, 0x19, 0xCF, 0xDF,
  0x38, 0xFF, 0xC7, 0x0F, 0xF0, 0xE0, 0x30, 0x00, 0xF0, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x00, 0xE3, 0x80, 0x0E, 0x38,
  0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0xC1,
  0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0x70,
  0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x19,
  0xC0, 0x01, 0xDC, 0x00, 0x1D, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0,
  0x01, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x01, 0xDE, 0x00, 0x7C, 0x00, 0xE7,
  0x00, 0x36, 0x00, 0x73, 0x80, 0x3B, 0x00, 0x39, 0xC0, 0x1D, 0xC0, 0x3C,
  0xF0, 0x0E, 0xE0, 0x1C, 0x78, 0x07, 0x70, 0x0E, 0x1C, 0x03, 0xB8, 0x07,
  0x0E, 0x03, 0x8C, 0x03, 0x87, 0x01, 0xC7, 0x03, 0xC3, 0xC0, 0xE3, 0x81,
  0xC0, 0xE0, 0x71, 0xC0, 0xE0, 0x70, 0x30, 0xE0, 0x70, 0x38, 0x38, 0x30,
  0x38, 0x1C, 0x1C, 0x1C, 0x38, 0x0F, 0x0E, 0x0E, 0x1C, 0x03, 0x87, 0x07,
  0x0E, 0x01, 0xC7, 0x03, 0x87, 0x00, 0xE3, 0x80, 0xE7, 0x80, 0x71, 0xC0,
  0x73, 0x80, 0x1C, 0xE0, 0x39, 0xC0, 0x0E, 0x70, 0x1C, 0xE0, 0x07, 0x30,
  0x0E, 0x70, 0x03, 0xB8, 0x03, 0x30, 0x01, 0xDC, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x70, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xC0, 0x38,
  0x38, 0x0F, 0x07, 0x81, 0xC0, 0x70, 0x78, 0x0F, 0x0E, 0x00, 0xE3, 0xC0,
  0x1E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00,
  0x3B, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x80, 0x78, 0x70, 0x0E, 0x0F, 0x03,
  0xC0, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0xC3, 0xC0, 0x38, 0x70, 0x07, 0x9E,
  0x00, 0x73, 0x80, 0x0F, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xFF, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x38, 0x1C, 0x07, 0x81, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x0F, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00,
  0x79, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x3B, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x9F, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0x80, 0x1F, 0xFF,
  0x81, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xFA, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 44, 13, 4, -44 },
  { 29, 13, 16, 21, 4, -44 },
  { 55, 25, 44, 27, 1, -44 },
  { 193, 21, 51, 26, 2, -47 },
  { 327, 33, 46, 38, 3, -45 },
  { 517, 25, 46, 27, 2, -45 },
  { 661, 4, 16, 11, 4, -44 },
  { 669, 12, 54, 17, 3, -44 },
  { 750, 12, 54, 17, 2, -44 },
  { 831, 17, 18, 23, 3, -47 },
  { 870, 22, 29, 26, 2, -36 },
  { 950, 7, 15, 12, 2, -7 },
  { 964, 13, 3, 17, 2, -18 },
  { 969, 5, 6, 13, 4, -6 },
  { 973, 20, 44, 22, 1, -44 },
  { 1083, 20, 46, 26, 3, -45 },
  { 1198, 13, 44, 26, 4, -44 },
  { 1270, 21, 45, 26, 2, -45 },
  { 1389, 21, 46, 26, 2, -45 },
  { 1510, 24, 45, 26, 1, -45 },
  { 1645, 20, 45, 26, 3, -44 },
  { 1758, 20, 46, 26, 3, -45 },
  { 1873, 21, 44, 26, 2, -44 },
  { 1989, 21, 46, 26, 2, -45 },
  { 2110, 20, 46, 26, 2, -45 },
  { 2225, 5, 33, 13, 4, -33 },
  { 2246, 7, 41, 13, 2, -33 },
  { 2282, 22, 26, 26, 2, -35 },
  { 2354, 22, 16, 26, 2, -30 },
  { 2398, 22, 26, 26, 2, -35 },
  { 2470, 16, 45, 18, 1, -45 },
  { 2560, 33, 50, 39, 3, -45 },
  { 2767, 26, 44, 26, 0, -44 },
  { 2910, 21, 44, 28, 5, -44 },
  { 3026, 22, 46, 27, 3, -45 },
  { 3153, 22, 44, 31, 5, -44 },
  { 3274, 16, 44, 24, 5, -44 },
  { 3362, 16, 44, 23, 5, -44 },
  { 3450, 27, 46, 33, 3, -45 },
  { 3606, 22, 44, 32, 5, -44 },
  { 3727, 11, 44, 16, 2, -44 },
  { 3788, 11, 55, 13, -3, -44 },
  { 3864, 21, 44, 26, 5, -44 },
  { 3980, 16, 44, 22, 5, -44 },
  { 4068, 33, 44, 42, 5, -44 },
  { 4250, 24, 44, 33, 5, -44 },
  { 4382, 27, 46, 33, 3, -45 },
  { 4538, 19, 44, 26, 5, -44 },
  { 4643, 27, 56, 33, 3, -45 },
  { 4832, 21, 44, 27, 5, -44 },
  { 4948, 20, 46, 25, 2, -45 },
  { 5063, 21, 44, 22, 1, -44 },
  { 5179, 23, 45, 31, 4, -44 },
  { 5309, 25, 44, 25, 0, -44 },
  { 5447, 42, 44, 42, 0, -44 },
  { 5678, 21, 44, 23, 1, -44 },
  { 5794, 22, 44, 22, 0, -44 },
  { 5915, 18, 44, 21, 2, -44 },
  { 6014, 12, 54, 19, 5, -44 },
  { 6095, 20, 44, 22, 1, -44 },
  { 6205, 12, 54, 19, 2, -44 },
  { 6286, 24, 22, 26, 1, -44 },
  { 6352, 26, 3, 26, 0, 5 },
  { 6362, 11, 9, 15, 2, -47 },
  { 6375, 18, 35, 24, 2, -34 },
  { 6454, 21, 48, 27, 4, -47 },
  { 6580, 16, 35, 20, 3, -34 },
  { 6650, 20, 48, 27, 3, -47 },
  { 6770, 19, 35, 25, 3, -34 },
  { 6854, 15, 47, 14, 1, -47 },
  { 6943, 20, 49, 27, 3, -34 },
  { 7066, 19, 47, 27, 4, -47 },
  { 7178, 4, 45, 12, 4, -45 },
  { 7201, 8, 60, 12, 0, -45 },
  { 7261, 18, 47, 22, 4, -47 },
  { 7367, 4, 47, 12, 4, -47 },
  { 7391, 32, 34, 40, 4, -34 },
  { 7527, 19, 34, 27, 4, -34 },
  { 7608, 21, 35, 26, 3, -34 },
  { 7700, 21, 49, 27, 4, -34 },
  { 7829, 20, 49, 27, 3, -34 },
  { 7952, 13, 34, 18, 4, -34 },
  { 8008, 16, 35, 20, 2, -34 },
  { 8078, 13, 42, 15, 1, -41 },
  { 8147, 19, 34, 27, 4, -33 },
  { 8228, 20, 33, 21, 0, -33 },
  { 8311, 33, 33, 35, 1, -33 },
  { 8448, 19, 33, 21, 1, -33 },
  { 8527, 20, 48, 21, 1, -33 },
  { 8647, 14, 33, 17, 2, -33 },
  { 8705, 16, 54, 22, 3, -44 },
  { 8813, 3, 62, 24, 11, -47 },
  { 8837, 16, 54, 22, 3, -44 },
  { 8945, 22, 6, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Light62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT62PT7B_H_
