#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x54, 0x1C, 0xDE, 0x73, 0x18, 0x80, 0x11, 0x09, 0x04,
  0x82, 0x47, 0xF8, 0x90, 0x48, 0x44, 0x22, 0x7F, 0x89, 0x04, 0x82, 0x41,
  0x20, 0x90, 0x10, 0x21, 0xF4, 0x89, 0x12, 0x24, 0x38, 0x38, 0x38, 0x48,
  0x91, 0x32, 0xBF, 0x08, 0x10, 0x71, 0x12, 0x22, 0x44, 0x49, 0x09, 0x21,
  0x24, 0x25, 0x74, 0xA9, 0x65, 0x21, 0x24, 0x24, 0x84, 0x91, 0x12, 0x22,
  0x4C, 0x30, 0x78, 0x48, 0x48, 0x48, 0x48, 0x48, 0x30, 0x70, 0xD3, 0x8A,
  0x8A, 0x86, 0x86, 0x8E, 0x79, 0xFE, 0x80, 0x12, 0x64, 0x4C, 0x88, 0x88,
  0x88, 0xC4, 0x46, 0x23, 0x84, 0x42, 0x22, 0x31, 0x11, 0x13, 0x22, 0x24,
  0x48, 0x20, 0x8E, 0xCC, 0x51, 0x20, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04,
  0x08, 0x10, 0x5A, 0x80, 0xF0, 0xF0, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x30, 0x00, 0x38, 0x8B, 0x14, 0x28,
  0x70, 0xE0, 0xC1, 0x83, 0x0E, 0x1C, 0x2C, 0x48, 0x8E, 0x00, 0x19, 0xF6,
  0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x60, 0x79, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x08, 0x20, 0xC1, 0x04, 0x10, 0x3F, 0x80, 0x79, 0x08,
  0x10, 0x20, 0x40, 0x86, 0x3C, 0x04, 0x08, 0x18, 0x30, 0x50, 0xBE, 0x00,
  0x06, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x22, 0x22, 0x42, 0x42, 0xFF, 0xFF,
  0x02, 0x02, 0x02, 0x7C, 0x83, 0x04, 0x08, 0x10, 0x3E, 0x02, 0x06, 0x04,
  0x08, 0x30, 0x51, 0xBE, 0x00, 0x3C, 0xC1, 0x02, 0x08, 0x10, 0x2F, 0x62,
  0x87, 0x06, 0x0C, 0x1C, 0x48, 0x8E, 0x00, 0xFE, 0x0C, 0x10, 0x20, 0xC1,
  0x02, 0x0C, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x00, 0x79, 0x8A, 0x1C,
  0x38, 0x48, 0x8E, 0x1C, 0x4D, 0x0E, 0x0C, 0x18, 0x38, 0x9F, 0x00, 0x79,
  0x9A, 0x14, 0x28, 0x50, 0xE1, 0xE3, 0x7E, 0x08, 0x10, 0x20, 0x41, 0x3C,
  0x00, 0xF0, 0x00, 0x3C, 0xD0, 0x00, 0x16, 0xA0, 0x02, 0x18, 0x63, 0x08,
  0x0C, 0x06, 0x06, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0x80, 0xC0,
  0x60, 0x21, 0x8C, 0x60, 0x80, 0xFA, 0x20, 0xC1, 0x0C, 0x21, 0x84, 0x20,
  0x82, 0x00, 0x00, 0x82, 0x00, 0x0F, 0x06, 0x10, 0x81, 0x20, 0x34, 0x73,
  0x12, 0x64, 0x4C, 0x89, 0x91, 0x32, 0x26, 0x4C, 0xC5, 0xAC, 0x48, 0x80,
  0x10, 0x01, 0x88, 0x0E, 0x00, 0x18, 0x0C, 0x05, 0x02, 0x81, 0x41, 0x20,
  0x88, 0x44, 0x22, 0x3F, 0x10, 0xC8, 0x24, 0x16, 0x0A, 0x06, 0xF9, 0x1A,
  0x14, 0x28, 0x50, 0xA2, 0x7C, 0x85, 0x0E, 0x0C, 0x38, 0x51, 0xBE, 0x00,
  0x1F, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x20, 0x1E, 0xF9, 0x1A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x51, 0xBE, 0x00, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21,
  0x08, 0x43, 0xE0, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x42,
  0x00, 0x1F, 0x10, 0x50, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0,
  0x70, 0x28, 0x14, 0x09, 0x04, 0x7E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x80, 0xF4, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x12, 0xE0, 0x87, 0x1A, 0x24, 0x89, 0x14, 0x28, 0x70, 0xB1, 0x22, 0x64,
  0x48, 0xD0, 0xA1, 0x80, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x43, 0xE0, 0x80, 0x78, 0x0F, 0x02, 0xE0, 0x5A, 0x0B, 0x41, 0x68, 0x4D,
  0x09, 0x91, 0x32, 0x46, 0x48, 0xC5, 0x18, 0xE3, 0x18, 0x63, 0x08, 0x81,
  0xC1, 0xC1, 0xE1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x8D, 0x85, 0x85,
  0x83, 0x83, 0x3E, 0x31, 0x90, 0x48, 0x3C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x70, 0x28, 0x34, 0x13, 0x18, 0xF8, 0xF2, 0x38, 0x61, 0x86, 0x18,
  0x62, 0xF2, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3E, 0x31, 0x90, 0x48, 0x3C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x28, 0x34, 0x13, 0x18, 0xF8,
  0x08, 0x02, 0x01, 0x80, 0x40, 0xF1, 0x1A, 0x14, 0x28, 0x50, 0xA3, 0x7C,
  0x91, 0x22, 0x64, 0x48, 0xD0, 0xA1, 0x80, 0x7D, 0x86, 0x04, 0x08, 0x18,
  0x18, 0x1C, 0x0C, 0x08, 0x18, 0x30, 0x51, 0xBE, 0x00, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x00, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x41,
  0x63, 0x3E, 0x81, 0xC1, 0x41, 0x43, 0x42, 0x42, 0x22, 0x22, 0x24, 0x24,
  0x34, 0x14, 0x18, 0x18, 0x18, 0x81, 0x07, 0x0C, 0x14, 0x30, 0x50, 0xC3,
  0x42, 0x89, 0x0A, 0x26, 0x48, 0x89, 0x22, 0x24, 0x90, 0x91, 0x42, 0x45,
  0x06, 0x14, 0x18, 0x70, 0x61, 0x81, 0x82, 0x00, 0x42, 0x42, 0x24, 0x24,
  0x24, 0x18, 0x18, 0x18, 0x18, 0x38, 0x24, 0x24, 0x46, 0x42, 0xC3, 0x82,
  0x85, 0x1A, 0x22, 0x45, 0x8A, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x00, 0xFC, 0x20, 0x86, 0x10, 0x43, 0x08, 0x21, 0x04, 0x10, 0x82, 0x0F,
  0xC0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x81,
  0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x80,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x1C, 0x14,
  0x26, 0x22, 0x62, 0x41, 0xC1, 0xFF, 0x80, 0xC8, 0x80, 0x78, 0x30, 0x41,
  0x1D, 0x98, 0x61, 0x8E, 0x37, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xB0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x69, 0xDE, 0x7D, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xC1, 0x07, 0x80, 0x02, 0x04, 0x08, 0x10, 0x2F, 0x51, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0xD1, 0xBD, 0x79, 0x18, 0x61, 0x87, 0xE8,
  0x20, 0xC1, 0x13, 0xC0, 0x39, 0x08, 0x42, 0x78, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x7A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x8D, 0xE8,
  0x10, 0x20, 0xE1, 0x3C, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xB1, 0x61, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xD0, 0xFF, 0xFF, 0xFC, 0x64, 0x06,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0xB6,
  0xD3, 0xCF, 0x36, 0xCB, 0x2C, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xF8,
  0xC7, 0x18, 0xE2, 0x1C, 0x43, 0x88, 0x71, 0x0E, 0x21, 0xC4, 0x38, 0x87,
  0x10, 0x80, 0xBD, 0x8B, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x08,
  0x7C, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x89, 0xE0, 0xBD, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xCF, 0xF6, 0x0C, 0x18, 0x30, 0x60,
  0x7A, 0x8E, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x8D, 0xE8, 0x10, 0x20,
  0x40, 0x81, 0xBD, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0xFC, 0x21, 0x04,
  0x18, 0x61, 0x0C, 0x7C, 0x21, 0x09, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC2,
  0x1C, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC6, 0x8D, 0xE8, 0x82,
  0x89, 0x12, 0x24, 0x4D, 0x0A, 0x14, 0x28, 0x60, 0x40, 0x86, 0x34, 0x62,
  0x46, 0x24, 0xA2, 0x49, 0x66, 0x94, 0x29, 0x42, 0x94, 0x31, 0x43, 0x08,
  0x10, 0x80, 0x46, 0x88, 0xB1, 0x41, 0x82, 0x0E, 0x14, 0x64, 0x8B, 0x18,
  0xC2, 0x85, 0x12, 0x26, 0x44, 0x8A, 0x14, 0x18, 0x30, 0x40, 0x81, 0x06,
  0x08, 0x70, 0xF1, 0x32, 0x26, 0x44, 0x88, 0xF0, 0x19, 0x88, 0x42, 0x10,
  0x84, 0x66, 0x08, 0x42, 0x10, 0x84, 0x20, 0xC0, 0xFF, 0xFF, 0xF8, 0xC1,
  0x08, 0x42, 0x10, 0x84, 0x10, 0xCC, 0x42, 0x10, 0x84, 0x27, 0x00, 0x41,
  0x66, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 15, 5, 1, -15 },
  { 5, 5, 5, 7, 1, -15 },
  { 9, 9, 15, 9, 0, -15 },
  { 26, 7, 17, 9, 1, -16 },
  { 41, 11, 15, 13, 1, -15 },
  { 62, 8, 15, 9, 1, -15 },
  { 77, 2, 5, 4, 1, -15 },
  { 79, 4, 18, 6, 1, -15 },
  { 88, 4, 18, 6, 1, -15 },
  { 97, 6, 6, 8, 1, -16 },
  { 102, 7, 9, 9, 1, -12 },
  { 110, 2, 5, 4, 1, -2 },
  { 112, 4, 1, 6, 1, -6 },
  { 113, 2, 2, 4, 1, -2 },
  { 114, 7, 15, 7, 0, -15 },
  { 128, 7, 15, 9, 1, -15 },
  { 142, 5, 15, 9, 1, -15 },
  { 152, 7, 15, 9, 1, -15 },
  { 166, 7, 15, 9, 1, -15 },
  { 180, 8, 15, 9, 0, -15 },
  { 195, 7, 15, 9, 1, -15 },
  { 209, 7, 15, 9, 1, -15 },
  { 223, 7, 15, 9, 1, -15 },
  { 237, 7, 15, 9, 1, -15 },
  { 251, 7, 15, 9, 1, -15 },
  { 265, 2, 11, 4, 1, -11 },
  { 268, 2, 14, 4, 1, -11 },
  { 272, 7, 9, 9, 1, -12 },
  { 280, 7, 5, 9, 1, -10 },
  { 285, 7, 9, 9, 1, -12 },
  { 293, 6, 15, 6, 0, -15 },
  { 305, 11, 17, 13, 1, -15 },
  { 329, 9, 15, 9, 0, -15 },
  { 346, 7, 15, 10, 2, -15 },
  { 360, 8, 15, 9, 1, -15 },
  { 375, 7, 15, 10, 2, -15 },
  { 389, 5, 15, 8, 2, -15 },
  { 399, 5, 15, 8, 2, -15 },
  { 409, 9, 15, 11, 1, -15 },
  { 426, 7, 15, 11, 2, -15 },
  { 440, 4, 15, 5, 1, -15 },
  { 448, 4, 19, 4, -1, -15 },
  { 458, 7, 15, 9, 2, -15 },
  { 472, 5, 15, 7, 2, -15 },
  { 482, 11, 15, 14, 2, -15 },
  { 503, 8, 15, 11, 2, -15 },
  { 518, 9, 15, 11, 1, -15 },
  { 535, 6, 15, 9, 2, -15 },
  { 547, 9, 19, 11, 1, -15 },
  { 569, 7, 15, 9, 2, -15 },
  { 583, 7, 15, 8, 1, -15 },
  { 597, 7, 15, 8, 0, -15 },
  { 611, 8, 15, 11, 1, -15 },
  { 626, 8, 15, 8, 0, -15 },
  { 641, 14, 15, 14, 0, -15 },
  { 668, 8, 15, 8, 0, -15 },
  { 683, 7, 15, 7, 0, -15 },
  { 697, 6, 15, 7, 1, -15 },
  { 709, 4, 18, 6, 2, -15 },
  { 718, 7, 15, 7, 0, -15 },
  { 732, 4, 18, 6, 1, -15 },
  { 741, 8, 8, 9, 0, -15 },
  { 749, 9, 1, 9, 0, 2 },
  { 751, 3, 3, 5, 1, -16 },
  { 753, 6, 11, 8, 1, -11 },
  { 762, 7, 16, 9, 1, -16 },
  { 776, 6, 11, 7, 1, -11 },
  { 785, 7, 16, 9, 1, -16 },
  { 799, 6, 11, 8, 1, -11 },
  { 808, 5, 16, 5, 0, -16 },
  { 818, 7, 16, 9, 1, -11 },
  { 832, 7, 16, 9, 1, -16 },
  { 846, 2, 15, 4, 1, -15 },
  { 850, 3, 20, 4, 0, -15 },
  { 858, 6, 16, 8, 1, -16 },
  { 870, 2, 16, 4, 1, -16 },
  { 874, 11, 11, 14, 1, -11 },
  { 890, 7, 11, 9, 1, -11 },
  { 900, 7, 11, 9, 1, -11 },
  { 910, 7, 16, 9, 1, -11 },
  { 924, 7, 16, 9, 1, -11 },
  { 938, 5, 11, 6, 1, -11 },
  { 945, 5, 11, 7, 1, -11 },
  { 952, 5, 14, 5, 0, -14 },
  { 961, 7, 11, 9, 1, -11 },
  { 971, 7, 11, 7, 0, -11 },
  { 981, 12, 11, 12, 0, -11 },
  { 998, 7, 11, 7, 0, -11 },
  { 1008, 7, 16, 7, 0, -11 },
  { 1022, 4, 11, 6, 1, -11 },
  { 1028, 5, 18, 7, 1, -15 },
  { 1040, 1, 21, 8, 4, -16 },
  { 1043, 5, 18, 7, 1, -15 },
  { 1055, 7, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Light21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT21PT7B_H_
