#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x23, 0xEF,
  0xBF, 0xFF, 0xE7, 0x88, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x78, 0x0E,
  0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x03, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x78, 0x07,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00,
  0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3E, 0x38, 0x3C, 0x7C, 0x38,
  0x08, 0x78, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x38,
  0x00, 0x7C, 0x38, 0x00, 0x3E, 0x38, 0x00, 0x1F, 0xB8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x39, 0xF8, 0x00, 0x38, 0x7C, 0x00, 0x38,
  0x3E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38,
  0x0F, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38,
  0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x80, 0x38,
  0x3E, 0xE0, 0x38, 0x7C, 0xFC, 0x3B, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x70, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x07,
  0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x0F, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x0E,
  0x03, 0xC0, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x03, 0x83, 0x80, 0x00,
  0xF0, 0x0E, 0x0E, 0x03, 0x03, 0xC0, 0x38, 0x70, 0x7F, 0x07, 0x00, 0xE1,
  0xC3, 0xFE, 0x1C, 0x03, 0x87, 0x0F, 0x3C, 0x70, 0x1E, 0x38, 0x78, 0x79,
  0xC0, 0x70, 0xE1, 0xC0, 0xE7, 0x81, 0xC3, 0x8F, 0x03, 0x8E, 0x0F, 0x1C,
  0x38, 0x0F, 0x3C, 0x78, 0x70, 0xE0, 0x3C, 0x7F, 0xE3, 0xC3, 0x80, 0x70,
  0xFF, 0x0E, 0x1E, 0x01, 0xC1, 0xF0, 0x38, 0x78, 0x07, 0x00, 0x01, 0xE1,
  0xE0, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x1C, 0x01, 0xC0,
  0x00, 0xF0, 0x70, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x0E, 0x07,
  0x00, 0x70, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x07, 0x00,
  0x07, 0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x03, 0x80, 0x38, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x3C, 0x00,
  0x70, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x00, 0x78, 0x78, 0x00, 0xE0, 0x00, 0xF7, 0xC0, 0x07,
  0x80, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x70, 0xF0, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0x3C, 0x78, 0x07, 0x81,
  0xE3, 0xC0, 0x1E, 0x0F, 0x1E, 0x00, 0xF0, 0x78, 0xE0, 0x03, 0xC3, 0x8F,
  0x00, 0x0F, 0x3C, 0x78, 0x00, 0x79, 0xE3, 0xC0, 0x01, 0xEF, 0x1E, 0x00,
  0x0F, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0x80, 0x01, 0xF8, 0x3C, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xF8, 0x3C, 0x00, 0x3F, 0xC1,
  0xF0, 0x01, 0xEF, 0x07, 0xC0, 0x3E, 0x78, 0x3F, 0x03, 0xE1, 0xE0, 0xFF,
  0xFE, 0x0F, 0x83, 0xFF, 0xE0, 0x3C, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE,
  0x73, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0C, 0x0E, 0x0E, 0xFC, 0x73, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x0F, 0x00, 0x78, 0x3C, 0x07,
  0x81, 0xF0, 0x78, 0x07, 0x80, 0xC0, 0x18, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x11, 0xF7, 0xFF, 0xFD, 0xF7,
  0xC4, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0xCF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xE0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0xC0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1E, 0xF1, 0xFB, 0xCF, 0x8F, 0x7C,
  0x3F, 0xE0, 0xF7, 0x03, 0xC8, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x07,
  0xFE, 0xFF, 0x07, 0xC0, 0x3F, 0x06, 0x00, 0x1F, 0x08, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x0F, 0x80, 0x1F, 0x1E,
  0x00, 0x1F, 0x10, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x60, 0x00, 0xFC, 0xF8, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x38, 0x03,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00,
  0x3C, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x7F, 0x8F, 0xF0, 0x40, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x20, 0x00, 0xF8, 0x78,
  0x07, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x3F, 0x00, 0x70, 0xFF, 0xC0, 0x71, 0xFF, 0xE0, 0x73,
  0xFF, 0xF0, 0xF7, 0x80, 0xF8, 0xF6, 0x00, 0x7C, 0xFE, 0x00, 0x3C, 0xFC,
  0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x0F,
  0x00, 0x78, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xC3, 0xF0, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xEF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xCF, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3C,
  0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF0, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xBC,
  0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xFD, 0xF0, 0x01, 0xF9, 0xF0,
  0x06, 0xF1, 0xF0, 0x3D, 0xE3, 0xFF, 0xF3, 0xC3, 0xFF, 0xC7, 0x81, 0xFF,
  0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x20,
  0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x27, 0xFF, 0xFF, 0xFF, 0xE4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x67, 0xFF,
  0xFF, 0xFF, 0xE4, 0x08, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70,
  0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF9, 0xFC,
  0x70, 0x0F, 0x90, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x3F, 0xF0, 0x1C, 0x38, 0x01, 0xFF, 0xC0, 0x79,
  0xE0, 0x0F, 0xDF, 0x01, 0xE7, 0x00, 0x78, 0x1C, 0x03, 0x9C, 0x01, 0xC0,
  0x70, 0x0E, 0x70, 0x0F, 0x01, 0xC0, 0x3B, 0xC0, 0x38, 0x07, 0x00, 0xEF,
  0x01, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0xF0, 0x0F, 0xE0, 0x1C, 0x03,
  0xC0, 0x3F, 0x80, 0x70, 0x0F, 0x00, 0xFE, 0x01, 0xC0, 0x3C, 0x03, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x0F,
  0x00, 0xFE, 0x03, 0xC0, 0x3C, 0x03, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0xE0,
  0x3C, 0x03, 0xC0, 0x3B, 0x80, 0xF0, 0x0F, 0x00, 0xEE, 0x03, 0xC0, 0x3C,
  0x03, 0xB8, 0x07, 0x01, 0xF0, 0x0E, 0xE0, 0x1C, 0x07, 0xC0, 0x7B, 0x80,
  0x70, 0x1B, 0x01, 0xCF, 0x01, 0xE0, 0xEC, 0x0F, 0x3C, 0x03, 0x83, 0xB8,
  0x3C, 0xF0, 0x0F, 0x9C, 0xF3, 0xE1, 0xC0, 0x1F, 0xF1, 0xFF, 0x07, 0x00,
  0x3F, 0x87, 0xF8, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x1F, 0x80, 0x1E, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x03, 0xC0, 0x0E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1E, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x0F, 0xC3,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x3C, 0x00, 0x7E, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0xFB, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7,
  0x80, 0x01, 0xF3, 0xC0, 0x03, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x00, 0x30, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x78, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xC1, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0xC1, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xF7, 0xFF, 0x01, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x00,
  0x60, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x77, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C,
  0xF8, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x07, 0x0F,
  0x80, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x01, 0xC0, 0xFC,
  0x00, 0x07, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0x1F, 0xC0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xCE, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0,
  0x78, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xE0, 0x00, 0xF3,
  0xF0, 0x00, 0x7B, 0xFC, 0x00, 0x3D, 0xDE, 0x00, 0x1F, 0xCF, 0x80, 0x0F,
  0xC3, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF8,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFD, 0xC0, 0x00, 0x00, 0x7F,
  0xFB, 0x80, 0x00, 0x00, 0xFF, 0xF7, 0x80, 0x00, 0x01, 0xDF, 0xEF, 0x00,
  0x00, 0x07, 0xBF, 0xCE, 0x00, 0x00, 0x0F, 0x7F, 0x9E, 0x00, 0x00, 0x1C,
  0xFF, 0x3C, 0x00, 0x00, 0x79, 0xFE, 0x38, 0x00, 0x00, 0xF3, 0xFC, 0x70,
  0x00, 0x01, 0xC7, 0xF8, 0xF0, 0x00, 0x03, 0x8F, 0xF1, 0xE0, 0x00, 0x0F,
  0x1F, 0xE1, 0xC0, 0x00, 0x1E, 0x3F, 0xC3, 0xC0, 0x00, 0x38, 0x7F, 0x87,
  0x80, 0x00, 0xF0, 0xFF, 0x07, 0x00, 0x01, 0xE1, 0xFE, 0x0F, 0x00, 0x03,
  0x83, 0xFC, 0x1E, 0x00, 0x0F, 0x07, 0xF8, 0x1C, 0x00, 0x1E, 0x0F, 0xF0,
  0x38, 0x00, 0x3C, 0x1F, 0xE0, 0x78, 0x00, 0x70, 0x3F, 0xC0, 0xF0, 0x01,
  0xE0, 0x7F, 0x80, 0xE0, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x07, 0x01, 0xFE,
  0x03, 0xC0, 0x1E, 0x03, 0xFC, 0x03, 0x80, 0x3C, 0x07, 0xF8, 0x07, 0x80,
  0x70, 0x0F, 0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0xE0, 0x1E, 0x03, 0xC0, 0x3F,
  0xC0, 0x1C, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x0E, 0x00, 0xFF, 0x00, 0x78,
  0x3C, 0x01, 0xFE, 0x00, 0x70, 0x78, 0x03, 0xFC, 0x00, 0xF0, 0xE0, 0x07,
  0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0xF0, 0x01, 0xC7, 0x80, 0x1F, 0xE0, 0x03,
  0x8F, 0x00, 0x3F, 0xC0, 0x07, 0x9C, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x00,
  0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0x78, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0xFF, 0x3C, 0x00, 0x0F, 0xF3, 0xC0,
  0x00, 0xFF, 0x1C, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0xFF, 0x1E, 0x00, 0x0F,
  0xF0, 0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0xFF, 0x07,
  0x80, 0x0F, 0xF0, 0x38, 0x00, 0xFF, 0x03, 0xC0, 0x0F, 0xF0, 0x3C, 0x00,
  0xFF, 0x01, 0xE0, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0x78, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0x00, 0x78,
  0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0x00, 0x3C, 0x0F, 0xF0, 0x01, 0xE0, 0xFF,
  0x00, 0x1E, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0x00, 0x0F, 0x0F, 0xF0, 0x00,
  0xF0, 0xFF, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x78, 0xFF, 0x00, 0x03, 0xCF,
  0xF0, 0x00, 0x3C, 0x7F, 0x00, 0x01, 0xE7, 0xF0, 0x00, 0x1E, 0x7F, 0x00,
  0x01, 0xE7, 0xF0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x7C,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x87, 0x80, 0x7F, 0x8F, 0x00, 0x1F, 0x9E, 0x00, 0x1F, 0x3C, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78,
  0x00, 0x7C, 0xF0, 0x01, 0xF9, 0xE0, 0x07, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1E, 0x01, 0xFE, 0x0F, 0x00, 0x1F, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF0,
  0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xF8, 0x03, 0xC7, 0xC0, 0x01, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x60, 0x00, 0xFC, 0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC1,
  0xF0, 0x01, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xB8, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xDE, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x71, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0x83,
  0x80, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x70,
  0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03,
  0x80, 0x38, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0xF0, 0x00, 0x1E,
  0x1C, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x00,
  0xF3, 0x80, 0x03, 0x9E, 0x00, 0x00, 0x79, 0xC0, 0x01, 0xCF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x07, 0x80,
  0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x03, 0xEF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x70, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF8, 0xFC, 0x1C, 0x03,
  0xE1, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xC7, 0x1F, 0x80, 0x73, 0xE0, 0x07, 0x7C, 0x00, 0x77, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0x78, 0x03, 0x77, 0xC0, 0x77, 0x3F, 0xBE, 0x73, 0xFF, 0xC7, 0x0F,
  0xF8, 0x70, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xC0, 0xF1, 0xFF,
  0xE0, 0xF3, 0xF7, 0xF0, 0xF7, 0x00, 0xF8, 0xFE, 0x00, 0x78, 0xFC, 0x00,
  0x7C, 0xFC, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x3C, 0xFE, 0x00, 0x78, 0xF6, 0x00,
  0xF8, 0xE7, 0x81, 0xF0, 0xE3, 0xFF, 0xF0, 0xE1, 0xFF, 0xE0, 0xE0, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFD, 0xF0, 0xF8, 0x04, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x30, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xFC, 0x0F, 0x03, 0xFF, 0x0F, 0x07, 0xFF, 0xCF,
  0x0F, 0xFF, 0xCF, 0x1F, 0x80, 0xEF, 0x1E, 0x00, 0x7F, 0x3E, 0x00, 0x3F,
  0x3C, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x37, 0x1F, 0x00, 0x67,
  0x1F, 0x81, 0xE7, 0x0F, 0xFF, 0xC7, 0x07, 0xFF, 0x87, 0x03, 0xFF, 0x07,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7E, 0x3F, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x38, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0,
  0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x20, 0x7E, 0x01, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x7C, 0x30, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x87, 0x07, 0xFF, 0xC7, 0x0F, 0xEF, 0xE7, 0x1F, 0x80, 0xE7, 0x1E, 0x00,
  0x7F, 0x3E, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x3E, 0x00,
  0x7F, 0x1F, 0x00, 0xEF, 0x1F, 0x81, 0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF,
  0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x40, 0x00, 0x7C, 0x30, 0x00, 0xF8, 0x3E, 0x07, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x7F, 0x07, 0x87, 0xFE, 0x3C, 0xFF, 0xF9, 0xE7, 0xFF, 0xCF,
  0x70, 0x1F, 0x7F, 0x00, 0x7B, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x31, 0xE7, 0xFF, 0x7D,
  0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78,
  0x01, 0x80, 0x78, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0x80, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF2, 0x3E, 0x7F, 0x8F, 0xF1, 0xF8,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x17, 0x80, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF3, 0xE0, 0x07, 0xBF, 0x80, 0x3D, 0xFC, 0x01, 0xFE, 0xF0, 0x0F,
  0xE7, 0x80, 0x7E, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x03, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x07, 0x0F,
  0xFC, 0x0F, 0xFC, 0x38, 0xFF, 0xF0, 0xFF, 0xF1, 0xCF, 0xFF, 0x8F, 0xDF,
  0xCE, 0x70, 0x3E, 0x70, 0x3E, 0x77, 0x00, 0xF7, 0x00, 0xFB, 0xB0, 0x07,
  0xB0, 0x03, 0xDF, 0x00, 0x1F, 0x80, 0x1E, 0xF8, 0x00, 0xF8, 0x00, 0xF7,
  0xC0, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0xC0,
  0x03, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x3F,
  0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0xE0,
  0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0x78, 0x00,
  0x3F, 0xC0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x1F,
  0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00, 0x78,
  0x00, 0x3F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x07, 0x07, 0xFE,
  0x38, 0xFF, 0xF9, 0xC7, 0xDF, 0xCE, 0x70, 0x1F, 0x77, 0x00, 0x7B, 0xB0,
  0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xF7, 0xF0, 0x1F, 0x80, 0xF8, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x0F,
  0x80, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0x00, 0xE0, 0xFF, 0xC0, 0xE1, 0xFF, 0xE0, 0xE3,
  0xE7, 0xF0, 0xE7, 0x00, 0xF8, 0xE6, 0x00, 0x78, 0xEC, 0x00, 0x7C, 0xEC,
  0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x3C, 0xFC, 0x00, 0x3C, 0xFE, 0x00, 0x78, 0xF7, 0x00, 0xF8, 0xF7,
  0x81, 0xF0, 0xF3, 0xFF, 0xF0, 0xF1, 0xFF, 0xE0, 0xF0, 0xFF, 0x80, 0xF0,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F,
  0xFF, 0xC7, 0x1F, 0x80, 0xE7, 0x1F, 0x00, 0x7F, 0x3E, 0x00, 0x3F, 0x3C,
  0x00, 0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x1F, 0x00, 0xEF, 0x1F,
  0x81, 0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x8F, 0x01, 0xFF, 0x0F, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x7D, 0xC1, 0xFF, 0x87, 0xF7, 0x1F, 0xEE, 0x78, 0x5C,
  0xE0, 0x3B, 0x80, 0x76, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xFC, 0xFE,
  0x3E, 0x7C, 0x01, 0xBE, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x01, 0xE8, 0x00, 0xFB, 0xC0,
  0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x10, 0x7F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0x38, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x37, 0x78, 0x01, 0xBB, 0xE0, 0x1D, 0xDF, 0x83, 0xCE,
  0x7F, 0xFC, 0x71, 0xFF, 0xC3, 0x87, 0xFC, 0x1C, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x00,
  0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0xE0, 0x01,
  0xE7, 0x80, 0x0F, 0xC0, 0x03, 0x8F, 0x00, 0x1F, 0xC0, 0x07, 0x1E, 0x00,
  0x3B, 0x80, 0x1E, 0x3C, 0x00, 0xF7, 0x00, 0x3C, 0x38, 0x01, 0xEE, 0x00,
  0x78, 0x78, 0x03, 0x9C, 0x00, 0xE0, 0xF0, 0x07, 0x3C, 0x03, 0xC1, 0xE0,
  0x0E, 0x78, 0x07, 0x81, 0xC0, 0x3C, 0x70, 0x0F, 0x03, 0x80, 0x78, 0xE0,
  0x1E, 0x07, 0x80, 0xE1, 0xC0, 0x38, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0x1E,
  0x03, 0x87, 0x81, 0xE0, 0x1C, 0x0F, 0x07, 0x03, 0xC0, 0x3C, 0x1E, 0x0E,
  0x07, 0x00, 0x78, 0x38, 0x1E, 0x0E, 0x00, 0xF0, 0x70, 0x3C, 0x3C, 0x01,
  0xE1, 0xE0, 0x78, 0x78, 0x01, 0xC3, 0xC0, 0x70, 0xF0, 0x03, 0xC7, 0x80,
  0xE1, 0xC0, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x03, 0xCF, 0x00,
  0x0E, 0x78, 0x07, 0x9E, 0x00, 0x1C, 0xF0, 0x07, 0x38, 0x00, 0x3D, 0xC0,
  0x0E, 0x70, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x00, 0xF7, 0x00, 0x3F, 0xC0,
  0x00, 0xEE, 0x00, 0x7F, 0x80, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x70,
  0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x73, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x70, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xF0,
  0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x04, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x37, 0xFF, 0xE0, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xB0, 0x01, 0xFF, 0xC8, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 52, 15, 5, -51 },
  { 40, 16, 18, 24, 4, -51 },
  { 76, 30, 51, 32, 1, -51 },
  { 268, 24, 59, 30, 3, -55 },
  { 445, 38, 53, 45, 3, -52 },
  { 697, 29, 53, 31, 2, -52 },
  { 890, 5, 18, 13, 4, -51 },
  { 902, 14, 63, 20, 4, -52 },
  { 1013, 13, 63, 20, 3, -52 },
  { 1116, 21, 21, 27, 3, -55 },
  { 1172, 26, 33, 30, 2, -42 },
  { 1280, 8, 17, 14, 3, -8 },
  { 1297, 15, 3, 19, 2, -21 },
  { 1303, 6, 8, 15, 4, -7 },
  { 1309, 22, 52, 25, 2, -52 },
  { 1452, 23, 53, 30, 3, -52 },
  { 1605, 14, 51, 30, 5, -51 },
  { 1695, 23, 52, 30, 3, -52 },
  { 1845, 23, 53, 30, 3, -52 },
  { 1998, 28, 52, 30, 1, -52 },
  { 2180, 23, 52, 30, 4, -51 },
  { 2330, 24, 53, 30, 3, -52 },
  { 2489, 24, 51, 30, 3, -51 },
  { 2642, 24, 53, 30, 3, -52 },
  { 2801, 23, 53, 30, 3, -52 },
  { 2954, 5, 40, 15, 5, -39 },
  { 2979, 8, 48, 15, 3, -39 },
  { 3027, 26, 31, 30, 2, -41 },
  { 3128, 26, 19, 30, 2, -35 },
  { 3190, 26, 31, 30, 2, -41 },
  { 3291, 18, 53, 21, 1, -52 },
  { 3411, 38, 58, 45, 4, -52 },
  { 3687, 30, 51, 30, 0, -51 },
  { 3879, 25, 51, 33, 5, -51 },
  { 4039, 25, 53, 31, 4, -52 },
  { 4205, 27, 51, 36, 5, -51 },
  { 4378, 20, 51, 28, 5, -51 },
  { 4506, 20, 51, 26, 5, -51 },
  { 4634, 30, 53, 38, 4, -52 },
  { 4833, 26, 51, 37, 5, -51 },
  { 4999, 12, 51, 18, 3, -51 },
  { 5076, 13, 64, 15, -3, -51 },
  { 5180, 25, 51, 30, 5, -51 },
  { 5340, 19, 51, 26, 5, -51 },
  { 5462, 39, 51, 49, 5, -51 },
  { 5711, 28, 51, 39, 5, -51 },
  { 5890, 30, 53, 38, 4, -52 },
  { 6089, 23, 51, 30, 5, -51 },
  { 6236, 30, 64, 38, 4, -52 },
  { 6476, 25, 51, 31, 5, -51 },
  { 6636, 23, 53, 29, 3, -52 },
  { 6789, 24, 51, 26, 1, -51 },
  { 6942, 26, 52, 36, 5, -51 },
  { 7111, 29, 51, 29, 0, -51 },
  { 7296, 49, 51, 49, 0, -51 },
  { 7609, 25, 51, 26, 1, -51 },
  { 7769, 25, 51, 25, 0, -51 },
  { 7929, 21, 51, 25, 2, -51 },
  { 8063, 14, 63, 22, 6, -52 },
  { 8174, 22, 52, 25, 2, -52 },
  { 8317, 15, 63, 22, 2, -52 },
  { 8436, 28, 26, 30, 1, -51 },
  { 8527, 30, 3, 30, 0, 6 },
  { 8539, 12, 11, 18, 3, -55 },
  { 8556, 20, 40, 28, 3, -39 },
  { 8656, 24, 56, 32, 5, -55 },
  { 8824, 19, 40, 24, 3, -39 },
  { 8919, 24, 56, 32, 3, -55 },
  { 9087, 23, 40, 29, 3, -39 },
  { 9202, 17, 55, 17, 1, -55 },
  { 9319, 24, 56, 32, 3, -39 },
  { 9487, 21, 55, 31, 5, -55 },
  { 9632, 6, 53, 14, 4, -53 },
  { 9672, 11, 70, 14, -1, -53 },
  { 9769, 21, 55, 26, 5, -55 },
  { 9914, 4, 55, 14, 5, -55 },
  { 9942, 37, 39, 46, 5, -39 },
  { 10123, 21, 39, 31, 5, -39 },
  { 10226, 24, 40, 31, 3, -39 },
  { 10346, 24, 56, 32, 5, -39 },
  { 10514, 24, 56, 32, 3, -39 },
  { 10682, 15, 39, 20, 5, -39 },
  { 10756, 18, 40, 23, 3, -39 },
  { 10846, 15, 48, 17, 1, -47 },
  { 10936, 21, 39, 31, 5, -38 },
  { 11039, 24, 38, 24, 0, -38 },
  { 11153, 39, 38, 40, 1, -38 },
  { 11339, 23, 38, 25, 1, -38 },
  { 11449, 23, 55, 25, 1, -38 },
  { 11608, 17, 38, 20, 2, -38 },
  { 11689, 19, 63, 25, 3, -52 },
  { 11839, 4, 72, 28, 12, -55 },
  { 11875, 19, 63, 25, 3, -52 },
  { 12025, 26, 7, 30, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_Light72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT72PT7B_H_
