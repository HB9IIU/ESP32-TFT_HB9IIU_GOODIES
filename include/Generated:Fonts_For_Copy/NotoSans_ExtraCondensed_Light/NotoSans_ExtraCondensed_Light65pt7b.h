#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC3,
  0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x79, 0xEF, 0xFF, 0x79, 0xE0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0x98, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x0F, 0xD8, 0xFC, 0x3C, 0x30, 0x30, 0x70, 0x60, 0x01, 0xE0, 0xC0, 0x03,
  0x81, 0x80, 0x07, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x3C, 0x0C, 0x00, 0x78,
  0x18, 0x00, 0xF0, 0x30, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0xC1,
  0x80, 0x03, 0xC3, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xEC, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0x3F, 0x00, 0x06, 0x1E, 0x00, 0x0C, 0x1E, 0x00, 0x18, 0x1E,
  0x00, 0x30, 0x1C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xF0,
  0x03, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x1E, 0x00,
  0x30, 0x39, 0x00, 0x60, 0xF3, 0xC0, 0xC7, 0xC7, 0xFD, 0xFF, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x03, 0xFE, 0x00,
  0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0xE0, 0x06, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x0E, 0x01, 0x80, 0xE0, 0x03,
  0x80, 0x70, 0x38, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x38, 0x07, 0x07, 0x00,
  0x0E, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x70, 0xE0, 0x00, 0xE0, 0x1C, 0x38,
  0x00, 0x38, 0x07, 0x0E, 0x00, 0x0E, 0x03, 0x87, 0x01, 0x03, 0x80, 0xE1,
  0xC3, 0xF8, 0xE0, 0x38, 0x71, 0xFF, 0x38, 0x0E, 0x38, 0x71, 0xC7, 0x03,
  0x8E, 0x38, 0x39, 0xC0, 0xE3, 0x8E, 0x0E, 0x70, 0x71, 0xC7, 0x01, 0xCE,
  0x3C, 0x71, 0xC0, 0x73, 0xFE, 0x1C, 0x70, 0x1C, 0x7F, 0x0E, 0x1C, 0x07,
  0x0F, 0x83, 0x87, 0x01, 0xC0, 0x00, 0xE1, 0xC0, 0x70, 0x00, 0x70, 0x70,
  0x1C, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x07, 0x07, 0x01, 0xC0, 0x03, 0x81,
  0xC0, 0x70, 0x00, 0xE0, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x07, 0x00, 0x1C,
  0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x01, 0xC7,
  0x00, 0x38, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x39, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xC3, 0xC0, 0x78, 0xF0, 0x70, 0x1E, 0x78, 0x1E, 0x07, 0x1E,
  0x03, 0xC1, 0xC7, 0x00, 0xF0, 0x73, 0xC0, 0x1E, 0x3C, 0xF0, 0x03, 0x8F,
  0x3C, 0x00, 0xF3, 0x8F, 0x00, 0x1C, 0xE3, 0xC0, 0x07, 0xF8, 0xF0, 0x00,
  0xFC, 0x3C, 0x00, 0x3F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x70,
  0x00, 0xFC, 0x1E, 0x00, 0x7F, 0x87, 0xC0, 0x3C, 0xE0, 0xF8, 0x1F, 0x3C,
  0x1F, 0xFF, 0x87, 0x87, 0xFF, 0xC1, 0xE0, 0x7F, 0xC0, 0x3C, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x20, 0x30, 0x1F, 0x0C, 0x3F, 0xFB, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xE1,
  0xC0, 0x70, 0x38, 0x3C, 0x0F, 0x06, 0x01, 0x80, 0x80, 0x40, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x77, 0xFF,
  0xFF, 0xBC, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x3C, 0xE0,
  0x01, 0xE7, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0E,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x77, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x0E, 0x07, 0x80, 0xF0, 0x3E,
  0x0F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x3E, 0x77, 0x87,
  0xF0, 0x7E, 0x07, 0x40, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x03, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xC3, 0xF0, 0x38, 0x03, 0xE0, 0x40,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF8, 0xF8, 0x03, 0xE1, 0x80, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC8, 0x00, 0x1F, 0x1C, 0x00, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xB8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8F, 0x00,
  0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0x70, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0x1C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x03, 0xC0,
  0x0F, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1D, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE4, 0x00, 0x1E,
  0x38, 0x03, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xE0,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x1F, 0x01, 0xE3, 0xFE, 0x0F, 0x3F, 0xF8, 0x7B, 0xE7, 0xE3,
  0xF8, 0x0F, 0x9F, 0x80, 0x3C, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xE0, 0x00,
  0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x38,
  0x00, 0xF1, 0xE0, 0x07, 0x07, 0x80, 0x78, 0x3E, 0x07, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7C, 0x1F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1E, 0x1C,
  0x00, 0x3C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0xF0, 0x0F, 0x83,
  0xC0, 0x0F, 0x07, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x70,
  0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x0F, 0x81, 0xFE, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x07, 0xC7, 0x80, 0x3C,
  0x78, 0x01, 0xC7, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0x73,
  0xE0, 0x77, 0x3F, 0xFE, 0x71, 0xFF, 0xC7, 0x07, 0xF8, 0x70, 0x04, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0x77, 0xFF, 0xFF,
  0xBC, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xDE, 0x1C, 0x1E, 0x3E, 0x3E, 0x3E,
  0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70,
  0x70, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0xF8, 0xFF, 0xFC, 0x78, 0x7E, 0x60, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x78, 0x07, 0x0E, 0x00, 0x7F, 0xC0,
  0xF1, 0xC0, 0x1F, 0xF8, 0x0E, 0x38, 0x07, 0x87, 0x01, 0xCE, 0x01, 0xE0,
  0xE0, 0x39, 0xC0, 0x38, 0x1C, 0x07, 0x38, 0x0E, 0x03, 0x80, 0xE7, 0x01,
  0xC0, 0x70, 0x1E, 0xE0, 0x38, 0x0E, 0x01, 0xDC, 0x0E, 0x01, 0xC0, 0x3F,
  0x81, 0xC0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0x00, 0xFC, 0x07, 0x00, 0xE0,
  0x1F, 0x80, 0xE0, 0x1C, 0x03, 0xF0, 0x1C, 0x03, 0x80, 0x7E, 0x03, 0x80,
  0xF0, 0x1D, 0xC0, 0x70, 0x1E, 0x03, 0xB8, 0x0E, 0x03, 0xC0, 0x77, 0x01,
  0xC0, 0x78, 0x0E, 0xF0, 0x38, 0x0F, 0x01, 0xCE, 0x07, 0x81, 0xE0, 0x39,
  0xC0, 0x70, 0x6C, 0x0E, 0x38, 0x0E, 0x0D, 0xC3, 0xC7, 0x00, 0xE3, 0xBC,
  0xF0, 0xE0, 0x1F, 0xE3, 0xFE, 0x1E, 0x01, 0xF8, 0x3F, 0x81, 0xC0, 0x0E,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1E,
  0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0xF8, 0xF0, 0x01,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0x8F, 0x00, 0x1E, 0x3C, 0x01, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3C, 0x03, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xE1, 0xF0, 0x3E, 0x00, 0x40, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x30, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xC0,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE,
  0x03, 0xF0, 0x00, 0xE0, 0x7C, 0x00, 0x04, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x70, 0x7C, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x70, 0x3F, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0xC7, 0xCF, 0xFC, 0xFF, 0x87, 0xE0, 0xF0,
  0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x3C, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80,
  0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x87,
  0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1C, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xDC, 0x00, 0x00, 0x1F, 0xFB, 0x80,
  0x00, 0x07, 0xFF, 0x70, 0x00, 0x00, 0xEF, 0xEF, 0x00, 0x00, 0x1D, 0xFC,
  0xE0, 0x00, 0x03, 0xBF, 0x9C, 0x00, 0x00, 0xF7, 0xF3, 0xC0, 0x00, 0x1C,
  0xFE, 0x38, 0x00, 0x03, 0x9F, 0xC7, 0x00, 0x00, 0xF3, 0xF8, 0xE0, 0x00,
  0x1C, 0x7F, 0x1E, 0x00, 0x03, 0x8F, 0xE1, 0xC0, 0x00, 0xF1, 0xFC, 0x38,
  0x00, 0x1E, 0x3F, 0x87, 0x80, 0x03, 0x87, 0xF0, 0x70, 0x00, 0x70, 0xFE,
  0x0E, 0x00, 0x1E, 0x1F, 0xC1, 0xE0, 0x03, 0x83, 0xF8, 0x1C, 0x00, 0x70,
  0x7F, 0x03, 0x80, 0x1E, 0x0F, 0xE0, 0x70, 0x03, 0x81, 0xFC, 0x0F, 0x00,
  0x70, 0x3F, 0x80, 0xE0, 0x0E, 0x07, 0xF0, 0x1C, 0x03, 0xC0, 0xFE, 0x03,
  0xC0, 0x70, 0x1F, 0xC0, 0x38, 0x0E, 0x03, 0xF8, 0x07, 0x03, 0xC0, 0x7F,
  0x00, 0xE0, 0x70, 0x0F, 0xE0, 0x1E, 0x0E, 0x01, 0xFC, 0x01, 0xC3, 0xC0,
  0x3F, 0x80, 0x38, 0x78, 0x07, 0xF0, 0x07, 0x8E, 0x00, 0xFE, 0x00, 0x71,
  0xC0, 0x1F, 0xC0, 0x0E, 0x78, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0x7F, 0x00,
  0x3D, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xB8, 0x00, 0x0F, 0xDE, 0x00, 0x07, 0xE7, 0x00, 0x03, 0xF3, 0xC0,
  0x01, 0xF9, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x7E, 0x3C, 0x00, 0x3F, 0x0E,
  0x00, 0x1F, 0x87, 0x80, 0x0F, 0xC1, 0xC0, 0x07, 0xE0, 0xF0, 0x03, 0xF0,
  0x78, 0x01, 0xF8, 0x1C, 0x00, 0xFC, 0x0F, 0x00, 0x7E, 0x03, 0x80, 0x3F,
  0x01, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x3C, 0x07, 0xE0, 0x1E, 0x03,
  0xF0, 0x07, 0x81, 0xF8, 0x03, 0xC0, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x78,
  0x3F, 0x00, 0x1C, 0x1F, 0x80, 0x0F, 0x0F, 0xC0, 0x07, 0x87, 0xE0, 0x01,
  0xE3, 0xF0, 0x00, 0xF1, 0xF8, 0x00, 0x38, 0xFC, 0x00, 0x1E, 0x7E, 0x00,
  0x07, 0x3F, 0x00, 0x03, 0xDF, 0x80, 0x00, 0xEF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F,
  0x00, 0x7E, 0x03, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x3C, 0xF0, 0x07, 0xCF, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3C, 0x03, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x73,
  0xC0, 0x01, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x1F,
  0x0F, 0x03, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x78,
  0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x3C,
  0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x3C, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFC, 0x7E, 0x3E, 0x00, 0x67, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x80, 0x03, 0xCF, 0x00, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0xF0, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1E, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x70, 0x0F, 0x00,
  0x1C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x01, 0xE0,
  0x03, 0x80, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x78, 0x00,
  0x1F, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x38, 0x00, 0x1F,
  0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF8, 0x00, 0x1C, 0x3C, 0x00, 0x1D, 0xC0,
  0x01, 0xC3, 0xC0, 0x03, 0xDC, 0x00, 0x3C, 0x1C, 0x00, 0x39, 0xC0, 0x03,
  0xC1, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x1E, 0x00, 0x39, 0xC0, 0x03, 0x81,
  0xE0, 0x03, 0x9E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0xE0, 0x07, 0x80, 0xE0,
  0x07, 0x8E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x80, 0xF0, 0x07,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x07,
  0x00, 0xF0, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x07, 0x00,
  0xF0, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x00, 0x78, 0x0E, 0x07, 0x81, 0xE0,
  0x03, 0x81, 0xE0, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x03, 0x81, 0xE0, 0x03,
  0xC1, 0xC0, 0x38, 0x1C, 0x00, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x03, 0xC1,
  0xC0, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x01, 0xC3, 0xC0, 0x01, 0xC3, 0xC0,
  0x1C, 0x3C, 0x00, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x01, 0xE3, 0x80, 0x1C,
  0x38, 0x00, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x00, 0xE3, 0x80, 0x0E, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x7F, 0x00, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x1C, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x1C, 0x07, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xEF, 0x00,
  0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x1E, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x1C, 0x00,
  0x38, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0F, 0x00, 0xF0,
  0x3C, 0x03, 0x80, 0x70, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9C,
  0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0xE0,
  0x00, 0x39, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01,
  0xE0, 0x38, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x38,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xC7, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x78,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x1E,
  0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xF3, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0xFE,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x03, 0xE0, 0x80, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x07, 0xFF,
  0x07, 0xFF, 0xE1, 0xFE, 0x1C, 0x7C, 0x03, 0x9E, 0x00, 0x77, 0x80, 0x0E,
  0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x07, 0xDE, 0x01, 0xBB,
  0xE0, 0x37, 0x3F, 0x1C, 0xE3, 0xFF, 0x9C, 0x3F, 0xC3, 0x80, 0xE0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x07, 0xF0, 0x3C, 0x7F, 0xE0, 0xF3, 0xFF, 0xC3, 0xDE,
  0x0F, 0x8F, 0x60, 0x1F, 0x3F, 0x00, 0x3C, 0xFC, 0x00, 0x73, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0xBE, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBE,
  0x00, 0x0E, 0xF8, 0x00, 0x3B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBF, 0x00,
  0x3C, 0xFE, 0x00, 0xF3, 0xDC, 0x07, 0x8F, 0x3E, 0xFC, 0x38, 0x7F, 0xF0,
  0xE0, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF0, 0x21, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x01, 0x0F, 0xEF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x0F, 0xE0, 0xE0, 0xFF, 0xC7, 0x0F, 0xFF, 0x38, 0xF8, 0x3D, 0xCF, 0x80,
  0x6E, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0,
  0x03, 0xDE, 0x00, 0x3E, 0x70, 0x01, 0xF3, 0xC0, 0x1B, 0x8F, 0x01, 0xDC,
  0x7F, 0x7C, 0xE1, 0xFF, 0xC3, 0x07, 0xFC, 0x18, 0x03, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x78, 0x1E, 0x03, 0xC3,
  0xC0, 0x1C, 0x38, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x21, 0xF0, 0x06, 0x0F, 0xE7, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x38, 0x01, 0xFF, 0x03, 0xFE, 0x07,
  0xE6, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x38,
  0x3F, 0xF1, 0xC3, 0xFF, 0xCE, 0x3E, 0x0F, 0x73, 0xE0, 0x1B, 0x9E, 0x00,
  0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x0F, 0x9C, 0x00, 0x7C, 0xF0, 0x06, 0xE3, 0xC0, 0x77, 0x1F, 0xDF, 0x38,
  0x7F, 0xF1, 0xC1, 0xFF, 0x0E, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x20, 0x00, 0xF1, 0xC0, 0x0F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFE,
  0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x78, 0x7C, 0xF6, 0x01, 0xEF, 0xC0,
  0x1E, 0xFC, 0x00, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0x27, 0xBF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x02, 0x07, 0x83, 0xE1,
  0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xCF, 0xE7, 0xE3, 0xF0, 0xC0, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x78,
  0x3C, 0x0E, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0x78, 0xE0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x3D, 0xFC, 0x07, 0xF7, 0x80,
  0xFE, 0x70, 0x1F, 0x8F, 0x03, 0xE0, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x38, 0x3C, 0x07, 0x87, 0x80, 0x70, 0xF0, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x1C, 0x78, 0x03, 0xCF, 0x00, 0x39, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xFE, 0x01, 0xF8, 0x38, 0x7F,
  0xC1, 0xFF, 0x8E, 0x3F, 0xF8, 0xFF, 0xF3, 0x9C, 0x1E, 0x38, 0x7C, 0xEE,
  0x03, 0xD8, 0x07, 0xBF, 0x00, 0xF6, 0x01, 0xEF, 0x80, 0x1F, 0x00, 0x3B,
  0xE0, 0x07, 0xC0, 0x0E, 0xF8, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07,
  0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00,
  0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F,
  0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00,
  0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0xE0,
  0xFE, 0x0E, 0x1F, 0xF8, 0xE3, 0xFF, 0xCE, 0x78, 0x3C, 0xE6, 0x01, 0xEE,
  0xC0, 0x1E, 0xFC, 0x00, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xC0, 0xF0, 0x3E, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00,
  0x1C, 0x70, 0x00, 0x79, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E,
  0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x39,
  0xC0, 0x01, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x70, 0xF0,
  0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x7F, 0x03, 0x87, 0xFE, 0x0E,
  0x3F, 0xFC, 0x39, 0xE0, 0xF8, 0xE6, 0x01, 0xF3, 0xB0, 0x03, 0xCF, 0xC0,
  0x07, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xEF, 0x00, 0x03,
  0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3B, 0xE0, 0x00, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xFC,
  0x00, 0x73, 0xF0, 0x03, 0xCF, 0xE0, 0x0F, 0x3D, 0xC0, 0xF8, 0xF3, 0xFF,
  0xC3, 0xC7, 0xFE, 0x0F, 0x0F, 0xF0, 0x3C, 0x07, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x38, 0x3F, 0xF1, 0xC3, 0xFF, 0xCE, 0x3E, 0x0F, 0x73, 0xE0,
  0x1B, 0x9E, 0x00, 0x7C, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x06, 0xE3, 0xC0, 0x77,
  0x1F, 0xDF, 0x38, 0x7F, 0xF1, 0xC0, 0xFF, 0x0E, 0x01, 0xE0, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xB9, 0xF2, 0xE7, 0x03, 0xD8, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC0, 0xE7, 0x80,
  0x13, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3D, 0xC0, 0x3E, 0xFF, 0xFE,
  0x7F, 0xFE, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x01, 0xC0, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xF7, 0x00, 0x1F, 0x70, 0x01, 0xF7, 0x80, 0x37, 0x78, 0x07,
  0x73, 0xC0, 0xE7, 0x3F, 0xFE, 0x71, 0xFF, 0xC7, 0x0F, 0xF8, 0x70, 0x3C,
  0x00, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC1, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3B, 0xC0, 0x07, 0xC0, 0x07, 0x78, 0x00,
  0xF8, 0x00, 0xE7, 0x00, 0x3F, 0x00, 0x3C, 0xE0, 0x07, 0xE0, 0x07, 0x9C,
  0x00, 0xEC, 0x00, 0xE3, 0xC0, 0x1D, 0xC0, 0x1C, 0x78, 0x03, 0xB8, 0x03,
  0x87, 0x00, 0xE7, 0x00, 0xF0, 0xE0, 0x1C, 0xE0, 0x1C, 0x1C, 0x03, 0x9E,
  0x03, 0x83, 0xC0, 0x71, 0xC0, 0x70, 0x38, 0x0E, 0x38, 0x0E, 0x07, 0x03,
  0x87, 0x03, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x1E, 0x0E, 0x1E, 0x0E, 0x03,
  0xC1, 0xC1, 0xC1, 0xC0, 0x38, 0x78, 0x38, 0x78, 0x07, 0x0E, 0x07, 0x0F,
  0x00, 0xE1, 0xC0, 0xE1, 0xC0, 0x1E, 0x38, 0x1E, 0x38, 0x03, 0xC7, 0x01,
  0xC7, 0x00, 0x39, 0xE0, 0x39, 0xE0, 0x07, 0x38, 0x07, 0x38, 0x00, 0xE7,
  0x00, 0xE7, 0x00, 0x1E, 0xE0, 0x1E, 0xE0, 0x01, 0xDC, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x3B, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0xF7, 0x80, 0x0F,
  0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC1, 0xE0, 0x3C, 0x1E, 0x03,
  0x80, 0xE0, 0x78, 0x0F, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x8E, 0x00, 0x39,
  0xE0, 0x03, 0xDE, 0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3D, 0xC0, 0x03, 0x9E, 0x00, 0x78, 0xE0, 0x07, 0x0F, 0x00, 0xF0, 0x70,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x81, 0xC0, 0x3C, 0x3C, 0x01,
  0xC3, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0F,
  0x3C, 0x00, 0x79, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x3C, 0x0F, 0x01, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xC1,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x80, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x0F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x7C, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xD0, 0x00, 0xFF, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 46, 14, 4, -46 },
  { 36, 14, 16, 22, 4, -46 },
  { 64, 27, 46, 29, 1, -46 },
  { 220, 23, 53, 27, 2, -49 },
  { 373, 34, 48, 40, 3, -47 },
  { 577, 26, 48, 28, 2, -47 },
  { 733, 4, 16, 12, 4, -46 },
  { 741, 13, 57, 18, 3, -47 },
  { 834, 13, 57, 18, 2, -47 },
  { 927, 18, 19, 24, 3, -49 },
  { 970, 23, 30, 27, 2, -38 },
  { 1057, 8, 15, 13, 2, -7 },
  { 1072, 14, 3, 17, 2, -19 },
  { 1078, 5, 6, 13, 4, -6 },
  { 1082, 21, 47, 23, 1, -47 },
  { 1206, 21, 48, 27, 3, -47 },
  { 1332, 12, 46, 27, 5, -46 },
  { 1401, 22, 47, 27, 2, -47 },
  { 1531, 22, 48, 27, 2, -47 },
  { 1663, 25, 47, 27, 1, -47 },
  { 1810, 21, 47, 27, 3, -46 },
  { 1934, 21, 48, 27, 3, -47 },
  { 2060, 22, 46, 27, 2, -46 },
  { 2187, 23, 48, 27, 2, -47 },
  { 2325, 20, 48, 27, 3, -47 },
  { 2445, 5, 35, 13, 4, -35 },
  { 2467, 8, 43, 13, 2, -35 },
  { 2510, 23, 28, 27, 2, -37 },
  { 2591, 23, 17, 27, 2, -31 },
  { 2640, 23, 28, 27, 2, -37 },
  { 2721, 16, 47, 19, 1, -47 },
  { 2815, 35, 53, 41, 3, -47 },
  { 3047, 27, 46, 27, 0, -46 },
  { 3203, 22, 46, 30, 5, -46 },
  { 3330, 23, 48, 28, 3, -47 },
  { 3468, 24, 46, 32, 5, -46 },
  { 3606, 17, 46, 25, 5, -46 },
  { 3704, 17, 46, 24, 5, -46 },
  { 3802, 28, 48, 35, 3, -47 },
  { 3970, 23, 46, 33, 5, -46 },
  { 4103, 12, 46, 16, 2, -46 },
  { 4172, 12, 58, 13, -3, -46 },
  { 4259, 22, 46, 27, 5, -46 },
  { 4386, 17, 46, 23, 5, -46 },
  { 4484, 35, 46, 45, 5, -46 },
  { 4686, 25, 46, 35, 5, -46 },
  { 4830, 28, 48, 35, 3, -47 },
  { 4998, 20, 46, 27, 5, -46 },
  { 5113, 28, 58, 35, 3, -47 },
  { 5316, 22, 46, 28, 5, -46 },
  { 5443, 20, 48, 26, 3, -47 },
  { 5563, 22, 46, 23, 1, -46 },
  { 5690, 23, 47, 33, 5, -46 },
  { 5826, 26, 46, 26, 0, -46 },
  { 5976, 44, 46, 44, 0, -46 },
  { 6229, 22, 46, 24, 1, -46 },
  { 6356, 23, 46, 23, 0, -46 },
  { 6489, 19, 46, 22, 2, -46 },
  { 6599, 13, 57, 20, 5, -47 },
  { 6692, 21, 47, 23, 1, -47 },
  { 6816, 13, 57, 20, 2, -47 },
  { 6909, 25, 23, 27, 1, -46 },
  { 6981, 27, 3, 27, 0, 6 },
  { 6992, 10, 11, 16, 3, -50 },
  { 7006, 19, 36, 25, 2, -35 },
  { 7092, 22, 50, 29, 4, -49 },
  { 7230, 17, 36, 21, 3, -35 },
  { 7307, 21, 50, 29, 3, -49 },
  { 7439, 20, 36, 26, 3, -35 },
  { 7529, 16, 50, 15, 1, -50 },
  { 7629, 21, 51, 29, 3, -35 },
  { 7763, 20, 49, 28, 4, -49 },
  { 7886, 5, 48, 13, 4, -48 },
  { 7916, 9, 64, 13, 0, -48 },
  { 7988, 19, 49, 24, 4, -49 },
  { 8105, 4, 49, 12, 4, -49 },
  { 8130, 34, 35, 42, 4, -35 },
  { 8279, 20, 35, 28, 4, -35 },
  { 8367, 22, 36, 28, 3, -35 },
  { 8466, 22, 50, 29, 4, -35 },
  { 8604, 21, 50, 29, 3, -35 },
  { 8736, 14, 35, 18, 4, -35 },
  { 8798, 17, 36, 21, 2, -35 },
  { 8875, 13, 44, 15, 1, -43 },
  { 8947, 20, 36, 28, 4, -35 },
  { 9037, 21, 35, 22, 0, -35 },
  { 9129, 35, 35, 36, 1, -35 },
  { 9283, 20, 35, 22, 1, -35 },
  { 9371, 21, 51, 22, 1, -35 },
  { 9505, 15, 35, 18, 2, -35 },
  { 9571, 17, 57, 23, 3, -47 },
  { 9693, 3, 66, 25, 11, -50 },
  { 9718, 17, 57, 23, 3, -47 },
  { 9840, 23, 6, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Light65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT65PT7B_H_
