#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x7E, 0xEC, 0x59, 0x3C, 0xEE, 0xF7, 0x70, 0xD9, 0x5E,
  0xC0, 0x6A, 0x90, 0x95, 0x60, 0xF0, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x56,
  0x80, 0xF6, 0xDE, 0xD5, 0x40, 0xE5, 0x2E, 0xE5, 0x1E, 0x4A, 0xF2, 0xD1,
  0x9E, 0x53, 0xDE, 0xE9, 0x24, 0xF5, 0x5E, 0xF7, 0x9C, 0x90, 0x98, 0x71,
  0x80, 0xE0, 0xC7, 0x00, 0xD6, 0x80, 0x7B, 0xFF, 0x86, 0x4A, 0xFA, 0xFB,
  0xC0, 0x72, 0x46, 0xFF, 0xC0, 0xF8, 0xF8, 0x72, 0xD6, 0xFF, 0xC0, 0xEA,
  0xC0, 0xFC, 0xEA, 0xC0, 0xF8, 0xB6, 0xFE, 0xFF, 0xC0, 0x76, 0xD6, 0xBA,
  0x80, 0x76, 0xD6, 0x40, 0xFA, 0xC0, 0xF1, 0x1E, 0xD5, 0x40, 0xB6, 0xDE,
  0xB6, 0xA4, 0xAD, 0x7B, 0xA5, 0x00, 0xB9, 0x6A, 0xF5, 0x40, 0xD6, 0xC0,
  0xFC, 0xA5, 0x40, 0xD5, 0x70, 0x56, 0x80, 0xE0, 0x80, 0x5F, 0x9A, 0xDE,
  0x6B, 0x2E, 0xDE, 0x7B, 0xEA, 0x80, 0x76, 0xF3, 0x80, 0x9A, 0xDA, 0xF8,
  0xFE, 0xBF, 0xC0, 0xF8, 0xDB, 0xBB, 0xD6, 0xD0, 0x56, 0xF0, 0xD6, 0xF9,
  0x00, 0x76, 0xF2, 0x40, 0xEA, 0xE7, 0xBA, 0xC0, 0xB6, 0xF0, 0xF6, 0xDD,
  0x66, 0xD7, 0xF5, 0x60, 0xDB, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 5, 3, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 3, 5, 3, 0, -5 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 2, 6, 2, 0, -5 },
  { 17, 2, 2, 3, 0, -5 },
  { 18, 3, 3, 3, 0, -4 },
  { 20, 1, 2, 1, 0, -1 },
  { 21, 2, 1, 2, 0, -2 },
  { 22, 1, 1, 1, 0, -1 },
  { 23, 2, 5, 2, 0, -5 },
  { 25, 3, 5, 3, 0, -5 },
  { 27, 2, 5, 3, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 1, 4, 1, 0, -4 },
  { 46, 1, 5, 1, 0, -4 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 2, 5, 2, 0, -5 },
  { 54, 4, 6, 4, 0, -5 },
  { 57, 3, 5, 3, 0, -5 },
  { 59, 2, 5, 3, 1, -5 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 2, 5, 3, 1, -5 },
  { 65, 1, 5, 3, 1, -5 },
  { 66, 1, 5, 3, 1, -5 },
  { 67, 3, 5, 4, 0, -5 },
  { 69, 2, 5, 4, 1, -5 },
  { 71, 2, 5, 2, 0, -5 },
  { 73, 1, 6, 1, 0, -5 },
  { 74, 2, 5, 3, 1, -5 },
  { 76, 1, 5, 2, 1, -5 },
  { 77, 3, 5, 5, 1, -5 },
  { 79, 2, 5, 4, 1, -5 },
  { 81, 3, 5, 4, 0, -5 },
  { 83, 2, 5, 3, 1, -5 },
  { 85, 3, 6, 4, 0, -5 },
  { 88, 2, 5, 3, 1, -5 },
  { 90, 3, 5, 3, 0, -5 },
  { 92, 2, 5, 3, 0, -5 },
  { 94, 3, 5, 4, 0, -5 },
  { 96, 3, 5, 3, 0, -5 },
  { 98, 5, 5, 5, 0, -5 },
  { 102, 3, 5, 3, 0, -5 },
  { 104, 2, 5, 2, 0, -5 },
  { 106, 2, 5, 2, 0, -5 },
  { 108, 1, 6, 2, 1, -5 },
  { 109, 2, 5, 2, 0, -5 },
  { 111, 2, 6, 2, 0, -5 },
  { 113, 3, 3, 3, 0, -5 },
  { 115, 3, 1, 3, 0, 0 },
  { 116, 1, 1, 2, 0, -5 },
  { 117, 2, 4, 3, 0, -4 },
  { 118, 3, 5, 3, 0, -5 },
  { 120, 2, 4, 2, 0, -4 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 2, 4, 3, 0, -4 },
  { 124, 2, 5, 2, 0, -5 },
  { 126, 3, 6, 3, 0, -4 },
  { 129, 3, 5, 3, 0, -5 },
  { 131, 1, 5, 1, 0, -5 },
  { 132, 1, 7, 1, 0, -5 },
  { 133, 2, 5, 3, 0, -5 },
  { 135, 1, 5, 1, 0, -5 },
  { 136, 4, 4, 5, 0, -4 },
  { 138, 3, 4, 3, 0, -4 },
  { 140, 3, 4, 3, 0, -4 },
  { 142, 3, 6, 3, 0, -4 },
  { 145, 3, 6, 3, 0, -4 },
  { 148, 2, 4, 2, 0, -4 },
  { 149, 2, 4, 2, 0, -4 },
  { 150, 2, 5, 2, 0, -5 },
  { 152, 3, 4, 3, 0, -4 },
  { 154, 2, 4, 2, 0, -4 },
  { 155, 4, 4, 4, 0, -4 },
  { 157, 2, 4, 2, 0, -4 },
  { 158, 2, 6, 2, 0, -4 },
  { 160, 2, 4, 2, 0, -4 },
  { 161, 2, 6, 2, 0, -5 },
  { 163, 1, 7, 3, 1, -5 },
  { 164, 2, 6, 2, 0, -5 },
  { 166, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Light7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT7PT7B_H_
