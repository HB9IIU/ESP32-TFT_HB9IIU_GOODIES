#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light67pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xFE, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0x70, 0x1D, 0xC0,
  0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x1C,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x18, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0x38, 0x78, 0x78, 0x70, 0x10,
  0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x3C,
  0x0E, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x8E,
  0x00, 0x0F, 0xDC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0x7E, 0x00, 0x0E, 0x3E,
  0x00, 0x1C, 0x3E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x78,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0xF6, 0x01,
  0xC3, 0xEF, 0x83, 0x8F, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x38, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x1C,
  0x1C, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0x0E,
  0x01, 0xC3, 0x80, 0x00, 0xE0, 0x1C, 0x38, 0x7E, 0x0E, 0x01, 0xC7, 0x0F,
  0xF8, 0xE0, 0x1C, 0x70, 0xE7, 0x87, 0x03, 0x87, 0x1C, 0x1C, 0x70, 0x38,
  0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x38, 0x1E, 0x38, 0x70, 0xE3, 0x80, 0xE3,
  0xCF, 0x1C, 0x38, 0x0E, 0x1F, 0xE1, 0xC3, 0x80, 0xE0, 0xFC, 0x1C, 0x38,
  0x0E, 0x03, 0x03, 0x87, 0x80, 0xE0, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x03,
  0x87, 0x80, 0xF0, 0x00, 0x70, 0x70, 0x0F, 0x00, 0x07, 0x07, 0x00, 0xF0,
  0x00, 0x70, 0x70, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x70,
  0x0F, 0x00, 0x0E, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x1C,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x38, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x0F, 0xF8, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x1E, 0x01, 0xC3, 0xC1, 0xE0, 0x38, 0x78, 0x3C, 0x07,
  0x1E, 0x03, 0xC0, 0xE3, 0xC0, 0x38, 0x3C, 0x70, 0x07, 0x87, 0x9E, 0x00,
  0x70, 0xF3, 0xC0, 0x0F, 0x1C, 0x78, 0x00, 0xF7, 0x8F, 0x00, 0x0E, 0xF1,
  0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x1F, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x03, 0xF8, 0x3C, 0x00, 0x7F, 0x87,
  0xC0, 0x1E, 0xF0, 0x7C, 0x0F, 0x8F, 0x07, 0xFF, 0xE1, 0xE0, 0x7F, 0xF8,
  0x1E, 0x07, 0xFC, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x38, 0x17, 0xC7, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3B, 0x80,
  0x0F, 0x70, 0x01, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xF0,
  0x60, 0x1C, 0x04, 0x01, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xEF, 0xBF, 0xF9, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0x87, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x38, 0x3C, 0x00,
  0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x79,
  0xC0, 0x01, 0xE7, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x07,
  0x9C, 0x00, 0x1E, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x1E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0E, 0x07, 0x80,
  0x78, 0x1E, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07,
  0xF0, 0x7F, 0x87, 0xFC, 0x7D, 0xE7, 0xCF, 0x7C, 0x7F, 0x83, 0xF8, 0x1E,
  0x80, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x30, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7E,
  0x03, 0xE0, 0xE0, 0x07, 0xC1, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0xFC, 0x03, 0xE1, 0xC0, 0x07, 0xC2, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x40, 0x01, 0xF1, 0xC0, 0x0F, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE1, 0xFC,
  0x08, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x20, 0x00, 0xF8, 0xF0, 0x0F,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFC, 0x04, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x03, 0xC0, 0x3C, 0x3F, 0xE0, 0xF3, 0xFF, 0xC3, 0xDF, 0xFF,
  0x8F, 0x70, 0x1E, 0x3F, 0x80, 0x3C, 0xFC, 0x00, 0xF3, 0xE0, 0x01, 0xEF,
  0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9E,
  0x00, 0x1E, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x7C, 0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x79, 0xE0, 0x00, 0x73, 0xC0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F,
  0x00, 0x7C, 0x3E, 0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x1F, 0x00, 0x7C, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xE0, 0x07,
  0x83, 0xE0, 0x1F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xF0, 0x7C, 0x1E, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1C,
  0x70, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xEE, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x0D, 0xCF,
  0x00, 0xEE, 0x7F, 0x3E, 0x71, 0xFF, 0xE7, 0x87, 0xFE, 0x3C, 0x0F, 0xE1,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x38, 0x00, 0x00, 0x71, 0xEF, 0xBF, 0xF9, 0xE3, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xBE, 0xFB, 0xFF, 0x9E, 0x1E, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xC7, 0x03, 0xE2, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x03, 0xC0, 0x1C,
  0x3C, 0x01, 0xFF, 0x80, 0xE3, 0x80, 0x3F, 0xF8, 0x0E, 0x38, 0x07, 0x83,
  0x80, 0xE3, 0x80, 0x70, 0x38, 0x0E, 0x78, 0x0E, 0x03, 0x80, 0xE7, 0x00,
  0xE0, 0x38, 0x0F, 0x70, 0x1E, 0x03, 0x80, 0x77, 0x01, 0xC0, 0x38, 0x07,
  0x70, 0x1C, 0x03, 0x80, 0x77, 0x01, 0xC0, 0x38, 0x07, 0x70, 0x3C, 0x07,
  0x80, 0x7F, 0x03, 0xC0, 0x78, 0x07, 0xF0, 0x3C, 0x07, 0x80, 0x7F, 0x03,
  0x80, 0x78, 0x07, 0xF0, 0x38, 0x07, 0x80, 0x7F, 0x03, 0x80, 0x78, 0x0F,
  0xF0, 0x3C, 0x07, 0x80, 0xEF, 0x03, 0xC0, 0x70, 0x0E, 0x70, 0x1C, 0x07,
  0x00, 0xE7, 0x01, 0xC0, 0xF8, 0x0E, 0x70, 0x1C, 0x0D, 0x81, 0xE7, 0x01,
  0xE0, 0xD8, 0x1C, 0x70, 0x0E, 0x1D, 0xC3, 0xC7, 0x00, 0xFF, 0x9F, 0xF8,
  0x78, 0x07, 0xF8, 0xFF, 0x03, 0x80, 0x3F, 0x07, 0xE0, 0x38, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x78, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0x80, 0xFF, 0x0F,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x3E,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE1,
  0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0xFB, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x00, 0x7F, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x0E, 0x03, 0xE0, 0x02,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0x01, 0xF8, 0x07,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xE0,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x0F, 0x00, 0x3F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x03, 0xFC, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F,
  0x01, 0xF8, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0xE0, 0x00, 0xFF, 0xF7,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x00,
  0x07, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x83, 0xEF, 0xFC, 0xFF,
  0x8F, 0xF0, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01,
  0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xF8, 0x00, 0x7B, 0xF0, 0x00, 0xFE,
  0xF0, 0x01, 0xFD, 0xE0, 0x03, 0xF1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x83,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xEE,
  0x00, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0x00, 0x00, 0x0E,
  0xFF, 0x70, 0x00, 0x00, 0xEF, 0xF7, 0x00, 0x00, 0x0E, 0xFF, 0x78, 0x00,
  0x01, 0xEF, 0xF3, 0x80, 0x00, 0x1C, 0xFF, 0x38, 0x00, 0x01, 0xCF, 0xF3,
  0xC0, 0x00, 0x3C, 0xFF, 0x1C, 0x00, 0x03, 0x8F, 0xF1, 0xC0, 0x00, 0x38,
  0xFF, 0x1C, 0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00, 0x78, 0xFF, 0x0E, 0x00,
  0x07, 0x0F, 0xF0, 0xE0, 0x00, 0x70, 0xFF, 0x0F, 0x00, 0x0F, 0x0F, 0xF0,
  0x70, 0x00, 0xE0, 0xFF, 0x07, 0x00, 0x0E, 0x0F, 0xF0, 0x78, 0x01, 0xE0,
  0xFF, 0x07, 0x80, 0x1C, 0x0F, 0xF0, 0x38, 0x01, 0xC0, 0xFF, 0x03, 0x80,
  0x3C, 0x0F, 0xF0, 0x3C, 0x03, 0xC0, 0xFF, 0x01, 0xC0, 0x38, 0x0F, 0xF0,
  0x1C, 0x03, 0x80, 0xFF, 0x01, 0xE0, 0x78, 0x0F, 0xF0, 0x1E, 0x07, 0x00,
  0xFF, 0x00, 0xE0, 0x70, 0x0F, 0xF0, 0x0E, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0xF0, 0x0F, 0xF0, 0x07, 0x0E, 0x00, 0xFF, 0x00, 0x70, 0xE0, 0x0F, 0xF0,
  0x07, 0x9E, 0x00, 0xFF, 0x00, 0x39, 0xC0, 0x0F, 0xF0, 0x03, 0x9C, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFE, 0xE0, 0x00, 0x3F, 0xBC, 0x00, 0x0F, 0xF7, 0x00,
  0x03, 0xFD, 0xE0, 0x00, 0xFF, 0x78, 0x00, 0x3F, 0xCE, 0x00, 0x0F, 0xF3,
  0xC0, 0x03, 0xFC, 0x70, 0x00, 0xFF, 0x1E, 0x00, 0x3F, 0xC3, 0x80, 0x0F,
  0xF0, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0xFF, 0x07, 0x80, 0x3F, 0xC1, 0xE0,
  0x0F, 0xF0, 0x38, 0x03, 0xFC, 0x0F, 0x00, 0xFF, 0x01, 0xC0, 0x3F, 0xC0,
  0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0xFF, 0x00, 0xF0, 0x3F,
  0xC0, 0x1C, 0x0F, 0xF0, 0x07, 0x83, 0xFC, 0x00, 0xE0, 0xFF, 0x00, 0x3C,
  0x3F, 0xC0, 0x0F, 0x0F, 0xF0, 0x01, 0xE3, 0xFC, 0x00, 0x78, 0xFF, 0x00,
  0x0E, 0x3F, 0xC0, 0x03, 0xCF, 0xF0, 0x00, 0x73, 0xFC, 0x00, 0x1E, 0x7F,
  0x00, 0x07, 0x9F, 0xC0, 0x00, 0xF7, 0xF0, 0x00, 0x3D, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xE1, 0xFF, 0x8F, 0x00, 0x7E, 0x78,
  0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00,
  0x7C, 0xF0, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x00, 0x7E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0xF3, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0,
  0x78, 0x0F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x00, 0x18, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x0F, 0x1F, 0x00, 0x09, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE8, 0x00, 0x3E, 0x78, 0x07,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xDE, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0xF3, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0x03,
  0x80, 0x0E, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC0, 0x3C,
  0x00, 0xE1, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x03, 0xC0,
  0x1E, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x78, 0x07, 0x80, 0x1C, 0x01,
  0xC0, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x3C,
  0x0E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x07,
  0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x70,
  0x38, 0x00, 0x1C, 0x1C, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x03, 0x87,
  0x80, 0x01, 0xE1, 0xC0, 0x0E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x3C, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x03, 0xCF, 0x00,
  0x00, 0xF3, 0x80, 0x07, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x1C, 0xF0, 0x00,
  0x0F, 0x38, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xE0, 0x01, 0xCE, 0x00, 0x00,
  0x77, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0E,
  0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xDE,
  0x00, 0x03, 0xBC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xE0, 0x00,
  0x71, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0x38, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xBC, 0x00, 0x07,
  0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x1C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0x80,
  0x01, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7B,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xE0, 0x3C, 0x08, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xC0, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x70, 0x01, 0xF7, 0x00, 0x1F, 0x78, 0x03, 0x77, 0x80, 0x37,
  0x3C, 0x06, 0x73, 0xF1, 0xE7, 0x1F, 0xFC, 0x70, 0xFF, 0x87, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x3F, 0x80, 0xE3, 0xFF, 0x83,
  0x9F, 0xFF, 0x0E, 0x70, 0x3E, 0x3B, 0x80, 0x78, 0xEC, 0x00, 0xF3, 0xE0,
  0x03, 0xCF, 0x80, 0x07, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0xCE, 0xC0, 0x1E, 0x3B, 0x80,
  0xF8, 0xE7, 0xFF, 0xC3, 0x8F, 0xFE, 0x0E, 0x1F, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x06, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x7F, 0x07, 0x07, 0xFF, 0x1C, 0x3F,
  0xFE, 0x71, 0xF0, 0x39, 0xC7, 0x80, 0x77, 0x3C, 0x00, 0xDC, 0xF0, 0x01,
  0xF7, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x7C, 0xF0, 0x03, 0xF3, 0xE0, 0x0D, 0xC7, 0xC0, 0xE7,
  0x0F, 0xFF, 0x9C, 0x3F, 0xFC, 0x70, 0x3F, 0xC1, 0xC0, 0x1C, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x81, 0xE0, 0x1E,
  0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x02, 0x1F,
  0x00, 0x70, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xC1, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x1C, 0x1F, 0xFC,
  0x70, 0xFF, 0xF9, 0xC7, 0xC0, 0xE7, 0x1E, 0x01, 0xDC, 0xF0, 0x03, 0x73,
  0xC0, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x0D, 0xCF, 0x80, 0x77, 0x1F,
  0x03, 0x9C, 0x3F, 0xFE, 0x70, 0xFF, 0xF1, 0xC0, 0xFF, 0x07, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x18, 0x00, 0x7C, 0x7C, 0x0F, 0xE1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xE0, 0xE3, 0xFF,
  0x0E, 0x7F, 0xF8, 0xEF, 0x07, 0xCE, 0xE0, 0x3C, 0xFC, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x07, 0x07, 0xC3,
  0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF4, 0xF3, 0xF9, 0xF8, 0xF8, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x1E, 0xE0, 0x03, 0x9C, 0x00, 0xF3, 0x80, 0x3C, 0x70, 0x07, 0x8E, 0x01,
  0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x1E,
  0x03, 0x87, 0x80, 0x70, 0xF0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x39, 0xF0,
  0x07, 0x7F, 0x00, 0xEE, 0xE0, 0x1F, 0x9E, 0x03, 0xE3, 0xC0, 0x7C, 0x38,
  0x0F, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x1E,
  0x1C, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x0F,
  0x38, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC1, 0xFC, 0x03,
  0xF8, 0x30, 0xFF, 0xC1, 0xFF, 0x8E, 0x7F, 0xF0, 0xFF, 0xF3, 0xB8, 0x3E,
  0x78, 0x7C, 0xEC, 0x07, 0x98, 0x0F, 0xBE, 0x00, 0xFC, 0x01, 0xEF, 0x80,
  0x3F, 0x00, 0x3B, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x0F,
  0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78,
  0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0xE0, 0x01,
  0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0x80,
  0x07, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x03,
  0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x80,
  0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0xFE, 0x0C, 0x3F, 0xF8, 0xE7,
  0xFF, 0x8E, 0xF0, 0x7C, 0xEE, 0x03, 0xEF, 0xC0, 0x1E, 0xF8, 0x01, 0xEF,
  0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x1E,
  0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x39, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7,
  0x00, 0x03, 0xDE, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0xC0,
  0x07, 0x07, 0x80, 0x3C, 0x1F, 0x01, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0xFE, 0x03, 0x0F, 0xFE, 0x0E,
  0x7F, 0xFC, 0x39, 0xC0, 0xF8, 0xEE, 0x01, 0xE3, 0xB0, 0x03, 0xCF, 0x80,
  0x0F, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x03,
  0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8,
  0x00, 0x7B, 0xE0, 0x03, 0xCF, 0xC0, 0x0F, 0x3B, 0x00, 0x78, 0xEF, 0x03,
  0xE3, 0x9F, 0xFF, 0x0E, 0x3F, 0xF8, 0x38, 0x7F, 0xC0, 0xE0, 0x38, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFC, 0x1C, 0x1F, 0xFC, 0x70, 0xFF,
  0xF9, 0xC7, 0xE0, 0xE7, 0x1E, 0x01, 0xDC, 0xF0, 0x03, 0x73, 0xC0, 0x07,
  0xDE, 0x00, 0x1F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00,
  0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x0D, 0xCF, 0x80, 0x77, 0x1F, 0x03, 0x9C,
  0x3F, 0xFE, 0x70, 0xFF, 0xF1, 0xC0, 0xFF, 0x07, 0x00, 0x60, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF, 0xBE, 0xE0,
  0x76, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0xF8, 0x0E,
  0x78, 0x01, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x7A, 0x00, 0x1E, 0xF0, 0x1F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xF0, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x37, 0x3E, 0x07, 0x73, 0xFF, 0xE7, 0x1F,
  0xFC, 0x70, 0xFF, 0x83, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xE3,
  0x80, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0,
  0x0E, 0x07, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0xC7, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xEF,
  0x00, 0x1F, 0x00, 0x0E, 0x70, 0x01, 0xF8, 0x01, 0xE7, 0x00, 0x1F, 0x80,
  0x1E, 0x78, 0x01, 0xF8, 0x01, 0xC7, 0x80, 0x3B, 0x80, 0x1C, 0x78, 0x03,
  0xBC, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x3C, 0x38, 0x03, 0x9C, 0x03, 0xC3,
  0xC0, 0x79, 0xC0, 0x38, 0x3C, 0x07, 0x1C, 0x03, 0x81, 0xC0, 0x71, 0xE0,
  0x38, 0x1C, 0x07, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0xE0, 0x70, 0x1E, 0x0F,
  0x0E, 0x07, 0x01, 0xE0, 0xE0, 0xE0, 0x70, 0x0E, 0x0E, 0x0F, 0x0F, 0x00,
  0xE0, 0xE0, 0x70, 0xF0, 0x0F, 0x0E, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x70,
  0xE0, 0x0F, 0x1C, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x79, 0xE0, 0x07, 0x1C,
  0x03, 0x9C, 0x00, 0x79, 0xC0, 0x39, 0xC0, 0x07, 0xBC, 0x03, 0x9C, 0x00,
  0x3B, 0x80, 0x39, 0xC0, 0x03, 0xB8, 0x03, 0xFC, 0x00, 0x3B, 0x80, 0x1F,
  0x80, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0x8E, 0x00, 0x3C,
  0x78, 0x03, 0xC1, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x70, 0x0F, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00,
  0x3C, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xEE, 0x00, 0x0F, 0x78, 0x00, 0x71, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x38,
  0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x70,
  0x07, 0x87, 0x80, 0x3C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1D,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0x9C,
  0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00,
  0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x78,
  0x1E, 0x01, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0xF0, 0x0F,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x87,
  0x00, 0x1E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00,
  0x0F, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x8F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0xBF, 0xC0, 0x1F,
  0xFE, 0x80, 0x07, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Light67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 48, 14, 5, -48 },
  { 31, 14, 17, 23, 4, -48 },
  { 61, 27, 48, 30, 1, -48 },
  { 223, 23, 55, 28, 2, -51 },
  { 382, 36, 50, 41, 3, -49 },
  { 607, 27, 50, 29, 2, -49 },
  { 776, 4, 17, 12, 4, -48 },
  { 785, 13, 59, 19, 3, -48 },
  { 881, 13, 59, 19, 2, -48 },
  { 977, 19, 20, 25, 3, -51 },
  { 1025, 24, 31, 28, 2, -39 },
  { 1118, 8, 16, 13, 2, -7 },
  { 1134, 14, 4, 18, 2, -20 },
  { 1141, 6, 6, 14, 4, -6 },
  { 1146, 21, 48, 23, 1, -48 },
  { 1272, 22, 50, 28, 3, -49 },
  { 1410, 13, 48, 28, 5, -48 },
  { 1488, 22, 49, 28, 2, -49 },
  { 1623, 22, 50, 28, 2, -49 },
  { 1761, 26, 48, 28, 1, -48 },
  { 1917, 22, 49, 28, 3, -48 },
  { 2052, 22, 49, 28, 3, -48 },
  { 2187, 22, 48, 28, 3, -48 },
  { 2319, 23, 50, 28, 2, -49 },
  { 2463, 21, 50, 28, 3, -49 },
  { 2595, 6, 36, 14, 4, -36 },
  { 2622, 8, 45, 14, 2, -36 },
  { 2667, 24, 29, 28, 2, -38 },
  { 2754, 24, 17, 28, 2, -32 },
  { 2805, 24, 29, 28, 2, -38 },
  { 2892, 17, 49, 20, 1, -49 },
  { 2997, 36, 54, 42, 3, -48 },
  { 3240, 28, 48, 28, 0, -48 },
  { 3408, 23, 48, 30, 5, -48 },
  { 3546, 24, 50, 29, 3, -49 },
  { 3696, 25, 48, 33, 5, -48 },
  { 3846, 18, 48, 26, 5, -48 },
  { 3954, 18, 48, 25, 5, -48 },
  { 4062, 29, 50, 36, 3, -49 },
  { 4244, 24, 48, 34, 5, -48 },
  { 4388, 12, 48, 17, 2, -48 },
  { 4460, 12, 60, 14, -3, -48 },
  { 4550, 23, 48, 28, 5, -48 },
  { 4688, 18, 48, 24, 5, -48 },
  { 4796, 36, 48, 46, 5, -48 },
  { 5012, 26, 48, 36, 5, -48 },
  { 5168, 29, 50, 36, 3, -49 },
  { 5350, 21, 48, 28, 5, -48 },
  { 5476, 29, 60, 36, 3, -49 },
  { 5694, 23, 48, 29, 5, -48 },
  { 5832, 21, 50, 27, 3, -49 },
  { 5964, 22, 48, 24, 1, -48 },
  { 6096, 24, 49, 34, 5, -48 },
  { 6243, 27, 48, 27, 0, -48 },
  { 6405, 46, 48, 46, 0, -48 },
  { 6681, 23, 48, 25, 1, -48 },
  { 6819, 24, 48, 24, 0, -48 },
  { 6963, 20, 48, 23, 2, -48 },
  { 7083, 13, 59, 21, 5, -48 },
  { 7179, 21, 48, 23, 1, -48 },
  { 7305, 13, 59, 21, 2, -48 },
  { 7401, 26, 24, 28, 1, -48 },
  { 7479, 28, 3, 28, 0, 6 },
  { 7490, 11, 10, 16, 3, -51 },
  { 7504, 20, 37, 26, 2, -36 },
  { 7597, 22, 52, 30, 5, -51 },
  { 7740, 18, 37, 22, 3, -36 },
  { 7824, 22, 52, 30, 3, -51 },
  { 7967, 21, 37, 27, 3, -36 },
  { 8065, 16, 51, 16, 1, -51 },
  { 8167, 22, 52, 30, 3, -36 },
  { 8310, 20, 51, 29, 5, -51 },
  { 8438, 5, 49, 13, 4, -49 },
  { 8469, 9, 65, 13, 0, -49 },
  { 8543, 19, 51, 24, 5, -51 },
  { 8665, 3, 51, 13, 5, -51 },
  { 8685, 34, 36, 43, 5, -36 },
  { 8838, 20, 36, 29, 5, -36 },
  { 8928, 22, 37, 28, 3, -36 },
  { 9030, 22, 52, 30, 5, -36 },
  { 9173, 22, 52, 30, 3, -36 },
  { 9316, 13, 36, 19, 5, -36 },
  { 9375, 18, 37, 22, 2, -36 },
  { 9459, 14, 45, 16, 1, -44 },
  { 9538, 20, 37, 29, 4, -36 },
  { 9631, 22, 36, 22, 0, -36 },
  { 9730, 36, 36, 37, 1, -36 },
  { 9892, 21, 36, 23, 1, -36 },
  { 9987, 22, 52, 23, 1, -36 },
  { 10130, 15, 36, 19, 2, -36 },
  { 10198, 18, 59, 24, 3, -48 },
  { 10331, 4, 67, 26, 11, -51 },
  { 10365, 18, 59, 24, 3, -48 },
  { 10498, 24, 7, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Light67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT67PT7B_H_
