#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x00, 0xEF, 0xFE, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x20, 0x60, 0x18, 0x30,
  0x06, 0x0C, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC, 0x18, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xC1, 0x80, 0x20, 0x60,
  0x18, 0x38, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x7F, 0x83, 0xFF, 0xCF, 0x63, 0x98, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x86,
  0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x1C, 0x60, 0x1C, 0xC0, 0x1D, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x1B, 0xC0, 0x33, 0xC0, 0x63, 0x80,
  0xC3, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x78, 0x31,
  0xD8, 0x67, 0x3F, 0xFC, 0x3F, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x73, 0x00,
  0xC0, 0x63, 0x81, 0x80, 0x61, 0x81, 0x80, 0xC1, 0x81, 0x80, 0xC1, 0x83,
  0x00, 0xC1, 0x83, 0x00, 0xC1, 0x83, 0x00, 0xC1, 0x86, 0x00, 0xC1, 0xC6,
  0x00, 0xC1, 0x86, 0x00, 0xC1, 0x8C, 0x00, 0xC1, 0x8C, 0x30, 0xC1, 0x8C,
  0xFC, 0xC1, 0x98, 0xCE, 0x61, 0x99, 0x86, 0x63, 0x19, 0x86, 0x77, 0x31,
  0x87, 0x3E, 0x31, 0x83, 0x0C, 0x33, 0x03, 0x00, 0x63, 0x03, 0x00, 0x63,
  0x03, 0x00, 0x63, 0x03, 0x00, 0xC3, 0x03, 0x00, 0xC3, 0x03, 0x00, 0xC3,
  0x83, 0x01, 0x81, 0x83, 0x01, 0x81, 0x86, 0x01, 0x81, 0x86, 0x03, 0x01,
  0xC6, 0x03, 0x00, 0xFC, 0x07, 0x00, 0x7C, 0x01, 0x00, 0x01, 0xF8, 0x00,
  0xEE, 0x00, 0x71, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60,
  0x03, 0xB8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x03,
  0x9C, 0x18, 0xC3, 0x06, 0x70, 0xE1, 0x98, 0x18, 0x66, 0x03, 0x3B, 0x80,
  0xEE, 0xE0, 0x1B, 0x38, 0x07, 0xCE, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x1F,
  0x1C, 0x06, 0xC3, 0x87, 0xB8, 0xFF, 0xC7, 0x1F, 0xC1, 0xC0, 0xFF, 0xED,
  0xB6, 0xDB, 0x00, 0x03, 0x83, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0xC0,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07,
  0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07,
  0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x60, 0xC0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0E, 0x63, 0x7F, 0xFC,
  0xFF, 0x00, 0xE0, 0x0D, 0x80, 0xCE, 0x0E, 0x30, 0xE1, 0xC2, 0x04, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x39, 0x8C, 0xE7, 0x31, 0x8C, 0xE6,
  0x30, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xC3, 0x83, 0x03, 0x8E,
  0x03, 0x1C, 0x06, 0x30, 0x0E, 0x60, 0x1D, 0xC0, 0x1B, 0x80, 0x37, 0x00,
  0x6E, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x37, 0x00, 0x6E, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0xE0,
  0x0C, 0xC0, 0x39, 0x80, 0x73, 0x80, 0xC7, 0x01, 0x87, 0x07, 0x0F, 0x1C,
  0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0x83, 0xC3, 0xE3, 0xB3, 0x9B, 0x8F, 0x86,
  0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x06, 0x00, 0xFF, 0x87, 0xFF, 0x38, 0x1C, 0x40,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x02, 0x00, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0x80, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xEC, 0x07, 0xBF, 0xFC, 0x7F, 0xC0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x01, 0xC6, 0x00,
  0xC3, 0x00, 0xE1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x00, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x7F, 0xF8, 0xFF, 0xF1,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x3F, 0xFC,
  0x20, 0x3C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x98, 0x0E, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0xF0,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x3E, 0x1D, 0xFE, 0x3F, 0x1E,
  0x7C, 0x0C, 0xF0, 0x1D, 0xC0, 0x1B, 0x80, 0x37, 0x00, 0x6E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x80,
  0xE3, 0x01, 0x87, 0x07, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x3F, 0xC0, 0xFF, 0xC3, 0x81, 0xC7, 0x01, 0xCC, 0x03, 0xB8, 0x03, 0x70,
  0x06, 0xE0, 0x0D, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC3, 0x03, 0x87, 0x0E,
  0x07, 0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0xE1, 0xC3, 0x81, 0xC6,
  0x01, 0xDC, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xCC, 0x03, 0x9C, 0x0E, 0x1F, 0xF8, 0x1F, 0xE0,
  0x03, 0x00, 0x7F, 0x03, 0xFE, 0x1C, 0x1C, 0x70, 0x39, 0x80, 0x6E, 0x01,
  0xB8, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0xC0, 0xB3, 0xCE, 0xCF, 0xF3, 0x0F,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x73, 0x9E, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x99, 0xCE, 0x63, 0x19,
  0x8C, 0x60, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x08, 0x0F,
  0xF3, 0xFF, 0x60, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xC0, 0x03, 0x80, 0x70, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x1C,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x3F, 0x86, 0x60, 0x7B, 0x87, 0x60, 0xE1, 0x83, 0x60, 0xC1, 0x83, 0x60,
  0xC1, 0x83, 0x61, 0xC1, 0x83, 0xE1, 0x83, 0x83, 0xC1, 0x83, 0x83, 0xC1,
  0x83, 0x83, 0xC1, 0x83, 0x83, 0xC1, 0x83, 0x83, 0xC1, 0x83, 0x03, 0xE1,
  0x83, 0x03, 0xE1, 0x83, 0x86, 0x60, 0xC7, 0x86, 0x60, 0xC4, 0x8E, 0x60,
  0x7C, 0xFC, 0x60, 0x38, 0x78, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x81, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x0E,
  0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x60, 0x70, 0x0C, 0x0E,
  0x03, 0x80, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x30, 0x06,
  0x0E, 0x00, 0xC1, 0xC0, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x31, 0xC0, 0x06,
  0x38, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C,
  0xE0, 0x1C, 0xE0, 0x38, 0xFF, 0xF0, 0xFF, 0xF0, 0xE0, 0x78, 0xE0, 0x1C,
  0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x7C,
  0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x03,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x01, 0x07, 0xFF, 0x01, 0xFE, 0xFF, 0xC0,
  0x7F, 0xF8, 0x38, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x0D, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0xC7,
  0x07, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xDF, 0xFE, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFE,
  0xFF, 0xF7, 0xFF, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x70, 0x0E,
  0x0E, 0x00, 0x21, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07,
  0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0F, 0x80, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xC0, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x8E, 0xFE, 0xFC, 0xE0, 0x0E, 0xE0,
  0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x60, 0xE0,
  0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE3, 0x80, 0xE3, 0x80, 0xE7, 0x00, 0xE6,
  0x00, 0xEE, 0x00, 0xEF, 0x00, 0xFB, 0x00, 0xF3, 0x80, 0xF1, 0x80, 0xE1,
  0xC0, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xDF, 0xB0, 0x00, 0x6F, 0xD8,
  0x00, 0x37, 0xEC, 0x00, 0x3B, 0xF3, 0x00, 0x19, 0xF9, 0x80, 0x0C, 0xFC,
  0xC0, 0x0E, 0x7E, 0x70, 0x06, 0x3F, 0x18, 0x03, 0x1F, 0x8C, 0x01, 0x8F,
  0xC7, 0x01, 0xC7, 0xE1, 0x80, 0xC3, 0xF0, 0xC0, 0x61, 0xF8, 0x60, 0x70,
  0xFC, 0x38, 0x30, 0x7E, 0x0C, 0x18, 0x3F, 0x06, 0x1C, 0x1F, 0x83, 0x8C,
  0x0F, 0xC0, 0xC6, 0x07, 0xE0, 0x63, 0x03, 0xF0, 0x3B, 0x81, 0xF8, 0x0D,
  0x80, 0xFC, 0x06, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xE0, 0x1F, 0x80,
  0x70, 0x0F, 0xC0, 0x38, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7E, 0xC0, 0x1F, 0xB8, 0x07, 0xE6,
  0x01, 0xF9, 0xC0, 0x7E, 0x30, 0x1F, 0x8C, 0x07, 0xE3, 0x81, 0xF8, 0x60,
  0x7E, 0x1C, 0x1F, 0x83, 0x07, 0xE0, 0xE1, 0xF8, 0x18, 0x7E, 0x07, 0x1F,
  0x81, 0xC7, 0xE0, 0x31, 0xF8, 0x0E, 0x7E, 0x01, 0x9F, 0x80, 0x77, 0xE0,
  0x0D, 0xF8, 0x03, 0xFE, 0x00, 0xEF, 0x80, 0x1B, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x01, 0xE0, 0x70, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00,
  0x0C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x06, 0x60,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0xCE, 0x0F, 0xB8, 0x0E, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xB8, 0x0E, 0xE1, 0xF3, 0xFF, 0x8F,
  0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x20, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xE0, 0x70, 0x1C, 0x03,
  0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0x60, 0x00, 0xE6, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0,
  0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0xC1, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xE0,
  0xF8, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0,
  0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x38, 0xE0, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xE1, 0xC0, 0xE1, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x38, 0xE0,
  0x18, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0x01,
  0x80, 0x3F, 0xE3, 0xFF, 0xDE, 0x02, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xEC, 0x07, 0x3F, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x70, 0x01, 0x98, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0xE1, 0xE0, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0xE0, 0x01, 0xF8,
  0x00, 0x76, 0x00, 0x1D, 0x80, 0x06, 0x70, 0x01, 0x9C, 0x00, 0xE3, 0x00,
  0x38, 0xC0, 0x0C, 0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x60, 0x18,
  0x18, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x30, 0x0C, 0x0C, 0x03,
  0x83, 0x00, 0xE1, 0xC0, 0x18, 0x60, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x73,
  0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x03, 0x80,
  0x0E, 0xC0, 0x07, 0x00, 0x19, 0x80, 0x0E, 0x00, 0x73, 0x00, 0x3C, 0x00,
  0xE7, 0x00, 0x78, 0x01, 0xCE, 0x00, 0xD8, 0x03, 0x0C, 0x01, 0xB0, 0x06,
  0x18, 0x03, 0x60, 0x1C, 0x38, 0x0E, 0xC0, 0x38, 0x70, 0x19, 0x80, 0x70,
  0xE0, 0x33, 0x80, 0xC0, 0xC0, 0x63, 0x01, 0x81, 0x80, 0xC6, 0x07, 0x03,
  0x83, 0x8C, 0x0E, 0x07, 0x06, 0x18, 0x18, 0x0E, 0x0C, 0x38, 0x30, 0x0C,
  0x18, 0x30, 0x60, 0x18, 0x30, 0x61, 0xC0, 0x38, 0xE0, 0xC3, 0x80, 0x71,
  0xC1, 0x86, 0x00, 0x63, 0x03, 0x8C, 0x00, 0xC6, 0x03, 0x38, 0x01, 0x8C,
  0x06, 0x70, 0x03, 0xB8, 0x0C, 0xE0, 0x07, 0x70, 0x19, 0x80, 0x06, 0xC0,
  0x3B, 0x00, 0x0D, 0x80, 0x36, 0x00, 0x1B, 0x00, 0x7C, 0x00, 0x36, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x70, 0x07, 0x38, 0x06, 0x38, 0x0E, 0x18, 0x0E, 0x1C, 0x0C, 0x1C,
  0x1C, 0x0C, 0x18, 0x0E, 0x18, 0x06, 0x38, 0x06, 0x30, 0x07, 0x70, 0x03,
  0x60, 0x03, 0x60, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xE0, 0x03, 0x60, 0x07, 0x70, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x38, 0x0C,
  0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x70,
  0x06, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x70,
  0x0E, 0x30, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x1C,
  0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFB, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07,
  0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00,
  0x37, 0x00, 0x31, 0x80, 0x18, 0xE0, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x39, 0x80, 0x0D, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xE0, 0xC1, 0xC1, 0xC1,
  0x80, 0x1F, 0xC3, 0xFF, 0x08, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFE, 0x3F, 0xF7, 0x83, 0xB8, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0xF0,
  0x6D, 0xFE, 0x67, 0xE3, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x1F,
  0x86, 0x7F, 0x8D, 0x83, 0x9A, 0x03, 0xBC, 0x07, 0x70, 0x06, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xDE, 0x03,
  0xB4, 0x07, 0x6C, 0x1C, 0xCF, 0xF1, 0x8F, 0xC0, 0x0F, 0xF1, 0xFF, 0x3C,
  0x13, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x81, 0x1F, 0xF0, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x3F, 0x18, 0xFF, 0x33, 0x83, 0x6E, 0x02, 0xDC, 0x07,
  0xB0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x76, 0x00, 0xEE, 0x03, 0xDC, 0x05, 0x9C, 0x1B, 0x1F, 0xE6, 0x1F, 0x8C,
  0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x0C, 0x0E, 0x70, 0x19, 0x80, 0x66, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x21, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7E, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xCF, 0xFC,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0xC6, 0x3F,
  0xCC, 0xE0, 0xDB, 0x80, 0xB7, 0x01, 0xEC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0xF7, 0x01,
  0x67, 0x06, 0xC7, 0xFB, 0x87, 0xE7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x20, 0x1C, 0x79, 0xF8, 0xFF,
  0xE0, 0x7E, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x31, 0xF9, 0x9F, 0xED, 0x87,
  0xE8, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x18, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x1B, 0xEF, 0x38, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x0F, 0x80, 0xEC, 0x0E, 0x60, 0x63, 0x07, 0x18, 0x30, 0xC3,
  0x86, 0x38, 0x31, 0x81, 0x9C, 0x0C, 0xE0, 0x6F, 0x83, 0xCC, 0x1E, 0x70,
  0xE1, 0x86, 0x0E, 0x30, 0x71, 0x81, 0x8C, 0x0E, 0x60, 0x33, 0x01, 0xD8,
  0x0E, 0xC0, 0x36, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC7, 0xC1, 0xF9, 0x9F, 0xC7, 0xFB, 0x61, 0xD8, 0x76, 0x81,
  0xA0, 0x7E, 0x03, 0xC0, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x01, 0xF0, 0x1C,
  0x03, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC7,
  0xE6, 0x7F, 0xB6, 0x0F, 0xA0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x0F, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE7, 0x00, 0xCC,
  0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D,
  0x80, 0x33, 0x80, 0x63, 0x01, 0xC7, 0x07, 0x07, 0xFC, 0x07, 0xF0, 0xC7,
  0xE1, 0x9F, 0xE3, 0x60, 0xE6, 0x80, 0xEF, 0x01, 0xDC, 0x01, 0xB8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x37, 0x80,
  0xED, 0x01, 0xDB, 0x07, 0x33, 0xFC, 0x63, 0xF0, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x00, 0x0F, 0xC6, 0x3F, 0xCC, 0xE0, 0xDB, 0x80,
  0xB7, 0x01, 0xEC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0xF7, 0x01, 0x67, 0x06, 0xC7, 0xFB,
  0x87, 0xE7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0xC7,
  0xE7, 0xF7, 0x1B, 0x0D, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x3F, 0xCF, 0xFF, 0x81, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x0F, 0x03, 0xBF, 0xF7, 0xFC, 0x18,
  0x0C, 0x06, 0x07, 0x03, 0x81, 0xC1, 0xFF, 0xFF, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xF8, 0xFC, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xB8, 0x6D, 0xFF, 0x67, 0xF3,
  0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE7, 0x01, 0xC6, 0x03, 0x0C,
  0x06, 0x18, 0x1C, 0x38, 0x38, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0xC7,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x1D, 0x80, 0x1B, 0x00,
  0x36, 0x00, 0x6C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x1C, 0x03,
  0xB0, 0x0E, 0x01, 0x98, 0x07, 0x80, 0xCE, 0x03, 0xC0, 0x67, 0x03, 0x60,
  0x71, 0x81, 0xB0, 0x38, 0xC0, 0xD8, 0x18, 0x60, 0x6E, 0x0C, 0x38, 0x33,
  0x06, 0x0C, 0x31, 0x87, 0x06, 0x18, 0xC3, 0x03, 0x0C, 0x61, 0x81, 0x86,
  0x38, 0xC0, 0xE7, 0x0C, 0x60, 0x33, 0x06, 0x70, 0x19, 0x83, 0x30, 0x0C,
  0xC1, 0x98, 0x07, 0x60, 0xEC, 0x03, 0xF0, 0x36, 0x00, 0xF0, 0x1E, 0x00,
  0x78, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0xE0,
  0xE0, 0x1D, 0x80, 0xE7, 0x03, 0x0C, 0x1C, 0x38, 0x70, 0x61, 0x81, 0x8E,
  0x03, 0x30, 0x0D, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0xD8, 0x03, 0x30, 0x1C, 0xC0, 0x63, 0x83, 0x86, 0x0C, 0x1C, 0x70,
  0x31, 0x80, 0xEE, 0x01, 0xB8, 0x07, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xF8,
  0x06, 0x60, 0x19, 0x80, 0xE7, 0x03, 0x8C, 0x0C, 0x30, 0x30, 0xC1, 0xC3,
  0x86, 0x06, 0x18, 0x18, 0x60, 0x63, 0x81, 0xCC, 0x03, 0x30, 0x0C, 0xC0,
  0x37, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0xB8, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x07, 0x80, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0xF8, 0x0E, 0x00, 0xFC,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0xF0, 0x07, 0x03, 0xE0,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x0F,
  0xC0, 0xF0, 0x00, 0x3F, 0x01, 0x7F, 0xC1, 0xC1, 0xFF, 0x80, 0x7E,
};

const GFXglyph NotoSans_ExtraCondensed_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 32, 10, 3, -32 },
  { 17, 9, 11, 15, 3, -32 },
  { 30, 18, 32, 20, 1, -32 },
  { 102, 15, 37, 19, 2, -34 },
  { 172, 24, 33, 28, 2, -33 },
  { 271, 18, 33, 19, 1, -33 },
  { 346, 3, 11, 8, 3, -32 },
  { 351, 9, 39, 12, 2, -32 },
  { 395, 8, 39, 12, 2, -32 },
  { 434, 13, 13, 17, 2, -34 },
  { 456, 16, 21, 19, 1, -26 },
  { 498, 5, 11, 9, 2, -5 },
  { 505, 10, 2, 12, 1, -13 },
  { 508, 3, 4, 9, 3, -4 },
  { 510, 14, 32, 16, 1, -32 },
  { 566, 15, 33, 19, 2, -33 },
  { 628, 9, 32, 19, 3, -32 },
  { 664, 14, 33, 19, 2, -33 },
  { 722, 14, 33, 19, 2, -33 },
  { 780, 17, 32, 19, 1, -32 },
  { 848, 15, 32, 19, 2, -32 },
  { 908, 15, 33, 19, 2, -32 },
  { 970, 15, 32, 19, 2, -32 },
  { 1030, 15, 33, 19, 2, -33 },
  { 1092, 14, 33, 19, 2, -33 },
  { 1150, 3, 24, 9, 3, -24 },
  { 1159, 5, 30, 9, 2, -24 },
  { 1178, 16, 20, 19, 1, -26 },
  { 1218, 16, 12, 19, 1, -22 },
  { 1242, 16, 20, 19, 1, -26 },
  { 1282, 11, 33, 13, 1, -33 },
  { 1328, 24, 36, 28, 2, -32 },
  { 1436, 19, 32, 19, 0, -32 },
  { 1512, 16, 32, 20, 3, -32 },
  { 1576, 16, 33, 19, 2, -33 },
  { 1642, 17, 32, 22, 3, -32 },
  { 1710, 13, 32, 18, 3, -32 },
  { 1762, 13, 32, 16, 3, -32 },
  { 1814, 20, 33, 24, 2, -33 },
  { 1897, 17, 32, 23, 3, -32 },
  { 1965, 8, 32, 11, 2, -32 },
  { 1997, 8, 40, 9, -2, -32 },
  { 2037, 16, 32, 19, 3, -32 },
  { 2101, 12, 32, 16, 3, -32 },
  { 2149, 25, 32, 31, 3, -32 },
  { 2249, 18, 32, 24, 3, -32 },
  { 2321, 20, 33, 24, 2, -33 },
  { 2404, 14, 32, 19, 3, -32 },
  { 2460, 20, 41, 24, 2, -33 },
  { 2563, 16, 32, 19, 3, -32 },
  { 2627, 14, 33, 18, 2, -33 },
  { 2685, 16, 32, 16, 0, -32 },
  { 2749, 17, 32, 23, 3, -32 },
  { 2817, 18, 32, 18, 0, -32 },
  { 2889, 31, 32, 31, 0, -32 },
  { 3013, 16, 32, 16, 0, -32 },
  { 3077, 16, 32, 16, 0, -32 },
  { 3141, 13, 32, 15, 1, -32 },
  { 3193, 8, 39, 14, 4, -32 },
  { 3232, 14, 32, 16, 1, -32 },
  { 3288, 8, 39, 14, 2, -32 },
  { 3327, 17, 16, 19, 1, -32 },
  { 3361, 19, 2, 19, 0, 4 },
  { 3366, 7, 7, 11, 2, -34 },
  { 3373, 13, 24, 18, 2, -24 },
  { 3412, 15, 34, 20, 3, -34 },
  { 3476, 12, 24, 15, 2, -24 },
  { 3512, 15, 34, 20, 2, -34 },
  { 3576, 14, 24, 18, 2, -24 },
  { 3618, 12, 34, 10, 0, -34 },
  { 3669, 15, 35, 20, 2, -24 },
  { 3735, 13, 34, 19, 3, -34 },
  { 3791, 3, 33, 9, 3, -33 },
  { 3804, 6, 44, 9, 0, -33 },
  { 3837, 13, 34, 16, 3, -34 },
  { 3893, 2, 34, 9, 3, -34 },
  { 3902, 23, 24, 29, 3, -24 },
  { 3971, 13, 24, 19, 3, -24 },
  { 4010, 15, 24, 19, 2, -24 },
  { 4055, 15, 35, 20, 3, -24 },
  { 4121, 15, 35, 20, 2, -24 },
  { 4187, 9, 24, 13, 3, -24 },
  { 4214, 11, 24, 15, 2, -24 },
  { 4247, 9, 30, 11, 1, -30 },
  { 4281, 13, 24, 19, 3, -24 },
  { 4320, 15, 24, 15, 0, -24 },
  { 4365, 25, 24, 25, 0, -24 },
  { 4440, 14, 24, 15, 1, -24 },
  { 4482, 14, 35, 15, 1, -24 },
  { 4544, 11, 24, 13, 1, -24 },
  { 4577, 12, 39, 16, 2, -32 },
  { 4636, 2, 45, 18, 8, -34 },
  { 4648, 12, 39, 16, 2, -32 },
  { 4707, 16, 4, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Light45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT45PT7B_H_
