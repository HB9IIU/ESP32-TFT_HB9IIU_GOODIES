#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light46pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xB8, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0x03, 0x03, 0x00,
  0x60, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC1, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06,
  0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x81, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3F, 0x01,
  0xFF, 0xC7, 0xEF, 0x9C, 0xC1, 0x71, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C,
  0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x38, 0xC0, 0x39, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x37, 0x80, 0x63, 0x80, 0xC3, 0x81,
  0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0xF0, 0x61,
  0xB8, 0xCF, 0x7F, 0xFC, 0x3F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x60, 0x1F, 0x80, 0x60, 0x18, 0xE0,
  0x30, 0x0C, 0x30, 0x18, 0x0E, 0x18, 0x18, 0x06, 0x0C, 0x0C, 0x03, 0x07,
  0x06, 0x01, 0x81, 0x86, 0x00, 0xC0, 0xC3, 0x00, 0x60, 0x61, 0x80, 0x30,
  0x31, 0x80, 0x18, 0x18, 0xC0, 0x0C, 0x0C, 0x60, 0x06, 0x0E, 0x63, 0xE3,
  0x06, 0x33, 0xF9, 0xC3, 0x19, 0x8C, 0x61, 0x99, 0xC3, 0x31, 0xCC, 0xC1,
  0x8F, 0xCE, 0x60, 0xC3, 0xC6, 0x30, 0x60, 0x03, 0x18, 0x30, 0x03, 0x8C,
  0x18, 0x01, 0x86, 0x0C, 0x00, 0xC3, 0x07, 0x00, 0xE1, 0x83, 0x00, 0x60,
  0xC1, 0x80, 0x30, 0x60, 0xC0, 0x38, 0x30, 0x60, 0x18, 0x18, 0x30, 0x0C,
  0x0E, 0x18, 0x0E, 0x03, 0x18, 0x06, 0x01, 0xFC, 0x03, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x31, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x80,
  0x30, 0x70, 0x06, 0x0E, 0x00, 0xC1, 0xC0, 0x18, 0x38, 0x03, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x38, 0x00, 0xE6, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xB8, 0x00, 0xE3, 0x07, 0x18, 0x70, 0xE7,
  0x06, 0x1C, 0xC0, 0xE3, 0x18, 0x0C, 0x67, 0x01, 0xDC, 0xE0, 0x1F, 0x9C,
  0x01, 0xE3, 0x80, 0x3C, 0x30, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x3F, 0x0E,
  0x0E, 0x61, 0xFF, 0x8E, 0x0F, 0xE0, 0xE0, 0xFF, 0xFF, 0xFE, 0xDB, 0x60,
  0x03, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0xC0, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07,
  0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x0C, 0x21, 0xFD, 0x7D, 0xFF,
  0xC0, 0xE0, 0x0D, 0x80, 0x6C, 0x06, 0x30, 0x71, 0xC7, 0x07, 0x08, 0x20,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x39, 0xCC, 0xE7,
  0x39, 0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xFE, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0x71, 0xC1, 0xC1, 0xC3, 0x01, 0x8E, 0x03, 0x9C, 0x07, 0x30, 0x06, 0x60,
  0x0D, 0xC0, 0x1B, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0xC0, 0x73, 0x80,
  0xE3, 0x01, 0x87, 0x07, 0x07, 0x1C, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0x81,
  0xC1, 0xE1, 0xF3, 0xDB, 0xCF, 0xC6, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x1F, 0xC0, 0xFF, 0xE3, 0xC1, 0xE2, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xE3, 0xC1, 0xE6, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0xB0, 0x1E,
  0x7F, 0xF8, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x03, 0x38, 0x01, 0x9C, 0x01,
  0x8E, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x30, 0x70,
  0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0C, 0x07, 0x06, 0x03, 0x86, 0x01,
  0xC3, 0x00, 0xE3, 0x00, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x3F, 0xF8, 0xFF, 0xF1, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0D, 0xF8, 0x1F, 0xFC, 0x3C, 0xFC, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xD0, 0x07, 0x30,
  0x1E, 0x7F, 0xF8, 0x7F, 0xC0, 0x01, 0xF8, 0x0F, 0xF0, 0x3C, 0x10, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0xFE, 0x3B, 0xFE, 0x7C, 0x1C, 0xF0,
  0x1D, 0xE0, 0x1B, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0E, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0x67, 0x00, 0xC7,
  0x03, 0x8F, 0x0E, 0x0F, 0xF8, 0x0F, 0xE0, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x0F,
  0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xB8, 0x03,
  0xF0, 0x07, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x73, 0x80, 0xE3, 0x83, 0x83,
  0x8E, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0xC0, 0x39, 0xE0, 0xE1, 0xE3, 0x80,
  0xE6, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7E, 0x00, 0xEE, 0x03, 0x9E, 0x0F, 0x1F, 0xFC, 0x1F,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xE1, 0xC3, 0x81, 0xC6, 0x01, 0x9C, 0x03,
  0xB8, 0x07, 0x70, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0x70, 0x1E, 0xE0, 0x7C, 0xFF,
  0xB0, 0xFE, 0x60, 0x70, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x78, 0x3F,
  0xE0, 0x7F, 0x80, 0x6E, 0xFE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0xFF, 0xE0, 0x33, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0xCE, 0x73, 0x98, 0xCE, 0x63, 0x00,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x00, 0x7F, 0x1F, 0xFB, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x60, 0x00, 0x38,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x07, 0x81, 0x9C, 0x0F, 0xE0,
  0xCC, 0x0E, 0x30, 0x66, 0x0E, 0x18, 0x33, 0x06, 0x0C, 0x19, 0x83, 0x06,
  0x0E, 0xC3, 0x83, 0x07, 0xE1, 0xC1, 0x83, 0xF0, 0xC0, 0xC1, 0xF8, 0x60,
  0x60, 0xFC, 0x30, 0x30, 0x7E, 0x18, 0x18, 0x37, 0x0C, 0x1C, 0x1B, 0x86,
  0x0E, 0x0C, 0xC1, 0x85, 0x06, 0x60, 0xC2, 0x86, 0x30, 0x73, 0x67, 0x18,
  0x1F, 0x3F, 0x0E, 0x07, 0x07, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x30, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0xEE, 0x00, 0x19, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x80, 0x70, 0x70,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x1C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x30, 0x06, 0x06, 0x00, 0xC1, 0xC0, 0x1C, 0x38, 0x03, 0x86, 0x00, 0x30,
  0xC0, 0x06, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0x98, 0x00, 0x37,
  0x00, 0x07, 0xE0, 0x00, 0xE0, 0xFF, 0xC0, 0xFF, 0xF8, 0xE0, 0xFC, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0xF8, 0xFF,
  0xE0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0x01,
  0xFE, 0x01, 0xFF, 0xC1, 0xE0, 0xC1, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x04, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xF8, 0x38, 0x7E, 0x1C, 0x07, 0x8E, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0xE3, 0x83, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFE, 0xFF,
  0xF7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0xB8, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0x07, 0xC0, 0xE0, 0xF0, 0x02, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0x60,
  0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x73,
  0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x07, 0x80, 0x70, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x07, 0x07, 0x07, 0x0E, 0xFE, 0xFC, 0xE0, 0x07, 0xE0,
  0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0,
  0x60, 0xE0, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0xE3, 0x80, 0xE3, 0x80, 0xE7,
  0x00, 0xE6, 0x00, 0xEF, 0x00, 0xFF, 0x00, 0xFB, 0x80, 0xF3, 0x80, 0xF1,
  0xC0, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0,
  0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xDF, 0xE0, 0x00, 0x6F, 0xB0, 0x00, 0x37, 0xD8, 0x00, 0x3B, 0xEE, 0x00,
  0x19, 0xF3, 0x00, 0x0C, 0xF9, 0x80, 0x0E, 0x7C, 0xC0, 0x06, 0x3E, 0x70,
  0x03, 0x1F, 0x18, 0x03, 0x8F, 0x8C, 0x01, 0xC7, 0xC7, 0x00, 0xC3, 0xE1,
  0x80, 0x61, 0xF0, 0xC0, 0x70, 0xF8, 0x70, 0x30, 0x7C, 0x38, 0x18, 0x3E,
  0x0C, 0x1C, 0x1F, 0x06, 0x0C, 0x0F, 0x83, 0x86, 0x07, 0xC0, 0xC3, 0x03,
  0xE0, 0x63, 0x81, 0xF0, 0x39, 0x80, 0xF8, 0x0C, 0xC0, 0x7C, 0x06, 0xE0,
  0x3E, 0x03, 0x60, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1C, 0x01, 0x80, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0xC0, 0x0F, 0xB8, 0x03, 0xE6,
  0x00, 0xF9, 0xC0, 0x3E, 0x30, 0x0F, 0x8C, 0x03, 0xE3, 0x80, 0xF8, 0x60,
  0x3E, 0x1C, 0x0F, 0x83, 0x03, 0xE0, 0xE0, 0xF8, 0x18, 0x3E, 0x07, 0x0F,
  0x81, 0xC3, 0xE0, 0x30, 0xF8, 0x0E, 0x3E, 0x01, 0x8F, 0x80, 0x73, 0xE0,
  0x0C, 0xF8, 0x03, 0xBE, 0x00, 0xEF, 0x80, 0x1B, 0xE0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x0C, 0x30,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00,
  0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x0F,
  0x07, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC3, 0x8F,
  0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xB8, 0x07, 0x70,
  0x0E, 0xE0, 0x79, 0xFF, 0xE3, 0xFF, 0x87, 0xF0, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x0C,
  0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0x67,
  0x00, 0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x38,
  0x0F, 0x07, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0xE3, 0xF8, 0xE0, 0x3C,
  0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xE1, 0xC0, 0xE0, 0xC0, 0xE0, 0xE0,
  0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0x0F, 0xF8,
  0x3F, 0xF8, 0xF0, 0x73, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xD0, 0x07, 0x38, 0x1E, 0x7F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xD8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x73, 0xC0, 0x38, 0xF0, 0x78,
  0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x19, 0x80, 0x07,
  0x30, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x1C, 0x00, 0xE1, 0x80, 0x1C,
  0x38, 0x03, 0x87, 0x00, 0x60, 0xE0, 0x0C, 0x0C, 0x03, 0x81, 0x80, 0x70,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x0E, 0x01, 0xC1, 0x80,
  0x38, 0x30, 0x03, 0x0E, 0x00, 0x61, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00,
  0x38, 0xC0, 0x03, 0x38, 0x00, 0x67, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0xC0, 0x07, 0x00, 0x1D, 0x80, 0x0E, 0x00, 0x3B,
  0x80, 0x1E, 0x00, 0x77, 0x00, 0x3C, 0x00, 0xCE, 0x00, 0xF8, 0x01, 0x8C,
  0x01, 0xB0, 0x07, 0x18, 0x03, 0x60, 0x0E, 0x38, 0x06, 0xE0, 0x18, 0x70,
  0x0D, 0xC0, 0x30, 0xE0, 0x39, 0x80, 0xE0, 0xC0, 0x73, 0x01, 0xC1, 0x80,
  0xC6, 0x03, 0x83, 0x81, 0x8E, 0x06, 0x07, 0x03, 0x1C, 0x0C, 0x0E, 0x0E,
  0x18, 0x38, 0x0C, 0x1C, 0x30, 0x70, 0x18, 0x30, 0x60, 0xE0, 0x38, 0x60,
  0xE1, 0x80, 0x70, 0xC1, 0xC3, 0x00, 0xE3, 0x81, 0x8E, 0x00, 0xC7, 0x03,
  0x1C, 0x01, 0x8C, 0x06, 0x38, 0x03, 0x98, 0x0E, 0x60, 0x07, 0x30, 0x1C,
  0xC0, 0x06, 0xE0, 0x1B, 0x80, 0x0D, 0xC0, 0x37, 0x00, 0x1B, 0x00, 0x6C,
  0x00, 0x3E, 0x00, 0xD8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x07, 0x30, 0x07,
  0x38, 0x06, 0x18, 0x0E, 0x1C, 0x0E, 0x1C, 0x0C, 0x0C, 0x1C, 0x0E, 0x18,
  0x06, 0x18, 0x06, 0x38, 0x07, 0x30, 0x03, 0x70, 0x03, 0x70, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0x70,
  0x07, 0x70, 0x06, 0x30, 0x06, 0x38, 0x0E, 0x38, 0x0C, 0x18, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x07, 0x70, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x06, 0x70, 0x0E,
  0x30, 0x0C, 0x38, 0x0C, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x38,
  0x0C, 0x30, 0x0E, 0x30, 0x06, 0x70, 0x06, 0x60, 0x07, 0x60, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFD, 0xFF, 0xF0,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0x70, 0x01, 0xCC, 0x00,
  0x63, 0x80, 0x38, 0x60, 0x0C, 0x1C, 0x07, 0x03, 0x01, 0x80, 0xE0, 0xE0,
  0x18, 0x30, 0x06, 0x1C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xC1, 0xC1, 0xC1, 0xC1,
  0x80, 0x0F, 0xC3, 0xFF, 0x0E, 0x3C, 0x40, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x1F, 0xF3, 0xF9, 0xBC, 0x0D,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x3F, 0x83, 0x6F, 0xF3, 0x3F, 0x18, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x8F, 0x87, 0x3F, 0x8E, 0xE7, 0x9F, 0x03, 0xBC, 0x03, 0x78, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0x68, 0x0E, 0xD8, 0x39, 0x9F, 0xF3, 0x1F, 0xC0,
  0x03, 0xE0, 0xFF, 0x1E, 0x33, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x11, 0xFF,
  0x0F, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x1E, 0x18, 0xFF,
  0x33, 0xC7, 0x67, 0x02, 0xDC, 0x07, 0xB8, 0x07, 0x60, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0xDC, 0x03,
  0xB8, 0x0F, 0x38, 0x36, 0x3F, 0xCC, 0x3F, 0x18, 0x07, 0xC0, 0x7F, 0x81,
  0xC7, 0x0E, 0x0E, 0x70, 0x19, 0xC0, 0x76, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0xC7, 0xFF, 0x0F, 0xF8, 0x03, 0xF0, 0x7E, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x0F, 0xFC, 0xFF, 0xC0,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xC0, 0x3F,
  0xCC, 0xF1, 0xD9, 0xC0, 0xB7, 0x01, 0xEE, 0x01, 0xD8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x77, 0x00,
  0xEE, 0x02, 0xCE, 0x0D, 0x8F, 0xF3, 0x0F, 0xC6, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x40, 0x1C, 0xE0,
  0xF1, 0xFF, 0xC0, 0xFE, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x3C,
  0x3B, 0xFC, 0xEE, 0xFB, 0xE0, 0xED, 0x01, 0xBC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x5F, 0xF4, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x71, 0xC7, 0x08,
  0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x6B, 0xBE, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x6E, 0x07, 0x70, 0x73, 0x83, 0x1C, 0x38, 0xE1, 0x87, 0x1C, 0x39,
  0xC1, 0xCC, 0x0E, 0xE0, 0x77, 0x83, 0xEC, 0x1E, 0x70, 0xF1, 0x87, 0x0C,
  0x38, 0x71, 0xC1, 0x8E, 0x0E, 0x70, 0x33, 0x81, 0xDC, 0x0E, 0xE0, 0x37,
  0x01, 0xF8, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0xF0, 0xCF, 0xE1, 0xFC, 0xDC,
  0xF3, 0x1E, 0xD0, 0x36, 0x0E, 0xF0, 0x3C, 0x06, 0xE0, 0x3C, 0x06, 0xE0,
  0x1C, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0,
  0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0,
  0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0,
  0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0,
  0x18, 0x07, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0x03, 0xE3, 0x3F, 0xCC,
  0xC7, 0xB6, 0x0E, 0xD0, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1C, 0x07, 0xC0, 0x3F, 0xE0, 0xF1, 0xE1, 0xC0, 0xE7,
  0x00, 0xCE, 0x01, 0xD8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x77, 0x00, 0xC6, 0x03, 0x8E, 0x0E, 0x0F,
  0xFC, 0x0F, 0xE0, 0x03, 0xE1, 0x8F, 0xE3, 0x31, 0xE6, 0xC0, 0xED, 0x01,
  0xDE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xDE, 0x03, 0xBF, 0x0E, 0x77, 0xFC,
  0xE7, 0xF1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xCC, 0xF9, 0xD9, 0xC0, 0xB7, 0x01, 0xEE, 0x01, 0xD8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x3B, 0x00,
  0x77, 0x00, 0xEE, 0x02, 0xCE, 0x0D, 0x8F, 0xF3, 0x0F, 0xC6, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x03, 0xF1, 0xEC, 0xFB, 0x60,
  0xD8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x1F, 0x87, 0xFD, 0xE3, 0xF0, 0x1C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x01, 0xF0, 0x7F, 0xFE,
  0xFF, 0x80, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC3, 0xFF, 0xFF, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xF8, 0x7C,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0x60,
  0x2D, 0xC1, 0xB3, 0xFC, 0xCF, 0xE3, 0xE0, 0x0E, 0xC0, 0x1D, 0x80, 0x33,
  0x80, 0x67, 0x01, 0xC6, 0x03, 0x8C, 0x06, 0x1C, 0x0C, 0x38, 0x38, 0x30,
  0x70, 0x60, 0xC0, 0xC1, 0x81, 0xC7, 0x01, 0x8E, 0x03, 0x18, 0x06, 0x30,
  0x0E, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0xE0, 0x1E, 0x01, 0xB0, 0x0F, 0x01, 0xDC, 0x07, 0x80,
  0xEE, 0x03, 0xC0, 0x63, 0x01, 0xE0, 0x31, 0x81, 0xB8, 0x18, 0xC0, 0xCC,
  0x1C, 0x70, 0x66, 0x0E, 0x38, 0x33, 0x06, 0x0C, 0x39, 0x83, 0x06, 0x18,
  0xE1, 0x83, 0x0C, 0x31, 0xC1, 0xC6, 0x18, 0xC0, 0x63, 0x0C, 0x60, 0x33,
  0x86, 0x30, 0x19, 0x83, 0xB8, 0x0C, 0xC0, 0xDC, 0x07, 0x60, 0x6C, 0x01,
  0xB0, 0x36, 0x00, 0xF8, 0x1B, 0x00, 0x78, 0x0D, 0x80, 0x3C, 0x03, 0x80,
  0x1E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0xE0, 0x1D, 0xC0, 0xE7, 0x03, 0x8E,
  0x0C, 0x38, 0x70, 0x61, 0x81, 0xCE, 0x03, 0x30, 0x0F, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0x30, 0x1C, 0xE0,
  0x61, 0x83, 0x87, 0x0C, 0x0C, 0x70, 0x39, 0x80, 0xEE, 0x01, 0xB8, 0x07,
  0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xD8, 0x06, 0x60, 0x19, 0xC0, 0xE7, 0x03,
  0x8C, 0x0C, 0x30, 0x30, 0xE0, 0xC3, 0x87, 0x06, 0x18, 0x18, 0x60, 0x71,
  0x81, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0xBC, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x70, 0x1F, 0x03, 0xC0, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x1C, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0x3C, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0x00, 0x1C,
  0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0xF8, 0x1F, 0xE8, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 33, 10, 3, -33 },
  { 18, 10, 12, 15, 3, -33 },
  { 33, 19, 33, 20, 1, -33 },
  { 112, 15, 38, 19, 2, -35 },
  { 184, 25, 33, 28, 2, -33 },
  { 288, 19, 33, 20, 1, -33 },
  { 367, 3, 12, 9, 3, -33 },
  { 372, 9, 40, 13, 2, -33 },
  { 417, 8, 40, 13, 2, -33 },
  { 457, 13, 14, 17, 2, -35 },
  { 480, 17, 21, 19, 1, -27 },
  { 525, 5, 11, 9, 2, -5 },
  { 532, 10, 3, 12, 1, -14 },
  { 536, 4, 4, 9, 3, -4 },
  { 538, 14, 33, 16, 1, -33 },
  { 596, 15, 33, 19, 2, -33 },
  { 658, 9, 33, 19, 3, -33 },
  { 696, 15, 33, 19, 2, -33 },
  { 758, 15, 33, 19, 2, -33 },
  { 820, 17, 33, 19, 1, -33 },
  { 891, 15, 33, 19, 2, -33 },
  { 953, 15, 34, 19, 2, -33 },
  { 1017, 15, 33, 19, 2, -33 },
  { 1079, 15, 33, 19, 2, -33 },
  { 1141, 15, 33, 19, 2, -33 },
  { 1203, 4, 25, 9, 3, -25 },
  { 1216, 5, 31, 9, 2, -25 },
  { 1236, 17, 20, 19, 1, -26 },
  { 1279, 17, 12, 19, 1, -22 },
  { 1305, 17, 20, 19, 1, -26 },
  { 1348, 11, 33, 13, 1, -33 },
  { 1394, 25, 37, 29, 2, -33 },
  { 1510, 19, 33, 19, 0, -33 },
  { 1589, 16, 33, 21, 3, -33 },
  { 1655, 17, 33, 20, 2, -33 },
  { 1726, 17, 33, 23, 3, -33 },
  { 1797, 13, 33, 18, 3, -33 },
  { 1851, 13, 33, 17, 3, -33 },
  { 1905, 20, 33, 25, 2, -33 },
  { 1988, 17, 33, 23, 3, -33 },
  { 2059, 8, 33, 12, 2, -33 },
  { 2092, 8, 41, 9, -2, -33 },
  { 2133, 16, 33, 19, 3, -33 },
  { 2199, 13, 33, 16, 3, -33 },
  { 2253, 25, 33, 32, 3, -33 },
  { 2357, 18, 33, 25, 3, -33 },
  { 2432, 20, 33, 24, 2, -33 },
  { 2515, 15, 33, 19, 3, -33 },
  { 2577, 20, 41, 24, 2, -33 },
  { 2680, 16, 33, 20, 3, -33 },
  { 2746, 15, 33, 18, 2, -33 },
  { 2808, 16, 33, 17, 0, -33 },
  { 2874, 17, 33, 23, 3, -33 },
  { 2945, 19, 33, 19, 0, -33 },
  { 3024, 31, 33, 31, 0, -33 },
  { 3152, 16, 33, 17, 0, -33 },
  { 3218, 16, 33, 16, 0, -33 },
  { 3284, 14, 33, 16, 1, -33 },
  { 3342, 9, 40, 14, 4, -33 },
  { 3387, 14, 33, 16, 1, -33 },
  { 3445, 9, 40, 14, 2, -33 },
  { 3490, 18, 17, 19, 1, -33 },
  { 3529, 19, 2, 19, 0, 4 },
  { 3534, 7, 7, 11, 2, -35 },
  { 3541, 13, 25, 18, 2, -25 },
  { 3582, 15, 35, 20, 3, -35 },
  { 3648, 12, 25, 15, 2, -25 },
  { 3686, 15, 35, 20, 2, -35 },
  { 3752, 14, 25, 18, 2, -25 },
  { 3796, 12, 35, 11, 0, -35 },
  { 3849, 15, 36, 20, 2, -25 },
  { 3917, 14, 35, 20, 3, -35 },
  { 3979, 3, 34, 9, 3, -34 },
  { 3992, 6, 45, 9, 0, -34 },
  { 4026, 13, 35, 17, 3, -35 },
  { 4083, 3, 35, 9, 3, -35 },
  { 4097, 24, 25, 30, 3, -25 },
  { 4172, 14, 25, 20, 3, -25 },
  { 4216, 15, 25, 20, 2, -25 },
  { 4263, 15, 36, 20, 3, -25 },
  { 4331, 15, 36, 20, 2, -25 },
  { 4399, 10, 25, 13, 3, -25 },
  { 4431, 11, 25, 15, 2, -25 },
  { 4466, 9, 30, 11, 1, -30 },
  { 4500, 14, 24, 20, 3, -24 },
  { 4542, 15, 24, 15, 0, -24 },
  { 4587, 25, 24, 26, 0, -24 },
  { 4662, 14, 24, 16, 1, -24 },
  { 4704, 14, 35, 16, 1, -24 },
  { 4766, 11, 24, 13, 1, -24 },
  { 4799, 12, 40, 16, 2, -33 },
  { 4859, 2, 46, 18, 8, -35 },
  { 4871, 12, 40, 16, 2, -33 },
  { 4931, 17, 5, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Light46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT46PT7B_H_
