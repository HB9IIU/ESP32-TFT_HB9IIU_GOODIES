#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0x7F,
  0xF8, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0,
  0xB0, 0x40, 0x03, 0x06, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x60,
  0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x3F, 0xFF, 0xDF,
  0xFF, 0xE0, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06, 0x1F, 0xFF, 0xEF, 0xFF, 0xF0, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03,
  0x04, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x01, 0xE0, 0x3F, 0xF9, 0xE9, 0xE6, 0x20, 0xB0, 0x80, 0xC2, 0x03,
  0x08, 0x0C, 0x20, 0x30, 0x80, 0xC2, 0x03, 0x88, 0x07, 0x20, 0x0E, 0x80,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x9C, 0x02, 0x38, 0x08, 0x70, 0x20,
  0xC0, 0x83, 0x02, 0x0C, 0x08, 0x30, 0x20, 0xC0, 0x87, 0x82, 0x3B, 0xFF,
  0xC7, 0xFC, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x3C,
  0x01, 0x80, 0xFC, 0x03, 0x01, 0x8C, 0x06, 0x02, 0x18, 0x18, 0x0C, 0x18,
  0x30, 0x18, 0x30, 0x60, 0x30, 0x61, 0x80, 0x60, 0xC3, 0x00, 0xC1, 0x86,
  0x01, 0x83, 0x18, 0x03, 0x06, 0x30, 0x06, 0x0C, 0x60, 0x0C, 0x19, 0x87,
  0x18, 0x33, 0x3F, 0x30, 0x66, 0x67, 0x31, 0x99, 0x86, 0x63, 0x33, 0x0C,
  0xFC, 0x66, 0x18, 0xF1, 0x8C, 0x18, 0x03, 0x18, 0x30, 0x06, 0x30, 0x60,
  0x18, 0x60, 0xC0, 0x30, 0xC1, 0x80, 0x61, 0x83, 0x01, 0x83, 0x06, 0x03,
  0x06, 0x0C, 0x06, 0x0C, 0x30, 0x18, 0x18, 0x60, 0x30, 0x18, 0xC0, 0x60,
  0x3B, 0x01, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xC6, 0x00,
  0x61, 0x80, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18,
  0x70, 0x06, 0x18, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0E, 0x60, 0xE7, 0x0C, 0x31,
  0x83, 0x8C, 0x60, 0x63, 0x38, 0x1C, 0xCE, 0x03, 0x73, 0x80, 0x78, 0xE0,
  0x1E, 0x38, 0x03, 0x06, 0x01, 0xE1, 0xC0, 0xF8, 0x70, 0x73, 0x0F, 0xF8,
  0xE1, 0xFC, 0x1C, 0xFF, 0xFF, 0xFC, 0x03, 0x07, 0x06, 0x0C, 0x1C, 0x18,
  0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x70, 0x30,
  0x38, 0x18, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0xE0, 0x38, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x07, 0x07, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x86, 0x3F, 0x7F,
  0x7F, 0xC0, 0xE0, 0x0F, 0x01, 0x98, 0x31, 0xC7, 0x0E, 0x20, 0x40, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x33, 0x77, 0x66, 0x6E, 0xCC, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x8E, 0x0C,
  0x1C, 0x70, 0x31, 0x80, 0xE6, 0x01, 0x98, 0x06, 0xE0, 0x1B, 0x80, 0x6E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x06,
  0x60, 0x19, 0x80, 0xE7, 0x03, 0x0C, 0x0C, 0x38, 0x70, 0x7F, 0x80, 0xFC,
  0x00, 0x03, 0x07, 0x0F, 0x1F, 0x3B, 0x73, 0xE3, 0x43, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0x81, 0xFF, 0x8E,
  0x0F, 0x10, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0x81, 0xFF, 0x8E, 0x0F, 0x30, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x81, 0xF8, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x80, 0x73, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xB8, 0x01, 0xB8,
  0x01, 0xB8, 0x03, 0x38, 0x03, 0x38, 0x06, 0x38, 0x06, 0x38, 0x0C, 0x38,
  0x0C, 0x38, 0x18, 0x38, 0x18, 0x38, 0x30, 0x38, 0x30, 0x38, 0x60, 0x38,
  0x60, 0x38, 0xC0, 0x38, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x7F, 0xF1, 0xFF, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE6, 0x03, 0xFF,
  0x07, 0xFF, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0xC0, 0xF3, 0xFF, 0x87, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xE0,
  0x87, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC7, 0xC3, 0x3F, 0xCD, 0x87, 0x34, 0x0E, 0xE0,
  0x1B, 0x80, 0x6E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0x60, 0x1D, 0x80, 0x66, 0x01, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0xC0,
  0xFC, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xF0, 0xE1, 0xC0, 0xE3, 0x00, 0xCE, 0x01, 0x9C, 0x03, 0xB8,
  0x07, 0x70, 0x0C, 0x60, 0x18, 0xE0, 0x70, 0xC0, 0xC1, 0xC7, 0x01, 0xFC,
  0x00, 0xF0, 0x03, 0xE0, 0x0E, 0xF0, 0x38, 0x70, 0xE0, 0x73, 0x80, 0x66,
  0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80,
  0x3B, 0x80, 0x63, 0x81, 0xC3, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0xFF,
  0x83, 0x8E, 0x1C, 0x1C, 0xE0, 0x33, 0x80, 0xEC, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x7E, 0x03, 0xD8,
  0x0E, 0x70, 0x78, 0xFF, 0x61, 0xF9, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC1,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x77, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x77,
  0x76, 0x6E, 0xCC, 0x80, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x7F, 0x1F, 0xF3, 0x0F, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x00, 0x0E, 0x07, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x07, 0x06, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xE0,
  0x7E, 0x19, 0x81, 0xDC, 0x33, 0x06, 0x18, 0x36, 0x1C, 0x30, 0x7C, 0x30,
  0x60, 0xF0, 0x60, 0xC1, 0xE0, 0xC1, 0x83, 0xC1, 0x83, 0x07, 0x83, 0x06,
  0x0F, 0x06, 0x0C, 0x1E, 0x0C, 0x38, 0x3C, 0x18, 0x70, 0x78, 0x30, 0xE1,
  0xB0, 0x61, 0xC3, 0x30, 0xE6, 0x8E, 0x60, 0xF9, 0xF8, 0xC0, 0xF1, 0xE1,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x03, 0x80, 0x07, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0x60, 0x00, 0xDC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8E,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x07, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x1C, 0x0C, 0x07, 0x03, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x18,
  0x06, 0x0E, 0x01, 0x83, 0x80, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x00,
  0xC7, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1C,
  0xFF, 0x01, 0xFF, 0xE3, 0x87, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8,
  0x03, 0x70, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x80, 0x77, 0x00, 0xCE, 0x03,
  0x9C, 0x0E, 0x3F, 0xF0, 0x7F, 0xF8, 0xE0, 0x79, 0xC0, 0x3B, 0x80, 0x37,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1B, 0x80, 0x77, 0x00, 0xEE, 0x07, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x01,
  0xFC, 0x07, 0xFF, 0x0F, 0x06, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0F, 0x02, 0x07, 0xFE, 0x03,
  0xFE, 0xFE, 0x00, 0xFF, 0xE0, 0xE3, 0xF0, 0xE0, 0x38, 0xE0, 0x1C, 0xE0,
  0x0C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1E, 0x07, 0x07, 0x00, 0x21, 0xC0,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x76, 0x00, 0x0E, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x30, 0x00,
  0xE7, 0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x70, 0xF0, 0x0E, 0x0F, 0xFF,
  0xC0, 0x7F, 0xE0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x9F, 0xFF, 0x80, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x8E, 0xFC, 0xF8,
  0xE0, 0x0D, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xCE, 0x07, 0x1C, 0x0C, 0x38,
  0x38, 0x70, 0x60, 0xE1, 0xC1, 0xC3, 0x03, 0x8E, 0x07, 0x38, 0x0E, 0x60,
  0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xE6, 0x03, 0x8E, 0x07,
  0x0C, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x30, 0xE0, 0x71, 0xC0,
  0x63, 0x80, 0xE7, 0x00, 0xCE, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x80, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFD, 0x80, 0x01,
  0xFB, 0x00, 0x06, 0xF6, 0x00, 0x0D, 0xF6, 0x00, 0x1B, 0xEC, 0x00, 0x77,
  0xD8, 0x00, 0xCF, 0xB8, 0x01, 0x9F, 0x30, 0x07, 0x3E, 0x60, 0x0C, 0x7C,
  0xE0, 0x18, 0xF8, 0xC0, 0x31, 0xF1, 0x80, 0xE3, 0xE3, 0x01, 0x87, 0xC3,
  0x03, 0x0F, 0x86, 0x0E, 0x1F, 0x0C, 0x18, 0x3E, 0x1C, 0x30, 0x7C, 0x18,
  0x60, 0xF8, 0x31, 0x81, 0xF0, 0x63, 0x03, 0xE0, 0x66, 0x07, 0xC0, 0xDC,
  0x0F, 0x81, 0xB0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x00,
  0xF8, 0x0E, 0x01, 0x80, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3D, 0x80, 0x1E, 0xC0, 0x0F, 0x70, 0x07, 0xD8, 0x03, 0xEE, 0x01, 0xF3,
  0x00, 0xF9, 0xC0, 0x7C, 0x60, 0x3E, 0x30, 0x1F, 0x1C, 0x0F, 0x86, 0x07,
  0xC3, 0x83, 0xE0, 0xC1, 0xF0, 0x70, 0xF8, 0x18, 0x7C, 0x0C, 0x3E, 0x03,
  0x1F, 0x01, 0x8F, 0x80, 0xE7, 0xC0, 0x33, 0xE0, 0x1D, 0xF0, 0x06, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0E, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x38, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x60, 0x07,
  0x1C, 0x00, 0x63, 0x80, 0x0E, 0x60, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x03,
  0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x70, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x01, 0x98, 0x00, 0x33, 0x80, 0x0E, 0x70, 0x01, 0xC6, 0x00, 0x30,
  0xE0, 0x0E, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x03, 0xFF, 0x0E, 0x3F, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x6E, 0x01,
  0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x1B, 0x80,
  0xEE, 0x03, 0xB8, 0x1C, 0xFF, 0xE3, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x38, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x60, 0x07, 0x1C, 0x00, 0x63,
  0x80, 0x0E, 0x60, 0x01, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0x6E,
  0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98,
  0x00, 0x33, 0x80, 0x0E, 0x70, 0x01, 0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0E,
  0x03, 0x81, 0xE0, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0xFF, 0x01, 0xFF, 0x83, 0x9F, 0xC7, 0x03, 0x8E, 0x03, 0x9C,
  0x03, 0x38, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00,
  0xCE, 0x01, 0x9C, 0x07, 0x38, 0x1C, 0x71, 0xF0, 0xFF, 0xC1, 0xFF, 0x03,
  0x86, 0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x18, 0x70, 0x30, 0xE0,
  0x71, 0xC0, 0x63, 0x80, 0xE7, 0x00, 0xCE, 0x01, 0xDC, 0x01, 0xB8, 0x03,
  0x80, 0x0F, 0xE0, 0x7F, 0xE3, 0x83, 0x9C, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0xC0, 0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0x60,
  0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0xE0, 0x01, 0xF0,
  0x00, 0xD8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x33, 0x80, 0x19, 0xC0, 0x1C,
  0x60, 0x0E, 0x30, 0x06, 0x1C, 0x03, 0x0E, 0x01, 0x83, 0x01, 0xC1, 0x80,
  0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x38, 0x0C, 0x1C, 0x06, 0x0C, 0x03,
  0x86, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x31, 0x80, 0x1C, 0xC0, 0x0E, 0x60,
  0x03, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x00, 0x38, 0x00, 0xD8, 0x01,
  0xC0, 0x0E, 0xC0, 0x0E, 0x00, 0x76, 0x00, 0x78, 0x03, 0x38, 0x06, 0xC0,
  0x18, 0xC0, 0x36, 0x01, 0xC6, 0x01, 0xB0, 0x0E, 0x30, 0x0D, 0x80, 0x61,
  0xC0, 0x66, 0x03, 0x0E, 0x07, 0x30, 0x18, 0x30, 0x31, 0x81, 0xC1, 0x81,
  0x8C, 0x0E, 0x0C, 0x0C, 0x60, 0x60, 0x70, 0x63, 0x83, 0x03, 0x87, 0x0C,
  0x18, 0x0C, 0x30, 0x61, 0xC0, 0x61, 0x83, 0x0E, 0x03, 0x0C, 0x18, 0x60,
  0x1C, 0x60, 0x63, 0x00, 0xE7, 0x03, 0x18, 0x03, 0x30, 0x19, 0xC0, 0x19,
  0x80, 0xCE, 0x00, 0xCC, 0x06, 0x60, 0x07, 0x60, 0x3B, 0x00, 0x1B, 0x00,
  0xD8, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x70, 0x06, 0x60, 0x1C,
  0xE0, 0x30, 0xC0, 0x61, 0x81, 0xC3, 0x83, 0x03, 0x0E, 0x06, 0x18, 0x0E,
  0x30, 0x0C, 0xE0, 0x19, 0x80, 0x1B, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1D, 0x80, 0x33, 0x00, 0x67, 0x01,
  0xC6, 0x03, 0x0C, 0x0E, 0x1C, 0x18, 0x18, 0x30, 0x30, 0xE0, 0x71, 0x80,
  0x67, 0x00, 0xCC, 0x01, 0xF8, 0x01, 0x80, 0xE0, 0x07, 0xC0, 0x1D, 0x80,
  0x33, 0x80, 0x67, 0x01, 0xC6, 0x03, 0x0E, 0x06, 0x1C, 0x1C, 0x18, 0x30,
  0x38, 0x60, 0x71, 0xC0, 0x63, 0x00, 0xC6, 0x00, 0xDC, 0x01, 0xB0, 0x03,
  0x60, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0F, 0xFF, 0xFC, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0xFF, 0xFF, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xFF, 0xFC, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x60,
  0x06, 0x60, 0x0E, 0x30, 0x0C, 0x30, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x1C,
  0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x80, 0x1F, 0xC7,
  0xFE, 0x20, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x0F, 0xF3, 0xE3, 0x70, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xB7, 0xBB, 0x3F, 0x30, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x7E, 0x33, 0xFC, 0xD8, 0x73, 0xC0, 0xEE, 0x01, 0xB8,
  0x07, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1B,
  0xC0, 0xED, 0x83, 0x37, 0xFC, 0xC7, 0xE0, 0x0F, 0xE3, 0xFC, 0xE0, 0x98,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x82,
  0x3F, 0xC3, 0xF8, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0xF8, 0xCF, 0xFB,
  0x38, 0x6D, 0xC0, 0xF6, 0x01, 0xD8, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0xF8, 0x07, 0x60, 0x1D, 0xC0, 0xF3, 0x82, 0xCF, 0xFB, 0x1F,
  0x8C, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x81, 0x8F,
  0xFC, 0x3F, 0xC0, 0x03, 0xC0, 0xFC, 0x38, 0x86, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x81, 0xFE, 0x7F, 0xC1, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0x0F, 0xCC, 0xFF, 0xB3, 0x86, 0xDC, 0x0F, 0x60, 0x1D, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x76, 0x01, 0xDC, 0x0F,
  0x38, 0x6C, 0xFF, 0x31, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE4, 0x07, 0x1F, 0xFC, 0x3F, 0xC0, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x31, 0xF1, 0x9F, 0xCD, 0x87, 0x78, 0x1B, 0x80, 0xDC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x38, 0xFF, 0x80, 0x00, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0xBE, 0xF0,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x7C, 0x06, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x38,
  0xC7, 0x0C, 0x60, 0xCE, 0x0C, 0xE0, 0xDE, 0x0D, 0x70, 0xF3, 0x0E, 0x30,
  0xC3, 0x8C, 0x18, 0xC1, 0xCC, 0x0C, 0xC0, 0xCC, 0x0E, 0xC0, 0x6C, 0x07,
  0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xCF,
  0xC3, 0xF3, 0x7F, 0x9F, 0xED, 0x0E, 0xC3, 0xBC, 0x1E, 0x06, 0xE0, 0x78,
  0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C,
  0x03, 0x00, 0xC0, 0xC7, 0xC6, 0x7F, 0x36, 0x1D, 0xE0, 0x6E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x1C, 0x0E,
  0x60, 0x19, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0D, 0x80,
  0x76, 0x01, 0x9C, 0x06, 0x38, 0x30, 0x7F, 0xC0, 0xFE, 0x00, 0xC7, 0xE3,
  0x3F, 0xCD, 0x87, 0x3C, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xBC, 0x0E, 0xD8, 0x73, 0x3F,
  0xCC, 0x7E, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0F, 0xCC, 0x7F, 0xB3,
  0x86, 0xDC, 0x0F, 0x60, 0x1D, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0x80, 0x76, 0x01, 0xDC, 0x0F, 0x38, 0x6C, 0xFF, 0x31, 0xF8,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xC7, 0xE7, 0xF6, 0x1A, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0xE3, 0xFF, 0x70,
  0x26, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0xC0, 0xEF, 0xFC, 0x7F, 0x80, 0x10, 0x30, 0x30, 0x30, 0x30,
  0x7F, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x38, 0x1F, 0x1F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xB6, 0x0D, 0xBF, 0xCC, 0xFC,
  0x60, 0xE0, 0x0D, 0x80, 0x76, 0x01, 0x98, 0x06, 0x70, 0x18, 0xC0, 0xE3,
  0x03, 0x0C, 0x0C, 0x30, 0x30, 0x61, 0xC1, 0x87, 0x06, 0x18, 0x18, 0x60,
  0x71, 0x80, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x3B, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x18, 0x07, 0x60, 0x1C, 0x06,
  0x60, 0x3C, 0x06, 0x60, 0x3C, 0x06, 0x70, 0x3C, 0x0E, 0x30, 0x34, 0x0C,
  0x30, 0x76, 0x0C, 0x30, 0x66, 0x0C, 0x38, 0x66, 0x0C, 0x38, 0x66, 0x1C,
  0x18, 0x67, 0x18, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x1C, 0xC3, 0x18,
  0x0C, 0xC3, 0x30, 0x0C, 0xC3, 0xB0, 0x0D, 0x81, 0xB0, 0x0D, 0x81, 0xB0,
  0x0F, 0x81, 0xB0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0x60, 0xC3, 0x06, 0x0C,
  0x60, 0x63, 0x03, 0xB8, 0x0D, 0x80, 0x7C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x06, 0xC0, 0x36, 0x03, 0x38, 0x18, 0xC1, 0xC7, 0x0C, 0x18, 0xE0, 0xE6,
  0x03, 0x70, 0x1B, 0x00, 0xE0, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x76,
  0x03, 0x30, 0x19, 0xC0, 0xCE, 0x0E, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x31,
  0xC1, 0x8C, 0x0C, 0x60, 0x63, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0x60,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x1F, 0x00, 0xF0, 0x00, 0x7F,
  0xDF, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x60, 0x7C, 0x1E, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x83, 0xE0, 0x78, 0x01, 0xC0, 0x18, 0x03, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x1E, 0x0F, 0x81, 0xC0, 0x00, 0x7F, 0x01, 0xFF, 0xC7, 0xC1,
  0xFE, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 9, 11, 14, 3, -31 },
  { 26, 17, 31, 19, 1, -31 },
  { 92, 14, 36, 18, 2, -33 },
  { 155, 23, 31, 27, 2, -31 },
  { 245, 18, 31, 19, 1, -31 },
  { 315, 2, 11, 8, 3, -31 },
  { 318, 8, 38, 12, 2, -31 },
  { 356, 9, 38, 12, 1, -31 },
  { 399, 12, 13, 16, 2, -33 },
  { 419, 16, 20, 18, 1, -25 },
  { 459, 4, 11, 9, 2, -5 },
  { 465, 9, 3, 12, 1, -13 },
  { 469, 3, 4, 9, 3, -4 },
  { 471, 13, 31, 15, 1, -31 },
  { 522, 14, 31, 18, 2, -31 },
  { 577, 8, 31, 18, 3, -31 },
  { 608, 14, 31, 18, 2, -31 },
  { 663, 14, 31, 18, 2, -31 },
  { 718, 16, 31, 18, 1, -31 },
  { 780, 14, 31, 18, 2, -31 },
  { 835, 14, 32, 18, 2, -31 },
  { 891, 14, 31, 18, 2, -31 },
  { 946, 15, 31, 18, 1, -31 },
  { 1005, 14, 31, 18, 2, -31 },
  { 1060, 3, 23, 9, 3, -23 },
  { 1069, 4, 29, 9, 2, -23 },
  { 1084, 16, 18, 18, 1, -24 },
  { 1120, 16, 11, 18, 1, -21 },
  { 1142, 16, 18, 18, 1, -24 },
  { 1178, 11, 31, 13, 1, -31 },
  { 1221, 23, 35, 27, 2, -31 },
  { 1322, 18, 31, 18, 0, -31 },
  { 1392, 15, 31, 20, 3, -31 },
  { 1451, 16, 31, 19, 2, -31 },
  { 1513, 16, 31, 21, 3, -31 },
  { 1575, 12, 31, 17, 3, -31 },
  { 1622, 12, 31, 16, 3, -31 },
  { 1669, 19, 31, 23, 2, -31 },
  { 1743, 16, 31, 22, 3, -31 },
  { 1805, 7, 31, 11, 2, -31 },
  { 1833, 8, 39, 9, -2, -31 },
  { 1872, 15, 31, 18, 3, -31 },
  { 1931, 12, 31, 15, 3, -31 },
  { 1978, 23, 31, 29, 3, -31 },
  { 2068, 17, 31, 23, 3, -31 },
  { 2134, 19, 31, 23, 2, -31 },
  { 2208, 14, 31, 18, 3, -31 },
  { 2263, 19, 38, 23, 2, -31 },
  { 2354, 15, 31, 19, 3, -31 },
  { 2413, 14, 31, 17, 2, -31 },
  { 2468, 15, 31, 15, 0, -31 },
  { 2527, 16, 31, 22, 3, -31 },
  { 2589, 17, 31, 17, 0, -31 },
  { 2655, 29, 31, 29, 0, -31 },
  { 2768, 15, 31, 16, 0, -31 },
  { 2827, 15, 31, 15, 0, -31 },
  { 2886, 13, 31, 15, 1, -31 },
  { 2937, 9, 38, 13, 3, -31 },
  { 2980, 13, 31, 15, 1, -31 },
  { 3031, 9, 38, 13, 1, -31 },
  { 3074, 16, 16, 18, 1, -31 },
  { 3106, 18, 2, 18, 0, 4 },
  { 3111, 7, 7, 11, 2, -33 },
  { 3118, 12, 23, 17, 2, -23 },
  { 3153, 14, 33, 19, 3, -33 },
  { 3211, 11, 23, 14, 2, -23 },
  { 3243, 14, 33, 19, 2, -33 },
  { 3301, 13, 23, 17, 2, -23 },
  { 3339, 11, 33, 10, 0, -33 },
  { 3385, 14, 33, 19, 2, -23 },
  { 3443, 13, 33, 19, 3, -33 },
  { 3497, 3, 31, 8, 3, -31 },
  { 3509, 6, 41, 8, 0, -31 },
  { 3540, 12, 33, 16, 3, -33 },
  { 3590, 2, 33, 8, 3, -33 },
  { 3599, 22, 23, 28, 3, -23 },
  { 3663, 13, 23, 19, 3, -23 },
  { 3701, 14, 23, 18, 2, -23 },
  { 3742, 14, 33, 19, 3, -23 },
  { 3800, 14, 33, 19, 2, -23 },
  { 3858, 9, 23, 12, 3, -23 },
  { 3884, 12, 23, 14, 1, -23 },
  { 3919, 8, 28, 10, 1, -28 },
  { 3947, 13, 23, 19, 3, -23 },
  { 3985, 14, 23, 14, 0, -23 },
  { 4026, 24, 23, 24, 0, -23 },
  { 4095, 13, 23, 15, 1, -23 },
  { 4133, 13, 33, 15, 1, -23 },
  { 4187, 10, 23, 12, 1, -23 },
  { 4216, 11, 38, 15, 2, -31 },
  { 4269, 3, 43, 17, 7, -33 },
  { 4286, 11, 38, 15, 2, -31 },
  { 4339, 16, 4, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Light43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT43PT7B_H_
