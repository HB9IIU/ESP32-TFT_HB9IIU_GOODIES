#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x29, 0x95, 0xF5, 0x2B, 0xEA, 0x50, 0x23, 0xA9,
  0x46, 0x18, 0xB6, 0x61, 0x00, 0x8B, 0x4D, 0x36, 0xF6, 0xD3, 0x55, 0x4C,
  0x22, 0x94, 0xC2, 0x36, 0x72, 0x68, 0xF0, 0x6A, 0xAA, 0xA4, 0x89, 0x12,
  0x49, 0x4A, 0x00, 0x2F, 0x70, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0, 0x80,
  0x11, 0x22, 0x24, 0x44, 0x80, 0x56, 0xDB, 0x6D, 0xE0, 0x7D, 0x55, 0x40,
  0x61, 0x11, 0x12, 0x24, 0xF0, 0x69, 0x11, 0x61, 0x11, 0xF0, 0x10, 0x8C,
  0xA5, 0x4B, 0xE2, 0x10, 0xF2, 0x4E, 0x49, 0xE0, 0x72, 0x6B, 0x6D, 0xE0,
  0xF1, 0x11, 0x22, 0x24, 0x40, 0x22, 0xA4, 0xA2, 0x2A, 0x31, 0x70, 0x25,
  0x99, 0x97, 0x11, 0x60, 0x84, 0x40, 0x16, 0x09, 0xB0, 0xC1, 0x80, 0xF8,
  0x3E, 0x83, 0x06, 0x6C, 0x00, 0xC4, 0x92, 0x90, 0x40, 0x31, 0x28, 0x6D,
  0xD7, 0x5D, 0x6A, 0x81, 0xC0, 0x21, 0x14, 0xA5, 0x3A, 0x31, 0x88, 0xE9,
  0x99, 0xE9, 0x99, 0xE0, 0x78, 0x88, 0x88, 0x88, 0x70, 0xE9, 0x99, 0x99,
  0x99, 0xE0, 0xF2, 0x4F, 0x24, 0xE0, 0xF2, 0x4F, 0x24, 0x80, 0x7C, 0x21,
  0x09, 0x46, 0x31, 0x78, 0x99, 0x99, 0xF9, 0x99, 0x90, 0xE9, 0x24, 0x92,
  0xE0, 0x24, 0x92, 0x49, 0x27, 0x00, 0x9A, 0xAC, 0xCC, 0xAA, 0x90, 0x92,
  0x49, 0x24, 0xE0, 0x86, 0x18, 0x73, 0xCE, 0xBB, 0x6D, 0x94, 0x8C, 0x73,
  0x9A, 0xD6, 0x73, 0x88, 0x64, 0xA3, 0x18, 0xC6, 0x32, 0x70, 0xCA, 0x99,
  0xAC, 0x88, 0x80, 0x64, 0xA3, 0x18, 0xC6, 0x32, 0x70, 0x84, 0xCB, 0x99,
  0xEA, 0xAA, 0x90, 0x34, 0x84, 0x21, 0x11, 0xF0, 0xF2, 0x22, 0x22, 0x22,
  0x20, 0x99, 0x99, 0x99, 0x99, 0xF0, 0x8C, 0x62, 0xA5, 0x29, 0x4C, 0x20,
  0x89, 0x89, 0x99, 0x59, 0x5A, 0x56, 0x66, 0x26, 0x24, 0x95, 0x52, 0x22,
  0x55, 0x90, 0x99, 0x56, 0x62, 0x22, 0x20, 0xF1, 0x22, 0x24, 0x44, 0xF0,
  0xEA, 0xAA, 0xAC, 0x88, 0x44, 0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27,
  0x80, 0x21, 0x14, 0xA8, 0x80, 0xF8, 0xD0, 0x61, 0x17, 0x99, 0x70, 0x88,
  0xE9, 0x99, 0x99, 0xE0, 0x72, 0x49, 0x38, 0x11, 0x5B, 0x99, 0x99, 0xF0,
  0x56, 0xF9, 0x38, 0x6B, 0xA4, 0x92, 0x40, 0x4B, 0x99, 0x99, 0xF1, 0x2E,
  0x93, 0x5B, 0x6D, 0xA0, 0x9F, 0x80, 0x41, 0x55, 0x56, 0x92, 0x5D, 0xB5,
  0xA0, 0xFF, 0x80, 0x4A, 0xDA, 0x69, 0xA6, 0x9A, 0x40, 0x56, 0xDB, 0x68,
  0x4A, 0x99, 0x99, 0xE0, 0x69, 0x99, 0x99, 0xE8, 0x88, 0x4B, 0x99, 0x99,
  0xF1, 0x11, 0xEA, 0xA0, 0x68, 0x84, 0x21, 0xE0, 0x5D, 0x24, 0x93, 0xB6,
  0xDB, 0xC0, 0x99, 0x66, 0x64, 0x93, 0x69, 0xB3, 0x66, 0xC9, 0x00, 0xD6,
  0x26, 0x69, 0x99, 0x66, 0x62, 0x44, 0xC0, 0xE5, 0x25, 0xC0, 0x29, 0x25,
  0x22, 0x49, 0x80, 0xFF, 0xF0, 0x89, 0x24, 0xD2, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 5, 9, 5, 0, -9 },
  { 10, 5, 10, 5, 0, -9 },
  { 17, 6, 9, 7, 1, -9 },
  { 24, 5, 9, 5, 0, -9 },
  { 30, 1, 4, 2, 1, -9 },
  { 31, 2, 11, 3, 1, -9 },
  { 34, 3, 11, 3, 0, -9 },
  { 39, 4, 3, 4, 0, -9 },
  { 41, 5, 6, 5, 0, -7 },
  { 45, 2, 3, 2, 0, -1 },
  { 46, 3, 1, 3, 0, -4 },
  { 47, 1, 1, 2, 1, -1 },
  { 48, 4, 9, 4, 0, -9 },
  { 53, 3, 9, 5, 1, -9 },
  { 57, 2, 9, 5, 1, -9 },
  { 60, 4, 9, 5, 0, -9 },
  { 65, 4, 9, 5, 0, -9 },
  { 70, 5, 9, 5, 0, -9 },
  { 76, 3, 9, 5, 1, -9 },
  { 80, 3, 9, 5, 1, -9 },
  { 84, 4, 9, 5, 0, -9 },
  { 89, 5, 9, 5, 0, -9 },
  { 95, 4, 9, 5, 0, -9 },
  { 100, 1, 6, 2, 1, -6 },
  { 101, 2, 8, 2, 0, -6 },
  { 103, 5, 5, 5, 0, -7 },
  { 107, 5, 3, 5, 0, -6 },
  { 109, 5, 5, 5, 0, -7 },
  { 113, 3, 9, 3, 0, -9 },
  { 117, 6, 10, 8, 1, -9 },
  { 125, 5, 9, 5, 0, -9 },
  { 131, 4, 9, 5, 1, -9 },
  { 136, 4, 9, 5, 1, -9 },
  { 141, 4, 9, 6, 1, -9 },
  { 146, 3, 9, 5, 1, -9 },
  { 150, 3, 9, 4, 1, -9 },
  { 154, 5, 9, 6, 1, -9 },
  { 160, 4, 9, 6, 1, -9 },
  { 165, 3, 9, 3, 0, -9 },
  { 169, 3, 11, 2, -1, -9 },
  { 174, 4, 9, 5, 1, -9 },
  { 179, 3, 9, 4, 1, -9 },
  { 183, 6, 9, 8, 1, -9 },
  { 190, 5, 9, 6, 1, -9 },
  { 196, 5, 9, 6, 1, -9 },
  { 202, 4, 9, 5, 1, -9 },
  { 207, 5, 11, 6, 1, -9 },
  { 214, 4, 9, 5, 1, -9 },
  { 219, 4, 9, 5, 0, -9 },
  { 224, 4, 9, 4, 0, -9 },
  { 229, 4, 9, 6, 1, -9 },
  { 234, 5, 9, 5, 0, -9 },
  { 240, 8, 9, 8, 0, -9 },
  { 249, 4, 9, 4, 0, -9 },
  { 254, 4, 9, 4, 0, -9 },
  { 259, 4, 9, 4, 0, -9 },
  { 264, 2, 11, 4, 1, -9 },
  { 267, 4, 9, 4, 0, -9 },
  { 272, 3, 11, 4, 0, -9 },
  { 277, 5, 5, 5, 0, -9 },
  { 281, 5, 1, 5, 0, 1 },
  { 282, 2, 2, 3, 0, -9 },
  { 283, 4, 7, 5, 0, -7 },
  { 287, 4, 9, 5, 1, -9 },
  { 292, 3, 7, 4, 1, -7 },
  { 295, 4, 9, 5, 1, -9 },
  { 300, 3, 7, 5, 1, -7 },
  { 303, 3, 9, 3, 0, -9 },
  { 307, 4, 10, 5, 1, -7 },
  { 312, 3, 9, 5, 1, -9 },
  { 316, 1, 9, 2, 1, -9 },
  { 318, 2, 12, 2, 0, -9 },
  { 321, 3, 9, 4, 1, -9 },
  { 325, 1, 9, 2, 1, -9 },
  { 327, 6, 7, 8, 1, -7 },
  { 333, 3, 7, 5, 1, -7 },
  { 336, 4, 7, 5, 1, -7 },
  { 340, 4, 10, 5, 1, -7 },
  { 345, 4, 10, 5, 1, -7 },
  { 350, 2, 6, 3, 1, -6 },
  { 352, 4, 7, 4, 0, -7 },
  { 356, 3, 8, 3, 0, -8 },
  { 359, 3, 6, 5, 1, -6 },
  { 362, 4, 6, 4, 0, -6 },
  { 365, 7, 6, 7, 0, -6 },
  { 371, 4, 6, 4, 0, -6 },
  { 374, 4, 9, 4, 0, -6 },
  { 379, 3, 6, 3, 0, -6 },
  { 382, 3, 11, 4, 1, -9 },
  { 387, 1, 12, 5, 2, -9 },
  { 389, 3, 11, 4, 1, -9 },
  { 394, 5, 1, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_Light12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT12PT7B_H_
