#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x00,
  0x00, 0x8F, 0xFF, 0xFE, 0xE0, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x3B, 0x80, 0xDC, 0x06, 0x00, 0x70, 0x38, 0x00, 0x30,
  0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x07, 0x01,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x01, 0xC0, 0x60,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x01, 0x80, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0x60, 0x00, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0x60, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x0E, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xCC, 0x1C, 0x38, 0x60,
  0x23, 0x83, 0x00, 0x1C, 0x18, 0x01, 0xE0, 0xC0, 0x0E, 0x06, 0x00, 0x70,
  0x30, 0x03, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xF0, 0x60, 0x03, 0x83, 0x00,
  0x1E, 0x18, 0x00, 0x78, 0xC0, 0x03, 0xE6, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x19, 0xF0,
  0x00, 0xC7, 0xC0, 0x06, 0x0F, 0x00, 0x30, 0x38, 0x01, 0x81, 0xE0, 0x0C,
  0x07, 0x00, 0x60, 0x38, 0x03, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x70,
  0x06, 0x03, 0x80, 0x30, 0x3A, 0x01, 0x83, 0xDC, 0x0C, 0x3C, 0xFC, 0x67,
  0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0x80, 0x3F, 0xC0, 0x07, 0x00, 0x39, 0xE0, 0x07,
  0x00, 0x70, 0xE0, 0x07, 0x00, 0x70, 0x60, 0x0E, 0x00, 0xE0, 0x70, 0x0E,
  0x00, 0xE0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x00, 0xE0, 0x30, 0x1C,
  0x00, 0xE0, 0x30, 0x1C, 0x00, 0xC0, 0x38, 0x38, 0x00, 0xC0, 0x38, 0x38,
  0x00, 0xC0, 0x38, 0x38, 0x00, 0xC0, 0x38, 0x70, 0x00, 0xC0, 0x38, 0x70,
  0x00, 0xC0, 0x38, 0x70, 0x00, 0xC0, 0x38, 0xE0, 0x00, 0xE0, 0x30, 0xE0,
  0xE0, 0xE0, 0x30, 0xE3, 0xF8, 0xE0, 0x71, 0xC7, 0xFC, 0xE0, 0x71, 0xC7,
  0x1C, 0xE0, 0x71, 0x8E, 0x0E, 0x70, 0x63, 0x8E, 0x0E, 0x70, 0xE3, 0x8E,
  0x06, 0x3F, 0xC3, 0x0C, 0x07, 0x3F, 0xC7, 0x1C, 0x07, 0x0F, 0x87, 0x1C,
  0x07, 0x00, 0x06, 0x1C, 0x07, 0x00, 0x0E, 0x1C, 0x07, 0x00, 0x0E, 0x1C,
  0x07, 0x00, 0x0C, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x1C,
  0x07, 0x00, 0x18, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x07, 0x00, 0x38, 0x1C,
  0x07, 0x00, 0x30, 0x1C, 0x07, 0x00, 0x70, 0x0C, 0x07, 0x00, 0x70, 0x0E,
  0x06, 0x00, 0x60, 0x0E, 0x0E, 0x00, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0x07,
  0x1C, 0x00, 0xC0, 0x03, 0xFC, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x40, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x3C, 0x78, 0x0E, 0x38, 0x38, 0x0E, 0x78, 0x3C, 0x0E, 0x70, 0x1C,
  0x1E, 0x70, 0x0E, 0x1C, 0xF0, 0x0F, 0x1C, 0xE0, 0x07, 0x1C, 0xE0, 0x07,
  0x9C, 0xE0, 0x03, 0xB8, 0xE0, 0x03, 0xF8, 0xE0, 0x01, 0xF8, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0x70, 0x03, 0xF8, 0x78, 0x03,
  0xBC, 0x7C, 0x0F, 0x9C, 0x3F, 0x7F, 0x1E, 0x1F, 0xFC, 0x0F, 0x0F, 0xF8,
  0x0F, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x30, 0x27, 0xCC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFE, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0E, 0xE0, 0x07, 0x38, 0x03,
  0xC7, 0x01, 0xE0, 0xE0, 0xF0, 0x3C, 0x1C, 0x06, 0x02, 0x01, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1C, 0x38,
  0x71, 0xE3, 0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x27,
  0xBF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x87, 0x81, 0xC0, 0x78,
  0x78, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x1E, 0x70, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x80, 0x1C, 0x70, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x1E,
  0x0F, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x0F,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xF7, 0x1E, 0x73, 0xC7, 0x78, 0x7F, 0x07,
  0x20, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC0,
  0xF8, 0x30, 0x03, 0xC2, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x8F, 0xC0, 0xFC, 0x70, 0x03, 0xC4, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE8, 0x00, 0x3C, 0xE0, 0x07, 0xCF,
  0xE3, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x02, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC7, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x40, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF4, 0x00, 0x3C, 0xC0, 0x0F, 0x1F, 0x9F, 0xE3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7C, 0x04, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F,
  0xC0, 0xE3, 0xFE, 0x0E, 0x7F, 0xF8, 0xEE, 0x07, 0x8E, 0xC0, 0x3C, 0xF8,
  0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E,
  0xF0, 0x00, 0xEF, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01,
  0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xF9,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x07, 0x83, 0xC0, 0x1E,
  0x1E, 0x00, 0x70, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x0F, 0x1C, 0x00, 0x70,
  0xF0, 0x03, 0x83, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xE3,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xF3, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xB8, 0x00, 0x39, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x3E, 0x01, 0xE0, 0xFC,
  0x7E, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0x83, 0xC0,
  0x3C, 0x78, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x03, 0x73, 0xC0, 0x77, 0x1F, 0x9E,
  0x70, 0xFF, 0xC7, 0x07, 0xF8, 0x70, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x03, 0xDF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x67, 0xBF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCF, 0x7F, 0xFF, 0xF0,
  0x18, 0x78, 0xF9, 0xF3, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x30, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xE3, 0x03, 0xE4, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x60,
  0x0E, 0x38, 0x03, 0xFE, 0x0E, 0x30, 0x0F, 0xFE, 0x07, 0x70, 0x0E, 0x0E,
  0x07, 0x70, 0x1C, 0x0E, 0x07, 0x70, 0x1C, 0x0E, 0x07, 0x70, 0x38, 0x1C,
  0x07, 0x60, 0x38, 0x1C, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0, 0x70, 0x1C,
  0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C,
  0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C,
  0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x3C,
  0x07, 0xE0, 0x38, 0x3C, 0x0E, 0xE0, 0x38, 0x3E, 0x0E, 0x70, 0x3C, 0x66,
  0x1C, 0x70, 0x1F, 0xE7, 0xFC, 0x70, 0x0F, 0xC3, 0xF8, 0x70, 0x07, 0x81,
  0xF0, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x02,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0x70, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x70, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0E, 0x07, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3C, 0xE0, 0x01,
  0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x01, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x00, 0x7C, 0xE0, 0x03, 0xCE, 0x00, 0x1E,
  0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0,
  0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xF8, 0x0E, 0x07, 0xC0, 0x08, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xE0, 0x08, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x06,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xE0, 0x0F, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0,
  0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xEE, 0x00,
  0x07, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x3C,
  0x38, 0x01, 0xF0, 0xE0, 0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xC0, 0x3E, 0x07,
  0xC0, 0x01, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x03, 0xE0, 0x03, 0xC0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xF3,
  0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x41, 0xEF, 0xFD, 0xFF, 0x3F, 0x80, 0xE0, 0x00, 0xFE, 0x00, 0x1E,
  0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07,
  0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xE0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE1,
  0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0xEF, 0x80, 0x0E,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xDE, 0x00, 0xF9, 0xE0, 0x0F, 0x0F, 0x00,
  0xE0, 0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00,
  0x77, 0xEE, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00,
  0xE7, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x80, 0x01,
  0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0x80, 0x03,
  0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE1, 0xC0, 0x07,
  0x87, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0xE0, 0x07,
  0x07, 0xE0, 0xF0, 0x0E, 0x07, 0xE0, 0x70, 0x0E, 0x07, 0xE0, 0x70, 0x0E,
  0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0, 0x38, 0x1C,
  0x07, 0xE0, 0x38, 0x3C, 0x07, 0xE0, 0x3C, 0x38, 0x07, 0xE0, 0x1C, 0x38,
  0x07, 0xE0, 0x1C, 0x38, 0x07, 0xE0, 0x1C, 0x70, 0x07, 0xE0, 0x0E, 0x70,
  0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEE, 0x00, 0x0F, 0xDE,
  0x00, 0x1F, 0x9C, 0x00, 0x3F, 0x38, 0x00, 0x7E, 0x38, 0x00, 0xFC, 0x70,
  0x01, 0xF8, 0xF0, 0x03, 0xF0, 0xE0, 0x07, 0xE1, 0xE0, 0x0F, 0xC1, 0xC0,
  0x1F, 0x83, 0xC0, 0x3F, 0x03, 0x80, 0x7E, 0x07, 0x00, 0xFC, 0x0F, 0x01,
  0xF8, 0x0E, 0x03, 0xF0, 0x1E, 0x07, 0xE0, 0x1C, 0x0F, 0xC0, 0x3C, 0x1F,
  0x80, 0x38, 0x3F, 0x00, 0x70, 0x7E, 0x00, 0xF0, 0xFC, 0x00, 0xE1, 0xF8,
  0x01, 0xE3, 0xF0, 0x01, 0xC7, 0xE0, 0x03, 0xCF, 0xC0, 0x03, 0x9F, 0x80,
  0x07, 0x3F, 0x00, 0x0F, 0x7E, 0x00, 0x0E, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x07, 0x81,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E,
  0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x70, 0xFF, 0x8E, 0x01, 0xF9, 0xC0, 0x0F, 0x38, 0x00, 0xF7,
  0x00, 0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x79, 0xC0, 0x1F, 0x38,
  0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x07, 0x81,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0E,
  0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x1C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE0, 0x0F,
  0x8E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0,
  0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCE,
  0x00, 0x78, 0xE0, 0x0F, 0x8E, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0E, 0x0F, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00,
  0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x1E,
  0x3E, 0x00, 0x23, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE8, 0x00, 0x3C, 0xE0, 0x07, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x8E, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x01, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xBC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x71, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1E,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x78,
  0x07, 0x00, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xC0, 0x00, 0xF7, 0x80, 0x03,
  0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0xFC, 0x00,
  0x1C, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x38, 0x00, 0x37, 0x00, 0x0F, 0x1E,
  0x00, 0x3B, 0x80, 0x07, 0x8F, 0x00, 0x1D, 0xC0, 0x03, 0x83, 0x80, 0x0E,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x9C, 0x00,
  0xF0, 0x78, 0x03, 0x8E, 0x00, 0x70, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0xE0, 0x1E, 0x03, 0x80, 0x38,
  0x70, 0x0F, 0x01, 0xE0, 0x38, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x1C, 0x03,
  0x80, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x0E,
  0x03, 0x81, 0xC0, 0xF0, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x01, 0xC1, 0xC0,
  0x70, 0x38, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x0E, 0x1E,
  0x00, 0x3C, 0x38, 0x07, 0x0E, 0x00, 0x1E, 0x38, 0x03, 0x87, 0x00, 0x07,
  0x1C, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x01, 0xC7, 0x00,
  0x39, 0xE0, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x00, 0x79, 0x80, 0x0E, 0x70,
  0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x01, 0x9C, 0x00, 0x07,
  0x70, 0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x7B, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0xC0, 0x0E,
  0x0E, 0x00, 0xF0, 0x70, 0x07, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78,
  0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x80,
  0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E,
  0x07, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x81, 0xC0, 0x1C,
  0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x70, 0x00, 0xF3, 0x80,
  0x07, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xE7, 0x00, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x70, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x07,
  0x81, 0xC0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1E,
  0x00, 0x70, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x70, 0x3C, 0x10, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0xFC, 0x1F, 0xFF, 0x0F,
  0xF1, 0xC7, 0x80, 0x73, 0xC0, 0x1D, 0xE0, 0x07, 0x70, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D,
  0xC0, 0x1F, 0x70, 0x07, 0xDE, 0x03, 0x73, 0xC1, 0x9C, 0xFF, 0xE7, 0x0F,
  0xF1, 0xC0, 0x60, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x0F, 0xC0, 0xE3, 0xFF, 0x0E, 0x7F, 0xF8, 0xE7, 0x07, 0xCE, 0xC0,
  0x3C, 0xEC, 0x01, 0xEF, 0x80, 0x0E, 0xF8, 0x00, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x80, 0x0E, 0xF8, 0x01, 0xEE, 0xC0,
  0x1C, 0xEE, 0x03, 0xCE, 0x78, 0xF8, 0xE3, 0xFF, 0x0E, 0x1F, 0xE0, 0x00,
  0x70, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x01, 0x1F, 0xCF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x3F, 0x07, 0x0F, 0xFC, 0x71,
  0xFF, 0xE7, 0x1E, 0x0F, 0x73, 0xC0, 0x37, 0x38, 0x01, 0xF7, 0x80, 0x1F,
  0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7,
  0x00, 0x1F, 0x78, 0x01, 0xF3, 0x80, 0x37, 0x3C, 0x07, 0x71, 0xF1, 0xE7,
  0x0F, 0xFC, 0x70, 0x7F, 0x87, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x70, 0x07, 0x1E, 0x00,
  0xF3, 0x80, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x04, 0x3C, 0x01, 0x87, 0xE1, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFC, 0x1F, 0xF0, 0x3E,
  0x20, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x7F, 0xF8, 0xFF,
  0xF0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xC7, 0x1F, 0xFE, 0x71, 0xE0, 0x77, 0x3C, 0x03, 0x73, 0x80,
  0x1F, 0x78, 0x01, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x00, 0x0F, 0x70, 0x01, 0xF7, 0x80, 0x1F, 0x38, 0x03, 0x73, 0xC0,
  0x77, 0x1F, 0x1E, 0x70, 0xFF, 0xC7, 0x07, 0xF8, 0x70, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC6, 0x00, 0x7C,
  0x7C, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x5C, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x3F, 0x0E, 0x3F, 0xE3, 0x9F, 0xFC, 0xE7, 0x0F,
  0xBB, 0x00, 0xEE, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x6F, 0xFF, 0xF6, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x0F, 0x0F, 0x0F, 0x0F, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E,
  0x1E, 0xBE, 0xFC, 0xF8, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x2E, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC3,
  0x80, 0xE0, 0xE0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x87, 0x80, 0xE1,
  0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x03, 0x9F, 0x00, 0xEF, 0xC0, 0x3B, 0xB8,
  0x0F, 0xCE, 0x03, 0xE3, 0xC0, 0xF0, 0x70, 0x3C, 0x1E, 0x0E, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x0E, 0x01, 0xE3, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xE1, 0xC7,
  0xFC, 0x1F, 0xF3, 0x9F, 0xF8, 0x7F, 0xE7, 0x70, 0x79, 0xC1, 0xEE, 0xC0,
  0x73, 0x01, 0xDF, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x03, 0xF8, 0x01,
  0xE0, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x0F,
  0x00, 0x3F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70,
  0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00,
  0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F,
  0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC,
  0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0xFC, 0x38, 0xFF, 0xCE, 0x7F, 0xF3, 0x9C, 0x1E,
  0xEC, 0x03, 0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1F, 0x9F, 0x80,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x0E, 0x3F, 0xF0,
  0xE7, 0xFF, 0x8E, 0x70, 0x7C, 0xEC, 0x03, 0xCE, 0xC0, 0x1E, 0xF8, 0x00,
  0xEF, 0x80, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0xF8, 0x00, 0xEF, 0x80, 0x1E, 0xEC, 0x01, 0xCE, 0xE0, 0x3C, 0xE7, 0x9F,
  0x8E, 0x3F, 0xF0, 0xE1, 0xFE, 0x0E, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC7, 0x1F, 0xFE,
  0x71, 0xE0, 0xF7, 0x3C, 0x03, 0x73, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x00,
  0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x01,
  0xF7, 0x80, 0x1F, 0x3C, 0x03, 0x73, 0xC0, 0x77, 0x1F, 0x1E, 0x70, 0xFF,
  0xC7, 0x07, 0xF8, 0x70, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0x1F, 0xF8, 0xFD, 0xCF, 0x2E, 0xE0, 0x76,
  0x03, 0xB0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x1F,
  0xFE, 0x3F, 0xFF, 0x7C, 0x0E, 0x78, 0x02, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0E, 0xC0, 0x1E, 0xFC, 0xFC, 0xFF,
  0xF8, 0x3F, 0xF0, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E,
  0x00, 0xF9, 0x0F, 0xF0, 0x7F, 0x00, 0xC0, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x7D, 0xE0, 0x1F, 0x78, 0x0D,
  0xCF, 0x9F, 0x33, 0xFF, 0x8C, 0x3F, 0xC3, 0x01, 0x80, 0x00, 0xF0, 0x00,
  0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x0F, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C,
  0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0x70, 0x07,
  0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0x60, 0x0E, 0x78, 0x07,
  0x70, 0x0E, 0x38, 0x0E, 0x70, 0x1E, 0x38, 0x0E, 0x70, 0x1C, 0x38, 0x0E,
  0x70, 0x1C, 0x38, 0x0E, 0x30, 0x1C, 0x3C, 0x0E, 0x38, 0x1C, 0x1C, 0x1C,
  0x38, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x1C,
  0x1C, 0x38, 0x0E, 0x18, 0x1C, 0x78, 0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x38,
  0x1C, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x70, 0x07, 0x30,
  0x0E, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x07, 0x70,
  0x0E, 0xE0, 0x07, 0x70, 0x06, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0,
  0x03, 0x80, 0x70, 0x01, 0xEF, 0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x01, 0xC1,
  0xC0, 0x78, 0x3C, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x07, 0x1E, 0x00,
  0xE3, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x70, 0x70, 0x1E,
  0x0F, 0x03, 0x80, 0xE0, 0xF0, 0x1E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0,
  0x07, 0x9C, 0x00, 0x77, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x70,
  0x01, 0xE7, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x80, 0x1C, 0x38, 0x03, 0xC3,
  0x80, 0x3C, 0x38, 0x03, 0x83, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x79,
  0xC0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x09, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x04, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xF8, 0x3F, 0x9F, 0xC0, 0x3F,
  0xFA, 0x00, 0x3F, 0xC8, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 44, 13, 4, -44 },
  { 29, 13, 16, 21, 4, -44 },
  { 55, 25, 44, 27, 1, -44 },
  { 193, 21, 50, 25, 2, -46 },
  { 325, 32, 45, 38, 3, -44 },
  { 505, 24, 45, 26, 2, -44 },
  { 640, 4, 16, 11, 4, -44 },
  { 648, 12, 54, 17, 3, -44 },
  { 729, 12, 54, 17, 2, -44 },
  { 810, 18, 18, 22, 2, -46 },
  { 851, 21, 29, 25, 2, -36 },
  { 928, 7, 15, 12, 2, -7 },
  { 942, 13, 3, 16, 2, -18 },
  { 947, 5, 6, 12, 4, -6 },
  { 951, 19, 44, 21, 1, -44 },
  { 1056, 19, 44, 25, 3, -44 },
  { 1161, 12, 44, 25, 4, -44 },
  { 1227, 20, 44, 25, 2, -44 },
  { 1337, 20, 45, 25, 2, -44 },
  { 1450, 23, 44, 25, 1, -44 },
  { 1577, 19, 45, 25, 3, -44 },
  { 1684, 20, 45, 25, 3, -44 },
  { 1797, 20, 44, 25, 2, -44 },
  { 1907, 21, 45, 25, 2, -44 },
  { 2026, 20, 45, 25, 2, -44 },
  { 2139, 5, 33, 12, 4, -33 },
  { 2160, 7, 41, 12, 2, -33 },
  { 2196, 21, 26, 25, 2, -35 },
  { 2265, 21, 15, 25, 2, -29 },
  { 2305, 21, 26, 25, 2, -35 },
  { 2374, 15, 44, 18, 1, -44 },
  { 2457, 32, 49, 38, 3, -44 },
  { 2653, 25, 44, 25, 0, -44 },
  { 2791, 20, 44, 28, 5, -44 },
  { 2901, 22, 45, 26, 3, -44 },
  { 3025, 22, 44, 30, 5, -44 },
  { 3146, 16, 44, 24, 5, -44 },
  { 3234, 16, 44, 22, 5, -44 },
  { 3322, 26, 45, 33, 3, -44 },
  { 3469, 22, 44, 31, 5, -44 },
  { 3590, 11, 44, 15, 2, -44 },
  { 3651, 11, 55, 13, -3, -44 },
  { 3727, 20, 44, 25, 5, -44 },
  { 3837, 16, 44, 22, 5, -44 },
  { 3925, 32, 44, 42, 5, -44 },
  { 4101, 23, 44, 33, 5, -44 },
  { 4228, 26, 45, 32, 3, -44 },
  { 4375, 19, 44, 26, 5, -44 },
  { 4480, 26, 54, 32, 3, -44 },
  { 4656, 20, 44, 26, 5, -44 },
  { 4766, 20, 45, 24, 2, -44 },
  { 4879, 20, 44, 22, 1, -44 },
  { 4989, 23, 45, 31, 4, -44 },
  { 5119, 25, 44, 25, 0, -44 },
  { 5257, 41, 44, 42, 0, -44 },
  { 5483, 21, 44, 22, 1, -44 },
  { 5599, 22, 44, 22, 0, -44 },
  { 5720, 18, 44, 21, 2, -44 },
  { 5819, 12, 54, 19, 5, -44 },
  { 5900, 19, 44, 21, 1, -44 },
  { 6005, 12, 54, 19, 2, -44 },
  { 6086, 24, 23, 26, 1, -44 },
  { 6155, 25, 3, 25, 0, 5 },
  { 6165, 11, 10, 15, 2, -47 },
  { 6179, 18, 34, 24, 2, -33 },
  { 6256, 20, 47, 27, 4, -46 },
  { 6374, 16, 34, 20, 3, -33 },
  { 6442, 20, 47, 27, 3, -46 },
  { 6560, 19, 34, 24, 3, -33 },
  { 6641, 15, 47, 14, 1, -47 },
  { 6730, 20, 48, 27, 3, -33 },
  { 6850, 18, 46, 26, 4, -46 },
  { 6954, 4, 45, 12, 4, -45 },
  { 6977, 8, 60, 12, 0, -45 },
  { 7037, 18, 46, 22, 4, -46 },
  { 7141, 3, 46, 12, 4, -46 },
  { 7159, 31, 33, 39, 4, -33 },
  { 7287, 18, 33, 26, 4, -33 },
  { 7362, 20, 34, 26, 3, -33 },
  { 7447, 20, 47, 27, 4, -33 },
  { 7565, 20, 47, 27, 3, -33 },
  { 7683, 13, 33, 17, 4, -33 },
  { 7737, 16, 34, 20, 2, -33 },
  { 7805, 12, 41, 14, 1, -40 },
  { 7867, 18, 33, 26, 4, -32 },
  { 7942, 20, 32, 20, 0, -32 },
  { 8022, 32, 32, 34, 1, -32 },
  { 8150, 19, 32, 21, 1, -32 },
  { 8226, 20, 47, 21, 1, -32 },
  { 8344, 14, 32, 17, 2, -32 },
  { 8400, 16, 54, 22, 3, -44 },
  { 8508, 3, 61, 24, 10, -46 },
  { 8531, 16, 54, 22, 3, -44 },
  { 8639, 22, 7, 25, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Light61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT61PT7B_H_
