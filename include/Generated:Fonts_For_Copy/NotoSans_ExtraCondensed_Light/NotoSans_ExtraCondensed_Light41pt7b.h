#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xB6, 0xDB, 0x64, 0x00, 0x1B, 0xFE,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x02, 0x0C,
  0x06, 0x0C, 0x06, 0x0C, 0x06, 0x08, 0x06, 0x08, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x10,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30, 0x08, 0x30, 0xFF, 0xFE,
  0xFF, 0xFE, 0x18, 0x30, 0x18, 0x20, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x10, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x03, 0xFC, 0x3F, 0xFC, 0xC4, 0x26, 0x10, 0x18, 0x40, 0x61, 0x03,
  0x04, 0x06, 0x10, 0x18, 0x40, 0x61, 0x00, 0xC4, 0x01, 0xD0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x13, 0x80, 0x47, 0x01, 0x0C, 0x04, 0x30, 0x10,
  0xC0, 0x43, 0x01, 0x0C, 0x04, 0x34, 0x11, 0x9F, 0x7C, 0x7F, 0xE0, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x18, 0x00, 0x80, 0xF8, 0x0C, 0x06,
  0x60, 0x30, 0x30, 0xC0, 0xC0, 0xC3, 0x06, 0x03, 0x0C, 0x18, 0x0C, 0x30,
  0x60, 0x30, 0x43, 0x00, 0xC1, 0x0C, 0x03, 0x06, 0x30, 0x0C, 0x11, 0x80,
  0x30, 0x46, 0x00, 0xC3, 0x18, 0xE3, 0x0C, 0xCF, 0xCC, 0x33, 0x31, 0x90,
  0xCC, 0x86, 0x66, 0x66, 0x18, 0xF9, 0x98, 0x61, 0x86, 0x60, 0x80, 0x31,
  0x83, 0x00, 0xC6, 0x0C, 0x03, 0x18, 0x30, 0x18, 0x60, 0xC0, 0x61, 0x83,
  0x01, 0x86, 0x18, 0x0C, 0x18, 0x60, 0x30, 0x61, 0x80, 0xC0, 0xC6, 0x06,
  0x03, 0xB0, 0x18, 0x07, 0x80, 0x03, 0x00, 0x07, 0xE0, 0x07, 0x30, 0x03,
  0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x30, 0xC0, 0x18, 0x60,
  0x0C, 0x30, 0x06, 0x30, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x3E, 0x00, 0x3B, 0x80, 0x18, 0xC1, 0x98, 0x71, 0xCC, 0x18, 0xCE,
  0x06, 0x67, 0x03, 0xB3, 0x00, 0xF9, 0xC0, 0x78, 0xE0, 0x1C, 0x30, 0x0E,
  0x18, 0x0F, 0x8E, 0x0E, 0xC3, 0xFE, 0x70, 0xFC, 0x1C, 0xFF, 0xFF, 0xF0,
  0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0xE0,
  0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0xE0, 0x06, 0x00,
  0xC0, 0x18, 0x42, 0x1E, 0x4F, 0xFF, 0xC3, 0x80, 0x58, 0x1B, 0x06, 0x31,
  0xC3, 0x10, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x77, 0x66, 0x6E, 0xCC, 0xC0, 0xFF, 0xFF, 0xC0, 0xDF,
  0xF0, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0xFE, 0x0F, 0x78, 0x60, 0xC7, 0x07, 0x30, 0x19, 0x80,
  0xDC, 0x06, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x80, 0xFC, 0x06, 0x60, 0x33, 0x01, 0x9C, 0x18, 0x71, 0xC1, 0xFC,
  0x07, 0xC0, 0x07, 0x0F, 0x1F, 0x3B, 0x73, 0xE3, 0x43, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x03, 0xFE, 0x3E, 0xF8,
  0x80, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xFF, 0x8F,
  0x9F, 0x18, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x80, 0xF8, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x90, 0x1C, 0x7F, 0xF1, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x81,
  0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x70, 0x30, 0xC0, 0x61, 0x80,
  0xC6, 0x01, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x7F, 0xF3, 0xFF, 0x98,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x9E, 0x0F, 0xFC, 0x30, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0xA0, 0x39, 0xFF, 0x87, 0xF8, 0x00, 0x00, 0xC0, 0x3F, 0x83,
  0xCC, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x7C, 0x6F, 0xF3, 0x41, 0xDC, 0x06, 0xE0, 0x3F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0x60,
  0x1B, 0x01, 0xDC, 0x0C, 0x60, 0xE3, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0x80, 0x3F,
  0x81, 0xC7, 0x0E, 0x0E, 0x70, 0x19, 0xC0, 0x76, 0x00, 0xD8, 0x03, 0x60,
  0x1D, 0xC0, 0x63, 0x01, 0x8E, 0x0C, 0x1C, 0x70, 0x3F, 0x80, 0x38, 0x03,
  0xF0, 0x1C, 0xE0, 0xE0, 0xC3, 0x01, 0x98, 0x07, 0x60, 0x0D, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0x60, 0x0D, 0x80, 0x37, 0x01, 0xCE, 0x0E, 0x3F, 0xF0,
  0x3F, 0x80, 0x07, 0x00, 0xFE, 0x0F, 0x70, 0xC0, 0xCE, 0x07, 0x60, 0x1B,
  0x00, 0xD8, 0x06, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0xEC, 0x0B, 0x70, 0xD9, 0xFC, 0xC7, 0xCE, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x87,
  0xF8, 0x3F, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x7F, 0xC0,
  0x67, 0x77, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0x76, 0x6E,
  0xCC, 0xC0, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x00, 0xC0, 0x00, 0x18, 0x3F, 0xCE, 0x7A, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x38,
  0x78, 0x01, 0x80, 0x70, 0x0C, 0x00, 0x60, 0x60, 0x01, 0xC3, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x19, 0x81, 0xF8, 0x66, 0x0E, 0x61, 0x98,
  0x71, 0x82, 0x41, 0x86, 0x0F, 0x06, 0x18, 0x3C, 0x30, 0x60, 0xF0, 0xC1,
  0x83, 0xC3, 0x06, 0x0F, 0x0C, 0x18, 0x3C, 0x30, 0x60, 0xF0, 0xC1, 0x83,
  0xC3, 0x0E, 0x1B, 0x0C, 0x28, 0x6C, 0x18, 0xA1, 0x98, 0x76, 0xDC, 0x60,
  0xF1, 0xE1, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x10, 0x03, 0xC1, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x19, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18,
  0x03, 0x8C, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x38,
  0x38, 0x18, 0x0C, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0x01, 0xC3, 0x00, 0x61,
  0x80, 0x30, 0xC0, 0x18, 0xE0, 0x0E, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00,
  0xDC, 0x00, 0x7E, 0x00, 0x38, 0xFF, 0xC3, 0xFF, 0xCC, 0x07, 0x30, 0x0E,
  0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03,
  0xB0, 0x0C, 0xC1, 0xE3, 0xFE, 0x0F, 0xFE, 0x30, 0x1C, 0xC0, 0x1B, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1B, 0x00, 0xEC, 0x07, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xE0, 0x0F, 0xFC,
  0x3E, 0x70, 0xE0, 0x21, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x20, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0xC3, 0x01, 0xC6, 0x01,
  0xCC, 0x01, 0x98, 0x03, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0, 0x03,
  0x60, 0x0E, 0xC0, 0x39, 0x80, 0x63, 0x03, 0xC7, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0xC0, 0x7C, 0xF8, 0x38, 0x06, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D,
  0xC0, 0x07, 0x30, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x07, 0x07,
  0xFF, 0xC0, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x7E, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1F, 0xF7, 0xE3,
  0x00, 0xC0, 0x1F, 0x00, 0xEC, 0x03, 0x30, 0x18, 0xC0, 0xE3, 0x03, 0x0C,
  0x1C, 0x30, 0x60, 0xC3, 0x83, 0x0C, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03,
  0x78, 0x0D, 0xE0, 0x3D, 0xC0, 0xE3, 0x03, 0x8E, 0x0C, 0x18, 0x30, 0x70,
  0xC0, 0xC3, 0x03, 0x0C, 0x0E, 0x30, 0x18, 0xC0, 0x73, 0x00, 0xCC, 0x03,
  0xB0, 0x06, 0xC0, 0x1C, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xD8, 0x00, 0x6F, 0x60, 0x01,
  0xBD, 0x80, 0x06, 0xF3, 0x00, 0x3B, 0xCC, 0x00, 0xCF, 0x30, 0x03, 0x3C,
  0xE0, 0x0C, 0xF1, 0x80, 0x63, 0xC6, 0x01, 0x8F, 0x18, 0x06, 0x3C, 0x30,
  0x30, 0xF0, 0xC0, 0xC3, 0xC3, 0x03, 0x0F, 0x0E, 0x0C, 0x3C, 0x18, 0x60,
  0xF0, 0x61, 0x83, 0xC1, 0x86, 0x0F, 0x03, 0x30, 0x3C, 0x0C, 0xC0, 0xF0,
  0x33, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x30, 0x0C, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xD8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xCE, 0x03, 0xC6, 0x03,
  0xC7, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0xC3,
  0xC0, 0xC3, 0xC0, 0xE3, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x33,
  0xC0, 0x3B, 0xC0, 0x1B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x70, 0x38, 0x38,
  0x07, 0x0C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0E, 0x60, 0x01, 0x98, 0x00,
  0x6E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x0E, 0x70, 0x03, 0x0C, 0x01,
  0xC3, 0x80, 0x60, 0x70, 0x38, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x87,
  0xFF, 0x30, 0x3D, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0x60, 0x3B, 0x07, 0x9F, 0xF8,
  0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x0C, 0x00, 0xC7,
  0x00, 0x31, 0x80, 0x0E, 0x60, 0x01, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x80,
  0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x19, 0xC0, 0x0E, 0x70, 0x03, 0x0C, 0x01, 0xC3, 0x80, 0x60, 0x70,
  0x38, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0xFF, 0x83,
  0xFF, 0x8C, 0x0F, 0x30, 0x1C, 0xC0, 0x33, 0x00, 0xEC, 0x01, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0xEC, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x03, 0x8F, 0xFC,
  0x3F, 0xE0, 0xC3, 0x03, 0x0E, 0x0C, 0x18, 0x30, 0x70, 0xC0, 0xC3, 0x03,
  0x8C, 0x06, 0x30, 0x1C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0xB0, 0x06, 0xC0,
  0x1C, 0x07, 0x80, 0xFF, 0x8F, 0xBC, 0xE0, 0x2E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1D, 0x01, 0xCF, 0xFC,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x0C, 0xC0, 0x39, 0xC0, 0xE1, 0xFF, 0xC1, 0xFE, 0x00,
  0xE0, 0x03, 0xF0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x80,
  0x30, 0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0C, 0x1C, 0x06, 0x06, 0x03, 0x03,
  0x01, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x30, 0x0C, 0x38,
  0x06, 0x18, 0x03, 0x8C, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x00, 0x1D,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x76, 0x00, 0x60, 0x06, 0x60, 0x0F, 0x00,
  0x66, 0x00, 0xF0, 0x06, 0x60, 0x0F, 0x00, 0x67, 0x00, 0xF0, 0x0E, 0x30,
  0x0F, 0x00, 0xC3, 0x01, 0x98, 0x0C, 0x30, 0x19, 0x80, 0xC3, 0x81, 0x98,
  0x1C, 0x38, 0x19, 0x81, 0xC1, 0x81, 0x98, 0x18, 0x18, 0x30, 0xC1, 0x81,
  0x83, 0x0C, 0x18, 0x1C, 0x30, 0xC3, 0x80, 0xC3, 0x0C, 0x38, 0x0C, 0x30,
  0xC3, 0x00, 0xC6, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0xE6, 0x06, 0x70,
  0x06, 0x60, 0x66, 0x00, 0x66, 0x06, 0x60, 0x06, 0xC0, 0x36, 0x00, 0x6C,
  0x03, 0x60, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x60, 0x38,
  0xE0, 0x60, 0xC0, 0xC1, 0x83, 0x83, 0x86, 0x03, 0x0C, 0x06, 0x38, 0x06,
  0x60, 0x0C, 0xC0, 0x1B, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x07, 0xC0, 0x0D, 0x80, 0x19, 0x80, 0x63, 0x00, 0xC7, 0x03,
  0x86, 0x06, 0x0C, 0x0C, 0x1C, 0x30, 0x18, 0x60, 0x31, 0xC0, 0x73, 0x00,
  0x6E, 0x00, 0xE0, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC3, 0x01,
  0x86, 0x07, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x70, 0x38, 0xC0, 0x31, 0x80,
  0x67, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x06, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x38,
  0x30, 0x18, 0x30, 0x1C, 0x60, 0x0C, 0x60, 0x0E, 0xC0, 0x06, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0xE1, 0x83, 0x0E, 0x18, 0x30, 0x1F, 0xC3, 0xFE, 0x10,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x3F, 0x1F,
  0xF3, 0xC3, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x36, 0x03, 0x60,
  0x77, 0x07, 0x39, 0x91, 0xF1, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x3E, 0x37, 0xF9, 0xA0,
  0xEE, 0x03, 0x70, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x0F, 0xC0, 0x6F, 0x07, 0x6F, 0xF3, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0xE0,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0xFE, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xFC, 0xCF, 0xF6, 0x60, 0xF7, 0x03,
  0xB0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xD8, 0x0E, 0xC0,
  0x77, 0x07, 0x9F, 0xE4, 0x7E, 0x20, 0x0F, 0x81, 0xFE, 0x0C, 0x18, 0xC0,
  0xE6, 0x03, 0x70, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x23, 0xFF, 0x07, 0xF0, 0x07, 0xE1, 0xF8, 0x30, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0xF3, 0xFE, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x1F, 0x89, 0xFE, 0xCC, 0x1E, 0xE0, 0x76, 0x03, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xE0, 0x1B, 0x01, 0xD8, 0x0E, 0xE0, 0xF3, 0xFD, 0x8F,
  0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x03,
  0x30, 0x79, 0xFF, 0x83, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xFC, 0xDF, 0xED, 0x0E, 0xE0,
  0x7E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x30, 0xDF, 0x60, 0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0x80, 0x18, 0x71, 0x86, 0x00, 0x00, 0x00, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xEF, 0x38, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x06, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x30, 0xC3, 0x0C, 0x60, 0xCE, 0x0C,
  0xC0, 0xDC, 0x0D, 0x60, 0xF6, 0x0E, 0x70, 0xC3, 0x0C, 0x38, 0xC1, 0x8C,
  0x18, 0xC1, 0xCC, 0x0C, 0xC0, 0xEC, 0x06, 0xC0, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0x87, 0xC6, 0xFE, 0x7F, 0x3C, 0x3A,
  0x1D, 0xC0, 0xF0, 0x6E, 0x07, 0x03, 0xE0, 0x38, 0x1F, 0x01, 0xC0, 0xF8,
  0x0C, 0x03, 0xC0, 0x60, 0x1E, 0x03, 0x00, 0xF0, 0x18, 0x07, 0x80, 0xC0,
  0x3C, 0x06, 0x01, 0xE0, 0x30, 0x0F, 0x01, 0x80, 0x78, 0x0C, 0x03, 0xC0,
  0x60, 0x1E, 0x03, 0x00, 0xF0, 0x18, 0x07, 0x80, 0xC0, 0x3C, 0x06, 0x01,
  0xE0, 0x30, 0x0C, 0xCF, 0xCD, 0xFE, 0xD0, 0x6E, 0x07, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x0F, 0xC0, 0xFF, 0x83, 0x07, 0x1C, 0x0C, 0x60, 0x3B, 0x80, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xE0, 0x19, 0x80, 0xE6, 0x03, 0x0C, 0x1C, 0x3F,
  0xE0, 0x7F, 0x00, 0xCF, 0xC6, 0xFF, 0x34, 0x1D, 0xE0, 0x6E, 0x03, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0D, 0xA0, 0xED,
  0xFE, 0x67, 0xE3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x0F, 0x89, 0xFE, 0xCE, 0x1E,
  0xE0, 0x76, 0x03, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1B, 0x01,
  0xD8, 0x0E, 0xE0, 0xF3, 0xFD, 0x8F, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xCF,
  0xDF, 0xD8, 0xF0, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0xC7, 0xFD,
  0xC1, 0x30, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x03, 0xE0,
  0x6F, 0xFC, 0xFF, 0x00, 0x30, 0x30, 0x30, 0x30, 0x30, 0x7F, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFE,
  0x0B, 0x7F, 0xB3, 0xF3, 0xE0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x76, 0x03,
  0x38, 0x18, 0xC0, 0xC6, 0x0E, 0x30, 0x61, 0xC3, 0x06, 0x18, 0x30, 0xC1,
  0x8C, 0x0C, 0x60, 0x33, 0x01, 0x98, 0x0D, 0x80, 0x6C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xC0, 0x70, 0x19, 0x80, 0xE0,
  0x33, 0x01, 0x40, 0x67, 0x06, 0xC1, 0xC6, 0x0D, 0x83, 0x0C, 0x1B, 0x06,
  0x18, 0x36, 0x0C, 0x30, 0x64, 0x18, 0x71, 0x8C, 0x60, 0x63, 0x18, 0xC0,
  0xC6, 0x31, 0x81, 0x8C, 0x63, 0x03, 0x30, 0x66, 0x03, 0x60, 0xD8, 0x06,
  0xC1, 0xB0, 0x0D, 0x83, 0x60, 0x1B, 0x06, 0xC0, 0x34, 0x05, 0x80, 0x38,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x36, 0x07, 0x60,
  0x63, 0x0E, 0x30, 0xC3, 0x8C, 0x19, 0x81, 0xD8, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x19, 0x81, 0x9C, 0x30, 0xC3, 0x0C, 0x70,
  0x66, 0x06, 0xE0, 0x7C, 0x03, 0x60, 0x1D, 0x80, 0x66, 0x01, 0x9C, 0x06,
  0x30, 0x38, 0xC0, 0xC3, 0x03, 0x0E, 0x0C, 0x18, 0x30, 0x61, 0x81, 0x86,
  0x07, 0x18, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x02, 0x70, 0x0F, 0x80, 0x3C,
  0x00, 0x7F, 0x9F, 0xE0, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06,
  0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0xFC, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x78, 0x1C, 0x03, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xF8, 0x0F, 0x80, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0x30, 0x07, 0x80, 0x3C, 0x0F, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x0F, 0x03, 0xC0, 0x40, 0x00, 0x18, 0x00, 0xFE, 0x07,
  0x9F, 0x3C, 0x0F, 0xE8, 0x03, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 8, 10, 14, 3, -29 },
  { 22, 16, 29, 18, 1, -29 },
  { 80, 14, 33, 17, 1, -31 },
  { 138, 22, 30, 25, 2, -30 },
  { 221, 17, 30, 18, 1, -30 },
  { 285, 2, 10, 8, 3, -29 },
  { 288, 8, 35, 11, 2, -29 },
  { 323, 8, 35, 11, 1, -29 },
  { 358, 11, 12, 15, 2, -31 },
  { 375, 15, 19, 17, 1, -24 },
  { 411, 4, 9, 8, 2, -4 },
  { 416, 9, 2, 11, 1, -12 },
  { 419, 3, 4, 8, 3, -4 },
  { 421, 13, 29, 14, 1, -29 },
  { 469, 13, 30, 17, 2, -30 },
  { 518, 8, 29, 17, 3, -29 },
  { 547, 13, 30, 17, 2, -30 },
  { 596, 14, 30, 17, 1, -30 },
  { 649, 15, 29, 17, 1, -29 },
  { 704, 13, 29, 17, 2, -29 },
  { 752, 13, 30, 17, 2, -30 },
  { 801, 13, 29, 17, 2, -29 },
  { 849, 14, 30, 17, 1, -30 },
  { 902, 13, 30, 17, 2, -30 },
  { 951, 3, 22, 8, 3, -22 },
  { 960, 4, 27, 8, 2, -22 },
  { 974, 15, 17, 17, 1, -23 },
  { 1006, 15, 11, 17, 1, -20 },
  { 1027, 15, 17, 17, 1, -23 },
  { 1059, 10, 30, 12, 1, -30 },
  { 1097, 22, 34, 26, 2, -30 },
  { 1191, 17, 29, 17, 0, -29 },
  { 1253, 14, 29, 19, 3, -29 },
  { 1304, 15, 30, 18, 2, -30 },
  { 1361, 15, 29, 20, 3, -29 },
  { 1416, 11, 29, 16, 3, -29 },
  { 1456, 11, 29, 15, 3, -29 },
  { 1496, 18, 30, 22, 2, -30 },
  { 1564, 15, 29, 21, 3, -29 },
  { 1619, 8, 29, 10, 1, -29 },
  { 1648, 7, 37, 8, -2, -29 },
  { 1681, 14, 29, 17, 3, -29 },
  { 1732, 11, 29, 15, 3, -29 },
  { 1772, 22, 29, 28, 3, -29 },
  { 1852, 16, 29, 22, 3, -29 },
  { 1910, 18, 30, 22, 2, -30 },
  { 1978, 13, 29, 17, 3, -29 },
  { 2026, 18, 37, 22, 2, -30 },
  { 2110, 14, 29, 18, 3, -29 },
  { 2161, 13, 30, 16, 2, -30 },
  { 2210, 14, 29, 15, 0, -29 },
  { 2261, 15, 29, 21, 3, -29 },
  { 2316, 17, 29, 17, 0, -29 },
  { 2378, 28, 29, 28, 0, -29 },
  { 2480, 15, 29, 15, 0, -29 },
  { 2535, 15, 29, 15, 0, -29 },
  { 2590, 12, 29, 14, 1, -29 },
  { 2634, 8, 36, 13, 3, -29 },
  { 2670, 13, 29, 14, 1, -29 },
  { 2718, 8, 36, 13, 1, -29 },
  { 2754, 16, 15, 17, 1, -29 },
  { 2784, 17, 1, 17, 0, 4 },
  { 2787, 6, 6, 10, 2, -31 },
  { 2792, 12, 22, 16, 1, -22 },
  { 2825, 13, 31, 18, 3, -31 },
  { 2876, 11, 22, 14, 2, -22 },
  { 2907, 13, 31, 18, 2, -31 },
  { 2958, 13, 22, 16, 2, -22 },
  { 2994, 11, 31, 10, 0, -31 },
  { 3037, 13, 32, 18, 2, -22 },
  { 3089, 12, 31, 18, 3, -31 },
  { 3136, 3, 30, 8, 3, -30 },
  { 3148, 6, 40, 8, 0, -30 },
  { 3178, 12, 31, 15, 3, -31 },
  { 3225, 2, 31, 8, 3, -31 },
  { 3233, 21, 22, 26, 3, -22 },
  { 3291, 12, 22, 18, 3, -22 },
  { 3324, 14, 22, 17, 2, -22 },
  { 3363, 13, 32, 18, 3, -22 },
  { 3415, 13, 32, 18, 2, -22 },
  { 3467, 8, 22, 12, 3, -22 },
  { 3489, 11, 22, 13, 1, -22 },
  { 3520, 8, 27, 10, 1, -27 },
  { 3547, 12, 22, 18, 3, -22 },
  { 3580, 13, 22, 14, 0, -22 },
  { 3616, 23, 22, 23, 0, -22 },
  { 3680, 12, 22, 14, 1, -22 },
  { 3713, 14, 32, 14, 0, -22 },
  { 3769, 10, 22, 12, 1, -22 },
  { 3797, 11, 36, 15, 2, -29 },
  { 3847, 2, 41, 16, 7, -31 },
  { 3858, 11, 36, 15, 2, -29 },
  { 3908, 15, 5, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Light41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT41PT7B_H_
