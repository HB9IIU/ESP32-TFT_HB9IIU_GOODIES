#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light63pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70, 0x00, 0x00,
  0x00, 0x06, 0x7F, 0xFF, 0xF7, 0x80, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0x80, 0xEC, 0x07, 0x00, 0x70, 0x1C, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00,
  0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFD, 0xFC, 0x3E, 0x30, 0x70,
  0xE0, 0xC0, 0x07, 0x83, 0x00, 0x1C, 0x0C, 0x00, 0xF0, 0x30, 0x03, 0x80,
  0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0xC0, 0xC0,
  0x07, 0x03, 0x00, 0x1E, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0xF8, 0xC0, 0x01,
  0xFB, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x33, 0xE0, 0x00, 0xC3, 0xC0, 0x03, 0x07,
  0x80, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xF0, 0x03, 0x01, 0xC0,
  0x0C, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0xF0, 0x03, 0x03, 0x80, 0x0C,
  0x1E, 0x80, 0x30, 0x73, 0x80, 0xC7, 0xCF, 0xE3, 0xFE, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x0F, 0xF8, 0x00, 0xE0, 0x07, 0x1C,
  0x00, 0x70, 0x07, 0x07, 0x00, 0x70, 0x03, 0x83, 0x80, 0x38, 0x03, 0x81,
  0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x70,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x03, 0x80, 0x0E,
  0x03, 0x81, 0xC0, 0x07, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0xE0, 0xE0, 0x01,
  0xC0, 0x70, 0x70, 0x00, 0xE0, 0x38, 0x70, 0x00, 0x70, 0x1C, 0x38, 0x00,
  0x38, 0x0E, 0x1C, 0x1C, 0x1C, 0x07, 0x1C, 0x3F, 0x8E, 0x03, 0x8E, 0x3F,
  0xE7, 0x01, 0x87, 0x1C, 0x71, 0x81, 0xC7, 0x1C, 0x1C, 0xE0, 0xE3, 0x8E,
  0x0E, 0x70, 0x71, 0xC6, 0x03, 0x1C, 0x71, 0xC7, 0x01, 0xCF, 0xF0, 0xE3,
  0x80, 0xE3, 0xF8, 0x71, 0xC0, 0x70, 0x30, 0x70, 0xE0, 0x38, 0x00, 0x38,
  0x70, 0x1C, 0x00, 0x1C, 0x38, 0x0E, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x0E,
  0x0E, 0x03, 0x80, 0x07, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0xE0, 0x03,
  0x81, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0xE0, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x03, 0x00,
  0x38, 0x03, 0x83, 0x80, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x71, 0xC0,
  0x0E, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x0F, 0x03,
  0xC7, 0x03, 0x81, 0xE7, 0x81, 0xE0, 0xF3, 0x80, 0x70, 0x73, 0xC0, 0x3C,
  0x39, 0xE0, 0x0E, 0x1C, 0xE0, 0x07, 0x9E, 0x78, 0x01, 0xEE, 0x38, 0x00,
  0x77, 0x1C, 0x00, 0x3F, 0x8E, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xE1, 0xE0, 0x01, 0xF0, 0x78, 0x01, 0xFC, 0x3C, 0x01, 0xEF, 0x0F,
  0x01, 0xE7, 0x87, 0xFF, 0xE1, 0xE1, 0xFF, 0xE0, 0x70, 0x7F, 0xE0, 0x3C,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x66, 0x00,
  0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x1C,
  0x3B, 0xF3, 0x3E, 0xFF, 0xFF, 0xC7, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0x70, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0x70, 0x78, 0x3C, 0x0F, 0x0E,
  0x03, 0x80, 0x80, 0x40, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0x87, 0x0E,
  0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xF0, 0x1E, 0x07, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0xC3,
  0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x3C, 0x03,
  0xC1, 0xE0, 0x38, 0x1F, 0x07, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7F,
  0x87, 0xBC, 0x79, 0xE7, 0x8F, 0xF8, 0x7B, 0x83, 0xC8, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0x80, 0x7C, 0x18, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xE0, 0xFF, 0x7F, 0x8F, 0x80, 0x7C, 0x38, 0x00, 0xF0, 0x80,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF4, 0x00, 0x0F, 0x18, 0x01, 0xF0,
  0xFE, 0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x78,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x00, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x80, 0x07, 0xCE, 0x00, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x0F, 0xC0, 0xE3, 0xFF, 0x0E, 0x7F, 0xF8, 0xE7,
  0x07, 0xCE, 0xE0, 0x3C, 0xEC, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xEF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xC1, 0xE0, 0x3C, 0x0F, 0xDF, 0x80, 0x7F, 0xF0, 0x03,
  0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFB, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00,
  0x1C, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x3C, 0x1C,
  0x00, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xE3, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xDF, 0x00,
  0x3E, 0x1E, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7,
  0x00, 0x03, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xE0,
  0x1E, 0x07, 0xF3, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xE0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00,
  0xE3, 0x80, 0x07, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x78,
  0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03,
  0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0,
  0x03, 0xE7, 0x80, 0x3F, 0x3C, 0x03, 0xF8, 0xF8, 0x3B, 0xC3, 0xFF, 0x9E,
  0x0F, 0xF8, 0xE0, 0x3F, 0x87, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F,
  0xFF, 0xFB, 0x80, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3, 0xC2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xC3, 0x87,
  0x1C, 0x38, 0x71, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0x60, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x07, 0x0E, 0x00, 0xFF,
  0xC1, 0xC3, 0x80, 0x7F, 0xE0, 0x39, 0xC0, 0x3C, 0x38, 0x0E, 0x70, 0x0E,
  0x0E, 0x03, 0x9C, 0x07, 0x03, 0x80, 0xE7, 0x01, 0xC0, 0xE0, 0x39, 0xC0,
  0xE0, 0x38, 0x0E, 0x70, 0x38, 0x0E, 0x03, 0xB8, 0x0E, 0x03, 0x80, 0x7E,
  0x03, 0x80, 0xE0, 0x1F, 0x80, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x0E, 0x01,
  0xF8, 0x0E, 0x03, 0x80, 0xEE, 0x03, 0x80, 0xE0, 0x3B, 0x80, 0xE0, 0x38,
  0x0E, 0xE0, 0x38, 0x0E, 0x03, 0xB8, 0x0E, 0x07, 0x80, 0xEE, 0x03, 0x81,
  0xE0, 0x3B, 0x80, 0xE0, 0x78, 0x0E, 0x70, 0x38, 0x1E, 0x07, 0x1C, 0x0F,
  0x0D, 0xC1, 0xC7, 0x01, 0xC7, 0x30, 0xE1, 0xC0, 0x7F, 0xCF, 0xF8, 0x70,
  0x0F, 0xE1, 0xFC, 0x1E, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x10, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xC0, 0x1F, 0x8E, 0x00, 0x3E, 0x70, 0x00, 0xF3, 0x80, 0x03,
  0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0xF1, 0xC0, 0x1F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x1C, 0x00, 0xF8, 0xE0, 0x01, 0xE7,
  0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x03,
  0xDC, 0x00, 0x3E, 0xE0, 0x03, 0xE7, 0x00, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3E, 0x00, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x30, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0x00, 0xFE, 0x0E, 0x00, 0x7C, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78, 0xE0, 0x00, 0x79, 0xC0,
  0x00, 0xF3, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00,
  0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x38, 0x00,
  0x7C, 0x70, 0x01, 0xF0, 0xE0, 0x07, 0xC1, 0xC0, 0x3F, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x3C,
  0x0F, 0x80, 0x01, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E,
  0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0F, 0x80,
  0x00, 0xE0, 0xF8, 0x00, 0x1C, 0x0F, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x3D, 0xFF,
  0xBF, 0xE7, 0xF8, 0x18, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xB8, 0x00,
  0x79, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C,
  0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE1,
  0xE0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x78, 0x00,
  0x77, 0xE0, 0x03, 0xBF, 0x00, 0x1F, 0xBC, 0x00, 0xFC, 0xE0, 0x07, 0xC7,
  0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x00, 0x78, 0x38, 0x03,
  0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x1C,
  0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xB8, 0x00, 0x00, 0xEF, 0xEE, 0x00, 0x00, 0x3B,
  0xFB, 0xC0, 0x00, 0x0E, 0xFE, 0x70, 0x00, 0x07, 0xBF, 0x9C, 0x00, 0x01,
  0xCF, 0xE7, 0x00, 0x00, 0x73, 0xF8, 0xE0, 0x00, 0x3C, 0xFE, 0x38, 0x00,
  0x0E, 0x3F, 0x8E, 0x00, 0x03, 0x8F, 0xE3, 0xC0, 0x00, 0xE3, 0xF8, 0x70,
  0x00, 0x70, 0xFE, 0x1C, 0x00, 0x1C, 0x3F, 0x87, 0x00, 0x07, 0x0F, 0xE0,
  0xE0, 0x03, 0xC3, 0xF8, 0x38, 0x00, 0xE0, 0xFE, 0x0E, 0x00, 0x38, 0x3F,
  0x83, 0xC0, 0x1E, 0x0F, 0xE0, 0x70, 0x07, 0x03, 0xF8, 0x1C, 0x01, 0xC0,
  0xFE, 0x07, 0x80, 0x70, 0x3F, 0x80, 0xE0, 0x3C, 0x0F, 0xE0, 0x38, 0x0E,
  0x03, 0xF8, 0x0E, 0x03, 0x80, 0xFE, 0x01, 0xC1, 0xE0, 0x3F, 0x80, 0x70,
  0x70, 0x0F, 0xE0, 0x1C, 0x1C, 0x03, 0xF8, 0x07, 0x87, 0x00, 0xFE, 0x00,
  0xE3, 0x80, 0x3F, 0x80, 0x38, 0xE0, 0x0F, 0xE0, 0x0E, 0x38, 0x03, 0xF8,
  0x01, 0xDE, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEF, 0x00,
  0x07, 0xE7, 0x00, 0x07, 0xE7, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0x80,
  0x07, 0xE3, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xE0, 0xE0,
  0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x78,
  0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1E,
  0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07,
  0x07, 0xE0, 0x07, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x03, 0xC7, 0xE0, 0x01,
  0xC7, 0xE0, 0x01, 0xE7, 0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00,
  0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x1C,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x1F,
  0x01, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70,
  0x1F, 0xCE, 0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0xB8, 0x03, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x3C, 0x07,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x70, 0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xF0, 0x03,
  0xC0, 0x1F, 0x01, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xC0, 0x7F, 0x0E, 0x00, 0x7C, 0x70, 0x01, 0xE3, 0x80, 0x07, 0x9C, 0x00,
  0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01,
  0xE7, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x70,
  0x07, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0x03, 0x80,
  0x38, 0x1E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x78, 0x1C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x01, 0xC1,
  0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00,
  0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3E, 0x00, 0xC7, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC8, 0x00, 0x7C,
  0xE0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70,
  0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x83,
  0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0xF0,
  0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x1E, 0x01,
  0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x87, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x8E, 0x00, 0x06, 0xC0, 0x00, 0xE1,
  0xC0, 0x01, 0xDC, 0x00, 0x1C, 0x3C, 0x00, 0x3B, 0x80, 0x07, 0x87, 0x80,
  0x07, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xEE, 0x00, 0x1E, 0x0E, 0x00, 0x1D,
  0xC0, 0x03, 0x81, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xE3, 0x80,
  0x1E, 0x07, 0x80, 0x1C, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x8E, 0x00, 0x78,
  0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x83, 0x80, 0x78, 0x07, 0x80, 0x70, 0x70, 0x0F, 0x00, 0x70, 0x0E,
  0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x70, 0x3C,
  0x00, 0x70, 0x38, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x01,
  0xC1, 0xE0, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x03, 0x87, 0x80, 0x03, 0x87,
  0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x01,
  0xC3, 0x80, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x00, 0x3C, 0xE0, 0x03, 0x9E,
  0x00, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0F, 0x00, 0x3C, 0x1C,
  0x00, 0xF0, 0x70, 0x03, 0x81, 0xE0, 0x1E, 0x03, 0x80, 0x70, 0x0F, 0x01,
  0xC0, 0x3C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80,
  0x0E, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1D, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x3C, 0x00, 0x78,
  0x70, 0x01, 0xC1, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x3C,
  0x07, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0E, 0x0E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03,
  0x9E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x07,
  0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x1E, 0x03, 0x80,
  0x70, 0x0F, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0,
  0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0x73, 0xC0, 0x01,
  0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xE3, 0x80,
  0x01, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0xE0, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x1E, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E,
  0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x03, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x70, 0x1E, 0x10, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xC7, 0xE0,
  0x73, 0xE0, 0x1C, 0xF0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0x70,
  0x03, 0xDE, 0x01, 0xB7, 0x80, 0xEC, 0xF8, 0x73, 0x1F, 0xF8, 0xC3, 0xFC,
  0x30, 0x18, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC3, 0xF8, 0x1E, 0x3F, 0xF0, 0xF3, 0xFF, 0xC7,
  0xB8, 0x1E, 0x3F, 0x80, 0x79, 0xF8, 0x01, 0xCF, 0x80, 0x0F, 0x7C, 0x00,
  0x3B, 0xE0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0E,
  0xF8, 0x00, 0x77, 0xC0, 0x07, 0xBF, 0x00, 0x39, 0xF8, 0x03, 0xCE, 0x60,
  0x3C, 0x73, 0xE7, 0xE3, 0x8F, 0xFE, 0x1C, 0x3F, 0xE0, 0x00, 0x18, 0x00,
  0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xE0, 0x61, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x02, 0x3F, 0x9E, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x0C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0xE1, 0xE0, 0xFF, 0x8F, 0x0F, 0xFE, 0x78,
  0xF8, 0x3B, 0xCF, 0x00, 0xFE, 0x78, 0x03, 0xF7, 0x80, 0x0F, 0xBC, 0x00,
  0x7D, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0x70, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x7E, 0x78, 0x03, 0x73, 0xE0,
  0x33, 0x8F, 0xC7, 0x9C, 0x3F, 0xF8, 0xE0, 0xFF, 0x87, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x03, 0xC3, 0xC0, 0x38,
  0x70, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x47,
  0x80, 0x30, 0x7E, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x03, 0xF8, 0x38, 0x3F, 0xF1, 0xC3,
  0xFF, 0x8E, 0x3E, 0x0E, 0x73, 0xC0, 0x3B, 0x9E, 0x00, 0xFD, 0xE0, 0x03,
  0xEF, 0x00, 0x1F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B,
  0x80, 0x07, 0xDC, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x1F, 0x9E, 0x00,
  0xFC, 0xF8, 0x0D, 0xE3, 0xF3, 0xCF, 0x0F, 0xFE, 0x78, 0x3F, 0xC3, 0xC0,
  0x30, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC4, 0x00, 0x3E, 0x3C, 0x07, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x3F, 0x87, 0x8F, 0xF8, 0xF3, 0xFF, 0x9E, 0xE0, 0xFB, 0xF8, 0x0F,
  0x76, 0x00, 0xEF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x77, 0xBF, 0xEF,
  0x30, 0x00, 0x00, 0x00, 0x0F, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x78, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E,
  0xFE, 0xFC, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x3F, 0xC0, 0x0E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78,
  0xF0, 0x3C, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xF0, 0xF0, 0x3C,
  0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xF8, 0x0F, 0xEE,
  0x03, 0xFB, 0xC0, 0xFC, 0x70, 0x3E, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xE0,
  0xF0, 0x3C, 0x3C, 0x07, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x0E, 0x3C,
  0x03, 0xCF, 0x00, 0x73, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xF0, 0xE3, 0xFE, 0x0F, 0xFC, 0xE7,
  0xFF, 0x1F, 0xFE, 0xE6, 0x0F, 0x9C, 0x3E, 0xEC, 0x07, 0xB8, 0x0F, 0xEC,
  0x03, 0xB0, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xF8, 0x03, 0xE0, 0x07, 0xF0,
  0x01, 0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0,
  0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0xFE, 0x1C, 0x3F, 0xE3,
  0x8F, 0xFE, 0x73, 0x83, 0xEE, 0xE0, 0x3D, 0xD8, 0x03, 0xBE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3E, 0x0F, 0x83, 0xC0, 0x3C, 0x1C, 0x00, 0xF1, 0xE0, 0x03, 0x8E, 0x00,
  0x1E, 0x70, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0x80, 0x0E, 0x1E, 0x00, 0xF0, 0x78,
  0x0F, 0x03, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x18, 0x00,
  0xE0, 0xFE, 0x07, 0x0F, 0xF8, 0x38, 0xFF, 0xF1, 0xCE, 0x07, 0x8E, 0xE0,
  0x1E, 0x76, 0x00, 0x73, 0xA0, 0x03, 0xDF, 0x00, 0x0E, 0xF8, 0x00, 0x77,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBE, 0x00, 0x1D, 0xF0,
  0x01, 0xEF, 0xC0, 0x0E, 0x7E, 0x00, 0xF3, 0xDC, 0x0F, 0x1E, 0xFB, 0xF8,
  0xF3, 0xFF, 0x87, 0x87, 0xF8, 0x3C, 0x0E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x38,
  0x3F, 0xE1, 0xC3, 0xFF, 0x8E, 0x3E, 0x0E, 0x73, 0xC0, 0x3B, 0x9E, 0x00,
  0xFD, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x70, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80,
  0x1F, 0x9E, 0x00, 0xFC, 0xF8, 0x0D, 0xE3, 0xF3, 0xCF, 0x0F, 0xFE, 0x78,
  0x3F, 0xC3, 0xC0, 0x30, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0xE0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF,
  0xBE, 0x60, 0x77, 0x03, 0xB0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0x3C, 0x07, 0x78, 0x02,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x0F, 0xE0, 0x1E, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3E, 0x60, 0xFF, 0x07, 0xF8, 0x07, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xB8, 0x01, 0xF7, 0x00, 0x3E, 0xF0, 0x0D, 0xDF, 0x03, 0xB9, 0xFB,
  0xE7, 0x1F, 0xF8, 0xE1, 0xFE, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x7B,
  0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xE0, 0x0E, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x07, 0x80, 0x78, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0xEC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xEE,
  0x00, 0x3E, 0x00, 0x3B, 0xC0, 0x0F, 0x80, 0x0E, 0xF0, 0x03, 0xE0, 0x07,
  0x9C, 0x00, 0xFC, 0x01, 0xE7, 0x00, 0x37, 0x00, 0x71, 0xC0, 0x1D, 0xC0,
  0x1C, 0x78, 0x07, 0x70, 0x07, 0x0E, 0x01, 0xCC, 0x03, 0xC3, 0x80, 0x73,
  0x80, 0xE0, 0xE0, 0x18, 0xE0, 0x38, 0x3C, 0x0E, 0x38, 0x0E, 0x0F, 0x03,
  0x8E, 0x03, 0x81, 0xC0, 0xE1, 0xC1, 0xE0, 0x70, 0x38, 0x70, 0x70, 0x1C,
  0x1C, 0x1C, 0x1C, 0x07, 0x87, 0x07, 0x07, 0x00, 0xE1, 0xC1, 0xC3, 0xC0,
  0x38, 0x70, 0x38, 0xE0, 0x0E, 0x1C, 0x0E, 0x38, 0x03, 0x8E, 0x03, 0x8E,
  0x00, 0xF3, 0x80, 0xE3, 0x80, 0x1C, 0xE0, 0x39, 0xE0, 0x07, 0x38, 0x07,
  0x70, 0x01, 0xCE, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x77, 0x00, 0x0F, 0xC0,
  0x1D, 0xC0, 0x03, 0xF0, 0x07, 0x60, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x70,
  0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0x9C,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x39, 0xC0, 0x07,
  0x9E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01,
  0xC0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1E,
  0x70, 0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x01, 0xE3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1C,
  0x03, 0x81, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0x00, 0x17, 0xFF, 0x00, 0xFE, 0x7F, 0x07, 0xC0,
  0x3F, 0xFE, 0x00, 0x7F, 0xE8, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Light63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 45, 14, 4, -45 },
  { 30, 13, 16, 21, 4, -45 },
  { 56, 26, 45, 28, 1, -45 },
  { 203, 22, 52, 26, 2, -48 },
  { 346, 33, 47, 39, 3, -46 },
  { 540, 25, 47, 27, 2, -46 },
  { 687, 4, 16, 12, 4, -45 },
  { 695, 12, 55, 17, 3, -45 },
  { 778, 12, 55, 17, 2, -45 },
  { 861, 18, 19, 23, 3, -48 },
  { 904, 22, 29, 26, 2, -37 },
  { 984, 7, 15, 13, 2, -7 },
  { 998, 13, 4, 17, 2, -19 },
  { 1005, 5, 6, 13, 4, -6 },
  { 1009, 20, 45, 22, 1, -45 },
  { 1122, 20, 47, 26, 3, -46 },
  { 1240, 13, 45, 26, 4, -45 },
  { 1314, 21, 46, 26, 2, -46 },
  { 1435, 21, 47, 26, 2, -46 },
  { 1559, 24, 45, 26, 1, -45 },
  { 1694, 20, 46, 26, 3, -45 },
  { 1809, 20, 46, 26, 3, -45 },
  { 1924, 21, 45, 26, 2, -45 },
  { 2043, 22, 47, 26, 2, -46 },
  { 2173, 21, 47, 26, 2, -46 },
  { 2297, 5, 34, 13, 4, -34 },
  { 2319, 7, 42, 13, 2, -34 },
  { 2356, 22, 27, 26, 2, -36 },
  { 2431, 22, 16, 26, 2, -30 },
  { 2475, 22, 27, 26, 2, -36 },
  { 2550, 16, 46, 18, 1, -46 },
  { 2642, 34, 51, 40, 3, -45 },
  { 2859, 26, 45, 26, 0, -45 },
  { 3006, 21, 45, 29, 5, -45 },
  { 3125, 23, 47, 27, 3, -46 },
  { 3261, 23, 45, 31, 5, -45 },
  { 3391, 17, 45, 25, 5, -45 },
  { 3487, 17, 45, 23, 5, -45 },
  { 3583, 27, 47, 34, 3, -46 },
  { 3742, 22, 45, 32, 5, -45 },
  { 3866, 12, 45, 16, 2, -45 },
  { 3934, 11, 57, 13, -3, -45 },
  { 4013, 21, 45, 26, 5, -45 },
  { 4132, 16, 45, 22, 5, -45 },
  { 4222, 34, 45, 43, 5, -45 },
  { 4414, 24, 45, 34, 5, -45 },
  { 4549, 27, 47, 33, 3, -46 },
  { 4708, 19, 45, 26, 5, -45 },
  { 4815, 27, 57, 33, 3, -46 },
  { 5008, 21, 45, 27, 5, -45 },
  { 5127, 20, 47, 25, 3, -46 },
  { 5245, 21, 45, 23, 1, -45 },
  { 5364, 23, 46, 32, 4, -45 },
  { 5497, 25, 45, 25, 0, -45 },
  { 5638, 43, 45, 43, 0, -45 },
  { 5880, 22, 45, 23, 1, -45 },
  { 6004, 22, 45, 22, 0, -45 },
  { 6128, 18, 45, 22, 2, -45 },
  { 6230, 12, 55, 19, 5, -45 },
  { 6313, 20, 45, 22, 1, -45 },
  { 6426, 13, 55, 19, 2, -45 },
  { 6516, 24, 23, 26, 1, -45 },
  { 6585, 26, 3, 26, 0, 5 },
  { 6595, 10, 10, 16, 3, -48 },
  { 6608, 18, 35, 25, 2, -34 },
  { 6687, 21, 49, 28, 4, -48 },
  { 6816, 17, 35, 21, 3, -34 },
  { 6891, 21, 49, 28, 3, -48 },
  { 7020, 19, 35, 25, 3, -34 },
  { 7104, 15, 48, 15, 1, -48 },
  { 7194, 21, 49, 28, 3, -34 },
  { 7323, 19, 48, 27, 4, -48 },
  { 7437, 5, 46, 12, 4, -46 },
  { 7466, 8, 61, 12, 0, -46 },
  { 7527, 18, 48, 23, 4, -48 },
  { 7635, 4, 48, 12, 4, -48 },
  { 7659, 32, 34, 41, 4, -34 },
  { 7795, 19, 34, 27, 4, -34 },
  { 7876, 21, 35, 27, 3, -34 },
  { 7968, 21, 49, 28, 4, -34 },
  { 8097, 21, 49, 28, 3, -34 },
  { 8226, 13, 34, 18, 4, -34 },
  { 8282, 16, 35, 21, 2, -34 },
  { 8352, 13, 42, 15, 1, -41 },
  { 8421, 19, 35, 27, 4, -34 },
  { 8505, 21, 34, 21, 0, -34 },
  { 8595, 34, 34, 35, 1, -34 },
  { 8740, 20, 34, 22, 1, -34 },
  { 8825, 20, 49, 22, 1, -34 },
  { 8948, 14, 34, 18, 2, -34 },
  { 9008, 16, 55, 22, 3, -45 },
  { 9118, 3, 63, 25, 11, -48 },
  { 9142, 16, 55, 22, 3, -45 },
  { 9252, 22, 7, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Light63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT63PT7B_H_
