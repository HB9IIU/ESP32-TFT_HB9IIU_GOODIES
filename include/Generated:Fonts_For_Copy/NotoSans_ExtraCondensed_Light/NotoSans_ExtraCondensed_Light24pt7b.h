#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x83, 0x80, 0xCD, 0x34, 0xD2, 0x49, 0x20, 0x08,
  0x82, 0x60, 0x90, 0x64, 0x11, 0x1F, 0xF1, 0x10, 0x44, 0x11, 0x04, 0x4F,
  0xFF, 0xFF, 0x22, 0x08, 0x82, 0x20, 0x88, 0x22, 0x00, 0x10, 0x18, 0x7F,
  0xD0, 0x90, 0x90, 0x90, 0xD0, 0x70, 0x1C, 0x16, 0x13, 0x11, 0x11, 0x11,
  0x92, 0xFC, 0x10, 0x10, 0x70, 0x46, 0x44, 0x22, 0x21, 0x11, 0x08, 0x90,
  0x44, 0x82, 0x24, 0x91, 0x4E, 0xCA, 0x93, 0xB4, 0x41, 0x22, 0x09, 0x10,
  0xC8, 0x84, 0x44, 0x22, 0x63, 0x12, 0x10, 0x70, 0x38, 0x32, 0x11, 0x08,
  0x84, 0x43, 0x60, 0xA0, 0x60, 0x70, 0x24, 0x62, 0x70, 0xA8, 0x74, 0x1A,
  0x0D, 0x8A, 0x78, 0x80, 0xD5, 0x50, 0x19, 0x88, 0xC4, 0x21, 0x18, 0xC6,
  0x31, 0x8C, 0x61, 0x08, 0x61, 0x08, 0x21, 0x80, 0xC4, 0x62, 0x33, 0x11,
  0x11, 0x11, 0x11, 0x13, 0x22, 0x64, 0x80, 0x10, 0x23, 0x59, 0xC2, 0x8D,
  0x91, 0x00, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x69, 0x2D, 0x00, 0xF8, 0xD0, 0x02, 0x08, 0x10, 0x60, 0x81, 0x06,
  0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x30, 0x40, 0x80, 0x3C, 0x66, 0x42,
  0xC2, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0x42, 0x42,
  0x66, 0x3C, 0x13, 0xD9, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0x7C,
  0x86, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x30,
  0x20, 0x40, 0xC0, 0xFF, 0x7C, 0x86, 0x02, 0x02, 0x02, 0x02, 0x06, 0x1C,
  0x3C, 0x06, 0x02, 0x03, 0x03, 0x03, 0x02, 0x86, 0xFC, 0x03, 0x01, 0xC0,
  0x70, 0x3C, 0x0B, 0x06, 0xC1, 0x30, 0xCC, 0x23, 0x08, 0xC4, 0x31, 0x0C,
  0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7E, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0xC0, 0xFC, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x86, 0xFC,
  0x1E, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC8, 0xBE, 0xC2, 0xC3, 0xC3, 0xC1,
  0xC3, 0xC3, 0x42, 0x66, 0x3C, 0xFF, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x60, 0x7C, 0x42,
  0xC3, 0xC3, 0xC3, 0x42, 0x66, 0x3C, 0x3C, 0x66, 0xC2, 0x83, 0x81, 0x81,
  0x83, 0x42, 0x7C, 0x7C, 0x46, 0xC2, 0x82, 0x83, 0x83, 0x83, 0xC3, 0xC7,
  0x7F, 0x12, 0x02, 0x02, 0x02, 0x04, 0x0C, 0x78, 0xE0, 0x18, 0x49, 0x00,
  0x00, 0x01, 0xA4, 0xB4, 0x01, 0x03, 0x0E, 0x38, 0xE0, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x06, 0x18, 0x60, 0xC0, 0x80, 0xFA, 0x10, 0x41,
  0x04, 0x10, 0xC2, 0x10, 0xC2, 0x08, 0x20, 0x00, 0x0C, 0x30, 0x0F, 0xC0,
  0x83, 0x08, 0x08, 0xC0, 0x24, 0x01, 0x23, 0xCD, 0x32, 0x39, 0x11, 0x88,
  0x8C, 0x44, 0x62, 0x23, 0x13, 0x1C, 0x99, 0x23, 0xB9, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x82, 0x03, 0xE0, 0x0C, 0x03, 0x01, 0xC0, 0x58, 0x12, 0x04,
  0x81, 0x20, 0xCC, 0x21, 0x08, 0x43, 0xF1, 0x86, 0x41, 0x90, 0x24, 0x0B,
  0x03, 0xC0, 0xC0, 0xFC, 0x86, 0x82, 0x83, 0x83, 0x82, 0x82, 0xFC, 0xFC,
  0x82, 0x83, 0x81, 0x81, 0x83, 0x83, 0x86, 0xFC, 0x1F, 0x98, 0x58, 0x08,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x61, 0x1F, 0x80, 0xFC, 0x43, 0x20, 0xD0, 0x68, 0x14, 0x0A, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x28, 0x14, 0x1A, 0x09, 0x1C, 0xF8, 0x00,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xFC, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x80, 0x1F, 0xCC, 0x12, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC3, 0xF0, 0x1C, 0x05, 0x01, 0x40, 0x58, 0x12, 0x04, 0xC1, 0x1F, 0xC0,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13,
  0xE0, 0x83, 0x86, 0x84, 0x8C, 0x88, 0x90, 0xB0, 0xA0, 0xF0, 0xD0, 0x98,
  0x88, 0x8C, 0x84, 0x86, 0x82, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x40, 0x7A, 0x07, 0xD0, 0x2E, 0xC1, 0x72, 0x1B, 0x90, 0x9C, 0xC4, 0xE2,
  0x27, 0x13, 0x38, 0x91, 0xC2, 0x8E, 0x1C, 0x70, 0xC3, 0x86, 0x18, 0xC0,
  0xE0, 0x78, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x31, 0x88, 0xC6, 0x61, 0x30,
  0x98, 0x2C, 0x16, 0x0F, 0x03, 0x81, 0x80, 0x1F, 0x06, 0x31, 0x83, 0x20,
  0x64, 0x05, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0x78, 0x0B, 0x01, 0x60, 0x24,
  0x04, 0x81, 0x98, 0x21, 0x8C, 0x1F, 0x00, 0xF9, 0x0E, 0x1C, 0x18, 0x30,
  0x60, 0xC3, 0x8D, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x1F, 0x06,
  0x31, 0x83, 0x20, 0x64, 0x05, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0x78, 0x0B,
  0x01, 0x60, 0x24, 0x04, 0x81, 0x98, 0x21, 0x8C, 0x1F, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0xF8, 0x86, 0x82, 0x82, 0x82, 0x82, 0x82, 0x86, 0xFC,
  0xF8, 0x88, 0x88, 0x84, 0x84, 0x86, 0x82, 0x83, 0x3E, 0x42, 0xC0, 0x80,
  0x80, 0xC0, 0x40, 0x70, 0x1C, 0x06, 0x02, 0x03, 0x03, 0x03, 0x02, 0x86,
  0xFC, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7E, 0xC0,
  0xF0, 0x24, 0x09, 0x06, 0x41, 0x98, 0x42, 0x10, 0x84, 0x23, 0x0C, 0x83,
  0x20, 0x48, 0x16, 0x05, 0x01, 0xC0, 0x30, 0x0C, 0x00, 0xC1, 0x81, 0xC1,
  0x81, 0x41, 0x83, 0x41, 0xC3, 0x41, 0x42, 0x63, 0x42, 0x22, 0x42, 0x22,
  0x46, 0x22, 0x64, 0x22, 0x24, 0x36, 0x24, 0x14, 0x24, 0x14, 0x2C, 0x14,
  0x28, 0x14, 0x18, 0x1C, 0x18, 0x08, 0x18, 0x41, 0xB1, 0x88, 0x84, 0x43,
  0x60, 0xA0, 0x50, 0x18, 0x08, 0x0A, 0x05, 0x06, 0xC2, 0x21, 0x11, 0x8C,
  0x82, 0xC1, 0x80, 0xC1, 0xA0, 0x90, 0xCC, 0x42, 0x21, 0x30, 0xD0, 0x28,
  0x1C, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x00, 0xFE,
  0x08, 0x10, 0x60, 0x81, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04, 0x08, 0x30,
  0x40, 0xFE, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x0F, 0x80, 0x81, 0x03, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10,
  0x20, 0x60, 0x40, 0x81, 0x81, 0x02, 0x02, 0xF8, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x80, 0x0C, 0x03, 0x01,
  0xA0, 0x48, 0x33, 0x08, 0x46, 0x19, 0x02, 0xC0, 0xC0, 0xFF, 0xC0, 0xC6,
  0x30, 0x7C, 0x88, 0x18, 0x30, 0x20, 0xDE, 0xE1, 0x83, 0x0E, 0x1E, 0x57,
  0xA0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC6, 0xC2, 0x82, 0x82, 0x83,
  0x83, 0x83, 0x83, 0x82, 0x82, 0xC6, 0xBC, 0x3D, 0x94, 0x30, 0xC2, 0x08,
  0x20, 0xC3, 0x04, 0x18, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01, 0x39, 0x65,
  0x43, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x43, 0x63, 0x3D, 0x3C,
  0x66, 0x42, 0xC2, 0x82, 0x83, 0xFF, 0x80, 0x80, 0xC0, 0x40, 0x62, 0x3E,
  0x1C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x80, 0x39, 0x65, 0x43, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC3,
  0x43, 0x65, 0x3D, 0x01, 0x01, 0x01, 0x02, 0x6E, 0x38, 0x81, 0x02, 0x04,
  0x08, 0x17, 0xB9, 0x63, 0x87, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x04, 0x74, 0x15, 0x55, 0x55, 0x50, 0x2C, 0x80, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x10, 0xA3, 0x44, 0x91, 0x62,
  0x86, 0x89, 0x13, 0x22, 0x46, 0x85, 0x0C, 0xFF, 0xFF, 0xC0, 0xB9, 0xEC,
  0xD2, 0x86, 0x38, 0x61, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18,
  0x41, 0x84, 0x18, 0x41, 0x84, 0x10, 0xBD, 0x8B, 0x1C, 0x38, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x3C, 0x66, 0x43, 0xC3, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC1, 0x43, 0x62, 0x3C, 0xBC, 0xE6, 0xC2, 0x82, 0x82,
  0x83, 0x83, 0x83, 0x83, 0x82, 0xC2, 0xC6, 0xBC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x39, 0x65, 0x43, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC3,
  0x43, 0x65, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBF, 0x71, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x00, 0x7F, 0x18, 0x20, 0x81, 0x83, 0x06,
  0x0C, 0x10, 0x63, 0xF8, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x87, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x57, 0x20, 0xC3, 0xC3, 0x42, 0x42, 0x42, 0x66, 0x24, 0x24, 0x24, 0x3C,
  0x18, 0x18, 0x18, 0xC3, 0x0A, 0x18, 0x50, 0xC6, 0x8A, 0x24, 0x51, 0x32,
  0xC8, 0x92, 0x45, 0x96, 0x28, 0xA1, 0x45, 0x0E, 0x38, 0x30, 0xC1, 0x84,
  0x00, 0x43, 0x62, 0x26, 0x24, 0x14, 0x18, 0x18, 0x18, 0x34, 0x24, 0x26,
  0x42, 0xC3, 0xC1, 0x43, 0x43, 0x42, 0x62, 0x26, 0x24, 0x24, 0x34, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0xE0, 0xC0, 0xF8, 0x46, 0x23,
  0x10, 0x8C, 0x42, 0x31, 0x0F, 0x80, 0x0C, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x30, 0x8C, 0x08, 0x30, 0x41, 0x04, 0x10, 0x41, 0x06, 0x04, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0x60, 0xC4, 0x10, 0x41,
  0x04, 0x10, 0x43, 0x18, 0xC0, 0x61, 0xDB, 0x86,
};

const GFXglyph NotoSans_ExtraCondensed_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 17, 5, 2, -17 },
  { 6, 6, 6, 8, 1, -17 },
  { 11, 10, 17, 11, 0, -17 },
  { 33, 8, 19, 10, 1, -18 },
  { 52, 13, 17, 15, 1, -17 },
  { 80, 9, 17, 10, 1, -17 },
  { 100, 2, 6, 4, 1, -17 },
  { 102, 5, 21, 7, 1, -17 },
  { 116, 4, 21, 7, 1, -17 },
  { 127, 7, 7, 9, 1, -18 },
  { 134, 8, 11, 10, 1, -14 },
  { 145, 3, 6, 5, 1, -3 },
  { 148, 5, 1, 6, 1, -7 },
  { 149, 2, 2, 5, 1, -2 },
  { 150, 7, 17, 8, 1, -17 },
  { 165, 8, 17, 10, 1, -17 },
  { 182, 4, 17, 10, 2, -17 },
  { 191, 8, 17, 10, 1, -17 },
  { 208, 8, 17, 10, 1, -17 },
  { 225, 10, 17, 10, 0, -17 },
  { 247, 8, 17, 10, 1, -17 },
  { 264, 8, 17, 10, 1, -17 },
  { 281, 8, 17, 10, 1, -17 },
  { 298, 8, 17, 10, 1, -17 },
  { 315, 8, 17, 10, 1, -17 },
  { 332, 1, 13, 5, 2, -13 },
  { 334, 3, 16, 5, 1, -13 },
  { 340, 8, 11, 10, 1, -14 },
  { 351, 8, 7, 10, 1, -12 },
  { 358, 8, 11, 10, 1, -14 },
  { 369, 6, 17, 7, 0, -17 },
  { 382, 13, 19, 15, 1, -17 },
  { 413, 10, 17, 10, 0, -17 },
  { 435, 8, 17, 11, 2, -17 },
  { 452, 9, 17, 10, 1, -17 },
  { 472, 9, 17, 12, 2, -17 },
  { 492, 6, 17, 9, 2, -17 },
  { 505, 6, 17, 9, 2, -17 },
  { 518, 10, 17, 13, 1, -17 },
  { 540, 8, 17, 12, 2, -17 },
  { 557, 4, 17, 6, 1, -17 },
  { 566, 4, 21, 5, -1, -17 },
  { 577, 8, 17, 10, 2, -17 },
  { 594, 6, 17, 9, 2, -17 },
  { 607, 13, 17, 16, 2, -17 },
  { 635, 9, 17, 13, 2, -17 },
  { 655, 11, 17, 13, 1, -17 },
  { 679, 7, 17, 10, 2, -17 },
  { 694, 11, 21, 13, 1, -17 },
  { 723, 8, 17, 10, 2, -17 },
  { 740, 8, 17, 10, 1, -17 },
  { 757, 8, 17, 9, 0, -17 },
  { 774, 8, 17, 12, 2, -17 },
  { 791, 10, 17, 10, 0, -17 },
  { 813, 16, 17, 16, 0, -17 },
  { 847, 9, 17, 9, 0, -17 },
  { 867, 9, 17, 9, 0, -17 },
  { 887, 7, 17, 8, 1, -17 },
  { 902, 5, 21, 7, 2, -17 },
  { 916, 7, 17, 8, 1, -17 },
  { 931, 5, 21, 7, 1, -17 },
  { 945, 10, 9, 10, 0, -17 },
  { 957, 10, 1, 10, 0, 2 },
  { 959, 4, 3, 6, 1, -18 },
  { 961, 7, 13, 9, 1, -13 },
  { 973, 8, 18, 11, 2, -18 },
  { 991, 6, 13, 8, 1, -13 },
  { 1001, 8, 18, 11, 1, -18 },
  { 1019, 8, 13, 10, 1, -13 },
  { 1032, 6, 18, 6, 0, -18 },
  { 1046, 8, 19, 11, 1, -13 },
  { 1065, 7, 18, 10, 2, -18 },
  { 1081, 2, 18, 5, 1, -18 },
  { 1086, 3, 24, 5, 0, -18 },
  { 1095, 7, 18, 9, 2, -18 },
  { 1111, 1, 18, 5, 2, -18 },
  { 1114, 12, 13, 15, 2, -13 },
  { 1134, 7, 13, 10, 2, -13 },
  { 1146, 8, 13, 10, 1, -13 },
  { 1159, 8, 19, 11, 2, -13 },
  { 1178, 8, 19, 11, 1, -13 },
  { 1197, 5, 13, 7, 2, -13 },
  { 1206, 6, 13, 8, 1, -13 },
  { 1216, 5, 16, 6, 0, -16 },
  { 1226, 7, 13, 10, 2, -13 },
  { 1238, 8, 13, 8, 0, -13 },
  { 1251, 13, 13, 13, 0, -13 },
  { 1273, 8, 13, 8, 0, -13 },
  { 1286, 8, 19, 8, 0, -13 },
  { 1305, 5, 13, 7, 1, -13 },
  { 1314, 6, 21, 9, 1, -17 },
  { 1330, 1, 24, 9, 4, -18 },
  { 1333, 6, 21, 9, 1, -17 },
  { 1349, 8, 3, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Light24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT24PT7B_H_
