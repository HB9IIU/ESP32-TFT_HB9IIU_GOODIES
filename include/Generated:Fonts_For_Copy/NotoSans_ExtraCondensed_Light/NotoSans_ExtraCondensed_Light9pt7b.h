#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x6F, 0x6F, 0x6A, 0x5F, 0x26, 0xFA, 0x45, 0xA9, 0x57,
  0x9D, 0x60, 0x4A, 0x64, 0xBA, 0xF0, 0xC0, 0x6A, 0xA4, 0xD5, 0x5C, 0x5E,
  0x80, 0x5D, 0x20, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x56, 0xDB, 0x58,
  0xFC, 0x54, 0x92, 0xB8, 0x54, 0xA2, 0x78, 0x26, 0x6A, 0xF2, 0xF3, 0x93,
  0xC0, 0x2A, 0x7B, 0x58, 0xE4, 0xA4, 0x80, 0x56, 0xAB, 0x78, 0x56, 0xD6,
  0x58, 0x88, 0x8C, 0x39, 0x10, 0xFC, 0xC5, 0xC0, 0xD5, 0x44, 0x7D, 0xEF,
  0x7A, 0xA0, 0xC0, 0x46, 0x66, 0x99, 0xF7, 0x5B, 0x80, 0x34, 0x88, 0x88,
  0x70, 0xF6, 0xDB, 0x80, 0xEE, 0xB0, 0xEE, 0xA0, 0x34, 0x88, 0x99, 0x70,
  0xB7, 0xDB, 0x40, 0xD5, 0x70, 0xFF, 0xFA, 0x6D, 0x40, 0xAA, 0xB0, 0x8C,
  0xE7, 0xDE, 0xD4, 0xB7, 0xFB, 0x40, 0x25, 0x99, 0x99, 0x70, 0xFE, 0xA0,
  0x25, 0x99, 0x99, 0x71, 0x10, 0xF7, 0x6D, 0x40, 0x72, 0x22, 0x78, 0xE9,
  0x24, 0x80, 0xB6, 0xDB, 0xC0, 0x9A, 0xA6, 0x44, 0xA6, 0xDB, 0x55, 0x49,
  0x20, 0xA9, 0x2B, 0x40, 0xB5, 0x24, 0x80, 0xE5, 0x29, 0xC0, 0xFE, 0x89,
  0x22, 0x40, 0xD5, 0x5C, 0x66, 0x90, 0xF0, 0x90, 0x65, 0xDE, 0x93, 0x5B,
  0x70, 0x72, 0x46, 0x25, 0xDB, 0x58, 0x77, 0xC6, 0x6E, 0xA8, 0x76, 0xD6,
  0x78, 0xAF, 0xFC, 0xBE, 0xBF, 0x80, 0xAE, 0xBC, 0xFE, 0xFD, 0xDD, 0xD0,
  0xFF, 0xC0, 0x76, 0xD6, 0xD6, 0xDD, 0x20, 0x76, 0xD6, 0x48, 0xF8, 0x71,
  0x1E, 0xBA, 0xB0, 0xFF, 0xC0, 0xB6, 0xA4, 0xAD, 0x74, 0xA5, 0x00, 0xA9,
  0x2A, 0xB6, 0xA4, 0xB0, 0xD6, 0xC0, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9,
  0x14, 0xB0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 8, 4, 0, -7 },
  { 9, 5, 7, 6, 0, -7 },
  { 14, 4, 7, 4, 0, -7 },
  { 18, 1, 2, 2, 0, -6 },
  { 19, 2, 7, 3, 0, -6 },
  { 21, 2, 7, 3, 0, -6 },
  { 23, 3, 3, 3, 0, -7 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 7, 4, 0, -7 },
  { 36, 1, 6, 4, 1, -6 },
  { 37, 3, 7, 4, 0, -7 },
  { 40, 3, 7, 4, 0, -7 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 3, 6, 4, 0, -6 },
  { 49, 3, 7, 4, 0, -7 },
  { 52, 3, 6, 4, 0, -6 },
  { 55, 3, 7, 4, 0, -7 },
  { 58, 3, 7, 4, 0, -7 },
  { 61, 1, 5, 2, 0, -5 },
  { 62, 1, 6, 2, 0, -5 },
  { 63, 3, 4, 4, 0, -5 },
  { 65, 3, 2, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -5 },
  { 68, 2, 7, 3, 0, -7 },
  { 70, 5, 7, 6, 0, -6 },
  { 75, 4, 6, 4, 0, -6 },
  { 78, 3, 6, 4, 1, -6 },
  { 81, 4, 7, 4, 0, -7 },
  { 85, 3, 6, 4, 1, -6 },
  { 88, 2, 6, 4, 1, -6 },
  { 90, 2, 6, 3, 1, -6 },
  { 92, 4, 7, 5, 0, -7 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 2, 6, 2, 0, -6 },
  { 101, 1, 8, 2, 0, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 2, 6, 3, 1, -6 },
  { 107, 5, 6, 6, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 4, 7, 5, 0, -7 },
  { 118, 2, 6, 4, 1, -6 },
  { 120, 4, 9, 5, 0, -7 },
  { 125, 3, 6, 4, 1, -6 },
  { 128, 3, 7, 4, 0, -7 },
  { 131, 3, 6, 3, 0, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 4, 6, 4, 0, -6 },
  { 140, 6, 6, 6, 0, -6 },
  { 145, 3, 6, 3, 0, -6 },
  { 148, 3, 6, 3, 0, -6 },
  { 151, 3, 6, 3, 0, -6 },
  { 154, 1, 7, 3, 1, -6 },
  { 155, 3, 6, 3, 0, -6 },
  { 158, 2, 7, 3, 0, -6 },
  { 160, 4, 3, 4, 0, -6 },
  { 162, 4, 1, 4, 0, 0 },
  { 163, 2, 2, 2, 0, -7 },
  { 164, 3, 5, 4, 0, -5 },
  { 166, 3, 7, 4, 1, -7 },
  { 169, 3, 5, 3, 0, -5 },
  { 171, 3, 7, 4, 0, -7 },
  { 174, 3, 5, 4, 0, -5 },
  { 176, 2, 7, 2, 0, -7 },
  { 178, 3, 7, 4, 0, -5 },
  { 181, 2, 7, 4, 1, -7 },
  { 183, 1, 7, 2, 0, -7 },
  { 184, 1, 9, 2, 0, -7 },
  { 186, 2, 7, 3, 1, -7 },
  { 188, 1, 7, 2, 0, -7 },
  { 189, 4, 5, 6, 1, -5 },
  { 192, 2, 5, 4, 1, -5 },
  { 194, 3, 5, 4, 0, -5 },
  { 196, 3, 7, 4, 1, -5 },
  { 199, 3, 7, 4, 0, -5 },
  { 202, 1, 5, 3, 1, -5 },
  { 203, 3, 5, 3, 0, -5 },
  { 205, 2, 6, 2, 0, -6 },
  { 207, 2, 5, 4, 1, -5 },
  { 209, 3, 5, 3, 0, -5 },
  { 211, 5, 5, 5, 0, -5 },
  { 215, 3, 5, 3, 0, -5 },
  { 217, 3, 7, 3, 0, -5 },
  { 220, 2, 5, 3, 0, -5 },
  { 222, 3, 7, 3, 0, -6 },
  { 225, 1, 9, 4, 1, -7 },
  { 227, 3, 7, 3, 0, -6 },
  { 230, 3, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Light9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT9PT7B_H_
