#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0x0B, 0xFE,
  0xE3, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0xB0, 0xD8,
  0x60, 0x06, 0x08, 0x06, 0x08, 0x06, 0x08, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x04, 0x18, 0x04, 0x18, 0x7F, 0xFF, 0x0C, 0x10, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30, 0x08, 0x30, 0x18,
  0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x10, 0x60, 0x10, 0x60, 0x30, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x07, 0xFE, 0x3B, 0x39, 0xCC, 0x26, 0x30, 0x18,
  0xC0, 0xC3, 0x03, 0x0C, 0x06, 0x30, 0x18, 0xC0, 0x73, 0x00, 0xEC, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0D, 0xC0, 0x31, 0x80, 0xC7, 0x03, 0x0C,
  0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x1E, 0x0C, 0xEF, 0xBF, 0x1F, 0xF8,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3C, 0x03, 0x03, 0xF0, 0x18,
  0x19, 0x80, 0x81, 0x86, 0x0C, 0x0C, 0x30, 0x60, 0x61, 0x82, 0x03, 0x0C,
  0x30, 0x18, 0x61, 0x80, 0xC3, 0x08, 0x06, 0x18, 0xC0, 0x30, 0xC6, 0x01,
  0x86, 0x21, 0x0C, 0x33, 0x3E, 0x61, 0x99, 0x9B, 0x0D, 0x98, 0xCC, 0xCC,
  0xC3, 0x7E, 0x66, 0x19, 0xE6, 0x20, 0xC0, 0x31, 0x06, 0x01, 0x88, 0x30,
  0x18, 0x41, 0x80, 0xC2, 0x0C, 0x06, 0x10, 0x60, 0x60, 0x83, 0x03, 0x06,
  0x18, 0x18, 0x30, 0xC1, 0x81, 0x8C, 0x0C, 0x06, 0xE0, 0x60, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0xC0, 0x18, 0xC0, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60,
  0x30, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x0D, 0x80,
  0x0F, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x1B, 0x00, 0x31, 0x86, 0x61, 0x86,
  0x60, 0xC6, 0xE0, 0xC6, 0xC0, 0x66, 0xC0, 0x7C, 0xC0, 0x3C, 0xE0, 0x18,
  0xE0, 0x3C, 0x60, 0x3C, 0x70, 0x6E, 0x3F, 0xC6, 0x1F, 0x83, 0xED, 0xB6,
  0xDB, 0x6D, 0x80, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x0E, 0x07, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06,
  0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0xE0, 0x0C, 0x01, 0x80, 0x10, 0x42, 0x3F, 0x5E, 0x7F, 0x03, 0x80, 0xD8,
  0x33, 0x0E, 0x31, 0x83, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x39, 0xCC, 0x63, 0x39, 0x8C, 0xC0, 0xFF, 0xFF, 0xC0, 0x67, 0xF6,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0xFE, 0x0E,
  0x30, 0xE0, 0xC6, 0x06, 0x30, 0x1B, 0x80, 0xDC, 0x06, 0xC0, 0x36, 0x01,
  0xB0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x80, 0xCC, 0x06, 0x60,
  0x73, 0x83, 0x0C, 0x38, 0x7F, 0x80, 0xF8, 0x00, 0x03, 0x07, 0x0F, 0x1B,
  0x73, 0xE7, 0xC7, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x0F, 0x80, 0xFF, 0x87, 0x0F, 0x08, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0x07, 0x10, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE4, 0x07, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x05, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30,
  0x0C, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18,
  0x18, 0x30, 0x30, 0xC0, 0x61, 0x80, 0xC6, 0x01, 0x8F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x7F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xF8, 0x7F,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0xA0, 0x39, 0xFF, 0x8F,
  0xF8, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0x84, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x8F, 0x0C, 0xFC, 0x6C,
  0x73, 0xC1, 0xDC, 0x06, 0xE0, 0x36, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xEC, 0x06, 0x60, 0x33, 0x01, 0x8C, 0x18, 0x7F, 0xC1,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0x7F, 0x83, 0x87, 0x0C, 0x0E, 0x70, 0x19, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x18, 0xC0, 0x63, 0x83, 0x06, 0x1C, 0x0E,
  0xE0, 0x1E, 0x00, 0x7C, 0x07, 0x38, 0x38, 0x70, 0xC0, 0xE6, 0x01, 0x98,
  0x07, 0x60, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0x80, 0x63,
  0x03, 0x8F, 0xFC, 0x0F, 0xE0, 0x0F, 0x03, 0xFC, 0x70, 0xC6, 0x06, 0xE0,
  0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x77, 0x0F, 0x7F, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x87, 0xF8, 0x7E,
  0x00, 0xFF, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x1B, 0xFC, 0x39, 0xCE, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x63, 0x19, 0xCC,
  0x66, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xC0, 0x00, 0x3E, 0x3F, 0xCC, 0x38,
  0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x1F, 0xF8, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x0C, 0x00,
  0x30, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x60, 0x3C, 0x33, 0x07, 0xF0, 0xD8,
  0x71, 0x86, 0x83, 0x0C, 0x3C, 0x18, 0x61, 0xE1, 0x83, 0x0F, 0x0C, 0x18,
  0x78, 0x60, 0xC3, 0xC3, 0x0E, 0x1E, 0x18, 0x60, 0xF0, 0xC3, 0x07, 0x86,
  0x18, 0x3C, 0x30, 0xC1, 0xE1, 0x87, 0x1B, 0x06, 0x6D, 0xCC, 0x1E, 0x7C,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x80, 0x3C, 0x18, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x18, 0x03, 0x8C, 0x01,
  0x86, 0x00, 0xC3, 0x80, 0x60, 0xC0, 0x70, 0x60, 0x30, 0x30, 0x18, 0x1C,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0x01, 0x83, 0x00, 0xE1, 0x80, 0x70, 0xC0,
  0x18, 0xE0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x98, 0x00, 0xDC, 0x00, 0x6C,
  0x00, 0x38, 0xFC, 0x03, 0xFF, 0x0C, 0x1F, 0x30, 0x1C, 0xC0, 0x3B, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xC0,
  0xE3, 0xFF, 0x0F, 0xFC, 0x30, 0x3C, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xB0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xEC,
  0x07, 0x3F, 0xF8, 0xFF, 0x80, 0x01, 0xF8, 0x1F, 0xF0, 0xE0, 0xC7, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x43, 0xFF, 0x03, 0xFC, 0xFC, 0x01, 0xFF, 0x83,
  0x0F, 0x86, 0x03, 0x8C, 0x03, 0x98, 0x03, 0x30, 0x07, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8,
  0x01, 0xB0, 0x07, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0xE3, 0x03, 0x87, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xBF, 0xF6,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x3F, 0xF7, 0xFE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0x80, 0x23, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0xC0, 0x06,
  0x60, 0x03, 0x38, 0x01, 0x8E, 0x00, 0xC7, 0x80, 0x60, 0xFF, 0xF0, 0x3F,
  0xF0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0xFF, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x1F, 0xF7, 0xC0, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0x30, 0x18,
  0xC0, 0xE3, 0x03, 0x0C, 0x1C, 0x30, 0x60, 0xC3, 0x83, 0x0C, 0x0C, 0x60,
  0x33, 0x80, 0xCC, 0x03, 0x70, 0x0D, 0xE0, 0x3D, 0x80, 0xE7, 0x03, 0x8C,
  0x0C, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x0E, 0x30, 0x18, 0xC0,
  0x63, 0x00, 0xCC, 0x03, 0x30, 0x0E, 0xC0, 0x1C, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xEC, 0x00, 0x3F, 0x60, 0x03, 0x7B, 0x00, 0x1B, 0xCC, 0x00, 0xDE,
  0x60, 0x06, 0xF3, 0x00, 0x67, 0x98, 0x03, 0x3C, 0x60, 0x19, 0xE3, 0x01,
  0x8F, 0x18, 0x0C, 0x78, 0x60, 0x63, 0xC3, 0x07, 0x1E, 0x18, 0x30, 0xF0,
  0xE1, 0x87, 0x83, 0x0C, 0x3C, 0x18, 0xC1, 0xE0, 0xC6, 0x0F, 0x03, 0x30,
  0x78, 0x1B, 0x03, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x01, 0x80, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7B, 0x00, 0xF6, 0x01, 0xE6, 0x03, 0xCC, 0x07, 0x9C, 0x0F,
  0x18, 0x1E, 0x38, 0x3C, 0x30, 0x78, 0x60, 0xF0, 0x61, 0xE0, 0xC3, 0xC1,
  0xC7, 0x81, 0x8F, 0x03, 0x9E, 0x03, 0x3C, 0x06, 0x78, 0x06, 0xF0, 0x0D,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x60,
  0x03, 0xE0, 0x07, 0xFC, 0x07, 0x87, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x80,
  0x39, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x1D, 0x80,
  0x0C, 0xE0, 0x06, 0x30, 0x07, 0x1C, 0x07, 0x07, 0x07, 0x01, 0xFF, 0x80,
  0x7F, 0x00, 0xF8, 0x0F, 0xF8, 0xC7, 0xEC, 0x0E, 0xC0, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0xEF, 0xFC, 0xFF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0xE0,
  0x07, 0xFC, 0x07, 0x87, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x39, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0C, 0xE0,
  0x06, 0x30, 0x07, 0x1C, 0x07, 0x07, 0x07, 0x01, 0xFF, 0x80, 0x7F, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0xF8, 0x03, 0xFE, 0x0C, 0x7E, 0x30, 0x38, 0xC0, 0x73,
  0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x3B, 0x00, 0xCC, 0x03, 0x30, 0x0C,
  0xC0, 0x73, 0x03, 0x8C, 0x3C, 0x3F, 0xE0, 0xFF, 0x03, 0x0C, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x0E, 0x30, 0x18, 0xC0, 0x73, 0x00,
  0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x1C, 0x0F, 0xC3, 0xFF, 0x78, 0x76, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x80, 0xEF, 0xFC,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x1D, 0x80, 0x77, 0x03, 0x8F, 0xFC, 0x1F, 0xE0, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x38, 0x0C, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0E, 0x70,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x7C, 0x01, 0xC0,
  0x0D, 0x80, 0x38, 0x03, 0xB0, 0x07, 0x00, 0x76, 0x00, 0xF0, 0x0C, 0xC0,
  0x16, 0x01, 0x9C, 0x06, 0xC0, 0x31, 0x80, 0xD8, 0x0E, 0x30, 0x1B, 0x01,
  0x86, 0x03, 0x30, 0x30, 0xE0, 0x66, 0x06, 0x0C, 0x18, 0xC0, 0xC1, 0x83,
  0x18, 0x38, 0x30, 0x63, 0x06, 0x06, 0x0C, 0x30, 0xC0, 0xE1, 0x86, 0x18,
  0x0C, 0x60, 0xC3, 0x01, 0x8C, 0x18, 0xE0, 0x31, 0x83, 0x18, 0x06, 0x30,
  0x23, 0x00, 0xE6, 0x06, 0x60, 0x0D, 0x80, 0xDC, 0x01, 0xB0, 0x1B, 0x80,
  0x36, 0x03, 0x60, 0x06, 0xC0, 0x2C, 0x00, 0xD8, 0x05, 0x80, 0x0E, 0x00,
  0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x70, 0x0C, 0xC0, 0x73,
  0x01, 0x8E, 0x06, 0x18, 0x38, 0x60, 0xC1, 0xC3, 0x03, 0x18, 0x0C, 0x60,
  0x19, 0x80, 0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x18, 0x0C, 0x60, 0x71, 0xC1, 0x83,
  0x06, 0x0C, 0x30, 0x38, 0xC0, 0x67, 0x01, 0x98, 0x07, 0xE0, 0x0C, 0xC0,
  0x0F, 0x80, 0x76, 0x01, 0x98, 0x06, 0x70, 0x18, 0xC0, 0xC3, 0x03, 0x0E,
  0x0C, 0x18, 0x60, 0x61, 0x81, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x3B, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0x01, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x36, 0x00,
  0x6C, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x38, 0x18, 0x30, 0x60, 0x70, 0xC0,
  0x63, 0x80, 0xC6, 0x00, 0xDC, 0x01, 0xB0, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x40, 0x03, 0x03, 0xFC, 0x38,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x0F,
  0xF3, 0xC3, 0x70, 0x36, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x60,
  0x76, 0x0F, 0x39, 0xB3, 0xF3, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC7, 0x06, 0x7E, 0x36, 0x39, 0xE0,
  0xEE, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x01, 0xB8,
  0x0D, 0xE0, 0xCD, 0xFE, 0x67, 0xE0, 0x03, 0x07, 0xF3, 0xC5, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x3F, 0xC7, 0xF0, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x06,
  0x18, 0xFC, 0xCE, 0x36, 0xE0, 0xF6, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0xB3, 0xFD, 0x8F, 0xCC, 0x06,
  0x01, 0xFC, 0x38, 0xC7, 0x06, 0x60, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x03, 0x01, 0x3F, 0xF0, 0xFE, 0x01, 0x01, 0xF0, 0xE4,
  0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x0F, 0xF3, 0xFC, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x06,
  0x00, 0xFC, 0xCE, 0x36, 0xE0, 0xF6, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0xB3, 0xFD, 0x8F, 0xCC, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x68, 0x07, 0x38, 0xF1,
  0xFF, 0x03, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC7, 0x0C, 0xFC, 0xD9, 0xEF, 0x06, 0xE0, 0x6E, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x7D, 0x80, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x19,
  0xC6, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7F, 0x7B, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x1B, 0x07, 0x60, 0xCC, 0x31, 0x86, 0x31, 0x86, 0x70, 0xCC, 0x1B,
  0x83, 0x78, 0x7B, 0x0E, 0x61, 0x86, 0x30, 0xC6, 0x1C, 0xC1, 0x98, 0x33,
  0x03, 0x60, 0x6C, 0x0F, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x06, 0x03, 0x09, 0xF8, 0xFE, 0xD9, 0xCC, 0xEE, 0x0D, 0x07,
  0xE0, 0x70, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0x07, 0x08, 0xFC,
  0xD9, 0xEF, 0x06, 0xE0, 0x6C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0x00, 0xFE, 0x0E, 0x38, 0xE0,
  0xE6, 0x03, 0x70, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x01, 0x98,
  0x0C, 0xE0, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x04, 0x7E, 0x36, 0x39, 0xE0,
  0xEE, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x37, 0x01, 0xB8,
  0x1D, 0xE0, 0xCD, 0xFE, 0x67, 0xE3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x06, 0x00, 0xFC,
  0xCE, 0x36, 0xE0, 0xF6, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0xB3, 0xFD, 0x8F, 0xCC, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x8F, 0xDF, 0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0x07,
  0xFD, 0xE3, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x1C, 0x03,
  0xC0, 0x6F, 0xFC, 0xFF, 0x00, 0x30, 0x30, 0x30, 0x30, 0x30, 0xFF, 0xFF,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x3F, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0B, 0xE1, 0xB7,
  0xF3, 0x3E, 0x30, 0xE0, 0x1B, 0x01, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x18,
  0x18, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x30, 0x31, 0x81, 0x8C,
  0x06, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x2C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0xE0, 0x38, 0x0D, 0x80, 0xE0, 0x76, 0x07, 0x81, 0x98, 0x1E,
  0x06, 0x70, 0x68, 0x18, 0xC1, 0xB0, 0x63, 0x06, 0xC3, 0x0C, 0x33, 0x0C,
  0x30, 0xCC, 0x30, 0x63, 0x10, 0xC1, 0x8C, 0x63, 0x06, 0x21, 0x98, 0x19,
  0x86, 0x60, 0x66, 0x19, 0x80, 0xD8, 0x26, 0x03, 0x60, 0xD8, 0x0D, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0x80,
  0xE0, 0x76, 0x06, 0x60, 0xE3, 0x0C, 0x30, 0xC1, 0x98, 0x19, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0x01, 0x98, 0x19, 0x83, 0x1C,
  0x30, 0xC6, 0x0E, 0x60, 0x6E, 0x06, 0xC0, 0x30, 0x60, 0x1B, 0x00, 0xD8,
  0x06, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC3, 0x0C, 0x18, 0x60, 0xC3,
  0x06, 0x18, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x0B, 0xC0, 0x7C, 0x01, 0x80, 0x00, 0x7F,
  0xBF, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03,
  0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x1F, 0xFF, 0xF8, 0x00,
  0x40, 0xF0, 0x78, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x3C, 0x0F, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x3C, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x3E, 0x0F,
  0x00, 0x7E, 0x07, 0xFE, 0x1C, 0x1F, 0xE0, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 9, 11, 13, 2, -29 },
  { 25, 16, 29, 18, 1, -29 },
  { 83, 14, 32, 16, 1, -30 },
  { 139, 21, 29, 25, 2, -29 },
  { 216, 16, 29, 17, 1, -29 },
  { 274, 3, 11, 7, 2, -29 },
  { 279, 8, 35, 11, 2, -29 },
  { 314, 8, 35, 11, 1, -29 },
  { 349, 11, 11, 15, 2, -30 },
  { 365, 14, 18, 17, 1, -23 },
  { 397, 5, 9, 8, 1, -4 },
  { 403, 9, 2, 11, 1, -12 },
  { 406, 4, 4, 8, 2, -4 },
  { 408, 12, 29, 14, 1, -29 },
  { 452, 13, 29, 16, 2, -29 },
  { 500, 8, 29, 16, 3, -29 },
  { 529, 14, 29, 16, 1, -29 },
  { 580, 14, 29, 16, 1, -29 },
  { 631, 15, 29, 16, 1, -29 },
  { 686, 13, 29, 16, 2, -29 },
  { 734, 13, 29, 16, 2, -29 },
  { 782, 13, 29, 16, 2, -29 },
  { 830, 14, 29, 16, 1, -29 },
  { 881, 12, 29, 16, 2, -29 },
  { 925, 3, 21, 8, 3, -21 },
  { 933, 5, 26, 8, 1, -21 },
  { 950, 14, 17, 17, 1, -23 },
  { 980, 14, 10, 17, 1, -19 },
  { 998, 14, 17, 17, 1, -23 },
  { 1028, 10, 29, 12, 1, -29 },
  { 1065, 21, 33, 25, 2, -29 },
  { 1152, 17, 29, 17, 0, -29 },
  { 1214, 14, 29, 18, 3, -29 },
  { 1265, 14, 29, 17, 2, -29 },
  { 1316, 15, 29, 20, 3, -29 },
  { 1371, 11, 29, 16, 3, -29 },
  { 1411, 11, 29, 15, 3, -29 },
  { 1451, 17, 29, 21, 2, -29 },
  { 1513, 14, 29, 20, 3, -29 },
  { 1564, 8, 29, 10, 1, -29 },
  { 1593, 7, 36, 8, -2, -29 },
  { 1625, 14, 29, 17, 3, -29 },
  { 1676, 11, 29, 14, 3, -29 },
  { 1716, 21, 29, 27, 3, -29 },
  { 1793, 15, 29, 21, 3, -29 },
  { 1848, 17, 29, 21, 2, -29 },
  { 1910, 12, 29, 17, 3, -29 },
  { 1954, 17, 36, 21, 2, -29 },
  { 2031, 14, 29, 17, 3, -29 },
  { 2082, 12, 29, 16, 2, -29 },
  { 2126, 14, 29, 14, 0, -29 },
  { 2177, 14, 29, 20, 3, -29 },
  { 2228, 16, 29, 16, 0, -29 },
  { 2286, 27, 29, 27, 0, -29 },
  { 2384, 14, 29, 15, 0, -29 },
  { 2435, 14, 29, 14, 0, -29 },
  { 2486, 12, 29, 14, 1, -29 },
  { 2530, 8, 35, 12, 3, -29 },
  { 2565, 12, 29, 14, 1, -29 },
  { 2609, 8, 35, 12, 1, -29 },
  { 2644, 15, 15, 17, 1, -29 },
  { 2673, 17, 2, 17, 0, 3 },
  { 2678, 6, 7, 10, 2, -31 },
  { 2684, 12, 22, 16, 1, -22 },
  { 2717, 13, 30, 18, 3, -30 },
  { 2766, 10, 22, 13, 2, -22 },
  { 2794, 13, 30, 18, 2, -30 },
  { 2843, 12, 22, 16, 2, -22 },
  { 2876, 10, 31, 9, 0, -31 },
  { 2915, 13, 32, 18, 2, -22 },
  { 2967, 12, 30, 17, 3, -30 },
  { 3012, 3, 29, 8, 2, -29 },
  { 3023, 5, 39, 8, 0, -29 },
  { 3048, 11, 30, 14, 3, -30 },
  { 3090, 2, 30, 8, 3, -30 },
  { 3098, 20, 22, 26, 3, -22 },
  { 3153, 12, 22, 17, 3, -22 },
  { 3186, 13, 22, 17, 2, -22 },
  { 3222, 13, 31, 18, 3, -22 },
  { 3273, 13, 31, 18, 2, -22 },
  { 3324, 8, 22, 11, 3, -22 },
  { 3346, 11, 22, 13, 1, -22 },
  { 3377, 8, 26, 9, 1, -26 },
  { 3403, 12, 21, 17, 3, -21 },
  { 3435, 13, 21, 13, 0, -21 },
  { 3470, 22, 21, 22, 0, -21 },
  { 3528, 12, 21, 14, 1, -21 },
  { 3560, 13, 31, 14, 0, -21 },
  { 3611, 9, 21, 11, 1, -21 },
  { 3635, 10, 35, 14, 2, -29 },
  { 3679, 2, 40, 16, 7, -30 },
  { 3689, 10, 35, 14, 2, -29 },
  { 3733, 14, 4, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Light40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT40PT7B_H_
