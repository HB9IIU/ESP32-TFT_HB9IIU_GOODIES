#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x5F, 0xF0,
  0xE3, 0xF1, 0xD8, 0xEC, 0x76, 0x3B, 0x1D, 0x84, 0xC2, 0x61, 0x20, 0x80,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x04, 0x18,
  0x04, 0x10, 0x0C, 0x10, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x08, 0x30, 0x08, 0x30, 0x08, 0x20, 0x18, 0x20, 0xFF, 0xFE,
  0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x10, 0x60, 0x10, 0x40,
  0x30, 0x40, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x03, 0xF8, 0x1F, 0xF8, 0xCC, 0x46, 0x30, 0x18, 0xC0, 0xC3, 0x03,
  0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xCC, 0x01, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0xC0, 0x33, 0x80, 0xC6, 0x03, 0x0C, 0x0C, 0x30, 0x30,
  0xC0, 0xC3, 0x03, 0x1A, 0x0C, 0xEF, 0xBF, 0x1F, 0xF8, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x3C, 0x03, 0x06, 0xE0, 0x60, 0xC6, 0x06, 0x0C,
  0x20, 0x60, 0xC3, 0x0C, 0x0C, 0x30, 0xC0, 0xC3, 0x0C, 0x08, 0x31, 0x80,
  0x83, 0x18, 0x08, 0x31, 0x00, 0xC3, 0x30, 0x0C, 0x33, 0x3C, 0xC3, 0x23,
  0xEC, 0x26, 0x63, 0x46, 0x64, 0x37, 0xE4, 0xC3, 0x3C, 0xCC, 0x30, 0x0C,
  0xC1, 0x00, 0x8C, 0x10, 0x18, 0xC1, 0x01, 0x8C, 0x10, 0x10, 0xC1, 0x03,
  0x0C, 0x30, 0x30, 0xC3, 0x02, 0x04, 0x30, 0x60, 0x63, 0x06, 0x07, 0x60,
  0xC0, 0x3C, 0x0F, 0x80, 0x1F, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0x60,
  0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x19, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1B, 0x00, 0x33, 0x06, 0x71, 0x86,
  0x61, 0xC6, 0xE0, 0xC6, 0xC0, 0xEC, 0xC0, 0x6C, 0xC0, 0x3C, 0xC0, 0x38,
  0xE0, 0x38, 0x60, 0x7C, 0x70, 0x6C, 0x3F, 0xC6, 0x1F, 0x87, 0xFD, 0xB6,
  0xDB, 0x6C, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x38, 0x60, 0xC1, 0x87,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60,
  0xC1, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0xE0, 0x60, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x30, 0x70, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0C,
  0xCF, 0xFF, 0xC7, 0x80, 0xF0, 0x1B, 0x06, 0x71, 0x87, 0x10, 0x40, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C,
  0xC0, 0xFF, 0xFF, 0x4E, 0xF6, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x0F,
  0x83, 0xFC, 0x30, 0xC7, 0x06, 0x60, 0x66, 0x06, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x76, 0x06, 0x70,
  0x63, 0x0C, 0x3F, 0xC1, 0xF8, 0x06, 0x1C, 0x79, 0xF7, 0x7C, 0xD1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x1F, 0xC3, 0xFF, 0x18, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xC3, 0xFF, 0x38, 0x1C, 0x80, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x3C, 0x0F, 0x80, 0x7F, 0x00, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x34, 0x03, 0x9F, 0xF8,
  0xFF, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x6C, 0x00, 0xD8, 0x03, 0x30, 0x06, 0x60, 0x08, 0xC0, 0x31, 0x80, 0x43,
  0x01, 0x86, 0x03, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xC3,
  0x01, 0x86, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x7F, 0xE7, 0xFE, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0D,
  0xF0, 0xFF, 0xC4, 0x1E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x68, 0x0E, 0xFF, 0xCF,
  0xF0, 0x07, 0xE0, 0xFE, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xFC, 0xDF, 0xEF, 0x06, 0xE0, 0x7E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x36,
  0x03, 0x60, 0x77, 0x06, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x83, 0x1C, 0x0E,
  0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x70, 0x18, 0xC0, 0xC3, 0x87,
  0x07, 0x38, 0x0F, 0xC0, 0x1E, 0x00, 0xFC, 0x06, 0x38, 0x30, 0x31, 0x80,
  0xE6, 0x01, 0x98, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xD8, 0x06, 0x60,
  0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x70, 0xCE, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x60, 0xF7, 0xBB, 0x3F, 0x30, 0x43, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x7F, 0x07, 0xE0,
  0x6E, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x6F, 0x60, 0x31,
  0xCE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x63,
  0x19, 0x8C, 0x66, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x7E, 0x7F,
  0xA0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x1C, 0x0E, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0x80, 0xE0, 0x18, 0x03, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x06, 0x60, 0x7C, 0x33, 0x06, 0x61, 0x90, 0x63, 0x05, 0x86,
  0x18, 0x2C, 0x30, 0xC1, 0xE1, 0x86, 0x0F, 0x0C, 0x30, 0x78, 0x61, 0x83,
  0xC3, 0x0C, 0x1E, 0x18, 0x60, 0xB0, 0xC3, 0x0D, 0x86, 0x18, 0x6C, 0x31,
  0xC3, 0x60, 0xCB, 0x31, 0x07, 0xCF, 0x8C, 0x08, 0x10, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x20, 0x07, 0x87,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x1F, 0xF8, 0x1F, 0xFC, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0E,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xFF, 0x07, 0xFF, 0x30, 0x39, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0xCF, 0xFC, 0x7F, 0xC3, 0x07,
  0x98, 0x0E, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x36, 0x07, 0xBF, 0xF9, 0xFF, 0x00, 0x03, 0xF8,
  0x3F, 0xF1, 0xC0, 0x86, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x10, 0xFF, 0x80, 0xFE, 0xFF,
  0x03, 0xFF, 0x0C, 0x1E, 0x30, 0x1C, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xB0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x73, 0x03, 0x8F, 0xFC, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xF7, 0xFE, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0x80, 0xC3, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00,
  0x0D, 0xC0, 0x06, 0x60, 0x03, 0x18, 0x01, 0x8F, 0x00, 0xC3, 0xFF, 0xE0,
  0x7F, 0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFE, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x31, 0xF7, 0xF0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0F, 0xFB, 0xE0, 0xC0,
  0x3E, 0x01, 0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0xE3, 0x06, 0x18, 0x70,
  0xC3, 0x06, 0x30, 0x31, 0x81, 0x98, 0x0D, 0xC0, 0x6E, 0x03, 0xF8, 0x1C,
  0xC0, 0xE7, 0x06, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x1C, 0x60, 0x63, 0x03,
  0x98, 0x0C, 0xC0, 0x76, 0x01, 0xB0, 0x0F, 0x80, 0x30, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0D, 0xEC, 0x00, 0x6F,
  0x60, 0x03, 0x7B, 0x00, 0x13, 0xC8, 0x01, 0x9E, 0x60, 0x0C, 0xF3, 0x00,
  0x67, 0x98, 0x06, 0x3C, 0x60, 0x31, 0xE3, 0x01, 0x8F, 0x18, 0x18, 0x78,
  0x60, 0xC3, 0xC3, 0x06, 0x1E, 0x18, 0x30, 0xF0, 0xC3, 0x07, 0x83, 0x18,
  0x3C, 0x18, 0xC1, 0xE0, 0xCC, 0x0F, 0x03, 0x60, 0x78, 0x1B, 0x03, 0xC0,
  0xD8, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x30, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7B, 0x00, 0xF6, 0x01, 0xE6,
  0x03, 0xCC, 0x07, 0x9C, 0x0F, 0x18, 0x1E, 0x30, 0x3C, 0x30, 0x78, 0x60,
  0xF0, 0x61, 0xE0, 0xC3, 0xC1, 0xC7, 0x81, 0x8F, 0x03, 0x9E, 0x03, 0x3C,
  0x06, 0x78, 0x06, 0xF0, 0x0D, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x70, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x07, 0x07, 0x01, 0xC3,
  0x00, 0x63, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x01,
  0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x19, 0xC0, 0x1C, 0x60, 0x0C, 0x38, 0x0E, 0x0E, 0x0E, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x0F, 0xFC, 0xC1, 0xEC, 0x06, 0xC0, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x0E,
  0xC3, 0xCF, 0xF8, 0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xF0, 0x07,
  0xFC, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x39, 0x80, 0x0C,
  0xC0, 0x06, 0xE0, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xDC, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0xC0, 0x1C, 0x60, 0x0C,
  0x38, 0x0E, 0x0E, 0x0E, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0xFE, 0x07, 0xFE, 0x30, 0x79, 0x80, 0xCC, 0x07, 0x60, 0x1B, 0x00, 0xD8,
  0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0xEC, 0x06, 0x60, 0xE3, 0xFE,
  0x1F, 0xE0, 0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x0C, 0x60, 0x63,
  0x03, 0x98, 0x0C, 0xC0, 0x76, 0x01, 0xB0, 0x0F, 0x80, 0x30, 0x1F, 0xE3,
  0xFF, 0x70, 0x2E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x68,
  0x0E, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x06, 0x60,
  0x19, 0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x1C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x18, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0xC0, 0x0C, 0x00, 0xF8, 0x03, 0x80, 0x36, 0x00, 0xE0, 0x0D,
  0x80, 0x38, 0x03, 0x60, 0x1E, 0x01, 0xD8, 0x06, 0x80, 0x63, 0x01, 0xB0,
  0x18, 0xC0, 0x6C, 0x06, 0x30, 0x1B, 0x01, 0x8C, 0x0C, 0xC0, 0xE3, 0x83,
  0x30, 0x30, 0x60, 0xC6, 0x0C, 0x18, 0x31, 0x83, 0x06, 0x0C, 0x61, 0xC1,
  0x86, 0x18, 0x60, 0x71, 0x86, 0x18, 0x0C, 0x60, 0xC6, 0x03, 0x18, 0x31,
  0x80, 0xC6, 0x0C, 0xE0, 0x33, 0x03, 0x30, 0x0E, 0xC0, 0xCC, 0x01, 0xB0,
  0x1B, 0x00, 0x6C, 0x06, 0xC0, 0x1B, 0x01, 0xF0, 0x06, 0x80, 0x78, 0x00,
  0xE0, 0x1E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0xC0,
  0x63, 0x01, 0x8E, 0x0E, 0x18, 0x30, 0x60, 0xC0, 0xC6, 0x03, 0x18, 0x0C,
  0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x06, 0xC0, 0x1B, 0x00, 0xCC, 0x03, 0x18, 0x18, 0x60, 0x61, 0xC1,
  0x83, 0x0C, 0x0C, 0x30, 0x39, 0xC0, 0x66, 0x01, 0xB8, 0x07, 0xC0, 0x1F,
  0x80, 0x66, 0x01, 0x98, 0x0E, 0x70, 0x30, 0xC0, 0xC3, 0x07, 0x06, 0x18,
  0x18, 0x60, 0x61, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF,
  0xEF, 0xFE, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x03, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x36, 0x00, 0xEC, 0x01, 0x8C, 0x07, 0x18, 0x0C, 0x38, 0x38, 0x30,
  0x60, 0x61, 0xC0, 0x63, 0x00, 0xC6, 0x00, 0xD8, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x1F, 0x83, 0xFC, 0x20, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x1F, 0x33,
  0x03, 0x60, 0x36, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x76, 0x07, 0x60, 0xB7,
  0xBB, 0x3F, 0x30, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x7C, 0x37, 0xF1, 0xE1, 0xCE, 0x07,
  0x70, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB8, 0x1D, 0xE0,
  0xCD, 0xFC, 0x47, 0xC0, 0x0F, 0xCF, 0xF3, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0xF8, 0xCF,
  0xE6, 0xE1, 0xB6, 0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3F,
  0x01, 0xD8, 0x1E, 0xE0, 0xB3, 0xDD, 0x8F, 0xCC, 0x1F, 0x83, 0xFC, 0x70,
  0xC6, 0x06, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x23, 0xDE, 0x1F, 0xE0, 0x07, 0x83, 0xF0, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0F, 0xCF, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x1F, 0x19, 0xFC, 0xDC, 0x36, 0xC0,
  0xFE, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3B, 0x03, 0xDC,
  0x16, 0x7F, 0x31, 0xF1, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x0D, 0x00, 0xC7, 0xFE, 0x3F, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x19, 0xF3, 0x7F, 0x78, 0x7E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xC0, 0x4F, 0xB0, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x10, 0xCE, 0x30, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7F, 0x78,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x1B, 0x07, 0x60, 0xCC, 0x31, 0x86, 0x31, 0x86, 0x70, 0xCC, 0x1B,
  0x83, 0x70, 0x7F, 0x0E, 0x61, 0x8C, 0x30, 0xC6, 0x18, 0xC3, 0x98, 0x33,
  0x06, 0x60, 0x6C, 0x0D, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x8F, 0x07, 0x89, 0xF8, 0xFC, 0xB1, 0xD0, 0xEE, 0x0F, 0x06,
  0xC0, 0xE0, 0x6C, 0x06, 0x07, 0xC0, 0x60, 0x7C, 0x06, 0x03, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x30, 0x8F, 0x93, 0xFA, 0xC3, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06,
  0x1F, 0x81, 0xFE, 0x1C, 0x18, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x06, 0xE0, 0x33, 0x01, 0x9C, 0x18, 0x7F, 0xC1, 0xFC, 0x00, 0x8F,
  0x84, 0xFE, 0x2C, 0x39, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1B, 0x00, 0xD8,
  0x06, 0xE0, 0x37, 0x03, 0xBC, 0x19, 0xBF, 0x8C, 0xF8, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x1F, 0x19, 0xFC, 0xDC, 0x36, 0xC0, 0xF6, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x3B, 0x03, 0xDC, 0x16, 0x7F, 0x31, 0xF1, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x8F, 0x9E, 0xB0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x8F,
  0xF7, 0x05, 0x80, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x1F, 0xFE, 0x7F,
  0x00, 0x30, 0x30, 0x30, 0x30, 0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x3F, 0x1F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x87, 0xBF, 0xB3, 0xE2, 0xC0, 0x1F, 0x01, 0x98,
  0x0C, 0xC0, 0x66, 0x03, 0x38, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x86,
  0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x40, 0x36, 0x01, 0xB0, 0x0D, 0x80,
  0x68, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x30, 0x1B, 0x01, 0x80,
  0xD8, 0x1E, 0x06, 0xC0, 0xF0, 0x36, 0x07, 0x83, 0x18, 0x3C, 0x18, 0xC3,
  0x20, 0xC6, 0x19, 0x86, 0x30, 0xCC, 0x31, 0x86, 0x63, 0x06, 0x33, 0x18,
  0x33, 0x08, 0xC1, 0x98, 0x66, 0x0C, 0xC3, 0x30, 0x66, 0x1B, 0x01, 0xA0,
  0xD8, 0x0F, 0x02, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x60, 0x38, 0x00, 0xC0, 0x76, 0x06, 0x60, 0xE7, 0x0C, 0x30, 0xC3, 0x18,
  0x19, 0x81, 0xB0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x01, 0xB0,
  0x19, 0x83, 0x18, 0x30, 0xC6, 0x0C, 0x60, 0xEE, 0x06, 0xC0, 0x70, 0x60,
  0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x63, 0x03, 0x18, 0x18, 0xC1, 0xC6, 0x0C,
  0x18, 0x60, 0xC3, 0x06, 0x38, 0x31, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x01,
  0xB0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x0F, 0x80, 0x7C, 0x00,
  0x7F, 0xBF, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x1F, 0xFF, 0xF8,
  0x01, 0xC1, 0xF0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0xF0, 0x3C, 0x03, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x38, 0x07, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x3E, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0xC0, 0xF0, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0xF8, 0x3C, 0x00,
  0x3C, 0x05, 0xFC, 0x1C, 0x3F, 0xE0, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 28, 8, 3, -28 },
  { 12, 9, 10, 13, 2, -28 },
  { 24, 16, 28, 17, 1, -28 },
  { 80, 14, 32, 16, 1, -30 },
  { 136, 20, 28, 24, 2, -28 },
  { 206, 16, 28, 17, 1, -28 },
  { 262, 3, 10, 7, 2, -28 },
  { 266, 7, 34, 11, 2, -28 },
  { 296, 8, 34, 11, 1, -28 },
  { 330, 11, 12, 14, 2, -30 },
  { 347, 14, 18, 16, 1, -23 },
  { 379, 5, 9, 8, 1, -4 },
  { 385, 8, 2, 10, 1, -12 },
  { 387, 4, 4, 8, 2, -4 },
  { 389, 12, 28, 14, 1, -28 },
  { 431, 12, 28, 16, 2, -28 },
  { 473, 7, 28, 16, 3, -28 },
  { 498, 13, 28, 16, 1, -28 },
  { 544, 13, 28, 16, 1, -28 },
  { 590, 15, 28, 16, 1, -28 },
  { 643, 12, 28, 16, 2, -28 },
  { 685, 12, 28, 16, 2, -28 },
  { 727, 13, 28, 16, 1, -28 },
  { 773, 14, 28, 16, 1, -28 },
  { 822, 12, 28, 16, 2, -28 },
  { 864, 4, 21, 8, 2, -21 },
  { 875, 5, 26, 8, 1, -21 },
  { 892, 14, 17, 16, 1, -22 },
  { 922, 14, 10, 16, 1, -19 },
  { 940, 14, 17, 16, 1, -22 },
  { 970, 9, 28, 11, 1, -28 },
  { 1002, 21, 31, 24, 2, -28 },
  { 1084, 16, 28, 16, 0, -28 },
  { 1140, 13, 28, 18, 3, -28 },
  { 1186, 14, 28, 17, 2, -28 },
  { 1235, 14, 28, 19, 3, -28 },
  { 1284, 10, 28, 15, 3, -28 },
  { 1319, 11, 28, 14, 3, -28 },
  { 1358, 17, 28, 21, 2, -28 },
  { 1418, 14, 28, 20, 3, -28 },
  { 1467, 7, 28, 10, 1, -28 },
  { 1492, 7, 35, 8, -2, -28 },
  { 1523, 13, 28, 16, 3, -28 },
  { 1569, 10, 28, 14, 3, -28 },
  { 1604, 21, 28, 27, 3, -28 },
  { 1678, 15, 28, 21, 3, -28 },
  { 1731, 17, 28, 21, 2, -28 },
  { 1791, 12, 28, 16, 3, -28 },
  { 1833, 17, 35, 21, 2, -28 },
  { 1908, 13, 28, 17, 3, -28 },
  { 1954, 12, 28, 16, 2, -28 },
  { 1996, 14, 28, 14, 0, -28 },
  { 2045, 14, 28, 20, 3, -28 },
  { 2094, 16, 28, 16, 0, -28 },
  { 2150, 26, 28, 27, 0, -28 },
  { 2241, 14, 28, 14, 0, -28 },
  { 2290, 14, 28, 14, 0, -28 },
  { 2339, 12, 28, 13, 1, -28 },
  { 2381, 8, 34, 12, 3, -28 },
  { 2415, 12, 28, 14, 1, -28 },
  { 2457, 8, 34, 12, 1, -28 },
  { 2491, 15, 14, 16, 1, -28 },
  { 2518, 16, 2, 16, 0, 3 },
  { 2522, 6, 6, 10, 2, -30 },
  { 2527, 12, 21, 15, 1, -21 },
  { 2559, 13, 30, 17, 3, -30 },
  { 2608, 10, 21, 13, 2, -21 },
  { 2635, 13, 30, 17, 2, -30 },
  { 2684, 12, 21, 16, 2, -21 },
  { 2716, 10, 30, 9, 0, -30 },
  { 2754, 13, 30, 17, 2, -21 },
  { 2803, 11, 30, 17, 3, -30 },
  { 2845, 3, 29, 8, 2, -29 },
  { 2856, 5, 38, 8, 0, -29 },
  { 2880, 11, 30, 14, 3, -30 },
  { 2922, 2, 30, 7, 3, -30 },
  { 2930, 20, 21, 25, 3, -21 },
  { 2983, 11, 21, 17, 3, -21 },
  { 3012, 13, 21, 17, 2, -21 },
  { 3047, 13, 30, 17, 3, -21 },
  { 3096, 13, 30, 17, 2, -21 },
  { 3145, 8, 21, 11, 3, -21 },
  { 3166, 10, 21, 13, 1, -21 },
  { 3193, 8, 26, 9, 1, -26 },
  { 3219, 11, 21, 17, 3, -21 },
  { 3248, 13, 21, 13, 0, -21 },
  { 3283, 21, 21, 22, 0, -21 },
  { 3339, 12, 21, 13, 1, -21 },
  { 3371, 13, 30, 13, 0, -21 },
  { 3420, 9, 21, 11, 1, -21 },
  { 3444, 10, 34, 14, 2, -28 },
  { 3487, 2, 39, 15, 7, -30 },
  { 3497, 10, 34, 14, 2, -28 },
  { 3540, 14, 4, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_Light39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT39PT7B_H_
