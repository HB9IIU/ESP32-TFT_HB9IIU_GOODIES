#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x76, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x60, 0x76, 0x07, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0,
  0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF1, 0xE6, 0x1C, 0x78, 0xC0, 0x8E, 0x18,
  0x03, 0x83, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30,
  0x07, 0x06, 0x00, 0xE0, 0xC0, 0x0E, 0x18, 0x01, 0xE3, 0x00, 0x1E, 0x60,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x19, 0xF0, 0x03, 0x0F, 0x00, 0x60, 0xE0, 0x0C, 0x0E, 0x01, 0x81,
  0xC0, 0x30, 0x38, 0x06, 0x07, 0x00, 0xC0, 0xE0, 0x18, 0x1C, 0x03, 0x03,
  0x80, 0x60, 0xE8, 0x0C, 0x3D, 0xE1, 0x8F, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x07, 0xF0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x18, 0x01, 0xFC,
  0x00, 0xE0, 0x0E, 0x38, 0x03, 0x00, 0x30, 0x60, 0x0C, 0x01, 0xC1, 0xC0,
  0x70, 0x06, 0x07, 0x01, 0x80, 0x18, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x38,
  0x01, 0x80, 0xC0, 0xC0, 0x0E, 0x03, 0x03, 0x00, 0x38, 0x0C, 0x1C, 0x00,
  0xE0, 0x30, 0x60, 0x03, 0x80, 0xC1, 0x80, 0x0E, 0x03, 0x0E, 0x00, 0x38,
  0x0C, 0x30, 0x00, 0x60, 0x30, 0xC1, 0x81, 0x80, 0xC7, 0x1F, 0x86, 0x07,
  0x18, 0xFF, 0x1C, 0x1C, 0x63, 0x8E, 0x70, 0x63, 0x9C, 0x38, 0xC1, 0x8C,
  0x70, 0x63, 0x8E, 0x71, 0x81, 0xC7, 0xF1, 0xC6, 0x07, 0x1F, 0x86, 0x18,
  0x1C, 0x08, 0x38, 0xE0, 0x30, 0x00, 0xE3, 0x80, 0xC0, 0x03, 0x0E, 0x03,
  0x00, 0x1C, 0x38, 0x0C, 0x00, 0x70, 0xE0, 0x30, 0x01, 0x83, 0x80, 0xC0,
  0x0E, 0x0E, 0x03, 0x00, 0x38, 0x38, 0x1C, 0x00, 0xC0, 0x60, 0x70, 0x07,
  0x01, 0x81, 0xC0, 0x1C, 0x06, 0x07, 0x00, 0x60, 0x1C, 0x18, 0x03, 0x80,
  0x30, 0xE0, 0x0E, 0x00, 0xE3, 0x80, 0x30, 0x01, 0xFC, 0x01, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0x8F, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xC0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E,
  0x00, 0x07, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x1C, 0x0E, 0x70,
  0x70, 0x39, 0xC0, 0xE0, 0xEE, 0x03, 0x83, 0xB8, 0x07, 0x1C, 0xE0, 0x1E,
  0x73, 0x80, 0x39, 0xCE, 0x00, 0x7E, 0x38, 0x01, 0xF8, 0xE0, 0x03, 0xE3,
  0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x3C, 0x01, 0xF8, 0x70, 0x07, 0xF1, 0xE0,
  0x39, 0xC3, 0xE3, 0xC7, 0x8F, 0xFE, 0x0E, 0x0F, 0xF0, 0x3C, 0x0C, 0x00,
  0x00, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x01, 0xE0, 0x30, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x00,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x41, 0x81,
  0x71, 0x8F, 0xFF, 0xFF, 0x3F, 0xFC, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0x70,
  0x0E, 0x30, 0x0E, 0x38, 0x1C, 0x1C, 0x38, 0x1E, 0x08, 0x08, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x18,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xFE, 0xF7, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07,
  0x8F, 0x01, 0xE0, 0xF0, 0x38, 0x0E, 0x0F, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x8F, 0x00, 0x79, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B, 0xC0,
  0x07, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x01, 0xC7, 0x00,
  0x70, 0xE0, 0x0E, 0x1E, 0x01, 0xC1, 0xC0, 0x70, 0x3C, 0x1E, 0x03, 0xEF,
  0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0,
  0xEE, 0x79, 0xDE, 0x3F, 0x87, 0xE0, 0xE8, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xF0, 0xF8, 0x70, 0x0F,
  0x08, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x80,
  0x03, 0xFE, 0x03, 0xFF, 0xE3, 0xF0, 0xFC, 0xF0, 0x0F, 0x10, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0xB0, 0x03, 0xCF,
  0x83, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0D,
  0xC0, 0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00,
  0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x60, 0x0E, 0x07, 0x00, 0x70,
  0x30, 0x03, 0x83, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x80, 0x1E, 0x3C, 0x3F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x02, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7C, 0x30, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x87, 0xC0, 0xE7, 0xFC, 0x3B, 0xFF, 0x8E, 0xC1, 0xF3, 0xE0, 0x1C,
  0xF0, 0x07, 0xBC, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3B, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x78, 0xE0, 0x1C,
  0x3C, 0x0F, 0x07, 0x87, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x8F, 0x83, 0xC0, 0x78, 0x70,
  0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE0, 0xE0,
  0x3C, 0x1E, 0x0F, 0x01, 0xE3, 0xC0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xF8, 0x03, 0xC7, 0x80, 0xE0, 0x78, 0x3C, 0x07, 0x8F, 0x00,
  0x79, 0xC0, 0x07, 0x78, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xB8, 0x00,
  0xE7, 0x80, 0x3C, 0x78, 0x07, 0x0F, 0x83, 0xE0, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7C, 0x78,
  0x3C, 0x0F, 0x0E, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xBC,
  0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F,
  0x78, 0x03, 0xCE, 0x01, 0xF3, 0xC0, 0xDC, 0x7F, 0xF7, 0x0F, 0xF9, 0xC1,
  0xF8, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x03, 0x0F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x01,
  0x80, 0x00, 0xEF, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xFF, 0xFE, 0x38, 0xF3, 0xCF, 0x3C, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x18, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x06,
  0x00, 0xFF, 0x0F, 0xFF, 0x3E, 0x3E, 0x40, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x1C, 0x60, 0x0F, 0xE0, 0x67, 0x00, 0xFF, 0x83, 0xB8, 0x0E,
  0x1C, 0x1D, 0x80, 0xE0, 0xC0, 0xEC, 0x0E, 0x06, 0x03, 0xE0, 0x70, 0x30,
  0x1F, 0x03, 0x81, 0x80, 0xF8, 0x18, 0x0C, 0x07, 0xC1, 0xC0, 0xE0, 0x3E,
  0x0E, 0x07, 0x01, 0xF0, 0x70, 0x38, 0x0F, 0x03, 0x81, 0xC0, 0x78, 0x1C,
  0x0E, 0x03, 0xC0, 0xE0, 0x70, 0x1F, 0x07, 0x03, 0x81, 0xF8, 0x38, 0x1C,
  0x0F, 0xC1, 0xC0, 0xE0, 0x7E, 0x06, 0x0F, 0x03, 0x70, 0x38, 0x68, 0x3B,
  0x81, 0xC7, 0x61, 0xCC, 0x07, 0xF3, 0xFC, 0x60, 0x1F, 0x0F, 0xC3, 0x80,
  0x60, 0x18, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0F, 0x0F, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x79, 0xE0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x07, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0xF7, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x07, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0E, 0x07, 0xF1, 0xC0, 0x0F, 0x38, 0x00, 0xF7, 0x00, 0x0E, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0x70, 0x01, 0xEE, 0x00, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x7E, 0x1E, 0x0F,
  0x80, 0x20, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x02,
  0x07, 0xF1, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xC0, 0x3E, 0x0E, 0x00, 0x78, 0x70,
  0x01, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x3C, 0xE0, 0x00, 0xE7, 0x00, 0x07,
  0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01,
  0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x0F, 0x0E, 0x01, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0x0E, 0x0F, 0x00, 0x02, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x03, 0xF0, 0x7F, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x8F, 0xFF,
  0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F,
  0xFE, 0xFF, 0x3F, 0x80, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0E, 0x70,
  0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0,
  0x3C, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0E, 0x0F, 0x01, 0xC1,
  0xC0, 0x38, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0xF0, 0x03, 0x9E,
  0x00, 0x77, 0xC0, 0x0E, 0xDC, 0x01, 0xFB, 0x80, 0x3E, 0x38, 0x07, 0x87,
  0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x87, 0x00, 0x70, 0xE0, 0x0F, 0x1C, 0x00,
  0xE3, 0x80, 0x1E, 0x70, 0x01, 0xCE, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xE0, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x37,
  0xEE, 0x00, 0x01, 0xDF, 0x98, 0x00, 0x07, 0x7E, 0x70, 0x00, 0x19, 0xF9,
  0xC0, 0x00, 0xE7, 0xE3, 0x00, 0x03, 0x9F, 0x8E, 0x00, 0x0E, 0x7E, 0x38,
  0x00, 0x71, 0xF8, 0xE0, 0x01, 0xC7, 0xE1, 0x80, 0x07, 0x1F, 0x87, 0x00,
  0x18, 0x7E, 0x1C, 0x00, 0xE1, 0xF8, 0x30, 0x03, 0x87, 0xE0, 0xE0, 0x0E,
  0x1F, 0x83, 0x80, 0x70, 0x7E, 0x0E, 0x01, 0xC1, 0xF8, 0x1C, 0x07, 0x07,
  0xE0, 0x70, 0x38, 0x1F, 0x81, 0xC0, 0xE0, 0x7E, 0x03, 0x03, 0x81, 0xF8,
  0x0E, 0x0C, 0x07, 0xE0, 0x38, 0x70, 0x1F, 0x80, 0x61, 0xC0, 0x7E, 0x01,
  0xC7, 0x01, 0xF8, 0x07, 0x38, 0x07, 0xE0, 0x1C, 0xE0, 0x1F, 0x80, 0x3B,
  0x80, 0x7E, 0x00, 0xEC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7E, 0xE0, 0x01, 0xFB, 0x80, 0x07, 0xE7, 0x00,
  0x1F, 0x9C, 0x00, 0x7E, 0x78, 0x01, 0xF8, 0xE0, 0x07, 0xE3, 0x80, 0x1F,
  0x87, 0x00, 0x7E, 0x1C, 0x01, 0xF8, 0x38, 0x07, 0xE0, 0xE0, 0x1F, 0x83,
  0xC0, 0x7E, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0,
  0x7E, 0x01, 0xC1, 0xF8, 0x07, 0x07, 0xE0, 0x0E, 0x1F, 0x80, 0x38, 0x7E,
  0x00, 0xE1, 0xF8, 0x01, 0xC7, 0xE0, 0x07, 0x1F, 0x80, 0x0E, 0x7E, 0x00,
  0x39, 0xF8, 0x00, 0x77, 0xE0, 0x01, 0xDF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xC3, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01,
  0xEE, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xC3, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xC3, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0xF1, 0xC0,
  0x0F, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x1F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F,
  0x03, 0x80, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1E, 0x70, 0x01,
  0xCE, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x70,
  0x00, 0xFF, 0xC0, 0xFF, 0xFC, 0x7E, 0x3E, 0x3C, 0x00, 0x8E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0xB0, 0x03, 0xCF,
  0xE7, 0xF3, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x77,
  0x00, 0x0F, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF0, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xCE, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xE0, 0xF0, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78, 0x01,
  0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0x00, 0x0E, 0x70, 0x00,
  0x78, 0x00, 0x39, 0xE0, 0x01, 0xF0, 0x00, 0xE3, 0x80, 0x0F, 0xC0, 0x03,
  0x8E, 0x00, 0x3F, 0x00, 0x1C, 0x38, 0x00, 0xEC, 0x00, 0x70, 0xE0, 0x03,
  0x30, 0x01, 0xC3, 0xC0, 0x0C, 0xE0, 0x07, 0x07, 0x00, 0x73, 0x80, 0x3C,
  0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x70, 0x07, 0x18, 0x03, 0x81, 0xC0, 0x1C,
  0x60, 0x0E, 0x03, 0x80, 0x61, 0xC0, 0x38, 0x0E, 0x03, 0x87, 0x01, 0xE0,
  0x38, 0x0E, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0xC0, 0x70, 0x07, 0x03, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x0E, 0x0E, 0x00,
  0x70, 0x70, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x07, 0x07, 0x01,
  0x83, 0x80, 0x0E, 0x18, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x1C, 0x70, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x03,
  0x1C, 0x00, 0x1C, 0xC0, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x06,
  0xE0, 0x00, 0x3E, 0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0xF3, 0x80, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x1C,
  0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x07, 0x07, 0x80,
  0x70, 0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0,
  0x01, 0xDC, 0x00, 0x0D, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xDC, 0x00, 0x1D,
  0xC0, 0x01, 0xDC, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xC0, 0x3C, 0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE7, 0x80, 0x0E,
  0x70, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x1E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC1, 0xC0,
  0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xE1,
  0x80, 0x03, 0x87, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0,
  0x0E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x10, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x1F, 0x03, 0xFF, 0x0F, 0xFF, 0x3E, 0x07,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0B, 0x70, 0x1B, 0x78, 0x33,
  0x3F, 0xF3, 0x1F, 0xC3, 0x02, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0xFE, 0x0E, 0x7F, 0xE3, 0xBC, 0xFC, 0xEC, 0x0F, 0x3E, 0x01, 0xEF, 0x00,
  0x3B, 0xC0, 0x0E, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x80, 0x7B, 0xF0, 0x1C,
  0xEE, 0x1F, 0x31, 0xFF, 0x8C, 0x3F, 0xC0, 0x01, 0x00, 0x03, 0xFC, 0x3F,
  0xF1, 0xF9, 0xCF, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x83, 0x1F, 0xFC,
  0x1F, 0xF0, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x07,
  0xE1, 0xC3, 0xFF, 0x38, 0xFC, 0xF7, 0x1E, 0x06, 0xE7, 0x80, 0x7C, 0xE0,
  0x07, 0x9C, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1E, 0x70, 0x03, 0xCE, 0x00,
  0xF8, 0xE0, 0x37, 0x1F, 0x0E, 0xE1, 0xFF, 0x8C, 0x1F, 0xE1, 0x80, 0x20,
  0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC7, 0x80, 0xE3,
  0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x43, 0xC0,
  0xE0, 0xFF, 0xF0, 0x3F, 0xE0, 0x01, 0x00, 0x01, 0xF0, 0x3F, 0xC1, 0xFE,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1F, 0xF3, 0xFF, 0x9F, 0xFC, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x03, 0xF8, 0xE1, 0xFF, 0x9C, 0x7E, 0x7B,
  0x8F, 0x03, 0x73, 0xC0, 0x3E, 0x70, 0x03, 0xDE, 0x00, 0x7B, 0x80, 0x0F,
  0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B,
  0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x7C, 0x70, 0x1B, 0x8F, 0x87, 0x70,
  0xFF, 0xCE, 0x0F, 0xF1, 0xC0, 0x20, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF1, 0x00, 0x3C, 0x3E, 0x1F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x1F, 0xC3, 0x9F, 0xF1, 0xDE, 0x7C,
  0xEC, 0x0F, 0x7C, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xEF, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x73, 0xBE,
  0xE7, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x0E, 0x0E, 0x1F, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0xBC, 0xFC, 0xF8, 0x40, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0xE0,
  0x1E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE1, 0xC0, 0xE3, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xE7, 0x80, 0xEF,
  0x80, 0xFF, 0xC0, 0xF9, 0xC0, 0xF9, 0xC0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xC3, 0xF0, 0x3F, 0x8C, 0x7F, 0x87, 0xFC, 0xCF, 0x7C, 0x73,
  0xED, 0x81, 0xEC, 0x0F, 0xD8, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x07, 0xF0,
  0x0F, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70,
  0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E,
  0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07,
  0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07,
  0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00,
  0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00,
  0x7E, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xC3,
  0xF8, 0x63, 0xFE, 0x33, 0xCF, 0x9B, 0x81, 0xED, 0x80, 0x77, 0x80, 0x3B,
  0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1C, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x7C, 0x0F, 0x03,
  0xC3, 0xC0, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x79, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x80, 0x78, 0x70, 0x1E, 0x07, 0x87, 0x80, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x10, 0x00, 0xC3, 0xF8, 0x31, 0xFF, 0x8C, 0xF1, 0xF3,
  0x30, 0x3C, 0xD8, 0x07, 0xB4, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0E, 0xF0,
  0x03, 0xBE, 0x01, 0xEE, 0xC0, 0xF3, 0xB8, 0x7C, 0xE7, 0xFE, 0x38, 0xFF,
  0x0E, 0x04, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0xE1, 0xFF, 0x9C, 0x7E,
  0x7B, 0x8F, 0x03, 0x73, 0xC0, 0x3E, 0x70, 0x03, 0xCE, 0x00, 0x7B, 0x80,
  0x0F, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x7B, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x80, 0x7C, 0x70, 0x1B, 0x8F, 0x87,
  0x70, 0xFF, 0xCE, 0x0F, 0xF1, 0xC0, 0x20, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0xC3, 0xF8, 0xFF, 0x3F, 0xE7, 0x0D, 0xC1, 0xF0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0xF7, 0xE7,
  0xDC, 0x02, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xFC, 0x3E, 0xFF, 0xF1, 0xFF, 0x80,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x87, 0xF0, 0x7E, 0x02, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0B, 0x70,
  0x1B, 0x7C, 0x73, 0x3F, 0xE3, 0x1F, 0xC3, 0x02, 0x00, 0xE0, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x03, 0x8E, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x07, 0x06, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C,
  0x1C, 0x0E, 0x03, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x01,
  0x87, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x33,
  0x80, 0x0E, 0xE0, 0x03, 0xB0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1E, 0x00,
  0x6E, 0x00, 0x78, 0x03, 0xB8, 0x03, 0xE0, 0x0E, 0xE0, 0x0F, 0x80, 0x39,
  0xC0, 0x3F, 0x00, 0xE7, 0x00, 0xDC, 0x07, 0x1C, 0x03, 0x70, 0x1C, 0x70,
  0x1C, 0xC0, 0x70, 0xE0, 0x73, 0x01, 0xC3, 0x81, 0xCE, 0x07, 0x0E, 0x06,
  0x38, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE0, 0xE1, 0x83, 0x81, 0xC3, 0x86,
  0x0E, 0x07, 0x0E, 0x1C, 0x30, 0x1C, 0x30, 0x71, 0xC0, 0x71, 0xC1, 0xC7,
  0x00, 0xC7, 0x03, 0x1C, 0x03, 0x9C, 0x0C, 0x70, 0x0E, 0x60, 0x39, 0x80,
  0x39, 0x80, 0xEE, 0x00, 0xEE, 0x03, 0xB8, 0x01, 0xB8, 0x06, 0xE0, 0x07,
  0xE0, 0x1B, 0x00, 0x1F, 0x00, 0x6C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF0,
  0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xB8, 0x03, 0xDE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0x70, 0x70,
  0x70, 0x1C, 0x38, 0x0E, 0x38, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0x6E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x01, 0xDC, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x70, 0x70, 0x38,
  0x38, 0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x3F,
  0x00, 0x1C, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01,
  0x83, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0xC1, 0xC0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x01, 0xCC, 0x00, 0x77, 0x00, 0x0D, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xBE, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x01, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x3F, 0x00,
  0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3C, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x0F, 0xE0, 0x3F, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x17, 0xF8, 0x01, 0xFF, 0xE0, 0x7E, 0x1F, 0xFF, 0x80, 0x7F,
  0xE8, 0x01, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 40, 12, 4, -40 },
  { 21, 12, 14, 19, 3, -40 },
  { 42, 23, 40, 25, 1, -40 },
  { 157, 19, 46, 23, 2, -43 },
  { 267, 30, 42, 35, 2, -41 },
  { 425, 22, 42, 24, 2, -41 },
  { 541, 4, 14, 10, 3, -40 },
  { 548, 11, 49, 16, 3, -40 },
  { 616, 11, 49, 16, 2, -40 },
  { 684, 16, 17, 21, 2, -43 },
  { 718, 20, 26, 23, 2, -33 },
  { 783, 6, 13, 11, 2, -6 },
  { 793, 12, 3, 15, 2, -17 },
  { 798, 5, 5, 11, 3, -5 },
  { 802, 18, 40, 20, 1, -40 },
  { 892, 19, 41, 23, 2, -41 },
  { 990, 11, 40, 23, 4, -40 },
  { 1045, 18, 41, 23, 2, -41 },
  { 1138, 18, 42, 23, 2, -41 },
  { 1233, 21, 40, 23, 1, -40 },
  { 1338, 18, 41, 23, 3, -40 },
  { 1431, 18, 41, 23, 3, -40 },
  { 1524, 19, 40, 23, 2, -40 },
  { 1619, 19, 42, 23, 2, -41 },
  { 1719, 18, 42, 23, 2, -41 },
  { 1814, 4, 30, 11, 4, -30 },
  { 1829, 6, 37, 11, 2, -30 },
  { 1857, 20, 24, 23, 2, -32 },
  { 1917, 20, 15, 23, 2, -27 },
  { 1955, 20, 24, 23, 2, -32 },
  { 2015, 14, 41, 16, 1, -41 },
  { 2087, 29, 45, 35, 3, -40 },
  { 2251, 23, 40, 23, 0, -40 },
  { 2366, 19, 40, 25, 4, -40 },
  { 2461, 20, 42, 24, 3, -41 },
  { 2566, 21, 40, 28, 4, -40 },
  { 2671, 15, 40, 22, 4, -40 },
  { 2746, 15, 40, 21, 4, -40 },
  { 2821, 24, 42, 30, 3, -41 },
  { 2947, 20, 40, 29, 4, -40 },
  { 3047, 10, 40, 14, 2, -40 },
  { 3097, 10, 50, 11, -3, -40 },
  { 3160, 19, 40, 23, 4, -40 },
  { 3255, 15, 40, 20, 4, -40 },
  { 3330, 30, 40, 38, 4, -40 },
  { 3480, 22, 40, 30, 4, -40 },
  { 3590, 24, 42, 30, 3, -41 },
  { 3716, 18, 40, 23, 4, -40 },
  { 3806, 24, 51, 30, 3, -41 },
  { 3959, 19, 40, 24, 4, -40 },
  { 4054, 18, 42, 22, 2, -41 },
  { 4149, 20, 40, 20, 0, -40 },
  { 4249, 20, 41, 28, 4, -40 },
  { 4352, 23, 40, 23, 0, -40 },
  { 4467, 38, 40, 38, 0, -40 },
  { 4657, 20, 40, 21, 0, -40 },
  { 4757, 20, 40, 20, 0, -40 },
  { 4857, 16, 40, 19, 2, -40 },
  { 4937, 11, 49, 17, 4, -40 },
  { 5005, 18, 40, 20, 1, -40 },
  { 5095, 11, 49, 17, 2, -40 },
  { 5163, 22, 20, 23, 1, -40 },
  { 5218, 23, 2, 23, 0, 5 },
  { 5224, 10, 9, 14, 2, -43 },
  { 5236, 16, 31, 22, 2, -30 },
  { 5298, 18, 44, 25, 4, -43 },
  { 5397, 14, 31, 18, 3, -30 },
  { 5452, 19, 44, 25, 2, -43 },
  { 5557, 17, 31, 22, 3, -30 },
  { 5623, 13, 43, 13, 1, -43 },
  { 5693, 19, 44, 25, 2, -30 },
  { 5798, 17, 43, 24, 4, -43 },
  { 5890, 5, 41, 11, 3, -41 },
  { 5916, 8, 55, 11, 0, -41 },
  { 5971, 16, 43, 20, 4, -43 },
  { 6057, 3, 43, 11, 4, -43 },
  { 6074, 28, 30, 36, 4, -30 },
  { 6179, 17, 30, 24, 4, -30 },
  { 6243, 19, 31, 24, 2, -30 },
  { 6317, 18, 43, 25, 4, -30 },
  { 6414, 19, 43, 25, 2, -30 },
  { 6517, 11, 30, 16, 4, -30 },
  { 6559, 14, 31, 18, 2, -30 },
  { 6614, 11, 38, 13, 1, -37 },
  { 6667, 16, 31, 24, 4, -30 },
  { 6729, 18, 30, 19, 0, -30 },
  { 6797, 30, 30, 31, 1, -30 },
  { 6910, 17, 30, 19, 1, -30 },
  { 6974, 18, 44, 19, 1, -30 },
  { 7073, 13, 30, 16, 2, -30 },
  { 7122, 14, 49, 20, 3, -40 },
  { 7208, 2, 56, 22, 10, -43 },
  { 7222, 14, 49, 20, 3, -40 },
  { 7308, 20, 6, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Light56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT56PT7B_H_
