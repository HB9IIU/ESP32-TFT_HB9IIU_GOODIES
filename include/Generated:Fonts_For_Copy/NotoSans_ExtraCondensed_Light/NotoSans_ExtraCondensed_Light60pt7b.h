#ifndef _NOTOSANS_EXTRACONDENSED_LIGHT60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_LIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x13, 0xDF, 0xFF, 0xDC, 0xF0, 0x7F, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0x00, 0x60, 0x38, 0x00, 0x60, 0x38,
  0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x30,
  0x00, 0xE0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x70,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x60, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xE0,
  0x01, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0,
  0x03, 0x80, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x03, 0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x01, 0x80,
  0x07, 0x01, 0x80, 0x07, 0x01, 0x80, 0x07, 0x03, 0x80, 0x06, 0x03, 0x80,
  0x06, 0x03, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x00,
  0x0E, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x07, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFC, 0xFC,
  0x3C, 0x60, 0x63, 0xC3, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0x0E, 0x06,
  0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x07,
  0x83, 0x00, 0x1C, 0x18, 0x00, 0xF0, 0xC0, 0x03, 0xC6, 0x00, 0x0F, 0xB0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x1B, 0xE0, 0x00, 0xC7, 0x80, 0x06, 0x1E, 0x00, 0x30, 0x78, 0x01, 0x81,
  0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x38, 0x03, 0x01, 0xC0, 0x18, 0x0E, 0x00,
  0xC0, 0x60, 0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0x83, 0xD8, 0x0C, 0x3C,
  0xF8, 0x67, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x1F, 0x80, 0x07, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x79, 0xC0, 0x06, 0x00,
  0x70, 0xE0, 0x0E, 0x00, 0x60, 0x60, 0x0E, 0x00, 0xE0, 0x70, 0x0C, 0x00,
  0xE0, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x18, 0x00,
  0xC0, 0x70, 0x38, 0x00, 0xC0, 0x30, 0x38, 0x00, 0xC0, 0x30, 0x30, 0x00,
  0xC0, 0x30, 0x70, 0x00, 0xC0, 0x30, 0x70, 0x00, 0xC0, 0x30, 0x60, 0x00,
  0xC0, 0x30, 0xE0, 0x00, 0xC0, 0x70, 0xE0, 0x00, 0xE0, 0x70, 0xC3, 0xF0,
  0xE0, 0x71, 0xC7, 0xF8, 0xE0, 0x71, 0xC7, 0x3C, 0xE0, 0x71, 0x8E, 0x1C,
  0x60, 0x63, 0x8E, 0x0C, 0x70, 0xE3, 0x9C, 0x0E, 0x79, 0xC7, 0x1C, 0x0E,
  0x3F, 0xC7, 0x1C, 0x0E, 0x1F, 0x87, 0x1C, 0x06, 0x00, 0x0E, 0x1C, 0x06,
  0x00, 0x0E, 0x1C, 0x06, 0x00, 0x0E, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07,
  0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x06,
  0x00, 0x38, 0x1C, 0x06, 0x00, 0x38, 0x1C, 0x06, 0x00, 0x70, 0x1C, 0x0E,
  0x00, 0x70, 0x1C, 0x0E, 0x00, 0x70, 0x0C, 0x0E, 0x00, 0xE0, 0x0C, 0x0E,
  0x00, 0xE0, 0x0E, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x01, 0xC0, 0x07, 0xF8,
  0x01, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x03, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x78, 0x1E, 0x78,
  0x38, 0x1C, 0x70, 0x1C, 0x1C, 0x70, 0x1E, 0x1C, 0xF0, 0x0E, 0x1C, 0xE0,
  0x0F, 0x1C, 0xE0, 0x07, 0x38, 0xE0, 0x07, 0xB8, 0xE0, 0x03, 0xF8, 0xE0,
  0x01, 0xF0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xE0, 0xF0, 0x01, 0xF0, 0x70,
  0x03, 0xF8, 0x78, 0x07, 0xB8, 0x7C, 0x0F, 0x3C, 0x3F, 0x7E, 0x1C, 0x1F,
  0xFC, 0x1E, 0x0F, 0xF8, 0x0F, 0x00, 0x80, 0x00, 0xFE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x0C, 0x39, 0xFB, 0x3E, 0xFF, 0xFF,
  0xC1, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0xE1, 0xC0, 0x70, 0x38, 0x3C, 0x0F, 0x02, 0x01, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x27, 0xBD, 0xFF, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0x07, 0x83, 0xC0, 0x70, 0x70, 0x0F, 0x0E, 0x00, 0xE3, 0xC0, 0x1E, 0x70,
  0x03, 0xCE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0E, 0xF0, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x38, 0x70, 0x0F, 0x0F, 0x01,
  0xC0, 0xF0, 0x78, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00,
  0x70, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xF7, 0x3E, 0x77, 0xC7, 0xF8,
  0x76, 0x07, 0x20, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0x80, 0x78, 0x20, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F,
  0x80, 0x78, 0x60, 0x03, 0xC4, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x80, 0x03, 0xCE, 0x00, 0x7C, 0xFC, 0x3F, 0x8F, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x28, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x30,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x20, 0x01, 0xE6, 0x00, 0xF8, 0xFC, 0xFE, 0x1F,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xFE, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x60, 0x1C,
  0x7F, 0xC3, 0x9F, 0xFC, 0x77, 0x8F, 0xCE, 0xC0, 0x79, 0xF0, 0x07, 0xBE,
  0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x80, 0x1C, 0x70,
  0x07, 0x8F, 0x00, 0xE0, 0xE0, 0x3C, 0x1F, 0x1F, 0x01, 0xFF, 0xC0, 0x1F,
  0xF0, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xF7, 0xE0,
  0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8F, 0x00,
  0x1E, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xE3,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x78, 0x0E, 0x07,
  0x80, 0x7C, 0x78, 0x01, 0xF7, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xFE, 0x00, 0x1E, 0x78, 0x01, 0xE1, 0xF0, 0x1E, 0x07, 0xC1, 0xE0, 0x1E,
  0x0E, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0xC0,
  0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1D,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0x87, 0x80,
  0x7C, 0x1F, 0x8F, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xE0, 0x78, 0x3C, 0x03,
  0x83, 0x80, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7,
  0x00, 0x0F, 0x78, 0x01, 0xF3, 0x80, 0x3F, 0x3C, 0x03, 0xF1, 0xE0, 0xEF,
  0x1F, 0xFE, 0xE0, 0x7F, 0x8E, 0x03, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x39, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x30, 0x00, 0xF7, 0xBF, 0xEF, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x19, 0xEF, 0x7F, 0xDE, 0x1C, 0x7C,
  0xF9, 0xF3, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xC3,
  0x8F, 0x1E, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x18, 0x70, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFF,
  0xE3, 0xFF, 0xE3, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x03, 0xF8, 0x0E, 0x38, 0x07,
  0xFC, 0x0E, 0x70, 0x0F, 0x1C, 0x0E, 0x70, 0x1C, 0x1C, 0x0E, 0x70, 0x1C,
  0x1C, 0x06, 0x70, 0x38, 0x1C, 0x07, 0x60, 0x38, 0x1C, 0x07, 0xE0, 0x70,
  0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70,
  0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70,
  0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x3C, 0x06, 0xE0, 0x70,
  0x3C, 0x0E, 0xE0, 0x70, 0x3C, 0x0E, 0xE0, 0x70, 0x3C, 0x0E, 0xE0, 0x38,
  0x6C, 0x0C, 0x60, 0x38, 0x6E, 0x1C, 0x70, 0x3C, 0xE7, 0x78, 0x70, 0x1F,
  0xC7, 0xF8, 0x70, 0x0F, 0x83, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x06, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x0E, 0x00,
  0x38, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xE0, 0x03,
  0x80, 0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xE0, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x01, 0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3C,
  0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x0F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xEE,
  0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00,
  0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7C, 0x01, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x08, 0x1F, 0xEF, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x38, 0x0F, 0xC0, 0xE0, 0x0F, 0x83, 0x80, 0x0F,
  0x0E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xEE, 0x00,
  0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0,
  0x01, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x78, 0x38, 0x0F, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x1E,
  0x07, 0xC0, 0x01, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x03, 0xFE, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0E, 0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3A,
  0x0F, 0x7F, 0xCF, 0xF0, 0xFC, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0,
  0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0E,
  0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x80,
  0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0,
  0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xEF, 0x80, 0x0F, 0xFC,
  0x00, 0xFD, 0xC0, 0x0F, 0x9E, 0x00, 0xF0, 0xE0, 0x0F, 0x0F, 0x00, 0xE0,
  0xF0, 0x0E, 0x07, 0x80, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0E,
  0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x77, 0xFC, 0x00, 0x00, 0x77, 0xFC, 0x00, 0x00, 0x77, 0xEE,
  0x00, 0x00, 0xEF, 0xEE, 0x00, 0x00, 0xEF, 0xEE, 0x00, 0x00, 0xEF, 0xE7,
  0x00, 0x01, 0xEF, 0xE7, 0x00, 0x01, 0xCF, 0xE7, 0x00, 0x01, 0xCF, 0xE7,
  0x00, 0x01, 0xCF, 0xE3, 0x80, 0x03, 0x8F, 0xE3, 0x80, 0x03, 0x8F, 0xE3,
  0x80, 0x03, 0x8F, 0xE1, 0xC0, 0x07, 0x0F, 0xE1, 0xC0, 0x07, 0x0F, 0xE1,
  0xC0, 0x07, 0x0F, 0xE0, 0xE0, 0x07, 0x0F, 0xE0, 0xE0, 0x0E, 0x0F, 0xE0,
  0xE0, 0x0E, 0x0F, 0xE0, 0xE0, 0x0E, 0x0F, 0xE0, 0x70, 0x1C, 0x0F, 0xE0,
  0x70, 0x1C, 0x0F, 0xE0, 0x70, 0x1C, 0x0F, 0xE0, 0x38, 0x3C, 0x0F, 0xE0,
  0x38, 0x38, 0x0F, 0xE0, 0x38, 0x38, 0x0F, 0xE0, 0x3C, 0x38, 0x0F, 0xE0,
  0x1C, 0x70, 0x0F, 0xE0, 0x1C, 0x70, 0x0F, 0xE0, 0x1C, 0x70, 0x0F, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0xE0,
  0x07, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xEE, 0x00, 0x0F, 0xDE, 0x00, 0x1F,
  0x9C, 0x00, 0x3F, 0x38, 0x00, 0x7E, 0x38, 0x00, 0xFC, 0x70, 0x01, 0xF8,
  0x70, 0x03, 0xF0, 0xE0, 0x07, 0xE1, 0xE0, 0x0F, 0xC1, 0xC0, 0x1F, 0x83,
  0xC0, 0x3F, 0x03, 0x80, 0x7E, 0x07, 0x00, 0xFC, 0x07, 0x01, 0xF8, 0x0E,
  0x03, 0xF0, 0x1E, 0x07, 0xE0, 0x1C, 0x0F, 0xC0, 0x3C, 0x1F, 0x80, 0x38,
  0x3F, 0x00, 0x70, 0x7E, 0x00, 0x70, 0xFC, 0x00, 0xE1, 0xF8, 0x01, 0xE3,
  0xF0, 0x01, 0xC7, 0xE0, 0x03, 0xCF, 0xC0, 0x03, 0x9F, 0x80, 0x07, 0x3F,
  0x00, 0x07, 0x7E, 0x00, 0x0E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x79, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x07, 0xF7, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x81, 0xFC, 0xE0, 0x0F, 0x38, 0x01, 0xEE,
  0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x0F, 0xB8, 0x07, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x79, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xF7, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0E,
  0x07, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x3C,
  0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00,
  0x38, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xE0,
  0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x07,
  0x8E, 0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x00, 0xC3, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE8, 0x00, 0x3C, 0xE0, 0x07, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F,
  0x78, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x80, 0x7C, 0x1F,
  0xEF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3,
  0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xE3, 0x80, 0x00, 0xE7,
  0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0xB8, 0x00, 0x0E, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0xE0, 0x00, 0xD8, 0x00, 0x38, 0x70, 0x00, 0xEE, 0x00, 0x1C,
  0x38, 0x00, 0x77, 0x00, 0x0E, 0x1E, 0x00, 0x3B, 0x80, 0x0F, 0x0F, 0x00,
  0x1D, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x38,
  0x01, 0xC0, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x8E, 0x00, 0xF0,
  0x1C, 0x01, 0xC7, 0x00, 0x78, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x01, 0xE0, 0x38, 0x38,
  0x0F, 0x00, 0x70, 0x1C, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x0E, 0x03, 0x80,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x07, 0x83,
  0x80, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x38,
  0x38, 0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x00, 0x3C, 0x70, 0x07, 0x1E, 0x00,
  0x1E, 0x38, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x01, 0xC6, 0x00, 0x31, 0xC0, 0x00, 0xE7, 0x00, 0x1D,
  0xE0, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x07, 0x60, 0x01, 0xDC, 0x00, 0x03, 0xF0,
  0x00, 0x6E, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0x77, 0x80, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x3C, 0x01,
  0xE1, 0xC0, 0x1C, 0x1C, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x8F, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x07, 0x8E,
  0x00, 0x70, 0xF0, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x81, 0xE0,
  0x38, 0x1C, 0x03, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x78,
  0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x80,
  0x0F, 0x1C, 0x00, 0x70, 0xF0, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC0,
  0xF0, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xF0, 0x38, 0x03, 0x83,
  0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x70, 0x00,
  0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01,
  0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x78, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xF3, 0x80, 0x00, 0xE7, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x00, 0x40, 0x01, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x7C,
  0x18, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x03,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0, 0x0F,
  0x70, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0x70, 0x05, 0xDE, 0x03, 0x73, 0xC3,
  0x9C, 0xFF, 0xC7, 0x1F, 0xE1, 0xC0, 0x40, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x02, 0x00, 0xE1, 0xFE, 0x0E, 0x3F, 0xF0,
  0xE7, 0x9F, 0x8E, 0xE0, 0x3C, 0xEC, 0x03, 0xCF, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xCE, 0xC0, 0x3C, 0xEE, 0x07, 0xCE, 0x78, 0xF8, 0xE3, 0xFF,
  0x0E, 0x1F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x0F, 0xFE,
  0x1F, 0xCE, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x01, 0x1F, 0x8E, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0C,
  0x0F, 0x07, 0xF8, 0xF0, 0xFF, 0xCF, 0x1F, 0x9E, 0xF3, 0xC0, 0x7F, 0x38,
  0x03, 0xF7, 0x80, 0x1F, 0x70, 0x01, 0xF7, 0x00, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x37, 0x3C,
  0x07, 0x71, 0xF1, 0xE7, 0x1F, 0xFC, 0x70, 0x7F, 0x87, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x7C, 0x78, 0x3C, 0x0F, 0x0E,
  0x01, 0xE7, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x21, 0xF8, 0x78, 0x3F, 0xFE,
  0x03, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xC1, 0xE1,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x07, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x87, 0x0F, 0xFC, 0x71, 0xFB, 0xE7,
  0x3C, 0x07, 0x73, 0x80, 0x37, 0x78, 0x01, 0xF7, 0x00, 0x1F, 0x70, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x70, 0x01, 0xF7, 0x80, 0x1F,
  0x78, 0x03, 0xF3, 0xC0, 0x6F, 0x1F, 0x1E, 0xF0, 0xFF, 0xCF, 0x07, 0xF8,
  0xF0, 0x18, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x80,
  0x03, 0xC6, 0x00, 0x78, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x08, 0x0E, 0x1F, 0xC3, 0x8F, 0xFC,
  0xE7, 0xFF, 0x3B, 0x81, 0xEE, 0xC0, 0x3B, 0xE0, 0x0E, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x6F, 0xFF, 0xF4, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0F, 0x0F, 0x0F, 0x0F, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1E, 0xFE, 0xFC, 0xF8, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1F,
  0xC0, 0x1E, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x07,
  0x87, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE1, 0xC0, 0x71, 0xE0, 0x38,
  0xE0, 0x1C, 0xF8, 0x0E, 0x7C, 0x07, 0x7F, 0x03, 0xF3, 0x81, 0xF1, 0xC0,
  0xF0, 0x70, 0x78, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x00,
  0xE3, 0x80, 0x71, 0xC0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0xB8, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x7F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x01, 0x01, 0xC7, 0xF8, 0x1F, 0xC3, 0x9F, 0xF8, 0x7F, 0xE7,
  0x3D, 0xF1, 0xE7, 0xCE, 0xC0, 0xF7, 0x03, 0xDF, 0x00, 0xEC, 0x07, 0xBE,
  0x01, 0xF0, 0x07, 0x78, 0x03, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0x1F, 0xE0,
  0x07, 0x00, 0x3F, 0xC0, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70,
  0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00,
  0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x20, 0x38, 0x7F,
  0x8E, 0x3F, 0xF3, 0x9E, 0x7C, 0xEE, 0x07, 0xBB, 0x00, 0xEF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xF9, 0xF0, 0x3C, 0x07, 0x83,
  0x80, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC3,
  0xC0, 0x78, 0x1F, 0x9F, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x0E, 0x1F, 0xE0, 0xE3, 0xFF, 0x0E, 0x78, 0xF8, 0xEE, 0x03,
  0xCE, 0xC0, 0x3C, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xF8, 0x01, 0xEF, 0x80, 0x1C, 0xEC, 0x03,
  0xCE, 0xE0, 0x78, 0xE7, 0x9F, 0x8E, 0x3F, 0xF0, 0xE1, 0xFE, 0x0E, 0x06,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x7F, 0x87, 0x0F, 0xFC, 0x71, 0xFB, 0xE7, 0x3C, 0x07, 0x73, 0x80,
  0x37, 0x78, 0x01, 0xF7, 0x00, 0x1F, 0x70, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0x70, 0x01, 0xF7, 0x80, 0x1F, 0x38, 0x03, 0xF3, 0xC0,
  0x6F, 0x1F, 0x1E, 0xF0, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x18, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xE1, 0xFE, 0x3F, 0xE7,
  0xFE, 0xE0, 0xEC, 0x0E, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x3E, 0x3E, 0x78, 0x04, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x80, 0x1E, 0xC0, 0x1E, 0xFC, 0xFC, 0xFF, 0xF8,
  0x3F, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x10,
  0xFF, 0x07, 0xF0, 0x08, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7D, 0xC0, 0x37, 0x78, 0x1D, 0xCF, 0x9E, 0x73,
  0xFF, 0x9C, 0x7F, 0x87, 0x01, 0x00, 0x00, 0xF0, 0x00, 0xF7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x38, 0x1C, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x31, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x1B, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x0F, 0xE0,
  0x03, 0xC0, 0x0E, 0xF0, 0x07, 0xC0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70,
  0x07, 0xE0, 0x0E, 0x70, 0x06, 0xE0, 0x1E, 0x70, 0x06, 0xE0, 0x1C, 0x78,
  0x0E, 0x60, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38,
  0x0E, 0x70, 0x38, 0x38, 0x1C, 0x70, 0x38, 0x1C, 0x1C, 0x30, 0x38, 0x1C,
  0x1C, 0x38, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x38, 0x70, 0x1C,
  0x38, 0x38, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E,
  0x38, 0x1C, 0xE0, 0x0E, 0x30, 0x1C, 0xE0, 0x0F, 0x70, 0x1C, 0xE0, 0x07,
  0x70, 0x0C, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x07, 0x70, 0x0E, 0xC0, 0x07,
  0x60, 0x0F, 0xC0, 0x03, 0x60, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x01, 0xCF, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x38,
  0x0E, 0x07, 0x83, 0xC0, 0x70, 0x70, 0x0F, 0x1E, 0x00, 0xE3, 0x80, 0x1C,
  0xF0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x73,
  0x80, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81,
  0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x9C, 0x00,
  0x77, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xB8, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9E, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x83, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x1C, 0x78,
  0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x1F, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x07, 0xF0, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x7E, 0x03, 0xF8, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x3F, 0x80, 0x0B, 0xFF,
  0x00, 0x7E, 0xFE, 0x0F, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x40, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 43, 13, 4, -43 },
  { 28, 13, 16, 20, 4, -43 },
  { 54, 24, 43, 27, 1, -43 },
  { 183, 21, 49, 25, 2, -46 },
  { 312, 32, 44, 37, 3, -43 },
  { 488, 24, 44, 26, 2, -43 },
  { 620, 4, 16, 11, 4, -43 },
  { 628, 12, 52, 17, 3, -43 },
  { 706, 12, 52, 17, 2, -43 },
  { 784, 18, 18, 22, 2, -46 },
  { 825, 21, 28, 25, 2, -35 },
  { 899, 7, 14, 12, 2, -6 },
  { 912, 13, 3, 16, 2, -18 },
  { 917, 5, 6, 12, 4, -6 },
  { 921, 19, 43, 21, 1, -43 },
  { 1024, 19, 43, 25, 3, -43 },
  { 1127, 12, 43, 25, 4, -43 },
  { 1192, 20, 43, 25, 2, -43 },
  { 1300, 20, 44, 25, 2, -43 },
  { 1410, 23, 43, 25, 1, -43 },
  { 1534, 19, 44, 25, 3, -43 },
  { 1639, 19, 44, 25, 3, -43 },
  { 1744, 20, 43, 25, 2, -43 },
  { 1852, 21, 44, 25, 2, -43 },
  { 1968, 20, 44, 25, 2, -43 },
  { 2078, 5, 32, 12, 4, -32 },
  { 2098, 7, 40, 12, 2, -32 },
  { 2133, 21, 26, 25, 2, -34 },
  { 2202, 21, 16, 25, 2, -29 },
  { 2244, 21, 26, 25, 2, -34 },
  { 2313, 15, 43, 17, 1, -43 },
  { 2394, 32, 48, 38, 3, -43 },
  { 2586, 25, 43, 25, 0, -43 },
  { 2721, 20, 43, 27, 5, -43 },
  { 2829, 21, 45, 26, 3, -44 },
  { 2948, 22, 43, 30, 5, -43 },
  { 3067, 16, 43, 24, 5, -43 },
  { 3153, 16, 43, 22, 5, -43 },
  { 3239, 26, 44, 32, 3, -43 },
  { 3382, 21, 43, 31, 5, -43 },
  { 3495, 11, 43, 15, 2, -43 },
  { 3555, 11, 54, 12, -3, -43 },
  { 3630, 20, 43, 25, 5, -43 },
  { 3738, 15, 43, 21, 5, -43 },
  { 3819, 32, 43, 41, 5, -43 },
  { 3991, 23, 43, 32, 5, -43 },
  { 4115, 26, 44, 32, 3, -43 },
  { 4258, 18, 43, 25, 5, -43 },
  { 4355, 26, 53, 32, 3, -43 },
  { 4528, 20, 43, 26, 5, -43 },
  { 4636, 20, 45, 24, 2, -44 },
  { 4749, 20, 43, 22, 1, -43 },
  { 4857, 22, 44, 30, 4, -43 },
  { 4978, 24, 43, 24, 0, -43 },
  { 5107, 41, 43, 41, 0, -43 },
  { 5328, 20, 43, 22, 1, -43 },
  { 5436, 21, 43, 21, 0, -43 },
  { 5549, 17, 43, 21, 2, -43 },
  { 5641, 12, 53, 19, 5, -43 },
  { 5721, 19, 43, 21, 1, -43 },
  { 5824, 12, 53, 19, 2, -43 },
  { 5904, 23, 22, 25, 1, -43 },
  { 5968, 25, 3, 25, 0, 5 },
  { 5978, 10, 10, 15, 2, -46 },
  { 5991, 18, 34, 23, 2, -33 },
  { 6068, 20, 47, 27, 4, -46 },
  { 6186, 16, 34, 20, 3, -33 },
  { 6254, 20, 47, 27, 3, -46 },
  { 6372, 18, 34, 24, 3, -33 },
  { 6449, 14, 46, 14, 1, -46 },
  { 6530, 20, 47, 27, 3, -33 },
  { 6648, 18, 46, 26, 4, -46 },
  { 6752, 4, 44, 12, 4, -44 },
  { 6774, 8, 58, 12, 0, -44 },
  { 6832, 17, 46, 22, 4, -46 },
  { 6930, 3, 46, 11, 4, -46 },
  { 6948, 31, 33, 39, 4, -33 },
  { 7076, 18, 33, 26, 4, -33 },
  { 7151, 20, 34, 25, 3, -33 },
  { 7236, 20, 47, 27, 4, -33 },
  { 7354, 20, 47, 27, 3, -33 },
  { 7472, 12, 32, 17, 4, -32 },
  { 7520, 16, 34, 20, 2, -33 },
  { 7588, 12, 40, 14, 1, -39 },
  { 7648, 18, 33, 26, 4, -32 },
  { 7723, 20, 32, 20, 0, -32 },
  { 7803, 32, 32, 34, 1, -32 },
  { 7931, 19, 32, 21, 1, -32 },
  { 8007, 19, 46, 21, 1, -32 },
  { 8117, 14, 32, 17, 2, -32 },
  { 8173, 15, 53, 21, 3, -43 },
  { 8273, 3, 60, 24, 10, -46 },
  { 8296, 15, 53, 21, 3, -43 },
  { 8396, 21, 6, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_Light60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Light60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Light60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_LIGHT60PT7B_H_
