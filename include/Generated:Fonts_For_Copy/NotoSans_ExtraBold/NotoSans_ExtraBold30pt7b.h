#ifndef _NOTOSANS_EXTRABOLD30PT7B_H_
#define _NOTOSANS_EXTRABOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE0,
  0x00, 0x39, 0xFF, 0xDF, 0x78, 0xFB, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x78, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC3,
  0xCF, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x71, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x81, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xBF, 0xEF, 0x7D, 0xC0, 0xFB, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xDF, 0x03, 0x9F, 0xC7,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x87, 0xFC, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x08, 0x0F, 0xC0, 0x3C, 0x07, 0xF8, 0x0F, 0x03,
  0xFF, 0x07, 0x80, 0xF3, 0xC1, 0xE0, 0x3C, 0xF0, 0xF0, 0x0F, 0x3C, 0x78,
  0x03, 0xCF, 0x1E, 0x00, 0xF3, 0xCF, 0x00, 0x3C, 0xF3, 0xCF, 0x8F, 0xFD,
  0xE7, 0xF1, 0xFE, 0x7B, 0xFE, 0x3F, 0x3C, 0xF7, 0xC3, 0x0F, 0x78, 0xF0,
  0x07, 0x9E, 0x3C, 0x03, 0xC7, 0x8F, 0x00, 0xF1, 0xE3, 0xC0, 0x78, 0x78,
  0xF0, 0x1E, 0x0F, 0x3C, 0x0F, 0x03, 0xFE, 0x03, 0xC0, 0x7F, 0x81, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0x8F, 0xF8, 0x3E, 0x7F,
  0xF1, 0xF9, 0xF7, 0xE7, 0xCF, 0xCF, 0xFF, 0x3E, 0x1F, 0xF8, 0xFC, 0x3F,
  0xE3, 0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xC7, 0xF0, 0xFF, 0xBD, 0xEF, 0x7B, 0xC0, 0x0F, 0x87, 0x87, 0x87,
  0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E,
  0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0xC3, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F, 0x81,
  0xFE, 0x0F, 0x3C, 0x7C, 0xF8, 0x71, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x7D, 0xF7, 0x9E, 0x7B, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xFF,
  0xDF, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x00, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xEF, 0xCF,
  0x8F, 0xBF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x3E, 0xF8, 0xF9,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x7F,
  0x9F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFB, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xE7, 0x0F,
  0xC8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x7F, 0xE3, 0xFF,
  0xF3, 0xFF, 0xE7, 0xCF, 0xC4, 0x0F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xFC,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8, 0x78,
  0xF8, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xF3, 0xFF, 0xE7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xF8,
  0xFF, 0xF9, 0xFF, 0xF1, 0x87, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFC, 0x4F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF9, 0xF1, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0xF8, 0x7D, 0xFF, 0xF9, 0xFF,
  0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x3F,
  0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x3E,
  0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0xCF, 0xDF, 0xBE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFB, 0xFB, 0xFF, 0xE3, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0xEF,
  0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF3, 0xFB,
  0xFF, 0xF7, 0xFD, 0xE7, 0xF7, 0xC3, 0x8F, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x39, 0xFF, 0xFF,
  0x7C, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x39, 0xFF, 0xDF, 0x78, 0x39, 0xF7,
  0xDF, 0x7C, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDE, 0x79, 0xEF,
  0xBC, 0xF0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x07, 0x80, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFF, 0x7C, 0xFC, 0x81, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x3F, 0x81, 0xF0,
  0x03, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0xFF, 0x3C, 0xF1, 0xFF, 0xDE, 0x79,
  0xFF, 0xC7, 0x38, 0xF0, 0xE3, 0xDC, 0xF0, 0x71, 0xFE, 0x78, 0x38, 0xFF,
  0x3C, 0x3C, 0x7F, 0x9E, 0x1E, 0x3B, 0xCF, 0x0F, 0x3D, 0xE3, 0xCF, 0xDE,
  0x71, 0xFF, 0xFE, 0x3C, 0x7F, 0x7E, 0x1E, 0x06, 0x0C, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x02, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xCF,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF0, 0x1F,
  0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC3, 0xF7, 0xE0, 0xFB,
  0xF0, 0x7D, 0xF8, 0x7E, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF,
  0xEF, 0xC3, 0xF7, 0xE0, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xF0, 0x07, 0xFF,
  0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x02, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0x7F, 0xFF, 0x3F, 0xFF,
  0x1F, 0xFF, 0x07, 0xFE, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7E, 0xFC, 0x7F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0x80, 0x4F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0xC1,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xC0, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC3, 0xF0, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xF8, 0x1F, 0xFC, 0x1F,
  0xBE, 0x1F, 0x9F, 0x0F, 0x8F, 0x8F, 0xC7, 0xCF, 0xC3, 0xEF, 0xC1, 0xF7,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xDF, 0x07,
  0xCF, 0xC3, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x0F,
  0xDF, 0x03, 0xEF, 0x81, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7B, 0xFF,
  0xE0, 0xFF, 0xFB, 0xC1, 0xFF, 0xF7, 0x87, 0xBF, 0xEF, 0x0F, 0x7F, 0xCF,
  0x1E, 0xFF, 0x9E, 0x39, 0xFF, 0x3C, 0xF3, 0xFE, 0x7D, 0xE7, 0xFC, 0x7B,
  0xCF, 0xF8, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xE1, 0xFC, 0x7F, 0xC3, 0xF0,
  0xFF, 0x87, 0xE1, 0xFF, 0x07, 0xC3, 0xE0, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFD, 0xF0, 0x7F,
  0xBE, 0x0F, 0xF3, 0xE1, 0xFE, 0x7E, 0x3F, 0xC7, 0xC7, 0xF8, 0xFC, 0xFF,
  0x0F, 0x9F, 0xE1, 0xFB, 0xFC, 0x1F, 0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xF0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0, 0x7E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xE0,
  0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC1, 0xF3, 0xF0, 0xFC,
  0xFC, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0x3E, 0x0F, 0xC7, 0xC3, 0xF1, 0xF8, 0xFC, 0x3E, 0x3F, 0x0F, 0xCF, 0xC1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xC0, 0x03, 0xC0, 0x3F, 0xF8, 0xFF, 0xFB,
  0xFF, 0xE7, 0xFF, 0xCF, 0x81, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x87, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x1F, 0x7E, 0x0F, 0xDF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0x07, 0xC1,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0xC0, 0x7D, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x03,
  0xF0, 0x3E, 0x7C, 0x1F, 0xE0, 0xF8, 0xF8, 0x7F, 0x87, 0xC3, 0xE1, 0xFE,
  0x1F, 0x0F, 0x87, 0xF8, 0x7C, 0x3E, 0x3E, 0xF1, 0xF0, 0x78, 0xF3, 0xC7,
  0x81, 0xF3, 0xCF, 0x3E, 0x07, 0xCF, 0x3C, 0xF8, 0x1F, 0x7C, 0xFB, 0xE0,
  0x3D, 0xE1, 0xEF, 0x00, 0xF7, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF1, 0xF0, 0x3F, 0x0F,
  0xC1, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xEF, 0xC0,
  0x3F, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC1,
  0xF1, 0xF8, 0x3E, 0x3E, 0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFF, 0xF8, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x1E, 0x78, 0x1E,
  0x70, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F,
  0x07, 0xC1, 0xF0, 0x38, 0x03, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF1,
  0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xDF, 0xDF, 0xFF, 0xBF, 0xEF, 0x3F, 0x8E,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0xE0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E,
  0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xF1, 0xF8, 0x03, 0xE0,
  0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0x39, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x09, 0xFF, 0xE3, 0xFF,
  0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x07, 0x1F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0x7F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF,
  0x1F, 0x8F, 0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E,
  0x7C, 0x1F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x02, 0x7F, 0xBE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x07, 0xE1, 0xFF, 0x1F, 0xE3, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0xFE,
  0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0x00, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x00, 0x1F, 0x00,
  0x1F, 0x60, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7F, 0xFF, 0xF2,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x20, 0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xF7, 0xF0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x7E, 0xF8, 0x7E, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x3E, 0x0F,
  0xBF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x7C,
  0x3E, 0x3F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7, 0xC1, 0xFB, 0xE0, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x3C, 0x3C, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x9F, 0xBF, 0x0F, 0xC3, 0xFF, 0x83, 0xF0,
  0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xFF, 0x83,
  0xE0, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xFF,
  0x83, 0xE0, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xC0, 0x00, 0xF0,
  0xF3, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7D, 0xF8,
  0x3E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0xFB,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x1F,
  0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFE, 0x7F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xFF,
  0xDF, 0xFC, 0xFF, 0xEF, 0x83, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0,
  0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x7F,
  0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0xE7, 0xFC, 0x7F, 0x87, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xDF, 0x1F,
  0x8F, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x03, 0xDF, 0x00,
  0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x3F, 0x07, 0xDF, 0x0F, 0xE1, 0xF7, 0xC3, 0xF8, 0xF9, 0xF1,
  0xFE, 0x3E, 0x3E, 0x7F, 0x8F, 0x8F, 0x9E, 0xE3, 0xC3, 0xE7, 0x3D, 0xF0,
  0x79, 0xCF, 0x7C, 0x1E, 0xF3, 0xDF, 0x07, 0xFC, 0x77, 0x81, 0xFF, 0x1D,
  0xE0, 0x3F, 0x87, 0x78, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0xFE, 0x1F, 0xCF, 0x87, 0xC3, 0xF3, 0xF0,
  0x7C, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7E, 0xF8, 0x3F, 0x3F, 0x0F, 0x87,
  0xC7, 0xE1, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF8,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F,
  0x3C, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x41, 0xF0, 0xFC, 0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF1, 0xF8, 0xFE, 0x3C, 0x0F, 0xC3, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7F, 0x0F, 0xC3, 0xF0, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0xC3, 0xF8, 0xFF, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x87, 0xF0, 0xFE, 0x1F, 0x83,
  0xC0, 0x00, 0x7F, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 9, 1, -21 },
  { 17, 11, 7, 15, 2, -21 },
  { 27, 18, 21, 20, 1, -21 },
  { 75, 15, 25, 17, 1, -23 },
  { 122, 26, 22, 28, 1, -22 },
  { 194, 22, 22, 23, 1, -22 },
  { 255, 5, 7, 8, 2, -21 },
  { 260, 9, 27, 10, 1, -22 },
  { 291, 8, 27, 10, 1, -22 },
  { 318, 14, 14, 16, 1, -23 },
  { 343, 15, 15, 17, 1, -18 },
  { 372, 6, 8, 9, 1, -4 },
  { 378, 8, 4, 10, 1, -10 },
  { 382, 6, 5, 9, 1, -5 },
  { 386, 13, 22, 13, 0, -22 },
  { 422, 15, 22, 17, 1, -22 },
  { 464, 11, 21, 17, 2, -21 },
  { 493, 15, 22, 17, 1, -22 },
  { 535, 15, 22, 17, 1, -22 },
  { 577, 16, 21, 17, 1, -21 },
  { 619, 15, 21, 17, 1, -21 },
  { 659, 15, 22, 17, 1, -22 },
  { 701, 15, 21, 17, 1, -21 },
  { 741, 15, 22, 17, 1, -22 },
  { 783, 15, 22, 17, 1, -22 },
  { 825, 6, 17, 9, 1, -17 },
  { 838, 6, 21, 9, 1, -17 },
  { 854, 15, 16, 17, 1, -19 },
  { 884, 15, 9, 17, 1, -15 },
  { 901, 15, 16, 17, 1, -19 },
  { 931, 14, 22, 15, 0, -22 },
  { 970, 25, 24, 27, 1, -22 },
  { 1045, 21, 22, 21, 0, -22 },
  { 1103, 17, 21, 20, 2, -21 },
  { 1148, 16, 22, 19, 2, -22 },
  { 1192, 18, 21, 22, 2, -21 },
  { 1240, 12, 21, 17, 3, -21 },
  { 1272, 12, 21, 16, 3, -21 },
  { 1304, 18, 22, 22, 2, -22 },
  { 1354, 17, 21, 23, 3, -21 },
  { 1399, 10, 21, 12, 1, -21 },
  { 1426, 10, 27, 10, -2, -21 },
  { 1460, 17, 21, 20, 3, -21 },
  { 1505, 14, 21, 17, 2, -21 },
  { 1542, 23, 21, 29, 3, -21 },
  { 1603, 19, 21, 25, 3, -21 },
  { 1653, 20, 22, 24, 2, -22 },
  { 1708, 16, 21, 19, 2, -21 },
  { 1750, 20, 27, 24, 2, -22 },
  { 1818, 18, 21, 20, 2, -21 },
  { 1866, 15, 22, 17, 1, -22 },
  { 1908, 16, 21, 18, 1, -21 },
  { 1950, 18, 21, 23, 2, -21 },
  { 1998, 20, 21, 20, 0, -21 },
  { 2051, 30, 21, 30, 0, -21 },
  { 2130, 21, 21, 21, 0, -21 },
  { 2186, 19, 21, 19, 0, -21 },
  { 2236, 16, 21, 18, 1, -21 },
  { 2278, 7, 27, 10, 2, -22 },
  { 2302, 13, 22, 13, 0, -22 },
  { 2338, 7, 27, 10, 1, -22 },
  { 2362, 16, 15, 17, 0, -22 },
  { 2392, 14, 3, 14, 0, 2 },
  { 2398, 9, 5, 12, 1, -23 },
  { 2404, 15, 17, 18, 1, -17 },
  { 2436, 16, 23, 19, 2, -23 },
  { 2482, 14, 17, 16, 1, -17 },
  { 2512, 16, 23, 19, 1, -23 },
  { 2558, 16, 17, 18, 1, -17 },
  { 2592, 12, 23, 12, 1, -23 },
  { 2627, 16, 24, 19, 1, -17 },
  { 2675, 16, 23, 20, 2, -23 },
  { 2721, 5, 23, 9, 2, -23 },
  { 2736, 9, 30, 9, -2, -23 },
  { 2770, 17, 23, 19, 2, -23 },
  { 2819, 5, 23, 9, 2, -23 },
  { 2834, 26, 17, 30, 2, -17 },
  { 2890, 16, 17, 20, 2, -17 },
  { 2924, 17, 17, 19, 1, -17 },
  { 2961, 16, 24, 19, 2, -17 },
  { 3009, 16, 24, 19, 1, -17 },
  { 3057, 11, 17, 14, 2, -17 },
  { 3081, 13, 17, 15, 1, -17 },
  { 3109, 11, 20, 13, 1, -20 },
  { 3137, 16, 16, 20, 2, -16 },
  { 3169, 18, 16, 18, 0, -16 },
  { 3205, 26, 16, 26, 0, -16 },
  { 3257, 18, 16, 18, 0, -16 },
  { 3293, 18, 23, 18, 0, -16 },
  { 3345, 13, 16, 15, 1, -16 },
  { 3371, 10, 27, 12, 1, -22 },
  { 3405, 4, 30, 16, 6, -23 },
  { 3420, 11, 27, 12, 1, -22 },
  { 3458, 15, 5, 17, 1, -13 },
};

const GFXfont NotoSans_ExtraBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRABOLD30PT7B_H_
