#ifndef _NOTOSANS_EXTRABOLD70PT7B_H_
#define _NOTOSANS_EXTRABOLD70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x3F,
  0xF1, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x7F, 0xF0, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC,
  0xFF, 0xC1, 0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x7F, 0xE0,
  0xFF, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03,
  0xFE, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xF9, 0xF8, 0x7F, 0x87, 0xFF, 0x1F, 0x80,
  0x70, 0xFF, 0xE1, 0xF8, 0x01, 0x0F, 0xFE, 0x1F, 0x80, 0x00, 0xFF, 0xE1,
  0xF8, 0x00, 0x07, 0xFF, 0x1F, 0x80, 0x00, 0x7F, 0xFD, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFB, 0xFF, 0xF0, 0x00, 0x1F, 0x8F, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0xF0,
  0x00, 0x1F, 0x87, 0xFF, 0x40, 0x01, 0xF8, 0x7F, 0xF7, 0x80, 0x1F, 0x87,
  0xFF, 0x7F, 0x01, 0xF8, 0xFF, 0xF7, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0,
  0xFF, 0x87, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF,
  0xFC, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x3F, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF,
  0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3,
  0xFE, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1C, 0x01, 0xFE,
  0x00, 0xE7, 0xF0, 0x7F, 0x83, 0xF9, 0xFF, 0x9F, 0xC7, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x10, 0x02, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0xF0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFE,
  0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x07,
  0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF,
  0x9F, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF4,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFD, 0xFF, 0xCF, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7, 0xF0, 0xFF,
  0xF0, 0xF0, 0x3F, 0xFC, 0x38, 0x0F, 0xFF, 0x04, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xE0, 0x78, 0x00, 0x1F, 0xFE,
  0x03, 0x00, 0x01, 0xFF, 0xE0, 0x20, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xFE, 0x07,
  0x80, 0x07, 0xFF, 0xC0, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0xE0, 0x00, 0x0F, 0xFF, 0xDF, 0xC0,
  0x07, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFD, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xE0, 0x00, 0xFF,
  0xC7, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF8,
  0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0xFF,
  0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xC0, 0x07,
  0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xFF,
  0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F,
  0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFE,
  0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F,
  0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x9F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F,
  0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF0,
  0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xFE,
  0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F,
  0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0xF8,
  0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xFF, 0x7F, 0xFF, 0x0F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF7, 0xFF, 0x07, 0xFF,
  0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xE0,
  0x03, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC1, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xCF, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7,
  0xFF, 0xBF, 0xF8, 0xFF, 0x81, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xF8, 0x03, 0xFF, 0xE1, 0xE0, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F,
  0xFF, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0x8F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xFE,
  0x07, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x0F, 0xFB, 0xFC,
  0x0F, 0xFC, 0x01, 0xFE, 0x07, 0xFD, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x01,
  0xFE, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0x03,
  0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFD, 0xFF, 0x07,
  0xFC, 0x01, 0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1, 0xFE,
  0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF,
  0xF0, 0xFF, 0x8F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC7, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFF,
  0xBF, 0xFC, 0x00, 0xFF, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xDF,
  0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xC0,
  0xFF, 0xFF, 0x00, 0x0F, 0x81, 0xFF, 0xF8, 0x00, 0x02, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0C, 0x1F, 0xFF, 0xC0,
  0x00, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x00,
  0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xFB,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00,
  0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xF3,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x3F, 0xFC,
  0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x00, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0x04, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0xC0,
  0x00, 0x1F, 0xFD, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x7B, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0xCF,
  0xFF, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xC0,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x81,
  0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0xF3, 0xFF,
  0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFC, 0x00, 0x0F, 0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFF,
  0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0x9F, 0xF0, 0x00, 0xFF,
  0x9F, 0xFF, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xE0,
  0x03, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x3F, 0xE3, 0xFF,
  0xFF, 0xE3, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFC,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFD, 0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF,
  0xC0, 0x01, 0xFF, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF, 0xF0, 0x00, 0xF8, 0x7F,
  0xF8, 0x00, 0x0C, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xBF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x9F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xF3,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xE1, 0xFF,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0,
  0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFF,
  0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x1F,
  0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xFE, 0x00,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0xFF, 0xDF,
  0xF0, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFB,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0x1F, 0xFF, 0xC0, 0x7E, 0x00, 0x7F, 0xF8, 0x06, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFD, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xF1, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xF8,
  0x07, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x3F,
  0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x7F, 0xFF, 0xE0, 0xFF, 0xEF, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xF8, 0x3F, 0xFF, 0x00, 0x38, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x02, 0x7F, 0xFE, 0x00, 0x0E, 0x3F, 0xFF, 0x80, 0x7E, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xF8, 0x3F, 0xFF, 0xFB, 0xFF,
  0xC3, 0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFB, 0xFF, 0xE0, 0x07,
  0xFF, 0xDF, 0xFF, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xFE, 0x07, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xF8,
  0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x43, 0xFF, 0xE0,
  0x00, 0x1C, 0x3F, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xDF, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF,
  0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F,
  0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xF7, 0xFF,
  0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF,
  0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE3, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0x80, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0x07, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x02, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFF,
  0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF,
  0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x00,
  0xFF, 0xEF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x83, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF,
  0xE7, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x7F, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF, 0xEF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0, 0xFF,
  0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xE7,
  0xFF, 0xFE, 0x0F, 0xFF, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xFF, 0x8F, 0xFE, 0x0F, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFC,
  0x3F, 0xFF, 0xDF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xF8, 0x01, 0xFF, 0xF7,
  0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0xFF, 0xF0, 0x3F, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xFC,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xF8, 0x1F, 0xE3, 0xFF, 0xC0, 0x07, 0x8F, 0xFE, 0x00, 0x04, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xD0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x02, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xBF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xF9,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xF1, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x1F, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF1,
  0xFF, 0x0F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xF0, 0xFF, 0x8F, 0xFE,
  0x00, 0x7F, 0xF1, 0xFE, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xE0,
  0xFF, 0x9F, 0xFC, 0x00, 0x3F, 0xF3, 0xFE, 0x07, 0xF9, 0xFF, 0xC0, 0x03,
  0xFF, 0x3F, 0xE0, 0x7F, 0x9F, 0xF8, 0x00, 0x3F, 0xFB, 0xFC, 0x07, 0xFD,
  0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFB,
  0xFC, 0x03, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFF, 0xCF,
  0xFF, 0x80, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xBF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x47, 0xFF, 0xC0,
  0x00, 0x13, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF2, 0x00, 0x00, 0x7F, 0xF8, 0x80, 0x00, 0x00, 0x40,
  0x00,
};

const GFXglyph NotoSans_ExtraBold70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 14, 51, 20, 3, -50 },
  { 91, 27, 18, 35, 4, -50 },
  { 152, 43, 50, 46, 1, -50 },
  { 421, 36, 57, 40, 2, -53 },
  { 678, 61, 52, 65, 2, -51 },
  { 1075, 51, 52, 54, 3, -51 },
  { 1407, 11, 18, 19, 4, -50 },
  { 1432, 19, 62, 24, 3, -51 },
  { 1580, 20, 62, 24, 2, -51 },
  { 1735, 34, 33, 38, 2, -53 },
  { 1876, 34, 34, 40, 3, -42 },
  { 2021, 15, 18, 21, 2, -9 },
  { 2055, 19, 10, 22, 2, -24 },
  { 2079, 13, 12, 20, 3, -11 },
  { 2099, 30, 52, 30, 0, -51 },
  { 2294, 35, 52, 40, 3, -51 },
  { 2522, 26, 50, 40, 4, -50 },
  { 2685, 36, 51, 40, 2, -51 },
  { 2915, 35, 52, 40, 3, -51 },
  { 3143, 38, 50, 40, 1, -50 },
  { 3381, 34, 51, 40, 3, -50 },
  { 3598, 36, 52, 40, 2, -51 },
  { 3832, 36, 50, 40, 2, -50 },
  { 4057, 36, 52, 40, 2, -51 },
  { 4291, 36, 52, 40, 2, -51 },
  { 4525, 13, 40, 20, 3, -39 },
  { 4590, 15, 48, 20, 2, -39 },
  { 4680, 34, 37, 40, 3, -44 },
  { 4838, 34, 23, 40, 3, -36 },
  { 4936, 34, 37, 40, 3, -44 },
  { 5094, 33, 52, 34, 0, -51 },
  { 5309, 57, 55, 63, 3, -50 },
  { 5701, 50, 50, 50, 0, -50 },
  { 6014, 37, 50, 47, 6, -50 },
  { 6246, 39, 52, 45, 4, -51 },
  { 6500, 42, 50, 51, 6, -50 },
  { 6763, 29, 50, 39, 6, -50 },
  { 6945, 29, 50, 38, 6, -50 },
  { 7127, 42, 52, 51, 4, -51 },
  { 7400, 42, 50, 54, 6, -50 },
  { 7663, 25, 50, 29, 2, -50 },
  { 7820, 23, 65, 24, -5, -50 },
  { 8007, 41, 50, 47, 6, -50 },
  { 8264, 31, 50, 40, 6, -50 },
  { 8458, 55, 50, 67, 6, -50 },
  { 8802, 46, 50, 58, 6, -50 },
  { 9090, 48, 52, 56, 4, -51 },
  { 9402, 35, 50, 44, 6, -50 },
  { 9621, 48, 63, 56, 4, -51 },
  { 9999, 41, 50, 47, 6, -50 },
  { 10256, 34, 52, 39, 3, -51 },
  { 10477, 37, 50, 41, 2, -50 },
  { 10709, 41, 51, 53, 6, -50 },
  { 10971, 47, 50, 47, 0, -50 },
  { 11265, 70, 50, 70, 0, -50 },
  { 11703, 48, 50, 49, 0, -50 },
  { 12003, 45, 50, 45, 0, -50 },
  { 12285, 38, 50, 42, 2, -50 },
  { 12523, 17, 62, 23, 4, -51 },
  { 12655, 30, 52, 30, 0, -51 },
  { 12850, 16, 62, 23, 2, -51 },
  { 12974, 37, 33, 39, 1, -50 },
  { 13127, 32, 7, 32, 0, 5 },
  { 13155, 21, 12, 27, 3, -54 },
  { 13187, 35, 40, 43, 3, -39 },
  { 13362, 36, 54, 45, 5, -53 },
  { 13605, 32, 40, 37, 3, -39 },
  { 13765, 37, 54, 45, 3, -53 },
  { 14015, 36, 40, 42, 3, -39 },
  { 14195, 29, 54, 28, 1, -54 },
  { 14391, 37, 56, 45, 3, -39 },
  { 14650, 36, 53, 46, 5, -53 },
  { 14889, 12, 54, 22, 5, -54 },
  { 14970, 21, 71, 22, -4, -54 },
  { 15157, 40, 53, 45, 5, -53 },
  { 15422, 12, 53, 22, 5, -53 },
  { 15502, 59, 39, 69, 5, -39 },
  { 15790, 36, 39, 46, 5, -39 },
  { 15966, 38, 40, 44, 3, -39 },
  { 16156, 36, 56, 45, 5, -39 },
  { 16408, 37, 56, 45, 3, -39 },
  { 16667, 26, 39, 32, 5, -39 },
  { 16794, 30, 40, 36, 3, -39 },
  { 16944, 27, 47, 31, 2, -46 },
  { 17103, 36, 39, 46, 5, -38 },
  { 17279, 41, 38, 41, 0, -38 },
  { 17474, 60, 38, 62, 1, -38 },
  { 17759, 42, 38, 42, 0, -38 },
  { 17959, 41, 55, 41, 0, -38 },
  { 18241, 31, 38, 35, 2, -38 },
  { 18389, 24, 61, 29, 2, -50 },
  { 18572, 9, 69, 37, 14, -53 },
  { 18650, 24, 61, 29, 3, -50 },
  { 18833, 34, 13, 40, 3, -31 },
};

const GFXfont NotoSans_ExtraBold70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold70pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_EXTRABOLD70PT7B_H_
