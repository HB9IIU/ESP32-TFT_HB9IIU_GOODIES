#ifndef _NOTOSANS_EXTRABOLD19PT7B_H_
#define _NOTOSANS_EXTRABOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xE0, 0x0E, 0xEE, 0xEF, 0xDF, 0x9F, 0x3E,
  0x60, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x19, 0x81,
  0x98, 0xFF, 0xEF, 0xFE, 0x3B, 0x83, 0xB0, 0x33, 0x03, 0x30, 0x08, 0x3F,
  0xBF, 0xFD, 0x6E, 0x87, 0xC3, 0xF8, 0x7E, 0x0F, 0x85, 0xE2, 0xFF, 0xFF,
  0xF0, 0x40, 0x20, 0x38, 0x1C, 0x3E, 0x0C, 0x1B, 0x8E, 0x0C, 0xC6, 0x0E,
  0x66, 0x03, 0x37, 0x01, 0xBB, 0x7C, 0xFB, 0xBF, 0x39, 0xBB, 0x81, 0xDC,
  0xC0, 0xCE, 0x60, 0xE3, 0x70, 0x61, 0xF8, 0x60, 0x78, 0x1E, 0x00, 0xFC,
  0x07, 0xF8, 0x1C, 0xE0, 0x73, 0x81, 0xFC, 0x03, 0xE0, 0x1F, 0x9E, 0xFF,
  0x73, 0x9F, 0xCE, 0x3E, 0x3C, 0xF8, 0xFF, 0xF0, 0xFD, 0xF0, 0xFF, 0xFE,
  0x39, 0x9C, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0xCE, 0x38, 0xC7,
  0x1C, 0xE3, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x39, 0xDC, 0xE0, 0x0C, 0x03,
  0x06, 0xCD, 0xFF, 0xFF, 0xC7, 0x83, 0xF0, 0xCE, 0x12, 0x00, 0x1C, 0x0E,
  0x07, 0x1F, 0xFF, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0xFF, 0xEC, 0xFF,
  0xF0, 0xFF, 0x80, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x70, 0x70, 0x70, 0xE0, 0x1C, 0x3F, 0x9F, 0xDC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0x0E, 0x3C, 0xFB,
  0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x1C, 0x3F,
  0xBF, 0xEC, 0x70, 0x38, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3C, 0x7F, 0xBF, 0xE8, 0x70, 0x38, 0x38, 0xF8, 0x7E, 0x07,
  0x81, 0xC0, 0xF8, 0xFF, 0xF7, 0xF0, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC1,
  0xF8, 0x37, 0x0E, 0xE3, 0x9C, 0x63, 0x9F, 0xFF, 0xFF, 0x81, 0xC0, 0x38,
  0x07, 0x00, 0x7F, 0x3F, 0x9F, 0xDC, 0x0E, 0x07, 0xF3, 0xFD, 0xFF, 0x07,
  0x81, 0xC0, 0xF9, 0xFF, 0xF7, 0xF0, 0x0F, 0x1F, 0x9F, 0xCE, 0x0E, 0x07,
  0x73, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFE, 0xF7, 0xF1, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0xC0, 0x1C, 0x3F, 0xBF, 0xFC, 0x7E, 0x3B, 0xF8, 0xF8, 0xFE, 0xF7,
  0xF1, 0xF8, 0xFC, 0x7F, 0xFB, 0xF8, 0x1C, 0x3F, 0xBF, 0xDC, 0x7E, 0x3F,
  0x1F, 0x9F, 0xFF, 0x7F, 0x81, 0xC0, 0xF1, 0xE7, 0xE3, 0xE0, 0x5F, 0xB0,
  0x00, 0xFF, 0x80, 0x4E, 0xF6, 0x00, 0x00, 0x0E, 0xEE, 0xCC, 0x00, 0x81,
  0xC3, 0xE7, 0xCF, 0x87, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8, 0x3C,
  0x7D, 0xF8, 0xF0, 0x40, 0x00, 0x3E, 0x7F, 0x9F, 0xE8, 0x70, 0x38, 0x38,
  0x3C, 0x38, 0x18, 0x00, 0x00, 0x03, 0x83, 0xC0, 0xE0, 0x03, 0xC0, 0x3F,
  0xE0, 0xF0, 0xF3, 0x80, 0x66, 0x7E, 0xFD, 0xFC, 0xF3, 0x19, 0xE6, 0x33,
  0xCC, 0x67, 0x99, 0xDF, 0x3F, 0xF7, 0x39, 0xC7, 0x00, 0x07, 0x9E, 0x07,
  0xFC, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x81, 0xDC, 0x0E, 0xF0,
  0x73, 0x87, 0x1C, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0xE0, 0xF7, 0x07, 0xF8,
  0x1C, 0xFC, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB9, 0xEF, 0xF3, 0xFE, 0xE3,
  0xB8, 0xFE, 0x3F, 0xFF, 0xFF, 0xBF, 0x80, 0x07, 0x87, 0xFD, 0xFF, 0x3C,
  0x2F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3E, 0xE3,
  0xFC, 0x3F, 0x80, 0xF8, 0x1F, 0xE3, 0xFF, 0x71, 0xEE, 0x1F, 0xC3, 0xF8,
  0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x8F, 0x7F, 0xEF, 0xF9, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0xFF, 0xFF, 0xC3, 0x87, 0x0E,
  0x1C, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0xBC, 0x1F, 0x01, 0xE0, 0x38, 0xFF,
  0x1F, 0xE3, 0xFE, 0x1D, 0xC3, 0xBE, 0xF3, 0xFE, 0x3F, 0xC0, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0xFF, 0xFF, 0xDE, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0xFF, 0xF0, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x73, 0xFE, 0xFB, 0xC0, 0xE1, 0xFC, 0x7B, 0x8E, 0x73,
  0xCE, 0xF1, 0xDC, 0x3F, 0x07, 0xF0, 0xFF, 0x1C, 0xE3, 0x9E, 0x71, 0xCE,
  0x3D, 0xC3, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFD, 0x86, 0xFB, 0x0D, 0xF7, 0x3B, 0xEE, 0x67, 0xCC, 0xCF, 0x9F, 0x9F,
  0x3F, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF1, 0xC0, 0xF0, 0x7F, 0x07, 0xF8,
  0x7F, 0x87, 0xDC, 0x7D, 0xE7, 0xCE, 0x7C, 0xF7, 0xC7, 0x7C, 0x7F, 0xC3,
  0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF,
  0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xDC, 0x1E, 0xFF,
  0xE3, 0xFE, 0x0F, 0xE0, 0xF8, 0x7F, 0xBF, 0xFC, 0xFE, 0x3F, 0x1F, 0x9F,
  0xFE, 0xFE, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xF1, 0xEF, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x83,
  0xDC, 0x1E, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0xF8, 0x1F, 0xE3, 0xFE, 0x71, 0xCE, 0x39, 0xC7, 0x3F, 0xE7, 0xF8, 0xFE,
  0x1D, 0xE3, 0x9C, 0x71, 0xCE, 0x3D, 0xC3, 0xC0, 0x1E, 0x3F, 0xFF, 0xDC,
  0x2E, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xFD, 0xFF, 0xF7, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x77, 0x07, 0x70,
  0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xF0, 0x7F, 0x83, 0x9C, 0x1C, 0xE1, 0xE7,
  0x8E, 0x1C, 0x70, 0xE7, 0x87, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0xE0, 0xE0, 0xFE, 0x1C, 0x3D, 0xC7, 0xC7, 0x38,
  0xF8, 0xE7, 0x1B, 0x1C, 0xE3, 0x63, 0x8E, 0xEE, 0xE1, 0xDD, 0xDC, 0x3B,
  0xBB, 0x87, 0x63, 0x70, 0x6C, 0x6C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C,
  0x1E, 0x00, 0xF0, 0x7B, 0xC3, 0x8E, 0x3C, 0x7B, 0xC1, 0xDC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xEE, 0x0F, 0x78, 0x71, 0xC7, 0x8F, 0x78,
  0x3C, 0xF0, 0x77, 0x0F, 0x78, 0xE3, 0x9E, 0x39, 0xC1, 0xF8, 0x1F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9F, 0xF8, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C,
  0x1C, 0x0E, 0x0E, 0x06, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xFF, 0xF8, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x3F, 0x0C, 0xC7,
  0x39, 0x86, 0xE1, 0xC0, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0xC0, 0x1C, 0x3F,
  0x9F, 0xE0, 0x70, 0xFB, 0xFF, 0xCF, 0xC7, 0xE7, 0xFF, 0xDE, 0x60, 0xF0,
  0x3C, 0x0F, 0x03, 0xD8, 0xEF, 0xBF, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xEF, 0xFF, 0xBB, 0xC0, 0x0E, 0x1F, 0xDF, 0xDE, 0x2E, 0x07, 0x03,
  0x81, 0xC0, 0xF3, 0x3F, 0x8F, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x67, 0x7D,
  0xFF, 0xFF, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0x7F, 0xCF, 0x70,
  0x0C, 0x1F, 0xC7, 0xFB, 0x8F, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x9F,
  0xE3, 0xF8, 0x04, 0x1F, 0x3F, 0x38, 0x38, 0xFE, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1F, 0x7F, 0xFF, 0xCF, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x07, 0x83, 0xFF, 0xEF, 0xF0,
  0x70, 0xF0, 0x3C, 0x0F, 0x03, 0xDC, 0xEF, 0xBF, 0xFF, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x6F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xC0, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3F, 0xEF, 0x98, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x3D, 0xE7, 0x3D, 0xC7, 0x70, 0xFE, 0x1F, 0xE3, 0xDE, 0x79, 0xCF, 0x3D,
  0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x0C, 0xEF,
  0xBF, 0xFF, 0xFF, 0xF3, 0xE7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1,
  0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0x07, 0x3B, 0xEF, 0xFF, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1C, 0x0C, 0x0F, 0xC7,
  0xFB, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xE3, 0xF0, 0x06,
  0x3B, 0xEF, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xFB, 0xFF, 0xEE,
  0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x18, 0x1F, 0x7F, 0xFF, 0xCF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xDF, 0xF3, 0xDC, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x07, 0xDF, 0xFF, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC0, 0x1C, 0x7F, 0xFE, 0xE0, 0xF8, 0x7E, 0x3F, 0x07, 0x87, 0xFF, 0xFE,
  0x18, 0x38, 0x38, 0x7F, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x39, 0x3F,
  0x1F, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0x7F,
  0xCF, 0x30, 0xF0, 0xEE, 0x39, 0xC7, 0x3C, 0xE3, 0xB8, 0x77, 0x06, 0xE0,
  0xF8, 0x1F, 0x01, 0xC0, 0xF3, 0xC7, 0xB9, 0xF3, 0x9C, 0xF9, 0xCE, 0x6D,
  0xC3, 0xF6, 0xE1, 0xFB, 0x70, 0xF9, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F,
  0x1E, 0x00, 0xF1, 0xE7, 0x78, 0xFE, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xE1,
  0xDE, 0x79, 0xDE, 0x3C, 0xF0, 0xEE, 0x39, 0xC7, 0x1C, 0xE3, 0xB8, 0x77,
  0x06, 0xE0, 0xF8, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x07, 0xC0, 0xF0, 0x18,
  0x00, 0xFF, 0xFF, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE0, 0xFF, 0xFF, 0x06,
  0x3C, 0x78, 0xC1, 0x83, 0x06, 0x7C, 0xF1, 0xF0, 0xE0, 0xC1, 0x83, 0x07,
  0x0F, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xCF, 0x1C, 0x71, 0xC7,
  0x0F, 0x1C, 0xF7, 0x9C, 0x71, 0xC7, 0x3C, 0xE0, 0xFC, 0xFF, 0xE3, 0xC0,
};

const GFXglyph NotoSans_ExtraBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 5, 1, -14 },
  { 8, 7, 5, 10, 1, -14 },
  { 13, 12, 14, 12, 0, -14 },
  { 34, 9, 15, 11, 1, -14 },
  { 51, 17, 14, 18, 0, -14 },
  { 81, 14, 14, 15, 1, -14 },
  { 106, 3, 5, 5, 1, -14 },
  { 108, 5, 17, 7, 1, -14 },
  { 119, 5, 17, 7, 1, -14 },
  { 130, 10, 9, 10, 0, -14 },
  { 142, 9, 9, 11, 1, -11 },
  { 153, 3, 5, 6, 1, -2 },
  { 155, 6, 2, 6, 0, -6 },
  { 157, 3, 3, 5, 1, -3 },
  { 159, 8, 14, 8, 0, -14 },
  { 173, 9, 14, 11, 1, -14 },
  { 189, 7, 14, 11, 1, -14 },
  { 202, 9, 14, 11, 1, -14 },
  { 218, 9, 14, 11, 1, -14 },
  { 234, 11, 14, 11, 0, -14 },
  { 254, 9, 14, 11, 1, -14 },
  { 270, 9, 14, 11, 1, -14 },
  { 286, 9, 14, 11, 1, -14 },
  { 302, 9, 14, 11, 1, -14 },
  { 318, 9, 14, 11, 1, -14 },
  { 334, 3, 11, 5, 1, -11 },
  { 339, 4, 14, 6, 1, -11 },
  { 346, 9, 10, 11, 1, -12 },
  { 358, 9, 6, 11, 1, -10 },
  { 365, 9, 10, 11, 1, -12 },
  { 377, 9, 14, 9, 0, -14 },
  { 393, 15, 15, 17, 1, -14 },
  { 422, 13, 14, 13, 0, -14 },
  { 445, 10, 14, 13, 2, -14 },
  { 463, 11, 14, 12, 1, -14 },
  { 483, 11, 14, 14, 2, -14 },
  { 503, 8, 14, 11, 2, -14 },
  { 517, 7, 14, 10, 2, -14 },
  { 530, 11, 14, 14, 1, -14 },
  { 550, 11, 14, 15, 2, -14 },
  { 570, 6, 14, 8, 1, -14 },
  { 581, 6, 18, 6, -1, -14 },
  { 595, 11, 14, 13, 2, -14 },
  { 615, 8, 14, 11, 2, -14 },
  { 629, 15, 14, 18, 2, -14 },
  { 656, 12, 14, 16, 2, -14 },
  { 677, 13, 14, 15, 1, -14 },
  { 700, 9, 14, 12, 2, -14 },
  { 716, 13, 17, 15, 1, -14 },
  { 744, 11, 14, 13, 2, -14 },
  { 764, 9, 14, 11, 1, -14 },
  { 780, 11, 14, 11, 0, -14 },
  { 800, 12, 14, 14, 1, -14 },
  { 821, 13, 14, 13, 0, -14 },
  { 844, 19, 14, 19, 0, -14 },
  { 878, 13, 14, 13, 0, -14 },
  { 901, 12, 14, 12, 0, -14 },
  { 922, 10, 14, 11, 1, -14 },
  { 940, 5, 17, 6, 1, -14 },
  { 951, 8, 14, 8, 0, -14 },
  { 965, 5, 17, 6, 0, -14 },
  { 976, 10, 9, 10, 0, -14 },
  { 988, 9, 2, 9, 0, 1 },
  { 991, 6, 3, 7, 1, -15 },
  { 994, 9, 11, 12, 1, -11 },
  { 1007, 10, 14, 12, 1, -14 },
  { 1025, 9, 11, 10, 1, -11 },
  { 1038, 10, 14, 12, 1, -14 },
  { 1056, 10, 11, 12, 1, -11 },
  { 1070, 8, 15, 8, 0, -15 },
  { 1085, 10, 16, 12, 1, -11 },
  { 1105, 10, 14, 13, 1, -14 },
  { 1123, 4, 15, 6, 1, -15 },
  { 1131, 6, 20, 6, -1, -15 },
  { 1146, 11, 14, 12, 1, -14 },
  { 1166, 4, 14, 6, 1, -14 },
  { 1173, 16, 11, 19, 1, -11 },
  { 1195, 10, 11, 13, 1, -11 },
  { 1209, 10, 11, 12, 1, -11 },
  { 1223, 10, 16, 12, 1, -11 },
  { 1243, 10, 16, 12, 1, -11 },
  { 1263, 7, 11, 9, 1, -11 },
  { 1273, 8, 11, 10, 1, -11 },
  { 1284, 8, 13, 8, 0, -13 },
  { 1297, 10, 10, 13, 1, -10 },
  { 1310, 11, 10, 11, 0, -10 },
  { 1324, 17, 10, 17, 0, -10 },
  { 1346, 11, 10, 11, 0, -10 },
  { 1360, 11, 15, 11, 0, -10 },
  { 1381, 8, 10, 9, 1, -10 },
  { 1391, 7, 17, 8, 0, -14 },
  { 1406, 2, 18, 10, 4, -14 },
  { 1411, 6, 17, 8, 1, -14 },
  { 1424, 9, 3, 11, 1, -8 },
};

const GFXfont NotoSans_ExtraBold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRABOLD19PT7B_H_
