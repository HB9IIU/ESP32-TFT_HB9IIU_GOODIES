#ifndef _NOTOSANS_EXTRABOLD7PT7B_H_
#define _NOTOSANS_EXTRABOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0xF4, 0x5F, 0x6F, 0x60, 0x7A, 0x63, 0xE0, 0xCA, 0xCD,
  0xCB, 0x6C, 0x73, 0x9B, 0x77, 0x80, 0xE0, 0x7A, 0x90, 0xD5, 0x70, 0x4F,
  0x60, 0x2F, 0x20, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x6D, 0x9D, 0x60, 0x7C,
  0x92, 0xE3, 0x24, 0xF0, 0xE3, 0x61, 0xE0, 0x26, 0x6F, 0x20, 0x64, 0xF1,
  0xE0, 0x7C, 0xF9, 0x60, 0xF2, 0x26, 0x40, 0x6F, 0x69, 0xF0, 0x69, 0xF1,
  0x60, 0xC3, 0xC3, 0x80, 0x3C, 0x30, 0xF0, 0xF0, 0xC3, 0xC0, 0xE5, 0x04,
  0x79, 0xFA, 0xEF, 0x48, 0xC0, 0x22, 0x94, 0xE9, 0x80, 0xF7, 0xDE, 0x74,
  0xC4, 0x70, 0xEB, 0x9B, 0xE0, 0xF3, 0x4E, 0xF3, 0x48, 0x7A, 0x36, 0xB7,
  0x80, 0x99, 0xF9, 0x90, 0xE9, 0x2E, 0x24, 0x93, 0xD0, 0xBE, 0xCA, 0xB0,
  0x92, 0x4E, 0x9E, 0xF7, 0xDA, 0x80, 0x9D, 0xFB, 0xB0, 0x76, 0x72, 0x97,
  0x00, 0xF7, 0xC8, 0x76, 0x72, 0x97, 0x0C, 0xEA, 0xEE, 0xB0, 0x7C, 0x63,
  0xE0, 0xF6, 0x66, 0x60, 0x99, 0x9B, 0xE0, 0x9A, 0x94, 0xE2, 0x00, 0x93,
  0xAD, 0xB3, 0x66, 0xC0, 0xDA, 0x88, 0xAD, 0x80, 0xDB, 0x98, 0x42, 0x00,
  0xF2, 0x64, 0xF0, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x46, 0xB0, 0xE0,
  0xC0, 0x63, 0xDF, 0xCF, 0xDD, 0xF0, 0x7C, 0xC6, 0x17, 0xDD, 0x70, 0x6D,
  0xE7, 0x7D, 0x24, 0x7D, 0xD7, 0x96, 0xCF, 0xDD, 0xD0, 0xFF, 0xC0, 0xFF,
  0xF8, 0xCD, 0xEE, 0xD0, 0xFF, 0xC0, 0xFF, 0x5D, 0x75, 0xBD, 0xDD, 0x6D,
  0xD7, 0xFD, 0xDF, 0xCC, 0x7D, 0xD7, 0x11, 0xBB, 0x60, 0x78, 0xF0, 0x5D,
  0x26, 0xDD, 0xD7, 0x97, 0x66, 0xB7, 0xD7, 0x9A, 0xD6, 0x6D, 0x97, 0x66,
  0x4C, 0xE5, 0x70, 0x69, 0x64, 0xC0, 0xFE, 0xC9, 0x35, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 4, 0, -5 },
  { 4, 4, 5, 5, 0, -5 },
  { 7, 4, 5, 4, 0, -5 },
  { 10, 6, 5, 6, 0, -5 },
  { 14, 5, 5, 5, 0, -5 },
  { 18, 2, 2, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 2, 6, 2, 0, -5 },
  { 23, 4, 3, 4, 0, -5 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 2, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -2 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 3, 5, 4, 0, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 4, 5, 4, 0, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 4, 5, 4, 0, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 2, 4, 2, 0, -4 },
  { 62, 2, 5, 2, 0, -4 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 4, 3, 4, 0, -4 },
  { 70, 3, 5, 3, 0, -5 },
  { 72, 6, 6, 6, 0, -5 },
  { 77, 5, 5, 5, 0, -5 },
  { 81, 3, 5, 5, 1, -5 },
  { 83, 4, 5, 5, 0, -5 },
  { 86, 4, 5, 5, 1, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 5, 5, 5, 0, -5 },
  { 97, 4, 5, 5, 1, -5 },
  { 100, 3, 5, 3, 0, -5 },
  { 102, 3, 7, 2, -1, -5 },
  { 105, 4, 5, 5, 1, -5 },
  { 108, 3, 5, 4, 1, -5 },
  { 110, 5, 5, 7, 1, -5 },
  { 114, 4, 5, 6, 1, -5 },
  { 117, 5, 5, 6, 0, -5 },
  { 121, 3, 5, 4, 1, -5 },
  { 123, 5, 6, 6, 0, -5 },
  { 127, 4, 5, 5, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 4, 5, 4, 0, -5 },
  { 136, 4, 5, 5, 1, -5 },
  { 139, 5, 5, 5, 0, -5 },
  { 143, 7, 5, 7, 0, -5 },
  { 148, 5, 5, 5, 0, -5 },
  { 152, 5, 5, 5, 0, -5 },
  { 156, 4, 5, 4, 0, -5 },
  { 159, 2, 6, 2, 0, -5 },
  { 161, 3, 5, 3, 0, -5 },
  { 163, 2, 6, 2, 0, -5 },
  { 165, 4, 3, 4, 0, -5 },
  { 167, 3, 1, 3, 0, 0 },
  { 168, 2, 1, 3, 0, -5 },
  { 169, 4, 4, 4, 0, -4 },
  { 171, 4, 5, 4, 0, -5 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 4, 5, 4, 0, -5 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 3, 5, 3, 0, -5 },
  { 183, 4, 6, 4, 0, -4 },
  { 186, 4, 5, 5, 0, -5 },
  { 189, 2, 5, 2, 0, -5 },
  { 191, 2, 7, 2, 0, -5 },
  { 193, 4, 5, 4, 0, -5 },
  { 196, 2, 5, 2, 0, -5 },
  { 198, 6, 4, 7, 0, -4 },
  { 201, 4, 4, 5, 0, -4 },
  { 203, 4, 4, 4, 0, -4 },
  { 205, 4, 6, 4, 0, -4 },
  { 208, 4, 6, 4, 0, -4 },
  { 211, 3, 4, 3, 0, -4 },
  { 213, 3, 4, 4, 0, -4 },
  { 215, 3, 5, 3, 0, -5 },
  { 217, 4, 4, 5, 0, -4 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 6, 4, 6, 0, -4 },
  { 224, 4, 4, 4, 0, -4 },
  { 226, 4, 6, 4, 0, -4 },
  { 229, 3, 4, 4, 0, -4 },
  { 231, 3, 6, 3, 0, -5 },
  { 234, 1, 7, 4, 1, -5 },
  { 235, 3, 6, 3, 0, -5 },
  { 238, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraBold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRABOLD7PT7B_H_
