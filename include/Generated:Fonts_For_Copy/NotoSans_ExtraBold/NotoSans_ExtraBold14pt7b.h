#ifndef _NOTOSANS_EXTRABOLD14PT7B_H_
#define _NOTOSANS_EXTRABOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF7, 0xB0, 0x1B, 0x0D, 0x84, 0x8F, 0xF3,
  0x61, 0xB3, 0xFC, 0x48, 0x24, 0x36, 0x00, 0x18, 0x1C, 0x7E, 0xFA, 0x78,
  0x7C, 0x1E, 0x1F, 0x5F, 0x7E, 0x18, 0x18, 0x70, 0xC2, 0xCC, 0x36, 0x61,
  0xB6, 0x05, 0xBF, 0x3B, 0x78, 0x1B, 0x61, 0x9B, 0x08, 0xF0, 0xC7, 0x80,
  0x7C, 0x1F, 0x0E, 0xC1, 0xF0, 0x78, 0x3E, 0x6D, 0xFB, 0x3C, 0xFF, 0x1F,
  0xF0, 0xFF, 0x7F, 0x6D, 0xB6, 0xDB, 0x30, 0xE6, 0x33, 0x33, 0x33, 0x33,
  0x6E, 0x18, 0x31, 0x6F, 0xF3, 0x8F, 0x89, 0x00, 0x30, 0xCF, 0xFF, 0x30,
  0xC0, 0x6D, 0xE0, 0xFF, 0xF0, 0x0C, 0x61, 0x8E, 0x30, 0xC7, 0x18, 0x63,
  0x00, 0x3C, 0x7E, 0x66, 0x66, 0x67, 0xE7, 0x67, 0x66, 0x7E, 0x3C, 0x3B,
  0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC0, 0x3C, 0xFE, 0x46, 0x06, 0x0E, 0x1C,
  0x38, 0x70, 0xFF, 0xFF, 0x7C, 0x7E, 0x06, 0x06, 0x3C, 0x3E, 0x06, 0x07,
  0xFE, 0xFC, 0x0E, 0x1E, 0x1E, 0x3E, 0x6E, 0x6E, 0xFF, 0xFF, 0x0E, 0x0E,
  0xFF, 0xFC, 0x30, 0xFE, 0x70, 0xC3, 0xFF, 0xE0, 0x1E, 0x3E, 0x60, 0x6C,
  0x7E, 0xE7, 0x67, 0x67, 0x7E, 0x3C, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x0C,
  0x18, 0x18, 0x38, 0x70, 0x3C, 0x7E, 0x66, 0x7E, 0x3C, 0x7E, 0x66, 0xE7,
  0x7E, 0x3E, 0x3C, 0x7E, 0x66, 0xE7, 0x67, 0x7F, 0x36, 0x06, 0x7C, 0x78,
  0xFC, 0x0F, 0x6D, 0x80, 0x1B, 0x78, 0x04, 0x33, 0xB8, 0xE0, 0xF0, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0x07, 0x07, 0x1D, 0xEC, 0x20, 0x7D, 0xF8, 0x38,
  0x61, 0xC6, 0x0C, 0x00, 0x30, 0x60, 0x1F, 0x0E, 0x39, 0x99, 0x6F, 0xB9,
  0x37, 0x66, 0xEC, 0xDE, 0xFE, 0xC0, 0x0E, 0x30, 0xFC, 0x00, 0x1E, 0x07,
  0x81, 0xE0, 0xDC, 0x33, 0x0C, 0xC7, 0xF9, 0xFE, 0x61, 0xB8, 0x70, 0xFC,
  0xFE, 0xE6, 0xE6, 0xFC, 0xFE, 0xE7, 0xE7, 0xFE, 0xFC, 0x3F, 0x7E, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7E, 0x3E, 0xFC, 0x7F, 0x39, 0xDC, 0x6E,
  0x3F, 0x1B, 0x8D, 0xCE, 0xFE, 0x7E, 0x00, 0xFF, 0xFE, 0x38, 0xFF, 0xFE,
  0x38, 0xFF, 0xF0, 0xFF, 0xFE, 0x38, 0xFF, 0xFE, 0x38, 0xE3, 0x80, 0x3F,
  0x7F, 0xE0, 0xC0, 0xCF, 0xCF, 0xC3, 0xE3, 0x7F, 0x3F, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0xFB, 0xCC, 0x63,
  0x18, 0xC6, 0x7F, 0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCD, 0xEE,
  0x00, 0xE7, 0xE6, 0xEE, 0xFC, 0xF8, 0xFC, 0xEC, 0xEE, 0xE7, 0xE7, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xF0, 0xFE, 0x1F, 0xC7, 0xE8,
  0xFD, 0x97, 0xB6, 0xF6, 0xDE, 0x73, 0xCE, 0x79, 0xCC, 0xF1, 0xF8, 0xFE,
  0x7B, 0x3D, 0xDE, 0x6F, 0x3F, 0x8F, 0xC7, 0xE1, 0xC0, 0x3E, 0x3F, 0xB8,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC7, 0x7F, 0x1F, 0x00, 0xFD, 0xFF, 0x9F,
  0x3E, 0xFF, 0xBC, 0x70, 0xE1, 0xC0, 0x3E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0xC7, 0x7F, 0x1F, 0x01, 0xC0, 0x70, 0xFC, 0xFE, 0xE6, 0xE6,
  0xFE, 0xFC, 0xEC, 0xEE, 0xE6, 0xE7, 0x7F, 0xFC, 0x38, 0xF8, 0xF0, 0xE3,
  0xFF, 0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x3E, 0xE1, 0xF1,
  0xD8, 0xEE, 0x67, 0x31, 0xB8, 0xD8, 0x7C, 0x1E, 0x0E, 0x00, 0xE3, 0x1F,
  0x8C, 0x76, 0x79, 0x99, 0xE6, 0x67, 0x99, 0xD2, 0xE3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF0, 0xE1, 0xC0, 0xE3, 0x9C, 0xC3, 0x70, 0xF8, 0x1E, 0x07, 0x83,
  0xE0, 0xDC, 0x73, 0xB8, 0x70, 0xE3, 0xB1, 0x9D, 0xC6, 0xC3, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x1C, 0x38, 0x30,
  0x70, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x70, 0xC1, 0x86, 0x1C, 0x30,
  0xC3, 0x86, 0x18, 0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x38,
  0x3C, 0x6C, 0x66, 0x46, 0xC3, 0xFC, 0xC6, 0x30, 0x79, 0xF8, 0x3B, 0xFF,
  0xF9, 0xFF, 0xFB, 0xC1, 0x83, 0x06, 0xEF, 0xFC, 0xF1, 0xE3, 0xE7, 0xFF,
  0x70, 0x3B, 0xFE, 0x70, 0xC3, 0x0F, 0xDF, 0x06, 0x0C, 0x1B, 0xBF, 0xF9,
  0xF1, 0xE3, 0xC7, 0xFD, 0xD8, 0x39, 0xFB, 0x1F, 0xFF, 0xF8, 0x3F, 0x3E,
  0x1C, 0xF7, 0x1E, 0xF9, 0xC7, 0x1C, 0x71, 0xC7, 0x00, 0x77, 0xFF, 0x3E,
  0x3C, 0x78, 0xFF, 0xBB, 0x07, 0xFF, 0xF0, 0xC1, 0x83, 0x06, 0xEF, 0xFC,
  0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF3, 0xFF, 0xFC, 0x33, 0x03, 0x33, 0x33,
  0x33, 0x33, 0xFF, 0xC0, 0xC0, 0xC0, 0xC7, 0xCE, 0xDC, 0xF8, 0xF8, 0xEC,
  0xCE, 0xC7, 0xFF, 0xFF, 0xFC, 0xDC, 0xEF, 0xFF, 0xE6, 0x7C, 0x67, 0xC6,
  0x7C, 0x67, 0xC6, 0x7C, 0x67, 0xDD, 0xFF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3,
  0x39, 0xFB, 0x3E, 0x3C, 0x78, 0xFF, 0xBE, 0xDD, 0xFF, 0x9E, 0x3C, 0x7C,
  0xFF, 0xEE, 0xC1, 0x83, 0x00, 0x77, 0xFF, 0x3E, 0x3C, 0x78, 0xFF, 0xBB,
  0x06, 0x0C, 0x18, 0xDF, 0xF9, 0x8C, 0x63, 0x18, 0x7B, 0xEC, 0x3C, 0x78,
  0x7F, 0xBE, 0x31, 0xFF, 0xDC, 0x71, 0xC7, 0x1F, 0x3C, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xFF, 0xBF, 0xE3, 0xE7, 0x66, 0x66, 0x3E, 0x3C, 0x3C, 0x1C,
  0xE7, 0x3E, 0x73, 0x6F, 0x76, 0xF6, 0x6D, 0x63, 0x9E, 0x39, 0xC3, 0x9C,
  0xE7, 0x76, 0x3E, 0x3C, 0x3C, 0x3E, 0x76, 0xE7, 0xE3, 0xE7, 0x66, 0x66,
  0x3E, 0x3C, 0x3C, 0x1C, 0x18, 0x78, 0x70, 0x7C, 0xF8, 0x70, 0xC3, 0x0E,
  0x3F, 0xFF, 0x19, 0xCC, 0x63, 0x7B, 0x86, 0x31, 0x8E, 0x70, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE7, 0x8C, 0x63, 0x1C, 0xE6, 0x31, 0x9D, 0xC0, 0xF7, 0xF0,
};

const GFXglyph NotoSans_ExtraBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 7, 1, -10 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 8, 12, 8, 0, -11 },
  { 31, 13, 10, 13, 0, -10 },
  { 48, 10, 10, 11, 1, -10 },
  { 61, 2, 4, 4, 1, -10 },
  { 62, 3, 12, 5, 1, -10 },
  { 67, 4, 12, 5, 0, -10 },
  { 73, 7, 7, 8, 0, -11 },
  { 80, 6, 6, 8, 1, -8 },
  { 85, 3, 4, 4, 0, -2 },
  { 87, 4, 2, 4, 0, -5 },
  { 88, 2, 2, 4, 1, -2 },
  { 89, 6, 10, 6, 0, -10 },
  { 97, 8, 10, 8, 0, -10 },
  { 107, 5, 10, 8, 1, -10 },
  { 114, 8, 10, 8, 0, -10 },
  { 124, 8, 10, 8, 0, -10 },
  { 134, 8, 10, 8, 0, -10 },
  { 144, 6, 10, 8, 1, -10 },
  { 152, 8, 10, 8, 0, -10 },
  { 162, 8, 10, 8, 0, -10 },
  { 172, 8, 10, 8, 0, -10 },
  { 182, 8, 10, 8, 0, -10 },
  { 192, 2, 8, 4, 1, -8 },
  { 194, 3, 10, 4, 0, -8 },
  { 198, 6, 8, 8, 1, -9 },
  { 204, 6, 4, 8, 1, -7 },
  { 207, 6, 8, 8, 1, -9 },
  { 213, 7, 10, 7, 0, -10 },
  { 222, 11, 11, 13, 1, -10 },
  { 238, 10, 10, 10, 0, -10 },
  { 251, 8, 10, 9, 1, -10 },
  { 261, 8, 10, 9, 1, -10 },
  { 271, 9, 10, 10, 1, -10 },
  { 283, 6, 10, 8, 1, -10 },
  { 291, 6, 10, 8, 1, -10 },
  { 299, 8, 10, 10, 1, -10 },
  { 309, 9, 10, 11, 1, -10 },
  { 321, 5, 10, 6, 0, -10 },
  { 328, 5, 13, 5, -1, -10 },
  { 337, 8, 10, 9, 1, -10 },
  { 347, 6, 10, 8, 1, -10 },
  { 355, 11, 10, 13, 1, -10 },
  { 369, 9, 10, 12, 1, -10 },
  { 381, 9, 10, 11, 1, -10 },
  { 393, 7, 10, 9, 1, -10 },
  { 402, 9, 12, 11, 1, -10 },
  { 416, 8, 10, 9, 1, -10 },
  { 426, 6, 10, 8, 1, -10 },
  { 434, 8, 10, 8, 0, -10 },
  { 444, 8, 10, 11, 1, -10 },
  { 454, 9, 10, 9, 0, -10 },
  { 466, 14, 10, 14, 0, -10 },
  { 484, 10, 10, 10, 0, -10 },
  { 497, 9, 10, 9, 0, -10 },
  { 509, 8, 10, 8, 0, -10 },
  { 519, 3, 12, 5, 1, -10 },
  { 524, 6, 10, 6, 0, -10 },
  { 532, 4, 12, 5, 0, -10 },
  { 538, 8, 7, 8, 0, -10 },
  { 545, 6, 1, 6, 0, 1 },
  { 546, 4, 3, 5, 1, -11 },
  { 548, 7, 8, 9, 1, -8 },
  { 555, 7, 11, 9, 1, -11 },
  { 565, 6, 8, 7, 1, -8 },
  { 571, 7, 11, 9, 1, -11 },
  { 581, 7, 8, 9, 1, -8 },
  { 588, 6, 11, 6, 0, -11 },
  { 597, 7, 11, 9, 1, -8 },
  { 607, 7, 11, 9, 1, -11 },
  { 617, 2, 11, 4, 1, -11 },
  { 620, 4, 14, 4, -1, -11 },
  { 627, 8, 11, 9, 1, -11 },
  { 638, 2, 11, 4, 1, -11 },
  { 641, 12, 8, 14, 1, -8 },
  { 653, 7, 8, 9, 1, -8 },
  { 660, 7, 8, 9, 1, -8 },
  { 667, 7, 11, 9, 1, -8 },
  { 677, 7, 11, 9, 1, -8 },
  { 687, 5, 8, 6, 1, -8 },
  { 692, 6, 8, 7, 1, -8 },
  { 698, 6, 9, 6, 0, -9 },
  { 705, 7, 8, 9, 1, -8 },
  { 712, 8, 8, 8, 0, -8 },
  { 720, 12, 8, 12, 0, -8 },
  { 732, 8, 8, 8, 0, -8 },
  { 740, 8, 11, 8, 0, -8 },
  { 751, 7, 8, 7, 0, -8 },
  { 758, 5, 12, 6, 0, -10 },
  { 766, 2, 14, 7, 3, -11 },
  { 770, 5, 12, 6, 0, -10 },
  { 778, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_ExtraBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRABOLD14PT7B_H_
