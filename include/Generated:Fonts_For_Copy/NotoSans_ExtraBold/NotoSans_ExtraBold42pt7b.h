#ifndef _NOTOSANS_EXTRABOLD42PT7B_H_
#define _NOTOSANS_EXTRABOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0xFC, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0,
  0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF9, 0xE1, 0xCF, 0xE7,
  0x80, 0x3F, 0x9E, 0x00, 0x7F, 0x78, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xE7, 0xF0, 0x07, 0x9F, 0xD0, 0x1E,
  0x7F, 0x78, 0x7B, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0x07,
  0xCF, 0xC0, 0x7E, 0x00, 0x7E, 0x3E, 0x03, 0xE0, 0x03, 0xF1, 0xF8, 0x3F,
  0x00, 0x1F, 0x8F, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x07, 0xE3,
  0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0xFC, 0x00,
  0x0F, 0xC7, 0xC7, 0xC7, 0xF8, 0x3E, 0x7E, 0x7E, 0x7F, 0xE1, 0xFF, 0xF3,
  0xE7, 0xFF, 0x87, 0xFF, 0x3F, 0x3F, 0xFE, 0x1F, 0xF1, 0xF3, 0xF3, 0xF0,
  0x7F, 0x1F, 0x9F, 0x8F, 0x80, 0x00, 0xF8, 0xFC, 0x7E, 0x00, 0x0F, 0xC7,
  0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0xFC, 0x00,
  0x7E, 0x0F, 0x87, 0xE0, 0x03, 0xE0, 0x7E, 0x3F, 0x00, 0x3F, 0x03, 0xF1,
  0xF0, 0x01, 0xF0, 0x0F, 0x9F, 0x80, 0x1F, 0x80, 0x7F, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0x1F, 0xFF,
  0x03, 0xFC, 0x7F, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF,
  0xBF, 0x87, 0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF,
  0xF8, 0x3F, 0x80, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C, 0x09, 0xE3, 0xE3, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F,
  0x8F, 0xC1, 0xFC, 0x7E, 0x01, 0xC1, 0xC0, 0x02, 0x08, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x3F, 0xCF, 0xF1, 0xFC, 0x3F, 0xDF, 0xC0, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB,
  0xF8, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x9F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE3, 0xE0, 0x7F, 0x87, 0x00, 0xFE, 0x08, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x9F, 0xF8,
  0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0xF8,
  0x3F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F,
  0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0x87,
  0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x38, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xE0, 0x41, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0xE0, 0x1F, 0x9F, 0xF0, 0x7E, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F,
  0xDF, 0xE0, 0xFE, 0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFE, 0x1F, 0xE7,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFE, 0x1F, 0xE3, 0xFC,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F,
  0xC0, 0xFE, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0x7F, 0x03, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0xC7, 0xF0,
  0x7F, 0x9F, 0xC0, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xFD, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xE0, 0xFF, 0x9F, 0x80, 0xF8,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x20, 0x7F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x3F, 0x3F, 0xDF, 0xEF, 0xF7, 0xF9, 0xF8,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F,
  0x8F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xF1, 0xFF,
  0x30, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x01, 0xE0,
  0x7C, 0x3F, 0x07, 0xFF, 0x9F, 0x8F, 0x87, 0xFF, 0xE3, 0xE7, 0xC3, 0xFF,
  0xF8, 0xF9, 0xF0, 0xFF, 0xFE, 0x1F, 0xFC, 0x7E, 0x0F, 0x87, 0xFE, 0x1F,
  0x03, 0xE1, 0xFF, 0x8F, 0xC0, 0xF8, 0x7F, 0xE3, 0xE0, 0x3E, 0x1F, 0xF8,
  0xF8, 0x0F, 0x87, 0xFE, 0x3E, 0x03, 0xE1, 0xFF, 0x8F, 0x81, 0xF8, 0xFB,
  0xE3, 0xF0, 0x7E, 0x3E, 0xF8, 0x7C, 0x3F, 0x9F, 0xBE, 0x1F, 0xFF, 0xFF,
  0xCF, 0xC3, 0xFF, 0xFF, 0xE1, 0xF0, 0xFF, 0xCF, 0xF8, 0x7E, 0x0F, 0xE1,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xC0,
  0xFF, 0x7F, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x0F,
  0xF7, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xE0, 0x0C, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0E, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F,
  0xEF, 0xF0, 0x03, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x3F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x20, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xF7, 0xF0,
  0x7F, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF3,
  0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC1, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80,
  0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF7, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0x7C, 0x03, 0xEF, 0xFF, 0xBF, 0x03,
  0xF7, 0xFF, 0xDF, 0x81, 0xF3, 0xFF, 0xEF, 0xC0, 0xF9, 0xFF, 0xF3, 0xF0,
  0xFC, 0xFF, 0xF9, 0xF8, 0x7E, 0x7F, 0xFC, 0xFC, 0x3E, 0x3F, 0xFE, 0x3E,
  0x3F, 0x1F, 0xFF, 0x1F, 0x9F, 0x8F, 0xFF, 0x8F, 0xCF, 0x87, 0xFF, 0xC3,
  0xE7, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF8, 0x3F, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF,
  0x07, 0xFC, 0x0F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0x01, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xBF,
  0x80, 0xFF, 0xF7, 0xF8, 0x1F, 0xFE, 0x7F, 0x03, 0xFF, 0xCF, 0xF0, 0x7F,
  0xF8, 0xFE, 0x0F, 0xFF, 0x1F, 0xE1, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x3F,
  0xC7, 0xFF, 0x83, 0xF8, 0xFF, 0xF0, 0x7F, 0x9F, 0xFE, 0x07, 0xFB, 0xFF,
  0xC0, 0x7F, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x07,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB, 0xFC,
  0x7F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x07,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF1, 0xFE,
  0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0,
  0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFD, 0xFE, 0xFF, 0x00, 0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8,
  0x01, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xDF, 0xC0, 0x1F, 0xE0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x07,
  0xE0, 0x7F, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xCF, 0x83, 0xF8, 0x1F, 0xC1, 0xF3, 0xE0, 0xFE, 0x03, 0xF0, 0xFC, 0xFC,
  0x3F, 0x00, 0xFE, 0x3F, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xCF, 0xC7, 0xF0,
  0x0F, 0xE3, 0xE1, 0xF1, 0xFC, 0x01, 0xF9, 0xF8, 0x7E, 0x7E, 0x00, 0x7E,
  0x7E, 0x1F, 0x9F, 0x80, 0x1F, 0xDF, 0x87, 0xEF, 0xE0, 0x07, 0xF7, 0xC0,
  0xFB, 0xF8, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x7F,
  0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x3F,
  0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF9, 0xF0, 0x01,
  0xF7, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x06, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0xBF, 0xFC, 0xFC,
  0x7F, 0x83, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xBF, 0xC0, 0xFE, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xEF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xCF, 0xFC, 0x3F, 0x1F, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x87, 0x1F, 0xE0, 0x27,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x4F,
  0xF8, 0x79, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC7, 0xF1, 0xFF, 0xDF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xF7, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xF7,
  0xF1, 0xFF, 0xCF, 0xC1, 0xFC, 0x3F, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF1, 0xFE, 0x0F, 0xE7, 0xF0,
  0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0x18, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0xFC, 0x7F, 0xF7, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFD, 0xFC, 0x7F, 0xF7, 0xF0, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF6, 0x00, 0x7F, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF9, 0xFF, 0x0F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x03, 0xFC, 0xFE, 0x07, 0xF8,
  0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0,
  0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xC0,
  0xFF, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC1, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F,
  0xFC, 0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xF1, 0xFE, 0xFF, 0x03, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x80,
  0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFE, 0x03,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80,
  0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFE, 0x03,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0xFC, 0x7F, 0xC3, 0xF3, 0xFF, 0xCF, 0xDF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFF,
  0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x7F,
  0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x7F, 0x83, 0xF3, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFE, 0x3F, 0xEF, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFB, 0xFF, 0x0F,
  0xE7, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x7F, 0xF7, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFE, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFD, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFD, 0xFC, 0x7F, 0xF7, 0xF0, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0xF8, 0x3F, 0xFC, 0xFF, 0xFD, 0xFE, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x0F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xBF, 0x3F, 0x80,
  0xCF, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF,
  0x87, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE1, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFC, 0xFF, 0xF3, 0xF0,
  0xFF, 0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFF, 0x81, 0xFC, 0xFE, 0x07, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F,
  0xF0, 0xFE, 0x1F, 0xC3, 0xEF, 0x87, 0xF0, 0xFE, 0x1F, 0x7C, 0x3F, 0x83,
  0xF0, 0xFB, 0xE1, 0xF8, 0x1F, 0xC7, 0xDF, 0x1F, 0xC0, 0xFE, 0x7E, 0xFC,
  0xFE, 0x07, 0xF3, 0xE3, 0xE7, 0xF0, 0x1F, 0x9F, 0x1F, 0x3F, 0x00, 0xFC,
  0xF8, 0xF9, 0xF8, 0x07, 0xE7, 0xC7, 0xDF, 0xC0, 0x1F, 0xFC, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE3, 0xFC, 0x07, 0xFB, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xDF,
  0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xC1, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xF0, 0x00, 0x04, 0x00,
  0x17, 0xFC, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC0, 0x7F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_ExtraBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 31, 12, 2, -30 },
  { 32, 15, 11, 21, 3, -30 },
  { 53, 26, 30, 27, 1, -30 },
  { 151, 22, 34, 24, 1, -32 },
  { 245, 37, 30, 39, 1, -30 },
  { 384, 31, 30, 32, 2, -30 },
  { 501, 6, 11, 12, 3, -30 },
  { 510, 11, 37, 15, 2, -30 },
  { 561, 12, 37, 15, 1, -30 },
  { 617, 21, 20, 23, 1, -32 },
  { 670, 20, 20, 24, 2, -25 },
  { 720, 9, 11, 12, 1, -5 },
  { 733, 11, 6, 13, 1, -14 },
  { 742, 8, 8, 12, 2, -7 },
  { 750, 18, 30, 18, 0, -30 },
  { 818, 21, 30, 24, 2, -30 },
  { 897, 16, 30, 24, 2, -30 },
  { 957, 22, 30, 24, 1, -30 },
  { 1040, 21, 30, 24, 2, -30 },
  { 1119, 23, 30, 24, 1, -30 },
  { 1206, 20, 30, 24, 2, -30 },
  { 1281, 22, 30, 24, 1, -30 },
  { 1364, 22, 30, 24, 1, -30 },
  { 1447, 22, 30, 24, 1, -30 },
  { 1530, 22, 30, 24, 1, -30 },
  { 1613, 8, 24, 12, 2, -23 },
  { 1637, 9, 29, 12, 1, -23 },
  { 1670, 20, 23, 24, 2, -27 },
  { 1728, 20, 14, 24, 2, -22 },
  { 1763, 20, 23, 24, 2, -27 },
  { 1821, 20, 31, 21, 0, -30 },
  { 1899, 34, 33, 38, 2, -30 },
  { 2040, 30, 30, 30, 0, -30 },
  { 2153, 23, 30, 28, 3, -30 },
  { 2240, 24, 30, 27, 2, -30 },
  { 2330, 26, 30, 31, 3, -30 },
  { 2428, 17, 30, 23, 4, -30 },
  { 2492, 17, 30, 23, 4, -30 },
  { 2556, 26, 30, 31, 2, -30 },
  { 2654, 25, 30, 32, 4, -30 },
  { 2748, 15, 30, 17, 1, -30 },
  { 2805, 14, 39, 14, -3, -30 },
  { 2874, 24, 30, 28, 4, -30 },
  { 2964, 19, 30, 24, 3, -30 },
  { 3036, 33, 30, 40, 4, -30 },
  { 3160, 27, 30, 35, 4, -30 },
  { 3262, 29, 30, 33, 2, -30 },
  { 3371, 22, 30, 26, 3, -30 },
  { 3454, 29, 37, 33, 2, -30 },
  { 3589, 25, 30, 28, 3, -30 },
  { 3683, 20, 30, 24, 2, -30 },
  { 3758, 23, 30, 25, 1, -30 },
  { 3845, 25, 30, 32, 3, -30 },
  { 3939, 28, 30, 28, 0, -30 },
  { 4044, 42, 30, 42, 0, -30 },
  { 4202, 29, 30, 29, 0, -30 },
  { 4311, 27, 30, 27, 0, -30 },
  { 4413, 23, 30, 25, 1, -30 },
  { 4500, 10, 37, 14, 3, -30 },
  { 4547, 18, 30, 18, 0, -30 },
  { 4615, 10, 37, 14, 1, -30 },
  { 4662, 23, 20, 23, 0, -30 },
  { 4720, 19, 4, 19, 0, 3 },
  { 4730, 13, 7, 16, 2, -32 },
  { 4742, 21, 23, 26, 2, -23 },
  { 4803, 22, 32, 27, 3, -32 },
  { 4891, 19, 23, 22, 2, -23 },
  { 4946, 22, 32, 27, 2, -32 },
  { 5034, 22, 23, 26, 2, -23 },
  { 5098, 17, 32, 17, 1, -32 },
  { 5166, 22, 33, 27, 2, -23 },
  { 5257, 22, 32, 28, 3, -32 },
  { 5345, 7, 32, 13, 3, -32 },
  { 5373, 12, 42, 13, -2, -32 },
  { 5436, 24, 32, 27, 3, -32 },
  { 5532, 7, 32, 13, 3, -32 },
  { 5560, 36, 23, 41, 3, -23 },
  { 5664, 22, 23, 28, 3, -23 },
  { 5728, 23, 23, 26, 2, -23 },
  { 5795, 22, 33, 27, 3, -23 },
  { 5886, 22, 33, 27, 2, -23 },
  { 5977, 16, 23, 19, 3, -23 },
  { 6023, 18, 23, 21, 2, -23 },
  { 6075, 16, 28, 19, 1, -28 },
  { 6131, 22, 23, 28, 3, -23 },
  { 6195, 25, 23, 25, 0, -23 },
  { 6267, 37, 23, 37, 0, -23 },
  { 6374, 25, 23, 25, 0, -23 },
  { 6446, 25, 33, 25, 0, -23 },
  { 6550, 19, 23, 21, 1, -23 },
  { 6605, 15, 37, 17, 1, -30 },
  { 6675, 5, 41, 22, 9, -32 },
  { 6701, 14, 37, 17, 2, -30 },
  { 6766, 20, 8, 24, 2, -19 },
};

const GFXfont NotoSans_ExtraBold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRABOLD42PT7B_H_
