#ifndef _NOTOSANS_EXTRABOLD33PT7B_H_
#define _NOTOSANS_EXTRABOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFE, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x8F, 0xF8, 0xFF, 0x8F, 0xF8, 0xF7, 0x8F, 0x78, 0xF0, 0x01, 0xE7, 0x80,
  0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x70,
  0x07, 0x8F, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x71, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xF9,
  0xF3, 0x84, 0xF9, 0xC0, 0x7E, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xDF, 0x80, 0xE7, 0xF0,
  0x73, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F, 0xE0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x3E, 0x01, 0xFC,
  0x01, 0xE0, 0x1F, 0xF0, 0x1F, 0x01, 0xFF, 0xC0, 0xF0, 0x0F, 0x9E, 0x0F,
  0x80, 0x78, 0xF0, 0x78, 0x03, 0xC7, 0x87, 0xC0, 0x1E, 0x3C, 0x3C, 0x00,
  0xF1, 0xE3, 0xC0, 0x07, 0x8F, 0x3E, 0x10, 0x3E, 0x79, 0xE7, 0xF1, 0xFF,
  0xDF, 0x7F, 0xC7, 0xFC, 0xF3, 0xFF, 0x1F, 0xCF, 0xBE, 0x78, 0x3C, 0x79,
  0xF3, 0xC0, 0x07, 0xCF, 0x1F, 0x00, 0x3C, 0x78, 0xF8, 0x03, 0xC3, 0xC7,
  0xC0, 0x1E, 0x1E, 0x3E, 0x01, 0xE0, 0xF9, 0xE0, 0x1F, 0x03, 0xCF, 0x00,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x7F, 0x80, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xF1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xC3,
  0xFF, 0x87, 0xE1, 0xFF, 0xE3, 0xF1, 0xFB, 0xFB, 0xF1, 0xF8, 0xFF, 0xF8,
  0xFC, 0x3F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3F, 0x03, 0xFC, 0x0F, 0xE3, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xF8, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x78, 0x07, 0xC3, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0xC0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E,
  0x1F, 0x0F, 0x0F, 0x8F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xC3, 0xC2, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x07,
  0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E, 0x78, 0x3E, 0x7C, 0x0C, 0x30, 0x04,
  0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x7E,
  0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFB,
  0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0x7C,
  0xF8, 0x3E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F,
  0x8F, 0xCF, 0xC7, 0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x3F, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF,
  0x79, 0xF2, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF1, 0xE1,
  0xF8, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF1, 0x81, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7F,
  0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xDF, 0x81, 0xE7, 0xE0, 0xF9, 0xF8, 0x7C, 0x7E, 0x1E,
  0x1F, 0x8F, 0x87, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0x20, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x80, 0x7E, 0xE0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0x7E, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x20, 0x3C, 0xFE, 0x3E, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xDF, 0x07, 0xEF, 0xC7, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E,
  0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF1,
  0xFD, 0xFC, 0xF8, 0x3E, 0xFC, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x83,
  0xF7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0, 0x7D,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xCF, 0xF7, 0xFF,
  0xFB, 0xFF, 0x7C, 0xFF, 0xBE, 0x1F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80,
  0xFB, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF,
  0xFF, 0xE0, 0x7C, 0xFD, 0xFB, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xBE, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0x30, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0x07, 0x83, 0xF0, 0xF1, 0xE1, 0xFF, 0x9E, 0x3C, 0x7F, 0xF1, 0xEF, 0x1F,
  0xDE, 0x3D, 0xE3, 0xC3, 0xC7, 0xBC, 0xF0, 0x78, 0xF7, 0x9E, 0x0F, 0x1F,
  0xE3, 0xC1, 0xE3, 0xFC, 0x78, 0x3C, 0x7F, 0x8F, 0x07, 0x8F, 0x79, 0xF1,
  0xF3, 0xCF, 0x1F, 0xFF, 0xF9, 0xE3, 0xFE, 0xFE, 0x3E, 0x1F, 0x8F, 0x83,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x06, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x50, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0, 0x07,
  0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF8, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x40, 0x7F,
  0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0x0F, 0xFF,
  0xE7, 0xFF, 0xFB, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xE0,
  0x00, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xC0, 0x67, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x05, 0xFF, 0x1E, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF0, 0x7F, 0xBE, 0x03, 0xF7, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01,
  0xFB, 0xE0, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xF8, 0x0C, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x03, 0xF7,
  0xFC, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFC,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFD, 0xFF, 0x3F, 0x80, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x7C,
  0x0F, 0xCF, 0x83, 0xF1, 0xF0, 0xFE, 0x3E, 0x1F, 0x87, 0xC7, 0xE0, 0xF9,
  0xF8, 0x1F, 0x7F, 0x03, 0xEF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xE7, 0xE0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE0,
  0xFC, 0x7C, 0x1F, 0xCF, 0x81, 0xF9, 0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0,
  0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x78, 0x0F, 0xFF, 0xFE, 0x03, 0xDF,
  0xFF, 0xC0, 0xF7, 0xFE, 0xF0, 0x7D, 0xFF, 0xBC, 0x1E, 0x7F, 0xEF, 0x87,
  0xBF, 0xFB, 0xE3, 0xEF, 0xFE, 0x78, 0xF3, 0xFF, 0x9F, 0x3C, 0xFF, 0xE7,
  0xDF, 0x3F, 0xF8, 0xF7, 0x8F, 0xFE, 0x3D, 0xE3, 0xFF, 0x8F, 0xF8, 0xFF,
  0xE1, 0xFE, 0x3F, 0xF8, 0x7F, 0x0F, 0xFE, 0x1F, 0xC3, 0xFF, 0x87, 0xF0,
  0xFF, 0xE0, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFB, 0xE0, 0xFF, 0xDF, 0x87, 0xFE, 0x7E, 0x3F, 0xF3, 0xF1, 0xFF,
  0x8F, 0xCF, 0xFC, 0x7E, 0x7F, 0xE1, 0xFB, 0xFF, 0x0F, 0xDF, 0xF8, 0x3F,
  0x7F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFC, 0x0F, 0xE7,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x9F,
  0xFB, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0x80, 0x7F, 0x7F, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0xFC, 0xFC, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xFF, 0x7F, 0xC3, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xFC, 0xF8,
  0x1F, 0x1F, 0x07, 0xE3, 0xE1, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xE0,
  0xFC, 0x7C, 0x1F, 0x8F, 0x81, 0xF9, 0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0,
  0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E,
  0x06, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xCF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x1F,
  0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xCF, 0x80,
  0xFE, 0x03, 0xE7, 0xE0, 0x7F, 0x03, 0xF1, 0xF0, 0x3F, 0x81, 0xF8, 0xF8,
  0x3F, 0xE0, 0xF8, 0x7C, 0x1E, 0xF0, 0x7C, 0x3F, 0x0F, 0x78, 0x7E, 0x0F,
  0x87, 0xBC, 0x3F, 0x07, 0xC7, 0xDF, 0x1F, 0x03, 0xE3, 0xEF, 0x8F, 0x81,
  0xF1, 0xE3, 0xC7, 0xC0, 0x7C, 0xF1, 0xE7, 0xE0, 0x3E, 0xF8, 0xFB, 0xE0,
  0x1F, 0x7C, 0x7D, 0xF0, 0x0F, 0xBE, 0x1E, 0xF8, 0x03, 0xDE, 0x0F, 0x7C,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF8, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFC, 0x01,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x77, 0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x0F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x81, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x1F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0x87, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xEF,
  0x8F, 0xE3, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xFB, 0xF8, 0x7E,
  0xFF, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xEF, 0xF8, 0xF9, 0xFC, 0x00,
  0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0x0C, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x02, 0x7F, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x3F, 0xBF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFC, 0x7F, 0x7E, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xC0, 0xFD, 0xF8, 0x3F, 0x7F, 0x1F, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0x9F, 0x0F, 0xC7, 0xC0, 0x07, 0xFC, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0xFE, 0xFE, 0x7E, 0x0F, 0x9F, 0x83, 0xE7, 0xC0,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x43, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0xE3, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE7, 0xC7, 0xFD, 0xF3,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x1F, 0xDF, 0x83, 0xF7, 0xC0, 0xFD, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F,
  0xDF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xF3, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x40, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFC, 0x7F, 0xFE, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF8,
  0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC, 0x7E, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC3,
  0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xEF,
  0xFB, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0xFC,
  0x1F, 0x9F, 0x87, 0xE3, 0xF1, 0xFC, 0x7E, 0x7F, 0x0F, 0xCF, 0xC1, 0xFB,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFB,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x7F, 0x3F, 0x07, 0xE7, 0xE0,
  0x7E, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF9,
  0xFE, 0x3F, 0xCF, 0xBF, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xE3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFC, 0x1F, 0x81, 0xFF,
  0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F,
  0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F,
  0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1,
  0xF8, 0x1F, 0xF9, 0xFE, 0x3E, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE,
  0x1F, 0xBF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x83, 0xF7, 0xC0, 0xFD, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x0F,
  0xDF, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0xF8, 0xFC, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x3F, 0xBF,
  0x07, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFB, 0xF0, 0x3E, 0xFE, 0x1F, 0xBF, 0xCF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x3F, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0x1F, 0xDF, 0x83,
  0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD,
  0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC3, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0xFF,
  0xCF, 0xFE, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0xDF, 0xBE, 0xFC,
  0x0B, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC0,
  0x3F, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x80,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x4F, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xF8,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xF7,
  0x8F, 0xE3, 0xC0, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x3F, 0x07,
  0xE3, 0xE0, 0xFC, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F,
  0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x1F,
  0xC1, 0xFB, 0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0xF0, 0x7C, 0xFC, 0x3F, 0x87,
  0xE3, 0xE3, 0xDE, 0x3E, 0x1F, 0x1E, 0xF1, 0xF0, 0xF8, 0xF7, 0x8F, 0x87,
  0xE7, 0xBC, 0xFC, 0x1F, 0x7D, 0xF7, 0xC0, 0xFB, 0xC7, 0xBE, 0x07, 0xDE,
  0x3D, 0xF0, 0x1E, 0xF1, 0xEF, 0x00, 0xF7, 0x8F, 0x78, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x07, 0xE7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF9, 0xF8, 0x1F, 0xBF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x01, 0xF9, 0xF8, 0x3F, 0x9F, 0x83, 0xF0, 0xFC, 0x7E, 0x07, 0xEF, 0xE0,
  0x7F, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x3F, 0x03, 0xE3, 0xE0,
  0xFC, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xFC, 0x1F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x87, 0xF1, 0xFE, 0x3F, 0x07, 0xF0, 0xFF,
  0x07, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81,
  0xFC, 0x3F, 0x83, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x08, 0x00, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFC, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 24, 9, 2, -24 },
  { 19, 12, 9, 17, 2, -24 },
  { 33, 20, 24, 22, 1, -24 },
  { 93, 17, 27, 19, 1, -25 },
  { 151, 29, 24, 30, 1, -24 },
  { 238, 25, 24, 26, 1, -24 },
  { 313, 5, 9, 9, 2, -24 },
  { 319, 10, 29, 11, 1, -24 },
  { 356, 9, 29, 11, 1, -24 },
  { 389, 16, 16, 18, 1, -25 },
  { 421, 17, 16, 19, 1, -20 },
  { 455, 7, 8, 10, 1, -4 },
  { 462, 9, 4, 11, 1, -11 },
  { 467, 6, 5, 9, 2, -5 },
  { 471, 14, 24, 14, 0, -24 },
  { 513, 17, 24, 19, 1, -24 },
  { 564, 12, 24, 19, 2, -24 },
  { 600, 17, 24, 19, 1, -24 },
  { 651, 17, 24, 19, 1, -24 },
  { 702, 18, 24, 19, 1, -24 },
  { 756, 16, 24, 19, 2, -24 },
  { 804, 17, 24, 19, 1, -24 },
  { 855, 17, 24, 19, 1, -24 },
  { 906, 17, 24, 19, 1, -24 },
  { 957, 17, 24, 19, 1, -24 },
  { 1008, 6, 18, 9, 2, -18 },
  { 1022, 7, 22, 10, 1, -18 },
  { 1042, 17, 18, 19, 1, -21 },
  { 1081, 17, 11, 19, 1, -17 },
  { 1105, 17, 18, 19, 1, -21 },
  { 1144, 16, 24, 16, 0, -24 },
  { 1192, 27, 27, 30, 1, -24 },
  { 1284, 23, 24, 23, 0, -24 },
  { 1353, 17, 24, 22, 3, -24 },
  { 1404, 18, 24, 21, 2, -24 },
  { 1458, 19, 24, 24, 3, -24 },
  { 1515, 14, 24, 18, 3, -24 },
  { 1557, 13, 24, 18, 3, -24 },
  { 1596, 20, 24, 24, 2, -24 },
  { 1656, 19, 24, 25, 3, -24 },
  { 1713, 12, 24, 14, 1, -24 },
  { 1749, 11, 31, 11, -3, -24 },
  { 1792, 19, 24, 22, 3, -24 },
  { 1849, 15, 24, 19, 3, -24 },
  { 1894, 26, 24, 31, 3, -24 },
  { 1972, 21, 24, 27, 3, -24 },
  { 2035, 22, 24, 26, 2, -24 },
  { 2101, 16, 24, 21, 3, -24 },
  { 2149, 23, 30, 26, 2, -24 },
  { 2236, 19, 24, 22, 3, -24 },
  { 2293, 16, 24, 19, 1, -24 },
  { 2341, 18, 24, 19, 1, -24 },
  { 2395, 19, 24, 25, 3, -24 },
  { 2452, 22, 24, 22, 0, -24 },
  { 2518, 33, 24, 33, 0, -24 },
  { 2617, 23, 24, 23, 0, -24 },
  { 2686, 21, 24, 21, 0, -24 },
  { 2749, 18, 24, 20, 1, -24 },
  { 2803, 8, 29, 11, 2, -24 },
  { 2832, 14, 24, 14, 0, -24 },
  { 2874, 8, 29, 11, 1, -24 },
  { 2903, 18, 16, 18, 0, -24 },
  { 2939, 15, 3, 15, 0, 3 },
  { 2945, 11, 5, 13, 1, -25 },
  { 2952, 17, 18, 20, 1, -18 },
  { 2991, 18, 25, 21, 2, -25 },
  { 3048, 16, 18, 17, 1, -18 },
  { 3084, 18, 25, 21, 1, -25 },
  { 3141, 18, 18, 20, 1, -18 },
  { 3182, 13, 25, 13, 1, -25 },
  { 3223, 18, 26, 21, 1, -18 },
  { 3282, 18, 25, 22, 2, -25 },
  { 3339, 6, 25, 10, 2, -25 },
  { 3358, 10, 33, 10, -2, -25 },
  { 3400, 19, 25, 21, 2, -25 },
  { 3460, 6, 25, 10, 2, -25 },
  { 3479, 28, 18, 33, 2, -18 },
  { 3542, 18, 18, 22, 2, -18 },
  { 3583, 18, 18, 21, 1, -18 },
  { 3624, 18, 26, 21, 2, -18 },
  { 3683, 18, 26, 21, 1, -18 },
  { 3742, 13, 18, 15, 2, -18 },
  { 3772, 14, 18, 17, 1, -18 },
  { 3804, 13, 22, 15, 1, -22 },
  { 3840, 17, 18, 22, 2, -18 },
  { 3879, 19, 18, 19, 0, -18 },
  { 3922, 29, 18, 29, 0, -18 },
  { 3988, 20, 18, 20, 0, -18 },
  { 4033, 19, 26, 19, 0, -18 },
  { 4095, 15, 18, 16, 1, -18 },
  { 4129, 11, 29, 14, 1, -24 },
  { 4169, 4, 32, 18, 7, -25 },
  { 4185, 12, 29, 14, 1, -24 },
  { 4229, 17, 6, 19, 1, -15 },
};

const GFXfont NotoSans_ExtraBold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRABOLD33PT7B_H_
