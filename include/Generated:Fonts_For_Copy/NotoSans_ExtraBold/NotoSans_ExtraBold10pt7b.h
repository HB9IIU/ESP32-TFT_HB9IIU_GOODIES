#ifndef _NOTOSANS_EXTRABOLD10PT7B_H_
#define _NOTOSANS_EXTRABOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x5C, 0xB4, 0x2C, 0xA7, 0xCA, 0xFD, 0x45, 0x00, 0x23, 0xFB,
  0xC7, 0x97, 0xEE, 0x20, 0x62, 0x7A, 0x3F, 0x0D, 0x71, 0xE8, 0x94, 0xCE,
  0x78, 0x68, 0x78, 0x72, 0xDE, 0xCC, 0x7F, 0xC0, 0x69, 0x6D, 0x93, 0x20,
  0xCD, 0x92, 0x5A, 0xC0, 0x21, 0x3E, 0x65, 0x80, 0x21, 0x3E, 0x42, 0x00,
  0x70, 0xE0, 0x70, 0x33, 0x26, 0x64, 0xC0, 0x7A, 0xF3, 0x9C, 0xAD, 0xE0,
  0x7E, 0x92, 0x48, 0xFA, 0xC6, 0x33, 0x33, 0xE0, 0xFA, 0xC6, 0xE0, 0xCF,
  0xE0, 0x18, 0xE7, 0x96, 0xFF, 0xF1, 0x80, 0x7A, 0x1C, 0xF0, 0xCF, 0xE0,
  0x3B, 0x35, 0xFC, 0xA5, 0xE0, 0xF8, 0x46, 0x23, 0x11, 0x80, 0x7A, 0x5E,
  0xEC, 0xE5, 0xE0, 0x7E, 0x72, 0xF2, 0x8D, 0xC0, 0x70, 0x70, 0x50, 0x1C,
  0x09, 0xB0, 0x70, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0xEC, 0x00, 0xF4, 0xC4,
  0x46, 0x11, 0x80, 0x3E, 0x30, 0x97, 0xDE, 0xBF, 0x52, 0xD9, 0x88, 0x38,
  0x38, 0x50, 0xB3, 0x67, 0xC8, 0xF1, 0x80, 0xFE, 0xF7, 0xED, 0xEF, 0xC0,
  0x7E, 0x61, 0x08, 0x65, 0xE0, 0xFB, 0x6C, 0xF3, 0xCF, 0x6F, 0x00, 0xFC,
  0xCF, 0xCC, 0xF0, 0xFC, 0xCF, 0xCC, 0xC0, 0x7B, 0x28, 0x27, 0x8F, 0x37,
  0xC0, 0xCF, 0x3C, 0xFF, 0xCF, 0x3C, 0xC0, 0xF6, 0x66, 0x66, 0xF0, 0x33,
  0x33, 0x33, 0x32, 0xE0, 0xDF, 0x6F, 0x3C, 0xF3, 0x6C, 0xC0, 0xCC, 0xCC,
  0xCC, 0xF0, 0xC7, 0xE7, 0xA7, 0xAF, 0xBB, 0xBB, 0x9B, 0xC7, 0x9A, 0x6D,
  0x9E, 0x78, 0xC0, 0x7B, 0x38, 0x61, 0x8F, 0x37, 0x80, 0xF6, 0xF7, 0xEE,
  0x63, 0x00, 0x7B, 0x38, 0x61, 0x8F, 0x37, 0x86, 0x0C, 0xF3, 0x6D, 0xBC,
  0xF3, 0x6D, 0xC0, 0x7A, 0x58, 0xF1, 0xCF, 0xE0, 0xFC, 0xC3, 0x0C, 0x30,
  0xC3, 0x00, 0xCF, 0x3C, 0xF3, 0xCF, 0x37, 0x80, 0xC6, 0x99, 0xB3, 0x42,
  0x87, 0x0C, 0x00, 0xCC, 0xF3, 0x34, 0xC9, 0xFE, 0x73, 0x9C, 0xE3, 0x30,
  0xCE, 0xD8, 0xE1, 0xC3, 0x8D, 0xB1, 0x80, 0xCD, 0xB7, 0x8C, 0x30, 0xC3,
  0x00, 0xFC, 0x61, 0x8C, 0x61, 0x0F, 0xC0, 0xEA, 0xAB, 0xC0, 0xC4, 0x66,
  0x23, 0x30, 0xED, 0xB6, 0xDF, 0xE0, 0x23, 0x94, 0x98, 0x80, 0xF8, 0xC4,
  0x33, 0xC2, 0xFC, 0xBC, 0x84, 0x2D, 0xF9, 0xCF, 0x7E, 0x33, 0xD1, 0x86,
  0xBC, 0x0C, 0x32, 0xDF, 0x4F, 0x36, 0xDF, 0x31, 0xE4, 0xFF, 0x45, 0xE0,
  0x37, 0x6F, 0x66, 0x66, 0x21, 0xF4, 0xF3, 0x4D, 0xF0, 0xDE, 0x84, 0x2D,
  0xFD, 0xCE, 0x73, 0xDF, 0x24, 0x12, 0x49, 0x3C, 0x84, 0x23, 0x2B, 0x7A,
  0xD3, 0xFF, 0x32, 0xFF, 0x9B, 0x9B, 0x9B, 0x9B, 0x37, 0xF7, 0x39, 0xCC,
  0x31, 0xE4, 0xF3, 0x4D, 0xE0, 0x37, 0xE7, 0x3D, 0xFA, 0x10, 0x21, 0xF4,
  0xF3, 0x4D, 0xF0, 0xC3, 0x3F, 0x49, 0x00, 0x3B, 0xB8, 0xE9, 0xF8, 0x66,
  0xF6, 0x66, 0x70, 0x9C, 0xE7, 0xBF, 0x80, 0xCD, 0x27, 0x8C, 0x30, 0xDD,
  0xAA, 0x95, 0xCE, 0xE3, 0x60, 0xFD, 0xE3, 0x1E, 0xCC, 0xCD, 0x27, 0x8C,
  0x30, 0xCE, 0x00, 0xF9, 0x98, 0x8F, 0x80, 0x36, 0x66, 0xC6, 0x67, 0x30,
  0xFF, 0xC0, 0xE6, 0x66, 0x36, 0x6E, 0xC0, 0xF8,
};

const GFXglyph NotoSans_ExtraBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 7, 3, 0, -7 },
  { 3, 3, 2, 5, 1, -7 },
  { 4, 6, 7, 7, 0, -7 },
  { 10, 5, 9, 6, 0, -8 },
  { 16, 9, 7, 9, 0, -7 },
  { 24, 8, 7, 8, 0, -7 },
  { 31, 1, 2, 3, 1, -7 },
  { 32, 3, 9, 3, 0, -7 },
  { 36, 3, 9, 3, 0, -7 },
  { 40, 5, 5, 5, 0, -8 },
  { 44, 5, 5, 6, 0, -6 },
  { 48, 2, 2, 3, 0, -1 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 2, 2, 3, 0, -2 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 5, 7, 6, 0, -7 },
  { 60, 3, 7, 6, 1, -7 },
  { 63, 5, 7, 6, 0, -7 },
  { 68, 5, 7, 6, 0, -7 },
  { 73, 6, 7, 6, 0, -7 },
  { 79, 5, 7, 6, 0, -7 },
  { 84, 5, 7, 6, 0, -7 },
  { 89, 5, 7, 6, 0, -7 },
  { 94, 5, 7, 6, 0, -7 },
  { 99, 5, 7, 6, 0, -7 },
  { 104, 2, 6, 3, 0, -6 },
  { 106, 2, 7, 3, 0, -6 },
  { 108, 5, 5, 6, 0, -6 },
  { 112, 5, 3, 6, 0, -5 },
  { 114, 5, 5, 6, 0, -6 },
  { 118, 5, 7, 5, 0, -7 },
  { 123, 9, 8, 9, 0, -7 },
  { 132, 7, 7, 7, 0, -7 },
  { 139, 5, 7, 7, 1, -7 },
  { 144, 5, 7, 6, 1, -7 },
  { 149, 6, 7, 7, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 4, 7, 5, 1, -7 },
  { 163, 6, 7, 7, 1, -7 },
  { 169, 6, 7, 8, 1, -7 },
  { 175, 4, 7, 4, 0, -7 },
  { 179, 4, 9, 3, -1, -7 },
  { 184, 6, 7, 7, 1, -7 },
  { 190, 4, 7, 6, 1, -7 },
  { 194, 8, 7, 10, 1, -7 },
  { 201, 6, 7, 8, 1, -7 },
  { 207, 6, 7, 8, 1, -7 },
  { 213, 5, 7, 6, 1, -7 },
  { 218, 6, 9, 8, 1, -7 },
  { 225, 6, 7, 7, 1, -7 },
  { 231, 5, 7, 6, 0, -7 },
  { 236, 6, 7, 6, 0, -7 },
  { 242, 6, 7, 8, 1, -7 },
  { 248, 7, 7, 7, 0, -7 },
  { 255, 10, 7, 10, 0, -7 },
  { 264, 7, 7, 7, 0, -7 },
  { 271, 6, 7, 6, 0, -7 },
  { 277, 6, 7, 6, 0, -7 },
  { 283, 2, 9, 3, 1, -7 },
  { 286, 4, 7, 4, 0, -7 },
  { 290, 3, 9, 3, 0, -7 },
  { 294, 5, 5, 6, 0, -7 },
  { 298, 5, 1, 5, 0, 1 },
  { 299, 3, 2, 4, 0, -8 },
  { 300, 5, 6, 6, 0, -6 },
  { 304, 5, 8, 6, 1, -8 },
  { 309, 5, 6, 5, 0, -6 },
  { 313, 6, 8, 6, 0, -8 },
  { 319, 6, 6, 6, 0, -6 },
  { 324, 4, 8, 4, 0, -8 },
  { 328, 6, 8, 6, 0, -6 },
  { 334, 5, 8, 7, 1, -8 },
  { 339, 1, 8, 3, 1, -8 },
  { 340, 3, 10, 3, -1, -8 },
  { 344, 5, 8, 6, 1, -8 },
  { 349, 1, 8, 3, 1, -8 },
  { 350, 8, 6, 10, 1, -6 },
  { 356, 5, 6, 7, 1, -6 },
  { 360, 6, 6, 6, 0, -6 },
  { 365, 5, 8, 6, 1, -6 },
  { 370, 6, 8, 6, 0, -6 },
  { 376, 3, 6, 5, 1, -6 },
  { 379, 5, 6, 5, 0, -6 },
  { 383, 4, 7, 4, 0, -7 },
  { 387, 5, 5, 7, 1, -5 },
  { 391, 6, 5, 6, 0, -5 },
  { 395, 9, 5, 9, 0, -5 },
  { 401, 6, 5, 6, 0, -5 },
  { 405, 6, 7, 6, 0, -5 },
  { 411, 5, 5, 5, 0, -5 },
  { 415, 4, 9, 4, 0, -7 },
  { 420, 1, 10, 5, 2, -8 },
  { 422, 4, 9, 4, 0, -7 },
  { 427, 5, 1, 6, 0, -4 },
};

const GFXfont NotoSans_ExtraBold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRABOLD10PT7B_H_
