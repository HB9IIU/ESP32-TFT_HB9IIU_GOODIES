#ifndef _NOTOSANS_EXTRABOLD39PT7B_H_
#define _NOTOSANS_EXTRABOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFB, 0xE0, 0xFE, 0x7F, 0xF8, 0xFD, 0xF1, 0xFB, 0xE3, 0xF7, 0xC7, 0xEF,
  0x8F, 0xDF, 0x1F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF8, 0x78, 0x00, 0xF8, 0xF8,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x01, 0xF1, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F, 0x80,
  0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x73, 0xCF, 0xE7, 0x04, 0xFC, 0x70,
  0x0F, 0xE7, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x73, 0xF0, 0x07, 0x3F, 0x60, 0x73, 0xF7, 0xE7, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x01,
  0xF0, 0x07, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x3E, 0x00, 0xFC, 0xF8,
  0x0F, 0x80, 0x3E, 0x3E, 0x07, 0xC0, 0x0F, 0x8F, 0xC1, 0xF0, 0x03, 0xE1,
  0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x0F,
  0x8F, 0xCF, 0x80, 0x03, 0xE3, 0xE3, 0xE3, 0xF0, 0x7C, 0xF9, 0xF1, 0xFF,
  0x1F, 0xFE, 0x7C, 0xFF, 0xC7, 0xFF, 0x3E, 0x7F, 0xF8, 0xFF, 0x8F, 0x9F,
  0x3E, 0x0F, 0xC7, 0xC7, 0xC7, 0xC0, 0x03, 0xF3, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x87, 0xC0, 0x0F,
  0x83, 0xE1, 0xF0, 0x03, 0xE0, 0x7C, 0x7C, 0x01, 0xF0, 0x1F, 0x3E, 0x00,
  0x7C, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xF0,
  0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x7E, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xF8, 0x7F, 0xF8, 0x1F, 0x87, 0xFF,
  0xE1, 0xFC, 0x7F, 0xFF, 0x8F, 0xE3, 0xF9, 0xFE, 0xFE, 0x1F, 0xC7, 0xFF,
  0xF1, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0x3F, 0x81, 0xFF, 0x81,
  0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0xFF, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x83, 0xE0, 0x5E, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x81, 0xE1, 0xC0,
  0x08, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xF7, 0xE0,
  0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7,
  0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7E, 0x3F, 0x8F, 0xE3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7E,
  0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x7E, 0xFE, 0xF9, 0xFC, 0xE3, 0xF8, 0x87, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xF9, 0xFE, 0x3C, 0x0F, 0xE1, 0x80, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xE1, 0xFE, 0x10, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xF7, 0xF0, 0x1F, 0x3F, 0x81, 0xF9, 0xFC, 0x1F, 0x8F, 0xE0,
  0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xB8, 0x0F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFE, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x7F, 0x07,
  0xEF, 0xFC, 0x7D, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xF0, 0x7F, 0x7F, 0x8F, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7F, 0x07, 0xE3, 0xF8, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xDF, 0xE7, 0xF0,
  0xFE, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF7, 0xFD, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFB, 0xF0, 0xFF, 0x3F, 0x00,
  0x83, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00,
  0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x1C, 0x3F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFC,
  0x0F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0x07, 0xF2,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0x3F, 0x1F, 0x03, 0xFC, 0x3E, 0x3E, 0x1F, 0xFE, 0x3C,
  0xF8, 0x7F, 0xFC, 0x7D, 0xF1, 0xFF, 0xF8, 0xFF, 0xC7, 0xE1, 0xF0, 0xFF,
  0x8F, 0x83, 0xE1, 0xFF, 0x1F, 0x07, 0xC3, 0xFE, 0x7C, 0x0F, 0x87, 0xF8,
  0xF8, 0x1F, 0x0F, 0xF1, 0xF0, 0x3E, 0x3F, 0xE3, 0xE0, 0x7C, 0x7F, 0xC3,
  0xE1, 0xF8, 0xF7, 0xC7, 0xE7, 0xFB, 0xEF, 0x8F, 0xFF, 0xFF, 0x9F, 0x0F,
  0xFD, 0xFF, 0x1F, 0x0F, 0xF1, 0xFC, 0x3E, 0x03, 0x00, 0xC0, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x9F,
  0x80, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0x0F, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFE, 0x07,
  0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xC7, 0xC3, 0xFC,
  0x01, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x23, 0xFE, 0x07, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8,
  0x7C, 0x3F, 0xC0, 0x08, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0xC0,
  0x7F, 0x3F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xDF, 0xFE,
  0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x03,
  0xFB, 0xFC, 0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x7F, 0x03, 0xF8,
  0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x7F, 0xFB, 0xE0, 0x3E, 0xFF, 0xF7, 0xC0,
  0x7D, 0xFF, 0xEF, 0xC1, 0xFB, 0xFF, 0xCF, 0x83, 0xE7, 0xFF, 0x9F, 0x07,
  0xCF, 0xFF, 0x3F, 0x0F, 0x9F, 0xFE, 0x3E, 0x3E, 0x3F, 0xFC, 0x7C, 0x7C,
  0x7F, 0xF8, 0xF8, 0xF8, 0xFF, 0xF1, 0xFB, 0xE1, 0xFF, 0xE1, 0xF7, 0xC3,
  0xFF, 0xC3, 0xEF, 0x87, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0x07, 0xFC, 0x1F,
  0xFE, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF8, 0x3F, 0xC0, 0xFF,
  0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xF0, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x7F, 0x03, 0xFF, 0xCF, 0xE0, 0xFF, 0xF3, 0xF8, 0x3F, 0xFC,
  0x7F, 0x0F, 0xFF, 0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0xFF, 0xF0, 0xFE, 0x3F,
  0xFC, 0x1F, 0xCF, 0xFF, 0x07, 0xF3, 0xFF, 0xC0, 0xFE, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF8,
  0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF,
  0x80, 0xFF, 0x8F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xC7, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF9, 0xFC,
  0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFE, 0x1F, 0x3F, 0x80,
  0x67, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFD, 0x80, 0x1F,
  0xBE, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xF0, 0xFF, 0x3F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0xFC, 0x01, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0x03, 0xF3,
  0xF8, 0x07, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0xC0, 0x7E, 0x1F, 0x80, 0xFF, 0x80, 0xFC,
  0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0x7E, 0x0F,
  0xBE, 0x0F, 0xC0, 0xFC, 0x1F, 0x7C, 0x1F, 0x81, 0xFC, 0x7E, 0xFC, 0x7F,
  0x01, 0xF8, 0xFC, 0xF8, 0xFC, 0x03, 0xF1, 0xF1, 0xF1, 0xF8, 0x07, 0xE3,
  0xE3, 0xE3, 0xF0, 0x0F, 0xCF, 0xC7, 0xE7, 0xE0, 0x0F, 0xDF, 0x8F, 0xDF,
  0x80, 0x1F, 0xBE, 0x0F, 0xBF, 0x00, 0x3F, 0x7C, 0x1F, 0x7E, 0x00, 0x7E,
  0xF8, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0x7F, 0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE0, 0x7F, 0x08, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xC3, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x7F, 0x7E,
  0x07, 0xF7, 0xFB, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xF9, 0xF1,
  0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3C,
  0x0F, 0xCF, 0xF0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFD, 0xFF, 0x8F, 0x8F, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xF7, 0xCF, 0xF0, 0x13, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x02, 0x7F, 0x83, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xC3, 0xF0, 0xFF, 0x3F, 0x3F, 0xFB, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xFB, 0xF0, 0xFE, 0x1F, 0x01, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF0,
  0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x67, 0xFE, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xC2, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0x3F, 0x3F, 0xFB,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF9, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xFB, 0xF0, 0xFE, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF6, 0x00, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x0F, 0xCF, 0xF8,
  0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF,
  0xCF, 0xF8, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xEF, 0xC0, 0xFF, 0x3F, 0x03,
  0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80,
  0xFD, 0xFE, 0x03, 0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x7F, 0x8F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xFB,
  0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x7C, 0x7F, 0xC3, 0xFE, 0x3E, 0xFF,
  0xF3, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE,
  0x07, 0xF0, 0x3F, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF,
  0x80, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x81, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F,
  0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0x01, 0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xE0, 0x3F, 0x81, 0xFC, 0x00, 0x3E, 0x0F,
  0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xC7, 0xFB, 0xFC, 0x1F, 0xDF, 0xC0,
  0x7E, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE, 0x7F, 0x07,
  0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x3C, 0x0F, 0x8F, 0xF0, 0xFD, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFD, 0xFF, 0x8F, 0xCF, 0xF0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x3F, 0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF9, 0xFF, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xFB,
  0xF0, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xE3, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x0E, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F,
  0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x23, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xE1, 0xF0, 0xFE, 0x00, 0xFE, 0xFC, 0x03,
  0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x1F,
  0xDF, 0x81, 0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0xC1, 0xF8, 0xFC, 0x1F, 0xF0,
  0x7E, 0x3F, 0x0F, 0xFC, 0x3F, 0x8F, 0xC3, 0xFF, 0x0F, 0xC3, 0xF8, 0xFB,
  0xC3, 0xF0, 0x7E, 0x3C, 0xF8, 0xFC, 0x1F, 0x9F, 0x3E, 0x7E, 0x07, 0xE7,
  0xCF, 0x9F, 0x81, 0xF9, 0xF3, 0xE7, 0xE0, 0x3F, 0x7C, 0x7D, 0xF8, 0x0F,
  0xDE, 0x1F, 0x7C, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x7F, 0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE,
  0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xF3, 0xFC, 0x0F, 0xEF,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xF1,
  0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x7F, 0x00, 0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x7F, 0xC3, 0xFF, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0xFF, 0xA0, 0x03, 0xC0,
};

const GFXglyph NotoSans_ExtraBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 15, 10, 20, 2, -28 },
  { 45, 24, 28, 25, 1, -28 },
  { 129, 20, 32, 22, 1, -30 },
  { 209, 34, 28, 36, 1, -28 },
  { 328, 29, 28, 30, 1, -28 },
  { 430, 7, 10, 11, 2, -28 },
  { 439, 11, 34, 14, 1, -28 },
  { 486, 11, 34, 14, 1, -28 },
  { 533, 19, 19, 21, 1, -30 },
  { 579, 19, 19, 23, 2, -23 },
  { 625, 8, 10, 12, 1, -5 },
  { 635, 10, 5, 12, 1, -13 },
  { 642, 7, 6, 11, 2, -6 },
  { 648, 17, 28, 17, 0, -28 },
  { 708, 20, 28, 23, 1, -28 },
  { 778, 15, 28, 23, 2, -28 },
  { 831, 20, 28, 23, 1, -28 },
  { 901, 20, 28, 23, 1, -28 },
  { 971, 21, 28, 23, 1, -28 },
  { 1045, 19, 28, 23, 2, -28 },
  { 1112, 20, 28, 23, 1, -28 },
  { 1182, 20, 28, 23, 1, -28 },
  { 1252, 20, 28, 23, 1, -28 },
  { 1322, 20, 28, 23, 1, -28 },
  { 1392, 7, 22, 11, 2, -22 },
  { 1412, 8, 27, 11, 1, -22 },
  { 1439, 19, 21, 23, 2, -25 },
  { 1489, 19, 13, 23, 2, -20 },
  { 1520, 19, 21, 23, 2, -25 },
  { 1570, 18, 28, 19, 0, -28 },
  { 1633, 31, 31, 35, 2, -28 },
  { 1754, 28, 28, 28, 0, -28 },
  { 1852, 21, 28, 26, 3, -28 },
  { 1926, 22, 28, 25, 2, -28 },
  { 2003, 24, 28, 29, 3, -28 },
  { 2087, 17, 28, 22, 3, -28 },
  { 2147, 16, 28, 21, 3, -28 },
  { 2203, 24, 28, 29, 2, -28 },
  { 2287, 24, 28, 30, 3, -28 },
  { 2371, 14, 28, 16, 1, -28 },
  { 2420, 13, 36, 13, -3, -28 },
  { 2479, 23, 28, 26, 3, -28 },
  { 2560, 18, 28, 22, 3, -28 },
  { 2623, 31, 28, 37, 3, -28 },
  { 2732, 26, 28, 32, 3, -28 },
  { 2823, 27, 28, 31, 2, -28 },
  { 2918, 20, 28, 24, 3, -28 },
  { 2988, 27, 35, 31, 2, -28 },
  { 3107, 23, 28, 26, 3, -28 },
  { 3188, 19, 28, 22, 2, -28 },
  { 3255, 21, 28, 23, 1, -28 },
  { 3329, 23, 28, 29, 3, -28 },
  { 3410, 26, 28, 26, 0, -28 },
  { 3501, 39, 28, 39, 0, -28 },
  { 3638, 27, 28, 27, 0, -28 },
  { 3733, 25, 28, 25, 0, -28 },
  { 3821, 21, 28, 23, 1, -28 },
  { 3895, 10, 34, 13, 2, -28 },
  { 3938, 16, 28, 17, 0, -28 },
  { 3994, 9, 34, 13, 1, -28 },
  { 4033, 21, 18, 21, 0, -28 },
  { 4081, 18, 4, 18, 0, 3 },
  { 4090, 12, 6, 15, 2, -30 },
  { 4099, 20, 22, 24, 1, -22 },
  { 4154, 20, 30, 25, 3, -30 },
  { 4229, 18, 22, 21, 2, -22 },
  { 4279, 20, 30, 25, 2, -30 },
  { 4354, 20, 22, 24, 2, -22 },
  { 4409, 16, 30, 16, 1, -30 },
  { 4469, 20, 31, 25, 2, -22 },
  { 4547, 20, 30, 26, 3, -30 },
  { 4622, 7, 30, 12, 3, -30 },
  { 4649, 12, 39, 12, -2, -30 },
  { 4708, 22, 30, 25, 3, -30 },
  { 4791, 6, 30, 12, 3, -30 },
  { 4814, 33, 22, 38, 3, -22 },
  { 4905, 20, 22, 26, 3, -22 },
  { 4960, 21, 22, 25, 2, -22 },
  { 5018, 20, 31, 25, 3, -22 },
  { 5096, 20, 31, 25, 2, -22 },
  { 5174, 14, 22, 18, 3, -22 },
  { 5213, 16, 22, 20, 2, -22 },
  { 5257, 15, 26, 17, 1, -26 },
  { 5306, 20, 21, 26, 3, -21 },
  { 5359, 23, 21, 23, 0, -21 },
  { 5420, 34, 21, 34, 0, -21 },
  { 5510, 23, 21, 23, 0, -21 },
  { 5571, 23, 30, 23, 0, -21 },
  { 5658, 17, 21, 19, 1, -21 },
  { 5703, 14, 34, 16, 1, -28 },
  { 5763, 5, 39, 21, 8, -30 },
  { 5788, 14, 34, 16, 1, -28 },
  { 5848, 19, 7, 23, 2, -17 },
};

const GFXfont NotoSans_ExtraBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRABOLD39PT7B_H_
