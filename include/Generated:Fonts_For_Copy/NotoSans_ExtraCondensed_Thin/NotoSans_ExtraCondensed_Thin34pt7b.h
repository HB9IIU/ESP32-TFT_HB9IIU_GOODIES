#ifndef _NOTOSANS_EXTRACONDENSED_THIN34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin34pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x50, 0x0F, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x84, 0x08, 0x20, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x21, 0x1F, 0xFF, 0x10, 0x40, 0x82, 0x04, 0x20, 0x21, 0x01, 0x08, 0x08,
  0x40, 0x42, 0x1F, 0xFE, 0x10, 0x81, 0x04, 0x08, 0x20, 0x42, 0x02, 0x10,
  0x10, 0x80, 0x84, 0x04, 0x20, 0x04, 0x00, 0x80, 0x7E, 0x12, 0x24, 0x41,
  0x08, 0x21, 0x04, 0x20, 0x84, 0x10, 0x81, 0x10, 0x32, 0x01, 0x40, 0x18,
  0x01, 0xC0, 0x24, 0x04, 0x40, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41,
  0x0C, 0x22, 0x7F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x30, 0x00, 0x48, 0x10,
  0x88, 0x10, 0x84, 0x20, 0x84, 0x20, 0x84, 0x20, 0x84, 0x40, 0x84, 0x40,
  0x84, 0x40, 0x84, 0x80, 0x84, 0x9C, 0x84, 0xA2, 0x85, 0x22, 0x89, 0x21,
  0x49, 0x41, 0x22, 0x41, 0x02, 0x41, 0x02, 0x41, 0x04, 0x41, 0x04, 0x41,
  0x04, 0x41, 0x08, 0x21, 0x08, 0x22, 0x08, 0x22, 0x10, 0x1C, 0x0C, 0x01,
  0x20, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x01,
  0x20, 0x12, 0x00, 0xC0, 0x18, 0x02, 0x40, 0x44, 0x04, 0x21, 0x82, 0x28,
  0x12, 0x80, 0xA8, 0x0A, 0x80, 0x48, 0x04, 0x40, 0xA4, 0x12, 0x3E, 0x10,
  0xFF, 0x80, 0x0C, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x0C,
  0xC0, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x0C, 0x20, 0x82, 0x10, 0x42, 0x08, 0xC0, 0x10, 0x10,
  0x10, 0xD3, 0x3C, 0x18, 0x24, 0x44, 0x82, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x24, 0xA4, 0xA0, 0xFE, 0xF0,
  0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x08, 0x0C, 0x84, 0x11, 0x02, 0x40,
  0xA0, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0x80, 0x90, 0x24, 0x10, 0x84,
  0x1E, 0x00, 0x19, 0xDB, 0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x0E, 0x0E, 0x21, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02,
  0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08,
  0x02, 0x00, 0xFF, 0xE0, 0x1C, 0x0C, 0x62, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x02, 0x01, 0x81, 0xE0, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x14,
  0x04, 0x7F, 0x00, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14, 0x01,
  0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81, 0x04,
  0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x47, 0xFF, 0xC0, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x7F, 0xA0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x22, 0x0F, 0x70, 0x06, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x80, 0x28, 0x13, 0xF8,
  0x1F, 0x8C, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x27,
  0x8A, 0x13, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x90, 0x24, 0x18, 0xFC, 0xFF, 0xE0, 0x08, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x20,
  0x04, 0x01, 0x80, 0x04, 0x03, 0x30, 0x81, 0x20, 0x24, 0x02, 0x80, 0x50,
  0x0A, 0x02, 0x40, 0x44, 0x18, 0x46, 0x05, 0x00, 0xE0, 0x22, 0x08, 0x22,
  0x02, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x11, 0x06,
  0x1F, 0x80, 0x06, 0x06, 0x20, 0x82, 0x20, 0x24, 0x04, 0x80, 0xA0, 0x14,
  0x02, 0x80, 0x30, 0x06, 0x01, 0xA0, 0x34, 0x06, 0x81, 0x4C, 0x48, 0x72,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x7E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x25, 0x25, 0x00, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x06,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x08, 0x00, 0x21, 0x98, 0x18,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x00, 0x00, 0x00, 0x30, 0x60, 0x07, 0xF0, 0x04, 0x04, 0x04,
  0x01, 0x04, 0x00, 0x42, 0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x83, 0xC2,
  0x82, 0x20, 0xC2, 0x10, 0x61, 0x08, 0x30, 0x84, 0x18, 0x42, 0x0C, 0x21,
  0x06, 0x10, 0x83, 0x08, 0x41, 0x84, 0x21, 0x42, 0x30, 0xA1, 0x14, 0x50,
  0x73, 0xC4, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x0C, 0x08, 0x01, 0xF8, 0x00, 0x02, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x50, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x10, 0x20,
  0x81, 0x04, 0x10, 0x20, 0xFE, 0x84, 0x04, 0x20, 0x21, 0x01, 0x10, 0x04,
  0x80, 0x24, 0x01, 0x20, 0x0A, 0x00, 0x30, 0x01, 0xFF, 0x20, 0x28, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28, 0x33, 0xF8, 0x81,
  0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28,
  0x1B, 0xF8, 0x03, 0x81, 0x8C, 0x40, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x07,
  0xE0, 0xFE, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x28, 0x0D, 0x01, 0x20, 0xC7, 0xE0, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x00, 0x80,
  0x38, 0xE1, 0x00, 0x48, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xF8, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x04, 0x80,
  0x13, 0x00, 0x46, 0x01, 0x07, 0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xF8, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x9F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x0B, 0xC0, 0x80, 0xE0, 0x48, 0x12, 0x08, 0x82, 0x21,
  0x08, 0xC2, 0x20, 0x90, 0x24, 0x0A, 0x03, 0x40, 0xD0, 0x22, 0x08, 0x82,
  0x10, 0x84, 0x20, 0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x01, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0xB8, 0x00, 0x5C, 0x00, 0x2D, 0x00, 0x26,
  0x80, 0x13, 0x40, 0x09, 0x90, 0x08, 0xC8, 0x04, 0x64, 0x02, 0x31, 0x01,
  0x18, 0x81, 0x0C, 0x40, 0x86, 0x20, 0x43, 0x08, 0x41, 0x84, 0x20, 0xC2,
  0x10, 0x60, 0x90, 0x30, 0x48, 0x18, 0x24, 0x0C, 0x0A, 0x06, 0x06, 0x03,
  0x03, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90,
  0x19, 0x01, 0x88, 0x18, 0x81, 0x84, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82,
  0x18, 0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x09, 0x80, 0x58, 0x05, 0x80,
  0x38, 0x03, 0x06, 0x00, 0x63, 0x02, 0x02, 0x08, 0x04, 0x40, 0x11, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x42, 0x01, 0x0C, 0x08, 0x0F, 0xC0, 0xFE, 0x40,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28,
  0x67, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x07, 0x00, 0x63, 0x03, 0x02, 0x08, 0x04, 0x40, 0x11, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x02,
  0x40, 0x09, 0x00, 0x42, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0xFE, 0x20, 0x48, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x0C, 0xFC,
  0x22, 0x08, 0x42, 0x10, 0x82, 0x20, 0x88, 0x12, 0x04, 0x81, 0x20, 0x28,
  0x0A, 0x01, 0x06, 0x03, 0x18, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x14, 0x04, 0xFF,
  0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x01, 0x40, 0x14, 0x02, 0x20, 0x61, 0xF8, 0x80, 0x18,
  0x01, 0x40, 0x14, 0x01, 0x40, 0x24, 0x02, 0x40, 0x22, 0x02, 0x20, 0x42,
  0x04, 0x20, 0x41, 0x04, 0x10, 0x81, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80,
  0x90, 0x09, 0x00, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x60, 0x80, 0x30,
  0x05, 0x00, 0xC0, 0x24, 0x03, 0x00, 0x90, 0x0C, 0x02, 0x40, 0x30, 0x09,
  0x01, 0x20, 0x22, 0x04, 0x81, 0x08, 0x12, 0x04, 0x20, 0x48, 0x10, 0x81,
  0x20, 0x42, 0x08, 0x42, 0x04, 0x21, 0x08, 0x10, 0x84, 0x20, 0x42, 0x10,
  0x81, 0x08, 0x42, 0x02, 0x40, 0x90, 0x09, 0x02, 0x40, 0x24, 0x09, 0x00,
  0x90, 0x24, 0x02, 0x40, 0x90, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x40, 0x24, 0x08, 0x81, 0x08, 0x41, 0x08, 0x21,
  0x02, 0x40, 0x48, 0x09, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x14, 0x02,
  0x40, 0x48, 0x11, 0x02, 0x10, 0x82, 0x10, 0x42, 0x04, 0x80, 0x90, 0x16,
  0x01, 0x80, 0x68, 0x09, 0x01, 0x20, 0x22, 0x08, 0x41, 0x08, 0x20, 0x88,
  0x11, 0x02, 0x20, 0x28, 0x05, 0x00, 0xA0, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01,
  0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x03, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xE0, 0x06, 0x00, 0x60, 0x09, 0x00,
  0x90, 0x10, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40, 0x64, 0x02, 0x80, 0x30,
  0xFF, 0xF8, 0xC2, 0x08, 0x20, 0x80, 0x3F, 0x20, 0x80, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x1F, 0x90, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x41, 0x9F, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x9F, 0x14, 0x12, 0x81, 0x60, 0x2C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xB0, 0x15, 0x02,
  0xA0, 0x93, 0xE0, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x60, 0x3F, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x3E, 0x58, 0x54, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0D, 0x03, 0x41, 0x4F, 0x90, 0x3E, 0x20, 0x90, 0x50, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80,
  0x60, 0x9F, 0x80, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x3E, 0x50, 0x54, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0D,
  0x03, 0x41, 0x4F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x81,
  0x1F, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x9F, 0x28, 0x2A, 0x0B, 0x02, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x74,
  0x01, 0x55, 0x55, 0x55, 0x55, 0x40, 0x13, 0x10, 0x00, 0x02, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xE0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x81, 0x40, 0xA0, 0x90,
  0x88, 0x44, 0x42, 0x41, 0x30, 0xA8, 0x54, 0x31, 0x10, 0x88, 0x24, 0x12,
  0x09, 0x02, 0x81, 0x40, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x9E, 0x3E, 0xA1,
  0x43, 0xC1, 0x41, 0xC0, 0x81, 0xC0, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x9F, 0x28, 0x2A,
  0x0B, 0x02, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x3F, 0x10, 0x64, 0x0A,
  0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x02, 0x41, 0x8F, 0xC0, 0x9F, 0x14, 0x12, 0x81, 0x60,
  0x2C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0xB0, 0x15, 0x02, 0xA0, 0x93, 0xE2, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x3E, 0x58, 0x54, 0x0E, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0D, 0x03, 0x41, 0x4F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x9F, 0x42, 0x86, 0x0C, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x3F, 0x40, 0x40, 0x80,
  0x80, 0xC0, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x81, 0x7E, 0x41, 0x04, 0x10, 0xFD, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x20, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x83, 0x41, 0x9F, 0x40, 0x80, 0x60, 0x24, 0x09, 0x02, 0x40, 0x90, 0x22,
  0x10, 0x84, 0x21, 0x08, 0x41, 0x20, 0x48, 0x12, 0x04, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x80, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x18, 0x24,
  0x14, 0x12, 0x09, 0x08, 0x84, 0x84, 0x42, 0x42, 0x22, 0x22, 0x11, 0x11,
  0x04, 0x84, 0x82, 0x42, 0x41, 0x21, 0x40, 0xA0, 0xA0, 0x50, 0x50, 0x18,
  0x18, 0x0C, 0x08, 0x04, 0x04, 0x00, 0x80, 0xA0, 0x90, 0x48, 0x42, 0x21,
  0x20, 0x50, 0x28, 0x08, 0x0C, 0x05, 0x02, 0x82, 0x21, 0x11, 0x04, 0x82,
  0x81, 0x40, 0x40, 0x40, 0x50, 0x14, 0x04, 0x81, 0x20, 0x88, 0x22, 0x08,
  0x42, 0x11, 0x04, 0x41, 0x10, 0x24, 0x0A, 0x02, 0x80, 0xA0, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x38, 0x00,
  0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x81, 0xFC, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0, 0x20, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xE0, 0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x0C, 0x03, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0xE0, 0x7C, 0x18, 0x3E,
};

const GFXglyph NotoSans_ExtraCondensed_Thin34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 24, 7, 2, -24 },
  { 7, 6, 9, 10, 2, -24 },
  { 14, 13, 24, 14, 1, -24 },
  { 53, 11, 28, 13, 1, -26 },
  { 92, 16, 25, 19, 2, -25 },
  { 142, 12, 25, 13, 1, -25 },
  { 180, 1, 9, 5, 2, -24 },
  { 182, 6, 29, 9, 2, -24 },
  { 204, 6, 29, 9, 1, -24 },
  { 226, 8, 9, 12, 2, -26 },
  { 235, 12, 16, 14, 1, -20 },
  { 259, 3, 7, 6, 1, -3 },
  { 262, 7, 1, 9, 1, -10 },
  { 263, 2, 2, 6, 2, -2 },
  { 264, 10, 24, 11, 1, -24 },
  { 294, 10, 25, 13, 2, -25 },
  { 326, 5, 24, 13, 3, -24 },
  { 341, 11, 25, 13, 1, -25 },
  { 376, 11, 25, 13, 1, -25 },
  { 411, 13, 24, 13, 0, -24 },
  { 450, 10, 24, 13, 2, -24 },
  { 480, 10, 24, 13, 2, -24 },
  { 510, 11, 24, 13, 1, -24 },
  { 543, 11, 25, 13, 1, -25 },
  { 578, 11, 25, 13, 1, -25 },
  { 613, 2, 18, 6, 2, -18 },
  { 618, 3, 22, 6, 1, -18 },
  { 627, 12, 14, 14, 1, -19 },
  { 648, 12, 8, 14, 1, -16 },
  { 660, 12, 14, 14, 1, -19 },
  { 681, 7, 25, 9, 1, -25 },
  { 703, 17, 27, 21, 2, -24 },
  { 761, 13, 24, 13, 0, -24 },
  { 800, 10, 24, 15, 3, -24 },
  { 830, 11, 25, 14, 2, -25 },
  { 865, 11, 24, 16, 3, -24 },
  { 898, 8, 24, 13, 3, -24 },
  { 922, 8, 24, 12, 3, -24 },
  { 946, 14, 25, 18, 2, -25 },
  { 990, 11, 24, 17, 3, -24 },
  { 1023, 5, 24, 7, 1, -24 },
  { 1038, 6, 30, 6, -2, -24 },
  { 1061, 10, 24, 13, 3, -24 },
  { 1091, 8, 24, 12, 3, -24 },
  { 1115, 17, 24, 22, 3, -24 },
  { 1166, 12, 24, 17, 3, -24 },
  { 1202, 14, 25, 17, 2, -25 },
  { 1246, 9, 24, 13, 3, -24 },
  { 1273, 14, 31, 17, 2, -25 },
  { 1328, 10, 24, 14, 3, -24 },
  { 1358, 11, 25, 13, 1, -25 },
  { 1393, 11, 24, 11, 0, -24 },
  { 1426, 12, 24, 17, 2, -24 },
  { 1462, 12, 24, 12, 0, -24 },
  { 1498, 22, 24, 22, 0, -24 },
  { 1564, 11, 24, 11, 0, -24 },
  { 1597, 11, 24, 11, 0, -24 },
  { 1630, 9, 24, 11, 1, -24 },
  { 1657, 6, 29, 10, 3, -24 },
  { 1679, 10, 24, 11, 1, -24 },
  { 1709, 7, 29, 10, 1, -24 },
  { 1735, 12, 11, 13, 1, -24 },
  { 1752, 13, 1, 13, 0, 3 },
  { 1754, 5, 5, 8, 1, -26 },
  { 1758, 9, 18, 12, 1, -18 },
  { 1779, 11, 26, 14, 2, -26 },
  { 1815, 8, 18, 11, 2, -18 },
  { 1833, 10, 26, 14, 2, -26 },
  { 1866, 9, 18, 13, 2, -18 },
  { 1887, 8, 26, 7, 0, -26 },
  { 1913, 10, 26, 14, 2, -18 },
  { 1946, 10, 26, 14, 2, -26 },
  { 1979, 2, 25, 6, 2, -25 },
  { 1986, 4, 33, 6, 0, -25 },
  { 2003, 9, 26, 11, 2, -26 },
  { 2033, 1, 26, 6, 2, -26 },
  { 2037, 16, 18, 21, 2, -18 },
  { 2073, 10, 18, 14, 2, -18 },
  { 2096, 10, 18, 14, 2, -18 },
  { 2119, 11, 26, 14, 2, -18 },
  { 2155, 10, 26, 14, 2, -18 },
  { 2188, 7, 18, 9, 2, -18 },
  { 2204, 8, 18, 11, 1, -18 },
  { 2222, 6, 22, 7, 1, -22 },
  { 2239, 9, 18, 14, 2, -18 },
  { 2260, 10, 18, 10, 0, -18 },
  { 2283, 17, 18, 17, 0, -18 },
  { 2322, 9, 18, 11, 1, -18 },
  { 2343, 10, 26, 11, 0, -18 },
  { 2376, 7, 18, 9, 1, -18 },
  { 2392, 8, 29, 12, 2, -24 },
  { 2421, 1, 34, 13, 6, -26 },
  { 2426, 8, 29, 12, 2, -24 },
  { 2455, 12, 2, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Thin34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN34PT7B_H_
