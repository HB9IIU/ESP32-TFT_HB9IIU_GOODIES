#ifndef _NOTOSANS_EXTRACONDENSED_THIN64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x16, 0x02, 0xC0, 0x58, 0x0B, 0x01, 0x60, 0x2C,
  0x05, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0x40, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02,
  0x00, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x02, 0x00,
  0x04, 0x01, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0x00, 0x40, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x08, 0x02, 0x00, 0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00,
  0x40, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x04, 0x01, 0x00, 0x02,
  0x00, 0x80, 0x01, 0x00, 0x40, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x08, 0x02, 0x00,
  0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xF7, 0xE0, 0x71,
  0x83, 0x87, 0x0C, 0x04, 0x30, 0x60, 0x03, 0x03, 0x00, 0x10, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x10, 0x18, 0x00, 0xC0, 0xC0, 0x03,
  0x06, 0x00, 0x1C, 0x30, 0x00, 0x71, 0x80, 0x00, 0xEC, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xDC, 0x00, 0x06, 0x38, 0x00,
  0x30, 0xE0, 0x01, 0x83, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0xCC, 0x06, 0x0C, 0x7E, 0x33, 0xC0, 0x7F, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x71, 0x80, 0x04, 0x00, 0xC1,
  0x00, 0x18, 0x03, 0x03, 0x00, 0x30, 0x06, 0x02, 0x00, 0x40, 0x08, 0x04,
  0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x04, 0x00, 0xC0, 0x30,
  0x18, 0x01, 0x80, 0x20, 0x30, 0x03, 0x00, 0x40, 0x40, 0x06, 0x00, 0x81,
  0x80, 0x0C, 0x01, 0x03, 0x00, 0x10, 0x02, 0x04, 0x00, 0x20, 0x04, 0x18,
  0x00, 0x60, 0x08, 0x30, 0x00, 0xC0, 0x10, 0x40, 0x01, 0x80, 0x21, 0x80,
  0x03, 0x00, 0xC3, 0x0F, 0x86, 0x01, 0x84, 0x31, 0x8C, 0x03, 0x18, 0xC1,
  0x88, 0x06, 0x31, 0x83, 0x10, 0x08, 0x42, 0x03, 0x30, 0x11, 0x8C, 0x06,
  0x60, 0x63, 0x18, 0x0C, 0x61, 0x84, 0x20, 0x08, 0xE7, 0x18, 0x40, 0x10,
  0xFC, 0x30, 0x80, 0x30, 0x00, 0x43, 0x00, 0x60, 0x01, 0x86, 0x00, 0xC0,
  0x03, 0x0C, 0x01, 0x80, 0x04, 0x18, 0x03, 0x00, 0x18, 0x30, 0x06, 0x00,
  0x30, 0x60, 0x0C, 0x00, 0x40, 0xC0, 0x18, 0x01, 0x81, 0x80, 0x30, 0x03,
  0x01, 0x00, 0x60, 0x04, 0x02, 0x00, 0x80, 0x18, 0x04, 0x01, 0x00, 0x30,
  0x08, 0x02, 0x00, 0x40, 0x18, 0x0C, 0x01, 0x80, 0x30, 0x18, 0x03, 0x00,
  0x20, 0x20, 0x04, 0x00, 0x60, 0xC0, 0x08, 0x00, 0x63, 0x00, 0x30, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x60, 0x01, 0x00, 0xC0, 0x02,
  0x01, 0x80, 0x04, 0x03, 0x00, 0x08, 0x02, 0x00, 0x10, 0x04, 0x00, 0x20,
  0x18, 0x00, 0x40, 0x30, 0x00, 0x80, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x00, 0x02, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x40,
  0x00, 0x19, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x40, 0x00, 0xC0, 0xC0, 0x21,
  0x00, 0x80, 0x46, 0x01, 0x80, 0x88, 0x01, 0x81, 0x10, 0x03, 0x02, 0x60,
  0x03, 0x0C, 0xC0, 0x02, 0x19, 0x80, 0x06, 0x33, 0x00, 0x04, 0x46, 0x00,
  0x0D, 0x8C, 0x00, 0x0B, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x18, 0x20, 0x00,
  0x70, 0x60, 0x00, 0xF0, 0xC0, 0x03, 0x20, 0xC0, 0x0C, 0x61, 0x80, 0x30,
  0x41, 0xC1, 0xC0, 0xC1, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFD, 0x40, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xE1, 0x07, 0x39, 0x1C, 0x0F, 0xE0, 0x01, 0x80, 0x03, 0xC0, 0x06,
  0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x18, 0x30, 0x0C, 0x20, 0x04, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0C, 0x61, 0x86, 0x18, 0x61,
  0x0C, 0x30, 0xC2, 0x18, 0x63, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xE3, 0x80, 0x30,
  0x18, 0x06, 0x01, 0x81, 0x80, 0x10, 0x20, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x06, 0x20, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x01, 0x30, 0x00, 0x24, 0x00,
  0x06, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x40, 0x00,
  0x68, 0x00, 0x0D, 0x80, 0x01, 0x30, 0x00, 0x26, 0x00, 0x0C, 0xC0, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x04, 0x30, 0x01, 0x83, 0x00, 0x30, 0x70, 0x0C,
  0x06, 0x03, 0x00, 0x70, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x40, 0x30, 0x3C,
  0x1D, 0x0E, 0x47, 0x13, 0x05, 0x81, 0xC0, 0x50, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0F, 0xF8, 0x07, 0x83, 0x81, 0xC0,
  0x18, 0x20, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xF1,
  0xE0, 0x70, 0x03, 0x8E, 0x00, 0x18, 0x40, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC4, 0x00, 0x38, 0x78, 0x0F,
  0x03, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x80, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x02, 0x00, 0xC0,
  0x06, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x10, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x27, 0xFC, 0x07,
  0xF3, 0xE0, 0xC0, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x40, 0x03, 0x0F, 0x01, 0xC0, 0x7F,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x07,
  0xE0, 0x63, 0xFF, 0x0C, 0xE0, 0x31, 0xB0, 0x03, 0x34, 0x00, 0x37, 0x80,
  0x06, 0xE0, 0x00, 0x5C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x05, 0x00, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x19, 0x00, 0x02, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x60, 0x06, 0x0E, 0x00,
  0xC0, 0xE0, 0x70, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3C, 0x78, 0x03, 0x00, 0x60, 0x30, 0x01, 0x81, 0x00, 0x06, 0x18,
  0x00, 0x30, 0xC0, 0x00, 0x84, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x03, 0x18, 0x00, 0x10, 0xC0,
  0x01, 0x83, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0xC0,
  0x07, 0x0C, 0x00, 0x1D, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x71,
  0x80, 0x07, 0x07, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x70, 0x30, 0x01, 0x83,
  0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC8, 0x00, 0x02, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0D, 0x00, 0x00, 0x4C, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x03,
  0x0E, 0x00, 0x18, 0x38, 0x01, 0x80, 0xF0, 0x38, 0x01, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xF8, 0x01, 0xC3, 0x80, 0x60, 0x18, 0x18, 0x01, 0x86,
  0x00, 0x10, 0xC0, 0x03, 0x10, 0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x01, 0x40, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xD0, 0x00, 0x3B, 0x00, 0x0B, 0x30,
  0x03, 0x66, 0x00, 0xCC, 0x70, 0x71, 0x83, 0xFC, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x04, 0x07,
  0x00, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x7F, 0xF4, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x18, 0x73, 0xC7, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x71, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC6,
  0x18, 0x43, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x3F, 0xC3, 0xE3, 0x84, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x06,
  0x10, 0x00, 0x00, 0x06, 0x30, 0x00, 0xF0, 0x06, 0x30, 0x03, 0xFC, 0x02,
  0x20, 0x06, 0x04, 0x03, 0x60, 0x0C, 0x0C, 0x03, 0x60, 0x08, 0x0C, 0x03,
  0x60, 0x18, 0x0C, 0x03, 0x60, 0x10, 0x0C, 0x03, 0x60, 0x30, 0x0C, 0x01,
  0x40, 0x30, 0x0C, 0x01, 0x40, 0x30, 0x0C, 0x01, 0x40, 0x30, 0x0C, 0x01,
  0xC0, 0x20, 0x0C, 0x01, 0xC0, 0x20, 0x0C, 0x01, 0xC0, 0x20, 0x0C, 0x01,
  0xC0, 0x20, 0x0C, 0x01, 0xC0, 0x20, 0x0C, 0x03, 0xC0, 0x20, 0x0C, 0x03,
  0x40, 0x20, 0x0C, 0x03, 0x40, 0x30, 0x1C, 0x03, 0x40, 0x30, 0x14, 0x03,
  0x60, 0x30, 0x14, 0x06, 0x60, 0x30, 0x34, 0x06, 0x60, 0x18, 0x26, 0x0C,
  0x60, 0x1C, 0x66, 0x1C, 0x60, 0x0F, 0xC3, 0xF8, 0x20, 0x03, 0x80, 0xE0,
  0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x02, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x24, 0x00, 0x00, 0x26, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x62, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81, 0x00, 0x01, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0x80, 0x01, 0x00, 0x80, 0x01, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x08, 0x00,
  0x10, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x10, 0x00,
  0x08, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00,
  0x04, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0xC0, 0x07, 0x0C, 0x00, 0x18, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x04, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x30,
  0xC0, 0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0C, 0x00, 0x70, 0xC0, 0x01,
  0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x70,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0xF1, 0xF0, 0x1C,
  0x00, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x01, 0x00, 0xF0, 0x1C, 0x00, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0C, 0x01, 0xE0, 0x30,
  0x01, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x03, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0x80, 0x07,
  0x00, 0xC0, 0x00, 0x20, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C,
  0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x07, 0x80, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x3F, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x1B, 0xFC, 0xFE, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01, 0x86, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x9C, 0x00, 0x36, 0xC0, 0x06, 0xD8,
  0x00, 0xF1, 0x80, 0x1C, 0x30, 0x03, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0B, 0xD0, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00,
  0x00, 0x13, 0xC8, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00,
  0x00, 0x33, 0xCC, 0x00, 0x00, 0x63, 0xC4, 0x00, 0x00, 0x63, 0xC6, 0x00,
  0x00, 0x63, 0xC6, 0x00, 0x00, 0x43, 0xC2, 0x00, 0x00, 0xC3, 0xC3, 0x00,
  0x00, 0xC3, 0xC3, 0x00, 0x00, 0x83, 0xC1, 0x00, 0x01, 0x83, 0xC1, 0x80,
  0x01, 0x83, 0xC1, 0x80, 0x01, 0x83, 0xC1, 0x80, 0x03, 0x03, 0xC0, 0xC0,
  0x03, 0x03, 0xC0, 0xC0, 0x03, 0x03, 0xC0, 0xC0, 0x02, 0x03, 0xC0, 0x40,
  0x06, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0, 0x60, 0x04, 0x03, 0xC0, 0x20,
  0x0C, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x30, 0x08, 0x03, 0xC0, 0x30,
  0x18, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18,
  0x30, 0x03, 0xC0, 0x08, 0x30, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0C,
  0x20, 0x03, 0xC0, 0x04, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06,
  0x40, 0x03, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x40, 0x00, 0x1D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0x40, 0x00,
  0x71, 0x80, 0x01, 0xC2, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x10, 0x00, 0x70,
  0x60, 0x01, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x10,
  0x01, 0xC0, 0x60, 0x07, 0x00, 0x80, 0x1C, 0x03, 0x00, 0x70, 0x04, 0x01,
  0xC0, 0x18, 0x07, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0,
  0x04, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x20, 0x70, 0x00, 0xC1, 0xC0, 0x03,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x21, 0xC0, 0x00, 0xC7,
  0x00, 0x01, 0x1C, 0x00, 0x06, 0x70, 0x00, 0x09, 0xC0, 0x00, 0x37, 0x00,
  0x00, 0xDC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x38, 0x03, 0x80, 0x18,
  0x00, 0x70, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20,
  0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x41, 0x80, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x01, 0xC0, 0x70, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xD0, 0x00, 0xFF, 0x80,
  0x3F, 0xFE, 0x0C, 0x03, 0xC3, 0x00, 0x1C, 0xC0, 0x03, 0x30, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x38, 0xC0, 0x3C, 0x3F, 0xFC, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x22, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x41, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x01, 0xC0, 0x70, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0x70, 0xC0, 0x03,
  0x0C, 0x00, 0x18, 0xC0, 0x00, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x04, 0xC0, 0x00, 0x4C, 0x00, 0x04, 0xC0,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x8C,
  0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x0E, 0x0C, 0x07, 0x80,
  0xFF, 0xF0, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x0C, 0x01, 0x80, 0xC0, 0x08, 0x0C, 0x00,
  0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0x03, 0xFF, 0x01, 0xF0, 0xFC,
  0x70, 0x01, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x40, 0x03, 0x8F, 0x01, 0xE0, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28, 0x00, 0x00,
  0xA0, 0x00, 0x02, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x90,
  0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC3, 0x00, 0x06, 0x06, 0x00,
  0x30, 0x0E, 0x03, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x98, 0x00, 0x03, 0x10, 0x00, 0x06, 0x20, 0x00, 0x0C,
  0x60, 0x00, 0x10, 0xC0, 0x00, 0x60, 0x80, 0x00, 0xC1, 0x00, 0x01, 0x83,
  0x00, 0x02, 0x06, 0x00, 0x0C, 0x04, 0x00, 0x18, 0x08, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x04, 0x01,
  0x80, 0x0C, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x10, 0x18, 0x00, 0x20, 0x30,
  0x00, 0x60, 0x40, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x01, 0x06, 0x00,
  0x03, 0x08, 0x00, 0x06, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x08, 0xC0, 0x00,
  0x11, 0x00, 0x00, 0x32, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00, 0x00,
  0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x00, 0x00, 0xD8, 0x00, 0x07,
  0x00, 0x00, 0x6C, 0x00, 0x03, 0x80, 0x00, 0x26, 0x00, 0x01, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xA0, 0x00, 0x18, 0x80, 0x00, 0x58, 0x00, 0x0C, 0x60,
  0x00, 0x6C, 0x00, 0x06, 0x30, 0x00, 0x36, 0x00, 0x02, 0x18, 0x00, 0x1B,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x80, 0x01, 0x82, 0x00, 0x04, 0x60, 0x00,
  0xC1, 0x80, 0x06, 0x30, 0x00, 0x40, 0xC0, 0x03, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x84, 0x00, 0x30, 0x10, 0x00, 0xC2, 0x00, 0x18, 0x0C, 0x00, 0x41,
  0x80, 0x0C, 0x06, 0x00, 0x60, 0xC0, 0x04, 0x03, 0x00, 0x30, 0x60, 0x06,
  0x01, 0x80, 0x18, 0x30, 0x03, 0x00, 0x40, 0x0C, 0x08, 0x01, 0x80, 0x30,
  0x04, 0x06, 0x00, 0x80, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x01, 0x00, 0xC0, 0x20, 0x18,
  0x00, 0xC0, 0x40, 0x18, 0x08, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0x30,
  0x30, 0x06, 0x06, 0x00, 0x08, 0x18, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00,
  0x81, 0x00, 0x03, 0x04, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x0C, 0x30, 0x00, 0x18,
  0xC0, 0x02, 0x10, 0x00, 0x0C, 0x40, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x03, 0x30, 0x00, 0x66, 0x00, 0x00, 0x98, 0x00, 0x32, 0x00,
  0x00, 0x6C, 0x00, 0x09, 0x00, 0x00, 0x34, 0x00, 0x05, 0x80, 0x00, 0x1A,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x32, 0x00, 0x06,
  0x30, 0x00, 0x63, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x01,
  0x80, 0xC0, 0x18, 0x0C, 0x01, 0x00, 0x40, 0x30, 0x06, 0x03, 0x00, 0x60,
  0x20, 0x02, 0x06, 0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x10, 0xC0, 0x01,
  0x88, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x00,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0x60, 0x40, 0x06, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x02, 0x00, 0xC0,
  0x30, 0x18, 0x03, 0x01, 0x80, 0x18, 0x10, 0x01, 0x83, 0x00, 0x08, 0x30,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x06,
  0x60, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x10, 0x00,
  0x81, 0x80, 0x18, 0x18, 0x01, 0x80, 0x80, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x20, 0x40, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00,
  0x09, 0x80, 0x00, 0xD0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x1F, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x61, 0x80, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x61, 0x00, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x07, 0xF8, 0x0F, 0x8F, 0x04, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0xFF, 0x03, 0xE1, 0x87, 0x00, 0xC6, 0x00, 0x66, 0x00, 0x36, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x68, 0x00, 0x74, 0x00, 0x2B, 0x00, 0x15, 0x80, 0x1A, 0x60, 0x19, 0x18,
  0x18, 0x87, 0xF8, 0x40, 0x60, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x1F, 0xE0, 0x8F, 0x0E, 0x13, 0x00,
  0x62, 0x40, 0x06, 0x58, 0x00, 0xCA, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00,
  0x16, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x03,
  0x50, 0x00, 0x6A, 0x00, 0x19, 0x20, 0x07, 0x26, 0x01, 0xC4, 0x70, 0x70,
  0x87, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x07, 0xC7, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x03, 0x03,
  0xFF, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x3F, 0xC3, 0x07, 0x0E, 0x30, 0xC0, 0x33,
  0x18, 0x01, 0xB3, 0x00, 0x0B, 0x30, 0x00, 0xF6, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x76, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x0F, 0x30, 0x00, 0xB3, 0x00, 0x1B, 0x18, 0x03,
  0x30, 0xE0, 0xE3, 0x07, 0xFC, 0x30, 0x0E, 0x00, 0x03, 0xF8, 0x03, 0xC7,
  0x00, 0xC0, 0x60, 0x60, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x09,
  0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x02, 0x07, 0x03, 0x80, 0xFF,
  0xC0, 0x07, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x30, 0xF0, 0xE3, 0x1C, 0x03,
  0x31, 0x80, 0x1B, 0x30, 0x00, 0xB3, 0x00, 0x0F, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x40, 0x00, 0x74, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x74, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x0F, 0x20, 0x00, 0xB3, 0x00, 0x0B, 0x30, 0x01, 0x31, 0x80,
  0x33, 0x0E, 0x0E, 0x30, 0x7F, 0xC3, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x40, 0x03, 0x07, 0x81, 0xE0, 0x1F, 0xFC, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x07, 0xF0, 0x8F, 0x1C, 0x4E, 0x03, 0x24, 0x01,
  0x96, 0x00, 0x6A, 0x00, 0x37, 0x00, 0x0B, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0xFF, 0xB0, 0x00, 0x00, 0x06, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x0E,
  0x1C, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x18, 0x34, 0xCF, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x06, 0x80,
  0x0D, 0x00, 0x32, 0x00, 0x64, 0x01, 0x88, 0x06, 0x10, 0x0C, 0x20, 0x30,
  0x40, 0x40, 0x81, 0x81, 0x06, 0x02, 0x0C, 0x04, 0x30, 0x08, 0x60, 0x11,
  0xC0, 0x26, 0xC0, 0x49, 0x80, 0xB1, 0x81, 0x43, 0x03, 0x02, 0x06, 0x06,
  0x08, 0x04, 0x10, 0x0C, 0x20, 0x18, 0x40, 0x10, 0x80, 0x31, 0x00, 0x22,
  0x00, 0x64, 0x00, 0xC8, 0x00, 0x90, 0x01, 0xA0, 0x01, 0x40, 0x03, 0x80,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x87, 0xF0, 0x1F, 0xC2,
  0x38, 0xE0, 0xE3, 0x89, 0x80, 0xC6, 0x03, 0x2C, 0x03, 0x30, 0x0C, 0xA0,
  0x04, 0x80, 0x1B, 0x80, 0x1E, 0x00, 0x6C, 0x00, 0x70, 0x00, 0xB0, 0x00,
  0xC0, 0x02, 0xC0, 0x03, 0x00, 0x0A, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x20,
  0x00, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0x38, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x02, 0x00, 0x0E,
  0x00, 0x08, 0x00, 0x38, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x80, 0x03, 0x80,
  0x02, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x38, 0x00, 0x20, 0x00, 0xE0, 0x00,
  0x80, 0x03, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x08, 0x00, 0x38, 0x00, 0x20,
  0x00, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x08, 0x00,
  0x38, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x80, 0x03, 0x80, 0x02, 0x00, 0x0E,
  0x00, 0x08, 0x00, 0x30, 0x83, 0xF8, 0x47, 0x0E, 0x26, 0x01, 0x92, 0x00,
  0x6B, 0x00, 0x35, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0xFC, 0x00, 0xF1, 0xE0, 0x1C, 0x03,
  0x01, 0x80, 0x18, 0x30, 0x00, 0xC2, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00,
  0x06, 0x40, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x20, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01, 0x81, 0xC0,
  0x38, 0x0E, 0x07, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x83, 0xF8, 0x11,
  0xE3, 0xC2, 0x70, 0x1C, 0x4C, 0x00, 0xCB, 0x00, 0x19, 0x40, 0x01, 0xB8,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00,
  0x03, 0x70, 0x00, 0x6A, 0x00, 0x09, 0x60, 0x03, 0x24, 0x00, 0xC4, 0xC0,
  0x18, 0x8E, 0x0E, 0x10, 0xFF, 0x82, 0x03, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x30, 0x78, 0xE3, 0x0C,
  0x03, 0x31, 0x80, 0x1B, 0x30, 0x00, 0xB3, 0x00, 0x0F, 0x20, 0x00, 0x76,
  0x00, 0x07, 0x60, 0x00, 0x74, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x74, 0x00, 0x07, 0x60,
  0x00, 0x76, 0x00, 0x07, 0x20, 0x00, 0xB3, 0x00, 0x0B, 0x18, 0x01, 0x31,
  0xC0, 0x33, 0x0E, 0x0E, 0x30, 0x7F, 0xC3, 0x00, 0xE0, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x83, 0xF1, 0xEE,
  0x30, 0x4C, 0x0B, 0x01, 0x40, 0x28, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x07, 0xFC, 0x1E, 0x1F,
  0x38, 0x02, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0xC0, 0x0C,
  0xF0, 0x3C, 0x3F, 0xF0, 0x07, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x0E, 0x10, 0x7E, 0x01, 0xC0, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x74, 0x00, 0x1D,
  0x00, 0x07, 0x60, 0x03, 0xD8, 0x00, 0xB6, 0x00, 0x6C, 0xC0, 0x33, 0x18,
  0x18, 0xC3, 0xFC, 0x30, 0x1C, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0x88, 0x00, 0x62, 0x00, 0x18, 0xC0, 0x06,
  0x30, 0x01, 0x0C, 0x00, 0x41, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x06,
  0x00, 0x80, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x40,
  0xC0, 0x10, 0x30, 0x06, 0x0C, 0x01, 0x82, 0x00, 0x21, 0x80, 0x08, 0x60,
  0x03, 0x18, 0x00, 0xC4, 0x00, 0x13, 0x00, 0x04, 0xC0, 0x01, 0xB0, 0x00,
  0x68, 0x00, 0x1A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x80,
  0x01, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x24, 0x00, 0x28, 0x00, 0x48, 0x00, 0x58, 0x01, 0x98, 0x01,
  0xB0, 0x03, 0x30, 0x03, 0x60, 0x06, 0x60, 0x06, 0x40, 0x08, 0x40, 0x08,
  0xC0, 0x10, 0xC0, 0x31, 0x80, 0x61, 0x80, 0x63, 0x00, 0xC3, 0x00, 0xC2,
  0x01, 0x02, 0x01, 0x04, 0x02, 0x04, 0x02, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x40, 0x20, 0x40, 0x40,
  0x80, 0x61, 0x80, 0xC3, 0x00, 0xC3, 0x01, 0x86, 0x01, 0x86, 0x03, 0x08,
  0x01, 0x0C, 0x02, 0x10, 0x02, 0x10, 0x04, 0x60, 0x06, 0x60, 0x0C, 0xC0,
  0x0C, 0xC0, 0x19, 0x80, 0x09, 0x80, 0x32, 0x00, 0x12, 0x00, 0x24, 0x00,
  0x34, 0x00, 0x58, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0xE0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x60,
  0x00, 0xD8, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x10, 0x03, 0x06, 0x00,
  0x80, 0x80, 0x60, 0x30, 0x10, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x61, 0x80,
  0x0C, 0x60, 0x03, 0x30, 0x00, 0x4C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x06, 0x80, 0x03, 0x30, 0x00, 0xC4,
  0x00, 0x61, 0x80, 0x18, 0x20, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x80, 0x60,
  0x60, 0x18, 0x10, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0x60,
  0x01, 0xB0, 0x00, 0x30, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x80, 0x03, 0x30,
  0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x82, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x10,
  0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x00, 0x80, 0x80, 0x18,
  0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x04, 0x10, 0x00, 0xC6, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x22, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1A,
  0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x04, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x3F, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x05,
  0xC7, 0x80, 0x3C, 0x03, 0x81, 0xA0, 0x07, 0xFC, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 46, 12, 5, -46 },
  { 19, 11, 17, 19, 4, -46 },
  { 43, 25, 46, 27, 1, -46 },
  { 187, 21, 53, 25, 2, -49 },
  { 327, 31, 47, 37, 3, -46 },
  { 510, 23, 47, 25, 2, -46 },
  { 646, 2, 17, 10, 4, -46 },
  { 651, 11, 56, 17, 3, -46 },
  { 728, 11, 56, 17, 3, -46 },
  { 805, 16, 17, 22, 3, -49 },
  { 839, 22, 29, 26, 2, -37 },
  { 919, 6, 14, 11, 2, -6 },
  { 930, 13, 1, 17, 2, -18 },
  { 932, 3, 4, 12, 4, -4 },
  { 934, 18, 46, 21, 2, -46 },
  { 1038, 19, 46, 25, 3, -46 },
  { 1148, 10, 46, 25, 5, -46 },
  { 1206, 19, 46, 25, 3, -46 },
  { 1316, 20, 47, 25, 2, -46 },
  { 1434, 24, 46, 25, 1, -46 },
  { 1572, 19, 47, 25, 3, -46 },
  { 1684, 19, 47, 25, 3, -46 },
  { 1796, 19, 46, 25, 3, -46 },
  { 1906, 21, 47, 25, 2, -46 },
  { 2030, 19, 47, 25, 3, -46 },
  { 2142, 3, 34, 12, 4, -34 },
  { 2155, 6, 42, 11, 2, -34 },
  { 2187, 22, 27, 26, 2, -36 },
  { 2262, 22, 15, 26, 2, -30 },
  { 2304, 22, 27, 26, 2, -36 },
  { 2379, 14, 46, 17, 1, -46 },
  { 2460, 32, 52, 39, 3, -46 },
  { 2668, 24, 46, 24, 0, -46 },
  { 2806, 20, 46, 28, 5, -46 },
  { 2921, 22, 47, 27, 3, -46 },
  { 3051, 22, 46, 30, 5, -46 },
  { 3178, 16, 46, 24, 5, -46 },
  { 3270, 16, 46, 23, 5, -46 },
  { 3362, 27, 47, 33, 3, -46 },
  { 3521, 21, 46, 31, 5, -46 },
  { 3642, 10, 46, 14, 2, -46 },
  { 3700, 10, 57, 12, -3, -46 },
  { 3772, 19, 46, 24, 5, -46 },
  { 3882, 16, 46, 22, 5, -46 },
  { 3974, 32, 46, 42, 5, -46 },
  { 4158, 22, 46, 32, 5, -46 },
  { 4285, 26, 47, 33, 3, -46 },
  { 4438, 18, 46, 25, 5, -46 },
  { 4542, 26, 57, 33, 3, -46 },
  { 4728, 20, 46, 26, 5, -46 },
  { 4843, 19, 47, 25, 3, -46 },
  { 4955, 21, 46, 22, 0, -46 },
  { 5076, 22, 47, 31, 5, -46 },
  { 5206, 23, 46, 23, 0, -46 },
  { 5339, 41, 46, 41, 0, -46 },
  { 5575, 20, 46, 21, 1, -46 },
  { 5690, 20, 46, 20, 0, -46 },
  { 5805, 17, 46, 21, 2, -46 },
  { 5903, 12, 56, 20, 5, -46 },
  { 5987, 18, 46, 21, 2, -46 },
  { 6091, 12, 56, 20, 2, -46 },
  { 6175, 23, 22, 25, 1, -46 },
  { 6239, 25, 1, 25, 0, 6 },
  { 6243, 9, 10, 14, 3, -49 },
  { 6255, 17, 35, 23, 2, -34 },
  { 6330, 19, 50, 27, 5, -49 },
  { 6449, 16, 35, 20, 3, -34 },
  { 6519, 20, 50, 27, 3, -49 },
  { 6644, 18, 35, 24, 3, -34 },
  { 6723, 14, 49, 14, 1, -49 },
  { 6809, 20, 49, 27, 3, -34 },
  { 6932, 17, 49, 26, 5, -49 },
  { 7037, 3, 46, 11, 4, -46 },
  { 7055, 7, 61, 11, 0, -46 },
  { 7109, 15, 49, 21, 5, -49 },
  { 7201, 1, 49, 11, 5, -49 },
  { 7208, 30, 34, 39, 5, -34 },
  { 7336, 17, 34, 26, 5, -34 },
  { 7409, 20, 35, 26, 3, -34 },
  { 7497, 19, 49, 27, 5, -34 },
  { 7614, 20, 49, 27, 3, -34 },
  { 7737, 11, 34, 17, 5, -34 },
  { 7784, 16, 35, 20, 2, -34 },
  { 7854, 12, 43, 13, 1, -42 },
  { 7919, 18, 35, 26, 4, -34 },
  { 7998, 18, 34, 19, 0, -34 },
  { 8075, 31, 34, 33, 1, -34 },
  { 8207, 18, 34, 20, 1, -34 },
  { 8284, 19, 49, 20, 1, -34 },
  { 8401, 13, 34, 17, 2, -34 },
  { 8457, 16, 56, 22, 3, -46 },
  { 8569, 2, 64, 24, 11, -49 },
  { 8585, 16, 56, 22, 3, -46 },
  { 8697, 22, 5, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_Thin64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN64PT7B_H_
