#ifndef _NOTOSANS_EXTRACONDENSED_THIN10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xC0, 0x55, 0xE6, 0xF6, 0xA0, 0x4F, 0xCC, 0x25, 0x5A, 0x40,
  0xF5, 0xA9, 0x77, 0x9D, 0x60, 0x6A, 0x44, 0xBA, 0xF0, 0xC0, 0xFF, 0x80,
  0x95, 0x55, 0x80, 0x55, 0x80, 0x44, 0xF4, 0x40, 0xC0, 0xC0, 0x80, 0x24,
  0xA5, 0x20, 0x76, 0xDB, 0x58, 0xFE, 0x64, 0x92, 0xB8, 0xE4, 0xB2, 0x78,
  0x26, 0x6A, 0xA7, 0x20, 0xE8, 0xC3, 0x11, 0xE0, 0x68, 0xE9, 0x99, 0x60,
  0xE4, 0x94, 0x90, 0xF9, 0x66, 0x99, 0xF0, 0xF6, 0xD6, 0x58, 0x08, 0x0C,
  0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xD5, 0x88, 0xF4, 0x7B,
  0x5A, 0xFA, 0x1C, 0x44, 0x6A, 0xD9, 0x90, 0xF6, 0xFB, 0x78, 0xF2, 0x49,
  0x38, 0xF6, 0xDB, 0x78, 0xEB, 0xAC, 0xEB, 0xA8, 0xF8, 0x8B, 0x99, 0xF0,
  0xB6, 0xFB, 0x68, 0xD5, 0x5C, 0xFF, 0x80, 0xBA, 0x4D, 0xA8, 0xAA, 0xAC,
  0x8C, 0x63, 0x3D, 0xF6, 0xA0, 0xB6, 0xFF, 0x68, 0xE9, 0x99, 0x99, 0xE0,
  0xF6, 0xE9, 0x20, 0xE9, 0x99, 0x99, 0xE2, 0x20, 0xF6, 0xED, 0x68, 0xF2,
  0x32, 0x78, 0xE9, 0x24, 0x90, 0xB6, 0xDB, 0x78, 0x99, 0xAA, 0x64, 0x40,
  0x96, 0x5B, 0x6D, 0x49, 0x24, 0x80, 0xAD, 0x25, 0x68, 0xB5, 0x24, 0x90,
  0xE5, 0x25, 0x38, 0xEA, 0xAA, 0xC0, 0x91, 0x22, 0x48, 0xD5, 0x55, 0xC0,
  0x46, 0x90, 0xF0, 0x90, 0x65, 0xDE, 0x93, 0x5B, 0x6F, 0xF2, 0x46, 0x11,
  0x79, 0x99, 0x97, 0xF7, 0x46, 0x6E, 0xAA, 0xF9, 0x99, 0x71, 0x70, 0xAB,
  0xFF, 0x3E, 0x3F, 0x80, 0xAB, 0xAF, 0xFF, 0xFB, 0xBB, 0xB0, 0xFF, 0xC0,
  0xF9, 0x99, 0x60, 0xF6, 0xDF, 0x20, 0xF9, 0x99, 0x71, 0x10, 0xEA, 0x80,
  0xF1, 0x1E, 0xBA, 0xAC, 0xFF, 0xC0, 0xB6, 0xA4, 0xAD, 0x74, 0xA5, 0x00,
  0xA9, 0x2A, 0xB5, 0x24, 0xB0, 0xD6, 0xC0, 0xEA, 0xAA, 0x40, 0xFF, 0xC0,
  0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 0, -7 },
  { 2, 1, 2, 3, 1, -7 },
  { 3, 4, 7, 4, 0, -7 },
  { 7, 4, 9, 4, 0, -8 },
  { 12, 5, 7, 6, 0, -7 },
  { 17, 4, 7, 4, 0, -7 },
  { 21, 1, 2, 2, 0, -7 },
  { 22, 1, 9, 3, 1, -7 },
  { 24, 2, 9, 3, 0, -7 },
  { 27, 3, 3, 3, 0, -8 },
  { 29, 4, 5, 4, 0, -6 },
  { 32, 1, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 1, 1, 2, 0, -1 },
  { 35, 3, 7, 3, 0, -7 },
  { 38, 3, 7, 4, 0, -7 },
  { 41, 1, 7, 4, 1, -7 },
  { 42, 3, 7, 4, 0, -7 },
  { 45, 3, 7, 4, 0, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 3, 7, 4, 0, -7 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 3, 7, 4, 0, -7 },
  { 70, 1, 5, 2, 0, -5 },
  { 71, 1, 6, 2, 0, -5 },
  { 72, 4, 5, 4, 0, -6 },
  { 75, 4, 3, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -6 },
  { 80, 2, 7, 3, 0, -7 },
  { 82, 5, 8, 6, 1, -7 },
  { 87, 4, 7, 4, 0, -7 },
  { 91, 3, 7, 4, 1, -7 },
  { 94, 3, 7, 4, 1, -7 },
  { 97, 3, 7, 5, 1, -7 },
  { 100, 2, 7, 4, 1, -7 },
  { 102, 2, 7, 4, 1, -7 },
  { 104, 4, 7, 5, 1, -7 },
  { 108, 3, 7, 5, 1, -7 },
  { 111, 2, 7, 2, 0, -7 },
  { 113, 1, 9, 2, 0, -7 },
  { 115, 3, 7, 4, 1, -7 },
  { 118, 2, 7, 3, 1, -7 },
  { 120, 5, 7, 7, 1, -7 },
  { 125, 3, 7, 5, 1, -7 },
  { 128, 4, 7, 5, 1, -7 },
  { 132, 3, 7, 4, 1, -7 },
  { 135, 4, 9, 5, 1, -7 },
  { 140, 3, 7, 4, 1, -7 },
  { 143, 3, 7, 4, 0, -7 },
  { 146, 3, 7, 3, 0, -7 },
  { 149, 3, 7, 5, 1, -7 },
  { 152, 4, 7, 4, 0, -7 },
  { 156, 6, 7, 6, 0, -7 },
  { 162, 3, 7, 3, 0, -7 },
  { 165, 3, 7, 3, 0, -7 },
  { 168, 3, 7, 3, 0, -7 },
  { 171, 2, 9, 3, 1, -7 },
  { 174, 3, 7, 3, 0, -7 },
  { 177, 2, 9, 3, 0, -7 },
  { 180, 4, 3, 4, 0, -7 },
  { 182, 4, 1, 4, 0, 1 },
  { 183, 2, 2, 2, 0, -8 },
  { 184, 3, 5, 4, 0, -5 },
  { 186, 3, 8, 4, 1, -8 },
  { 189, 3, 5, 3, 0, -5 },
  { 191, 4, 8, 4, 0, -8 },
  { 195, 3, 5, 4, 0, -5 },
  { 197, 2, 8, 2, 0, -8 },
  { 199, 4, 7, 4, 0, -5 },
  { 203, 2, 8, 4, 1, -8 },
  { 205, 1, 7, 2, 0, -7 },
  { 206, 1, 9, 2, 0, -7 },
  { 208, 2, 8, 3, 1, -8 },
  { 210, 1, 8, 2, 0, -8 },
  { 211, 4, 5, 6, 1, -5 },
  { 214, 2, 5, 4, 1, -5 },
  { 216, 4, 5, 4, 0, -5 },
  { 219, 3, 7, 4, 1, -5 },
  { 222, 4, 7, 4, 0, -5 },
  { 226, 2, 5, 3, 1, -5 },
  { 228, 3, 5, 3, 0, -5 },
  { 230, 2, 7, 2, 0, -7 },
  { 232, 2, 5, 4, 1, -5 },
  { 234, 3, 5, 3, 0, -5 },
  { 236, 5, 5, 5, 0, -5 },
  { 240, 3, 5, 3, 0, -5 },
  { 242, 3, 7, 3, 0, -5 },
  { 245, 2, 5, 3, 0, -5 },
  { 247, 2, 9, 3, 1, -7 },
  { 250, 1, 10, 4, 1, -8 },
  { 252, 3, 9, 3, 0, -7 },
  { 256, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Thin10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN10PT7B_H_
