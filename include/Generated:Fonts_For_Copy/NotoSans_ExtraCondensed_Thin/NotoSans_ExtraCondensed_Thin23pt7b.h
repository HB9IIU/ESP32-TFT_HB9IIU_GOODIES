#ifndef _NOTOSANS_EXTRACONDENSED_THIN23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x99, 0x99, 0x99, 0x11, 0x08, 0x84, 0x42, 0x27, 0xF8,
  0x90, 0x48, 0x24, 0x22, 0x11, 0x3F, 0xE4, 0x42, 0x21, 0x20, 0x90, 0x48,
  0x10, 0xFE, 0x44, 0x89, 0x12, 0x24, 0x28, 0x30, 0x38, 0x48, 0x91, 0x22,
  0x44, 0xCA, 0x78, 0x20, 0x60, 0x92, 0x22, 0x44, 0x44, 0x88, 0xA1, 0x14,
  0x22, 0x84, 0x66, 0x95, 0x32, 0xA5, 0x94, 0x85, 0x10, 0xA2, 0x12, 0x44,
  0x48, 0x89, 0x11, 0xC0, 0x30, 0x48, 0x48, 0x48, 0x48, 0x48, 0x48, 0x30,
  0x20, 0x50, 0x91, 0x89, 0x86, 0x86, 0x82, 0x86, 0x79, 0xFC, 0x12, 0x44,
  0x48, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x21, 0x84, 0x22, 0x21, 0x11,
  0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x22, 0x97, 0x8C, 0x48, 0x10, 0x20,
  0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x5A, 0x80, 0xF0, 0x70, 0x04,
  0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x38,
  0x89, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x50,
  0xA2, 0x38, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x79, 0x08,
  0x10, 0x10, 0x20, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x40,
  0xFE, 0x79, 0x08, 0x08, 0x10, 0x20, 0x41, 0x02, 0x38, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x82, 0xF8, 0x02, 0x01, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48,
  0x24, 0x22, 0x11, 0x10, 0x88, 0x4F, 0xF8, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x7D, 0x02, 0x04, 0x08, 0x10, 0x3E, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x41, 0x7C, 0x18, 0x41, 0x02, 0x08, 0x10, 0x20, 0x5E, 0xC3, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xA1, 0x3C, 0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30,
  0x51, 0x14, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x7C, 0x38, 0x8A,
  0x14, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x8C, 0xE8, 0x10, 0x20, 0x81, 0x04,
  0xF0, 0xC0, 0x00, 0x07, 0x40, 0x00, 0x05, 0xA8, 0x02, 0x08, 0x63, 0x08,
  0x08, 0x0C, 0x04, 0x06, 0x04, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x86, 0x10, 0xC1, 0x00, 0x72, 0x20, 0x41, 0x04,
  0x10, 0x82, 0x10, 0x82, 0x08, 0x20, 0x00, 0x08, 0x20, 0x07, 0x01, 0x88,
  0x20, 0x44, 0x02, 0x40, 0x24, 0x71, 0x89, 0x18, 0x91, 0x91, 0x19, 0x11,
  0x91, 0x19, 0x11, 0x89, 0x28, 0xAA, 0x44, 0x44, 0x00, 0x40, 0x02, 0x00,
  0x1F, 0x00, 0x08, 0x0C, 0x05, 0x02, 0x81, 0x41, 0x20, 0x88, 0x44, 0x22,
  0x1F, 0x10, 0x48, 0x24, 0x14, 0x0A, 0x03, 0x01, 0xFD, 0x06, 0x0C, 0x18,
  0x30, 0xA1, 0x7C, 0x85, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x0E, 0x31,
  0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40,
  0x40, 0x20, 0x1F, 0xF8, 0x84, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x3E, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xFA, 0x08, 0x20, 0x82, 0x08, 0x20, 0x0F, 0x04, 0x32, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0xF8, 0x06, 0x01, 0x80, 0x50,
  0x14, 0x04, 0x81, 0x1F, 0xC0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFF,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xE9, 0x24, 0x92, 0x49, 0x24,
  0x97, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x85,
  0x12, 0x24, 0x89, 0x14, 0x28, 0x70, 0xA1, 0x22, 0x44, 0x48, 0x90, 0xA1,
  0x41, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80,
  0x30, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x41, 0x68, 0x2D, 0x05, 0x91, 0x32,
  0x26, 0x44, 0xC9, 0x18, 0xA3, 0x14, 0x62, 0x8C, 0x21, 0x81, 0x81, 0xC1,
  0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x85, 0x83, 0x83,
  0x81, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x24, 0x08, 0x84, 0x1E, 0x00, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x82, 0x08, 0x20, 0x1E,
  0x08, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x90, 0x24, 0x08, 0x84, 0x1E, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0xF9, 0x0A, 0x14, 0x18, 0x30, 0xA1, 0x44, 0xF1, 0x22, 0x44,
  0x48, 0x90, 0xA1, 0x41, 0x3C, 0x86, 0x04, 0x08, 0x10, 0x20, 0x20, 0x30,
  0x18, 0x08, 0x10, 0x20, 0x40, 0x82, 0xF8, 0xFF, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x7C, 0x81, 0x81, 0x81, 0x41, 0x42, 0x42, 0x42, 0x22, 0x22,
  0x24, 0x24, 0x14, 0x14, 0x18, 0x18, 0x08, 0x81, 0x03, 0x02, 0x05, 0x0C,
  0x12, 0x14, 0x24, 0x28, 0x48, 0x50, 0x90, 0xA2, 0x12, 0x44, 0x24, 0x48,
  0x48, 0x90, 0x91, 0x21, 0x22, 0x81, 0x85, 0x03, 0x06, 0x06, 0x08, 0x04,
  0x10, 0x42, 0x84, 0x91, 0x22, 0x43, 0x06, 0x04, 0x18, 0x30, 0x91, 0x24,
  0x48, 0x50, 0xC1, 0x83, 0x05, 0x12, 0x24, 0x45, 0x0A, 0x14, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0xFC, 0x10, 0x82, 0x10, 0x41, 0x08, 0x20,
  0x84, 0x10, 0x42, 0x08, 0x3F, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x41, 0x02,
  0x08, 0x20, 0x41, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x1F, 0x08, 0x0A, 0x04, 0x84, 0x42, 0x22, 0x0B, 0x06, 0xFF, 0x80, 0x91,
  0x10, 0x78, 0x10, 0x41, 0x04, 0xF4, 0x61, 0x86, 0x18, 0x5F, 0x81, 0x02,
  0x04, 0x09, 0x1D, 0x21, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x42,
  0xF8, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x0F, 0x02, 0x04,
  0x08, 0x11, 0x25, 0xD0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xA3,
  0x3A, 0x78, 0x8A, 0x0C, 0x18, 0x3F, 0xE0, 0x40, 0x81, 0x01, 0x01, 0xE0,
  0x19, 0x08, 0x42, 0x13, 0xC4, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00,
  0x7E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x19, 0xD0, 0x20,
  0x40, 0x81, 0x84, 0xF0, 0x82, 0x08, 0x20, 0x93, 0xA8, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x70, 0x15, 0x55, 0x55, 0x40, 0x2C, 0x00,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0xA0, 0x84, 0x21, 0x08, 0x46, 0x52,
  0xA6, 0x39, 0x49, 0x4A, 0x51, 0x88, 0xFF, 0xFF, 0x80, 0xFB, 0xE3, 0x18,
  0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x0A, 0x17, 0xC8, 0x10, 0x20, 0x40, 0x80, 0x3E,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x19, 0xD0, 0x20, 0x40,
  0x81, 0x02, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x7C, 0x21, 0x08, 0x30,
  0x41, 0x08, 0x43, 0xF0, 0x42, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x20, 0xE0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xFD, 0x83,
  0x09, 0x12, 0x24, 0x49, 0x12, 0x14, 0x28, 0x50, 0xC0, 0x80, 0x84, 0x18,
  0x62, 0x46, 0x24, 0x62, 0x4A, 0x24, 0x92, 0x49, 0x42, 0x94, 0x29, 0x43,
  0x08, 0x10, 0x81, 0x08, 0x42, 0x88, 0x91, 0x41, 0x82, 0x04, 0x14, 0x28,
  0x89, 0x14, 0x10, 0x82, 0x85, 0x0A, 0x24, 0x44, 0x89, 0x14, 0x28, 0x30,
  0x40, 0x81, 0x02, 0x04, 0x10, 0x21, 0x80, 0xF1, 0x12, 0x22, 0x44, 0x48,
  0x8F, 0x1C, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0x02, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x31, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x30, 0xF3, 0x1C,
};

const GFXglyph NotoSans_ExtraCondensed_Thin23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 16, 4, 2, -16 },
  { 3, 4, 6, 7, 1, -16 },
  { 6, 9, 16, 10, 0, -16 },
  { 24, 7, 18, 9, 1, -17 },
  { 40, 11, 17, 13, 1, -17 },
  { 64, 8, 17, 9, 1, -17 },
  { 81, 1, 6, 4, 1, -16 },
  { 82, 4, 20, 6, 1, -16 },
  { 92, 4, 20, 6, 1, -16 },
  { 102, 6, 5, 8, 1, -17 },
  { 106, 7, 10, 9, 1, -13 },
  { 115, 2, 5, 4, 1, -2 },
  { 117, 4, 1, 6, 1, -7 },
  { 118, 2, 2, 4, 1, -2 },
  { 119, 6, 16, 8, 1, -16 },
  { 131, 7, 17, 9, 1, -17 },
  { 146, 4, 16, 9, 2, -16 },
  { 154, 7, 17, 9, 1, -17 },
  { 169, 7, 17, 9, 1, -17 },
  { 184, 9, 17, 9, 0, -17 },
  { 204, 7, 16, 9, 1, -16 },
  { 218, 7, 17, 9, 1, -17 },
  { 233, 7, 16, 9, 1, -16 },
  { 247, 7, 17, 9, 1, -17 },
  { 262, 7, 17, 9, 1, -17 },
  { 277, 2, 12, 4, 1, -12 },
  { 280, 2, 15, 4, 1, -12 },
  { 284, 7, 10, 9, 1, -13 },
  { 293, 7, 6, 9, 1, -11 },
  { 299, 7, 10, 9, 1, -13 },
  { 308, 6, 17, 6, 0, -17 },
  { 321, 12, 19, 14, 1, -17 },
  { 350, 9, 16, 9, 0, -16 },
  { 368, 7, 16, 10, 2, -16 },
  { 382, 8, 17, 10, 1, -17 },
  { 399, 8, 16, 11, 2, -16 },
  { 415, 6, 16, 9, 2, -16 },
  { 427, 6, 16, 8, 2, -16 },
  { 439, 10, 17, 12, 1, -17 },
  { 461, 7, 16, 11, 2, -16 },
  { 475, 3, 16, 5, 1, -16 },
  { 481, 4, 20, 4, -1, -16 },
  { 491, 7, 16, 9, 2, -16 },
  { 505, 5, 16, 8, 2, -16 },
  { 515, 11, 16, 15, 2, -16 },
  { 537, 8, 16, 12, 2, -16 },
  { 553, 10, 17, 12, 1, -17 },
  { 575, 6, 16, 9, 2, -16 },
  { 587, 10, 21, 12, 1, -17 },
  { 614, 7, 16, 9, 2, -16 },
  { 628, 7, 17, 9, 1, -17 },
  { 643, 8, 16, 8, 0, -16 },
  { 659, 8, 16, 11, 2, -16 },
  { 675, 8, 16, 8, 0, -16 },
  { 691, 15, 16, 15, 0, -16 },
  { 721, 7, 16, 8, 0, -16 },
  { 735, 7, 16, 7, 0, -16 },
  { 749, 6, 16, 7, 1, -16 },
  { 761, 4, 20, 7, 2, -16 },
  { 771, 6, 16, 8, 1, -16 },
  { 783, 4, 20, 7, 1, -16 },
  { 793, 9, 7, 9, 0, -16 },
  { 801, 9, 1, 9, 0, 2 },
  { 803, 3, 4, 5, 1, -18 },
  { 805, 6, 12, 8, 1, -12 },
  { 814, 7, 17, 10, 2, -17 },
  { 829, 6, 12, 7, 1, -12 },
  { 838, 7, 17, 10, 1, -17 },
  { 853, 7, 12, 9, 1, -12 },
  { 864, 5, 18, 5, 0, -18 },
  { 876, 7, 18, 10, 1, -12 },
  { 892, 6, 17, 9, 2, -17 },
  { 905, 2, 17, 4, 1, -17 },
  { 910, 3, 23, 4, 0, -17 },
  { 919, 5, 17, 7, 2, -17 },
  { 930, 1, 17, 4, 1, -17 },
  { 933, 10, 12, 14, 2, -12 },
  { 948, 6, 12, 9, 2, -12 },
  { 957, 7, 12, 9, 1, -12 },
  { 968, 7, 17, 10, 2, -12 },
  { 983, 7, 17, 10, 1, -12 },
  { 998, 4, 12, 6, 2, -12 },
  { 1004, 5, 12, 7, 1, -12 },
  { 1012, 5, 15, 5, 0, -15 },
  { 1022, 6, 12, 9, 2, -12 },
  { 1031, 7, 12, 7, 0, -12 },
  { 1042, 12, 12, 12, 0, -12 },
  { 1060, 7, 12, 7, 0, -12 },
  { 1071, 7, 18, 7, 0, -12 },
  { 1087, 4, 12, 6, 1, -12 },
  { 1093, 6, 20, 8, 1, -16 },
  { 1108, 1, 24, 9, 4, -18 },
  { 1111, 6, 20, 8, 1, -16 },
  { 1126, 7, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Thin23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN23PT7B_H_
