#ifndef _NOTOSANS_EXTRACONDENSED_THIN53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C,
  0x00, 0x00, 0x6F, 0x80, 0xC1, 0xE0, 0xF0, 0x68, 0x34, 0x1A, 0x05, 0x02,
  0x81, 0x40, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x04, 0x01, 0x80, 0x80, 0x18,
  0x08, 0x01, 0x81, 0x80, 0x10, 0x18, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01,
  0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x30, 0x10, 0x03, 0x01, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x20, 0x30, 0x02, 0x02, 0x00, 0x20, 0x20,
  0x02, 0x02, 0x00, 0x20, 0x20, 0x06, 0x02, 0x00, 0x60, 0x20, 0x06, 0x06,
  0x00, 0x40, 0x60, 0x04, 0x06, 0x00, 0x40, 0x40, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x04, 0x04, 0x00, 0xC0, 0x40, 0x0C, 0x04, 0x00, 0xC0, 0xC0, 0x08,
  0x0C, 0x00, 0x80, 0xC0, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00,
  0x80, 0x80, 0x18, 0x08, 0x01, 0x81, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x01, 0xFF, 0x81, 0x98, 0xF1, 0x8C, 0x11, 0x86, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0x40, 0xC0, 0x20, 0x60, 0x10, 0x30, 0x08, 0x18, 0x04, 0x0C,
  0x03, 0x06, 0x01, 0x83, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x06, 0x60, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x06, 0xE0, 0x03, 0x18, 0x01, 0x86,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x04, 0x06,
  0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x40, 0x30, 0x6C,
  0x18, 0xE3, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x1F, 0x00, 0x10, 0x0C, 0x60, 0x0C, 0x02, 0x08, 0x02,
  0x01, 0x83, 0x00, 0x80, 0x40, 0x40, 0x60, 0x10, 0x10, 0x10, 0x04, 0x04,
  0x04, 0x01, 0x01, 0x03, 0x00, 0xC0, 0x60, 0x80, 0x30, 0x18, 0x20, 0x0C,
  0x06, 0x18, 0x03, 0x01, 0x84, 0x00, 0xC0, 0x61, 0x00, 0x30, 0x18, 0xC0,
  0x04, 0x06, 0x20, 0x01, 0x01, 0x08, 0x78, 0x40, 0x46, 0x23, 0x10, 0x11,
  0x10, 0x64, 0x04, 0x44, 0x09, 0x83, 0x33, 0x02, 0x20, 0x88, 0x80, 0x8C,
  0x62, 0x20, 0x31, 0xF1, 0x88, 0x0C, 0x00, 0x42, 0x03, 0x00, 0x10, 0x80,
  0x40, 0x0C, 0x20, 0x10, 0x02, 0x08, 0x04, 0x00, 0x82, 0x01, 0x00, 0x60,
  0x80, 0x40, 0x10, 0x20, 0x30, 0x04, 0x08, 0x0C, 0x03, 0x02, 0x03, 0x00,
  0x80, 0x80, 0x80, 0x20, 0x30, 0x20, 0x18, 0x04, 0x08, 0x04, 0x01, 0x06,
  0x01, 0x00, 0x21, 0x00, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x18, 0x01,
  0x82, 0x00, 0x40, 0xC0, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40,
  0x40, 0x10, 0x10, 0x04, 0x04, 0x01, 0x01, 0x00, 0x40, 0xC0, 0x08, 0x20,
  0x02, 0x08, 0x00, 0xC4, 0x00, 0x13, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x64, 0x00, 0x31, 0x80, 0x08, 0x20, 0x06, 0x0C, 0x09, 0x01,
  0x02, 0xC0, 0x20, 0xA0, 0x08, 0x28, 0x01, 0x0A, 0x00, 0x66, 0x80, 0x09,
  0x20, 0x03, 0x48, 0x00, 0x72, 0x00, 0x18, 0x80, 0x06, 0x30, 0x01, 0x44,
  0x00, 0x99, 0x80, 0x62, 0x30, 0x70, 0xC7, 0xF0, 0x10, 0x20, 0x00, 0xFD,
  0x55, 0x55, 0x50, 0x01, 0x81, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x0C, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x06, 0x00, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xC1, 0x0C, 0xC4, 0xC0, 0xFC, 0x00,
  0xC0, 0x06, 0x80, 0x33, 0x00, 0x84, 0x04, 0x08, 0x20, 0x10, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x13, 0x33, 0x32, 0x66, 0x44, 0xC8, 0xFF, 0xF0,
  0x7D, 0x80, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xF0, 0x0E, 0x18, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04,
  0x30, 0x06, 0x20, 0x02, 0x20, 0x02, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x20, 0x02, 0x20, 0x02, 0x30, 0x06, 0x10, 0x06, 0x18, 0x04,
  0x08, 0x0C, 0x0E, 0x18, 0x03, 0xF0, 0x01, 0x81, 0xC1, 0xE1, 0xB1, 0x99,
  0x8F, 0x06, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x1F, 0xE0, 0x38, 0x38, 0x40, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0x1F, 0xE0, 0x70, 0x38, 0xC0, 0x0C, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0xE0, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0xE0, 0x38, 0x7F, 0xF0, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00,
  0x6C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x18, 0xC0, 0x02,
  0x18, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30,
  0x30, 0x06, 0x06, 0x00, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80,
  0x60, 0x20, 0x0C, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x60, 0x06, 0x08, 0x00,
  0xC3, 0x00, 0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x7F, 0xFC, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x83, 0x00, 0xFF, 0xE0, 0xC0, 0x38, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x08, 0x80, 0x18, 0xC0, 0x70, 0x7F, 0xC0, 0x01, 0xFC,
  0x07, 0x04, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x87, 0xE0, 0x9C, 0x30, 0xB0, 0x08, 0xA0, 0x0C,
  0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02,
  0xC0, 0x02, 0x40, 0x06, 0x40, 0x04, 0x60, 0x04, 0x30, 0x08, 0x18, 0x18,
  0x0F, 0xF0, 0x03, 0x80, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x0E, 0x0E,
  0x04, 0x01, 0x04, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x00, 0x04, 0x80,
  0x02, 0x40, 0x01, 0x20, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x21,
  0x80, 0x30, 0x60, 0x30, 0x18, 0x30, 0x06, 0x70, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xC6, 0x00, 0xC1, 0x80, 0xC0, 0x60, 0xC0, 0x18, 0xC0, 0x04, 0x40,
  0x03, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x20, 0x01, 0x98, 0x00, 0xC6, 0x00,
  0xC1, 0x80, 0xC0, 0x7F, 0xC0, 0x02, 0x00, 0x07, 0xE0, 0x18, 0x38, 0x30,
  0x08, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x05, 0x60, 0x05, 0x30,
  0x09, 0x18, 0x19, 0x0F, 0xF3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x3F, 0xC0, 0x04,
  0x00, 0x7D, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xB0,
  0x33, 0x31, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x33, 0x33, 0x26, 0x64, 0x4C, 0x80, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x20, 0x00, 0x00, 0x7F, 0x0C, 0x1C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x01,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x18, 0x03, 0x80, 0x18,
  0x00, 0x30, 0x04, 0x00, 0x04, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30,
  0x40, 0x00, 0x04, 0x30, 0x00, 0x01, 0x08, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x09, 0x80, 0x3F, 0x02, 0x40, 0x38, 0xC0, 0xD0, 0x08, 0x30, 0x34, 0x06,
  0x0C, 0x07, 0x01, 0x03, 0x01, 0xC0, 0xC0, 0xC0, 0x70, 0x20, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x18, 0x08, 0x06, 0x06, 0x02, 0x01, 0x81, 0x80, 0x80, 0x60, 0x20,
  0x20, 0x38, 0x08, 0x18, 0x0F, 0x02, 0x05, 0x02, 0xC0, 0xC1, 0x41, 0xB0,
  0x10, 0xD0, 0x64, 0x06, 0x67, 0x71, 0x00, 0xF0, 0xF8, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xF0, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x09, 0x00,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x01, 0x08,
  0x00, 0x30, 0xC0, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x60,
  0x60, 0x06, 0x02, 0x00, 0x40, 0x20, 0x04, 0x02, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x10, 0x0F, 0xFF, 0x01, 0x80, 0x18, 0x18, 0x01, 0x81,
  0x00, 0x08, 0x10, 0x00, 0x83, 0x00, 0x0C, 0x30, 0x00, 0xC2, 0x00, 0x04,
  0x20, 0x00, 0x42, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00,
  0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xE0, 0x60, 0xFC,
  0x30, 0x03, 0x18, 0x00, 0xCC, 0x00, 0x26, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x26,
  0x00, 0x13, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x18, 0x7F, 0xF8, 0x3F, 0xFC,
  0x18, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x02, 0xC0,
  0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x05, 0x80, 0x02, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01, 0x98, 0x01,
  0x8C, 0x07, 0x87, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xE0, 0x70, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0xC0, 0x3F, 0xE0, 0x00, 0x80, 0xFF, 0x80, 0x30,
  0xFC, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00,
  0x13, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02,
  0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x01, 0x8C, 0x00, 0xC3, 0x00, 0x60, 0xC0, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0xB0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x07, 0x01, 0xE0, 0x70, 0x01, 0x83, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x32,
  0x00, 0x00, 0xCC, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0xC1, 0x80, 0x03, 0x03, 0x80, 0x3C, 0x03, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x02, 0x8E, 0xFC, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0xC0, 0xC0,
  0xC0, 0x80, 0xC1, 0x80, 0xC1, 0x00, 0xC3, 0x00, 0xC6, 0x00, 0xC4, 0x00,
  0xCC, 0x00, 0xCC, 0x00, 0xD6, 0x00, 0xF6, 0x00, 0xE3, 0x00, 0xE3, 0x00,
  0xC1, 0x00, 0xC1, 0x80, 0xC0, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0xC0, 0x60,
  0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x10, 0xC0, 0x18, 0xC0, 0x08, 0xC0, 0x0C,
  0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFC, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x07, 0xA0,
  0x00, 0x01, 0x6C, 0x00, 0x00, 0x5D, 0x00, 0x00, 0x37, 0x40, 0x00, 0x0D,
  0xD8, 0x00, 0x02, 0x72, 0x00, 0x01, 0x9C, 0x80, 0x00, 0x67, 0x30, 0x00,
  0x11, 0xC4, 0x00, 0x04, 0x71, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x87, 0x18,
  0x00, 0x21, 0xC2, 0x00, 0x18, 0x70, 0x80, 0x06, 0x1C, 0x30, 0x01, 0x07,
  0x04, 0x00, 0xC1, 0xC1, 0x00, 0x30, 0x70, 0x60, 0x08, 0x1C, 0x08, 0x02,
  0x07, 0x02, 0x01, 0x81, 0xC0, 0xC0, 0x40, 0x70, 0x30, 0x10, 0x1C, 0x04,
  0x0C, 0x07, 0x01, 0x02, 0x01, 0xC0, 0x60, 0x80, 0x70, 0x08, 0x60, 0x1C,
  0x02, 0x18, 0x07, 0x00, 0xC4, 0x01, 0xC0, 0x13, 0x00, 0x70, 0x04, 0xC0,
  0x1C, 0x01, 0xA0, 0x07, 0x00, 0x68, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x10, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xD0, 0x00, 0x3F,
  0x00, 0x07, 0xA0, 0x00, 0xF6, 0x00, 0x1E, 0x40, 0x03, 0xC8, 0x00, 0x78,
  0x80, 0x0F, 0x10, 0x01, 0xE3, 0x00, 0x3C, 0x20, 0x07, 0x86, 0x00, 0xF0,
  0x40, 0x1E, 0x0C, 0x03, 0xC0, 0x80, 0x78, 0x10, 0x0F, 0x03, 0x01, 0xE0,
  0x20, 0x3C, 0x06, 0x07, 0x80, 0x40, 0xF0, 0x0C, 0x1E, 0x00, 0x83, 0xC0,
  0x18, 0x78, 0x01, 0x0F, 0x00, 0x21, 0xE0, 0x06, 0x3C, 0x00, 0x47, 0x80,
  0x0C, 0xF0, 0x00, 0x9E, 0x00, 0x1B, 0xC0, 0x01, 0x78, 0x00, 0x2F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x01, 0xFE, 0x00,
  0x38, 0x38, 0x03, 0x00, 0x60, 0x30, 0x01, 0x81, 0x00, 0x06, 0x18, 0x00,
  0x30, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00,
  0x01, 0x20, 0x00, 0x09, 0x80, 0x00, 0xC4, 0x00, 0x06, 0x30, 0x00, 0x20,
  0x80, 0x03, 0x06, 0x00, 0x30, 0x18, 0x03, 0x00, 0x70, 0x30, 0x01, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0x01, 0x8F, 0xC3, 0x00, 0xE6, 0x00, 0x6C,
  0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x05,
  0x80, 0x1B, 0x00, 0x66, 0x01, 0x8F, 0xFE, 0x1F, 0xE0, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x38, 0x18, 0x03, 0x00, 0x60,
  0x30, 0x01, 0x81, 0x00, 0x06, 0x18, 0x00, 0x30, 0x80, 0x00, 0x8C, 0x00,
  0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0x20, 0x00, 0x09, 0x80,
  0x00, 0xC4, 0x00, 0x06, 0x30, 0x00, 0x20, 0x80, 0x03, 0x06, 0x00, 0x30,
  0x18, 0x03, 0x00, 0x60, 0x30, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0xFF, 0x80, 0xC7, 0xE0,
  0xC0, 0x38, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x30, 0xC1, 0xE0,
  0xFF, 0x80, 0xC1, 0x80, 0xC0, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0xC0, 0x60,
  0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x10, 0xC0, 0x18, 0xC0, 0x08,
  0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x01,
  0x07, 0xFC, 0x0C, 0x07, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0xE0, 0x18, 0x7F, 0xF0, 0x02, 0x00, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00, 0x66, 0x00, 0x10, 0xC0, 0x0C,
  0x1C, 0x0E, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x80, 0x00, 0x38, 0x00, 0x05,
  0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x11,
  0x00, 0x06, 0x20, 0x00, 0x84, 0x00, 0x10, 0xC0, 0x02, 0x08, 0x00, 0xC1,
  0x00, 0x18, 0x20, 0x02, 0x06, 0x00, 0x40, 0x40, 0x18, 0x08, 0x03, 0x01,
  0x00, 0x40, 0x30, 0x08, 0x06, 0x03, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01,
  0x81, 0x00, 0x30, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x08, 0x20, 0x01,
  0x84, 0x00, 0x11, 0x80, 0x02, 0x30, 0x00, 0x44, 0x00, 0x0C, 0x80, 0x01,
  0xB0, 0x00, 0x16, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xD0, 0x00, 0x30, 0x00, 0x34, 0x00,
  0x0C, 0x00, 0x0D, 0x00, 0x03, 0x00, 0x02, 0x60, 0x01, 0xE0, 0x00, 0x98,
  0x00, 0x78, 0x00, 0x62, 0x00, 0x1A, 0x00, 0x18, 0x80, 0x04, 0x80, 0x04,
  0x20, 0x01, 0x20, 0x01, 0x0C, 0x00, 0x4C, 0x00, 0x43, 0x00, 0x33, 0x00,
  0x30, 0x40, 0x0C, 0x40, 0x0C, 0x10, 0x02, 0x10, 0x02, 0x06, 0x00, 0x84,
  0x00, 0x81, 0x80, 0x21, 0x80, 0x60, 0x20, 0x18, 0x60, 0x18, 0x08, 0x06,
  0x08, 0x04, 0x02, 0x01, 0x02, 0x01, 0x00, 0xC0, 0x40, 0x80, 0x40, 0x30,
  0x10, 0x30, 0x30, 0x04, 0x0C, 0x0C, 0x0C, 0x01, 0x03, 0x01, 0x02, 0x00,
  0x60, 0x80, 0x40, 0x80, 0x18, 0x20, 0x10, 0x60, 0x06, 0x08, 0x06, 0x18,
  0x00, 0x86, 0x01, 0x84, 0x00, 0x21, 0x80, 0x21, 0x00, 0x0C, 0x40, 0x08,
  0x40, 0x03, 0x10, 0x02, 0x30, 0x00, 0x44, 0x00, 0xCC, 0x00, 0x13, 0x00,
  0x32, 0x00, 0x04, 0xC0, 0x04, 0x80, 0x01, 0xA0, 0x01, 0x20, 0x00, 0x68,
  0x00, 0x58, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x40, 0x03, 0x60, 0x03,
  0x20, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x04, 0x18, 0x0C, 0x18, 0x08,
  0x08, 0x18, 0x0C, 0x10, 0x04, 0x10, 0x04, 0x30, 0x06, 0x20, 0x02, 0x60,
  0x02, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x20, 0x04, 0x30,
  0x0C, 0x10, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C,
  0x20, 0x04, 0x60, 0x04, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x21, 0x00,
  0x10, 0xC0, 0x18, 0x60, 0x08, 0x10, 0x04, 0x08, 0x06, 0x06, 0x02, 0x01,
  0x01, 0x00, 0x81, 0x80, 0x60, 0x80, 0x10, 0x40, 0x08, 0x60, 0x06, 0x20,
  0x01, 0x10, 0x00, 0x98, 0x00, 0x68, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x7F, 0xFE, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xF0, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0xFF, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0xC0,
  0x00, 0x48, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC2, 0x00, 0x30, 0x60,
  0x06, 0x04, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x0C, 0x01, 0x81, 0x80, 0x10,
  0x60, 0x03, 0x0C, 0x00, 0x23, 0x00, 0x06, 0x60, 0x00, 0x58, 0x00, 0x0C,
  0xFF, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x02, 0x01, 0x1F,
  0xE0, 0xC0, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFC, 0x1E, 0x31,
  0x80, 0xCC, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x05, 0x40, 0x15, 0x80, 0xD3, 0x06, 0x47, 0xF1,
  0x06, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x8F, 0xF0, 0x98, 0x18, 0xB0, 0x0C, 0xA0, 0x04, 0xE0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02,
  0xE0, 0x06, 0xA0, 0x04, 0xB0, 0x0C, 0x98, 0x38, 0x8F, 0xF0, 0x01, 0x00,
  0x03, 0xFC, 0x38, 0x20, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x41,
  0xFE, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x7F, 0x18, 0x60, 0xCC, 0x60, 0x16, 0x60,
  0x0F, 0x30, 0x03, 0x90, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x1A,
  0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0xE4, 0x00, 0x53, 0x00, 0x68, 0x80, 0x24,
  0x30, 0x62, 0x0F, 0xE1, 0x01, 0x80, 0x00, 0x07, 0xF0, 0x0C, 0x18, 0x18,
  0x0C, 0x30, 0x04, 0x20, 0x06, 0x20, 0x02, 0x60, 0x02, 0x60, 0x02, 0x40,
  0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x02, 0x0C,
  0x06, 0x07, 0xFC, 0x00, 0x40, 0x00, 0x80, 0x7F, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x0F, 0xF8, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0x07, 0xF0, 0x86, 0x0E, 0x46,
  0x01, 0x66, 0x00, 0x72, 0x00, 0x39, 0x00, 0x0D, 0x80, 0x06, 0x80, 0x03,
  0x40, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x68,
  0x00, 0x34, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0E, 0x40, 0x07, 0x30, 0x05,
  0x88, 0x06, 0xC3, 0x06, 0x60, 0xFE, 0x30, 0x18, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x31, 0x80, 0x30, 0x7F, 0xF0, 0x07, 0xC0, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x8F, 0xE2, 0x60, 0xC9,
  0x01, 0xA8, 0x02, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x7D, 0x80, 0x00,
  0x01, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80,
  0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x1B, 0xCE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x03,
  0x40, 0x12, 0x01, 0x90, 0x08, 0x80, 0x84, 0x0C, 0x20, 0x41, 0x06, 0x08,
  0x60, 0x42, 0x02, 0x30, 0x11, 0x80, 0x96, 0x05, 0x90, 0x28, 0x81, 0xC6,
  0x0C, 0x10, 0x40, 0xC2, 0x02, 0x10, 0x10, 0x80, 0xC4, 0x02, 0x20, 0x19,
  0x00, 0x48, 0x02, 0x40, 0x1A, 0x00, 0x50, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xC1, 0xFC, 0x4C, 0x31, 0x83, 0x2C, 0x0C, 0x80, 0xD4, 0x02,
  0x80, 0x6C, 0x01, 0x40, 0x16, 0x00, 0xE0, 0x0B, 0x00, 0x60, 0x05, 0x00,
  0x30, 0x03, 0x80, 0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00, 0x70,
  0x01, 0x00, 0x38, 0x00, 0x80, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x20, 0x07,
  0x00, 0x10, 0x03, 0x80, 0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02, 0x00,
  0x70, 0x01, 0x00, 0x38, 0x00, 0x80, 0x1C, 0x00, 0x40, 0x0E, 0x00, 0x20,
  0x07, 0x00, 0x10, 0x03, 0x80, 0x08, 0x01, 0xC0, 0x04, 0x00, 0xE0, 0x02,
  0x00, 0x70, 0x01, 0x00, 0x30, 0x8F, 0xE2, 0x60, 0xCB, 0x01, 0xA8, 0x02,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x07, 0xF8, 0x06, 0x0E, 0x06, 0x01,
  0x86, 0x00, 0xC2, 0x00, 0x33, 0x00, 0x19, 0x80, 0x04, 0x80, 0x02, 0x40,
  0x01, 0xA0, 0x00, 0xD0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00,
  0x34, 0x00, 0x13, 0x00, 0x09, 0x80, 0x0C, 0x40, 0x06, 0x30, 0x02, 0x0C,
  0x03, 0x03, 0x03, 0x00, 0xFF, 0x00, 0x0C, 0x00, 0x8F, 0xF0, 0x9C, 0x18,
  0x90, 0x0C, 0xA0, 0x04, 0xA0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xA0, 0x06, 0xA0, 0x04, 0xB0, 0x0C,
  0x98, 0x18, 0x8F, 0xE0, 0x81, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x86, 0x0C, 0x46, 0x01, 0x22, 0x00,
  0xF3, 0x00, 0x39, 0x00, 0x1D, 0x80, 0x06, 0x80, 0x03, 0x40, 0x01, 0xA0,
  0x00, 0xD0, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD0, 0x00, 0x68, 0x00, 0x34, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x0E, 0x40, 0x07, 0x30, 0x05, 0x8C, 0x06, 0xC3,
  0x06, 0x60, 0xFE, 0x30, 0x08, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x8F, 0xCC, 0x64, 0x14, 0x0A, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x00, 0x1F, 0xF1, 0x80, 0xD8, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x14, 0x01, 0xB0, 0x18, 0xFF, 0x80, 0x40,
  0x00, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x41, 0xFF, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x0C, 0x03, 0xE0, 0x40, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x05,
  0xC0, 0x15, 0x00, 0x96, 0x06, 0x4F, 0xE1, 0x04, 0x00, 0xC0, 0x02, 0x80,
  0x0D, 0x00, 0x1B, 0x00, 0x26, 0x00, 0x44, 0x00, 0x88, 0x03, 0x10, 0x04,
  0x30, 0x08, 0x60, 0x10, 0x40, 0x60, 0x80, 0xC1, 0x81, 0x03, 0x02, 0x02,
  0x0C, 0x04, 0x18, 0x0C, 0x20, 0x18, 0x40, 0x11, 0x80, 0x23, 0x00, 0x44,
  0x00, 0xC8, 0x00, 0x90, 0x01, 0x60, 0x02, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x00, 0x28, 0x01, 0xC0, 0x0B,
  0x00, 0x70, 0x02, 0x40, 0x14, 0x01, 0x90, 0x05, 0x80, 0x44, 0x01, 0x20,
  0x11, 0x80, 0xC8, 0x04, 0x60, 0x32, 0x03, 0x08, 0x08, 0xC0, 0xC2, 0x02,
  0x30, 0x20, 0x81, 0x84, 0x08, 0x30, 0x61, 0x02, 0x04, 0x10, 0x41, 0x81,
  0x04, 0x18, 0x40, 0x41, 0x06, 0x10, 0x18, 0xC0, 0x84, 0x06, 0x30, 0x23,
  0x00, 0x88, 0x08, 0xC0, 0x22, 0x03, 0x20, 0x08, 0x80, 0xC8, 0x03, 0x60,
  0x12, 0x00, 0x58, 0x05, 0x80, 0x14, 0x01, 0x40, 0x05, 0x00, 0x70, 0x01,
  0xC0, 0x0C, 0x00, 0x70, 0x03, 0x00, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0xC0,
  0x18, 0x80, 0x21, 0x00, 0xC3, 0x01, 0x82, 0x02, 0x06, 0x0C, 0x04, 0x10,
  0x0C, 0x60, 0x08, 0x80, 0x1B, 0x00, 0x14, 0x00, 0x38, 0x00, 0x20, 0x00,
  0xE0, 0x01, 0x40, 0x06, 0xC0, 0x08, 0x80, 0x31, 0x00, 0x43, 0x01, 0x82,
  0x02, 0x06, 0x0C, 0x04, 0x18, 0x0C, 0x20, 0x08, 0xC0, 0x19, 0x00, 0x16,
  0x00, 0x30, 0xC0, 0x02, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x26, 0x00, 0x44,
  0x01, 0x88, 0x03, 0x10, 0x04, 0x30, 0x08, 0x20, 0x30, 0x40, 0x60, 0x80,
  0x81, 0x81, 0x01, 0x06, 0x02, 0x0C, 0x04, 0x10, 0x0C, 0x20, 0x08, 0xC0,
  0x11, 0x80, 0x22, 0x00, 0x64, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x40, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x80, 0x06, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01,
  0x00, 0xC0, 0x20, 0x08, 0x03, 0xFF, 0x00, 0x38, 0x0F, 0x80, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xC0, 0x06, 0x01, 0xE0, 0x1E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x0F, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x01, 0xC0,
  0x78, 0x00, 0x3E, 0x00, 0x5D, 0xE0, 0x18, 0x0E, 0x1A, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 38, 10, 4, -38 },
  { 16, 9, 14, 16, 3, -38 },
  { 32, 20, 38, 22, 1, -38 },
  { 127, 17, 43, 21, 2, -40 },
  { 219, 26, 38, 30, 2, -38 },
  { 343, 18, 39, 20, 2, -38 },
  { 431, 2, 14, 9, 3, -38 },
  { 435, 9, 46, 14, 3, -38 },
  { 487, 9, 46, 14, 2, -38 },
  { 539, 14, 13, 18, 2, -40 },
  { 562, 18, 24, 21, 2, -31 },
  { 616, 4, 12, 9, 2, -5 },
  { 622, 12, 1, 14, 1, -15 },
  { 624, 3, 3, 10, 3, -3 },
  { 626, 15, 38, 17, 1, -38 },
  { 698, 16, 38, 21, 2, -38 },
  { 774, 9, 38, 21, 4, -38 },
  { 817, 16, 38, 21, 2, -38 },
  { 893, 16, 39, 21, 2, -38 },
  { 971, 19, 38, 21, 1, -38 },
  { 1062, 16, 38, 21, 3, -38 },
  { 1138, 16, 39, 21, 3, -38 },
  { 1216, 16, 38, 21, 2, -38 },
  { 1292, 17, 39, 21, 2, -38 },
  { 1375, 16, 39, 21, 2, -38 },
  { 1453, 3, 28, 10, 3, -28 },
  { 1464, 4, 35, 9, 2, -28 },
  { 1482, 18, 22, 21, 2, -30 },
  { 1532, 18, 13, 21, 2, -25 },
  { 1562, 18, 22, 21, 2, -30 },
  { 1612, 12, 38, 14, 1, -38 },
  { 1669, 26, 43, 32, 3, -38 },
  { 1809, 20, 38, 20, 0, -38 },
  { 1904, 17, 38, 23, 4, -38 },
  { 1985, 18, 39, 22, 3, -38 },
  { 2073, 18, 38, 25, 4, -38 },
  { 2159, 14, 38, 20, 4, -38 },
  { 2226, 14, 38, 19, 4, -38 },
  { 2293, 22, 39, 28, 3, -38 },
  { 2401, 18, 38, 26, 4, -38 },
  { 2487, 8, 38, 12, 2, -38 },
  { 2525, 8, 47, 10, -2, -38 },
  { 2572, 16, 38, 20, 4, -38 },
  { 2648, 13, 38, 18, 4, -38 },
  { 2710, 26, 38, 35, 4, -38 },
  { 2834, 19, 38, 27, 4, -38 },
  { 2925, 21, 39, 27, 3, -38 },
  { 3028, 15, 38, 21, 4, -38 },
  { 3100, 21, 47, 27, 3, -38 },
  { 3224, 16, 38, 21, 4, -38 },
  { 3300, 16, 39, 21, 2, -38 },
  { 3378, 17, 38, 18, 0, -38 },
  { 3459, 18, 39, 26, 4, -38 },
  { 3547, 19, 38, 19, 0, -38 },
  { 3638, 34, 38, 34, 0, -38 },
  { 3800, 16, 38, 18, 1, -38 },
  { 3876, 17, 38, 17, 0, -38 },
  { 3957, 15, 38, 17, 1, -38 },
  { 4029, 10, 46, 16, 4, -38 },
  { 4087, 15, 38, 17, 1, -38 },
  { 4159, 10, 46, 16, 2, -38 },
  { 4217, 19, 18, 21, 1, -38 },
  { 4260, 21, 1, 21, 0, 5 },
  { 4263, 8, 8, 12, 2, -40 },
  { 4271, 14, 29, 19, 2, -28 },
  { 4322, 16, 41, 22, 4, -40 },
  { 4404, 14, 29, 17, 2, -28 },
  { 4455, 17, 41, 22, 2, -40 },
  { 4543, 16, 29, 20, 2, -28 },
  { 4601, 12, 41, 11, 1, -41 },
  { 4663, 17, 41, 22, 2, -28 },
  { 4751, 14, 40, 22, 4, -40 },
  { 4821, 3, 38, 9, 3, -38 },
  { 4836, 6, 51, 9, 0, -38 },
  { 4875, 13, 40, 17, 4, -40 },
  { 4940, 1, 40, 9, 4, -40 },
  { 4945, 25, 28, 32, 4, -28 },
  { 5033, 14, 28, 22, 4, -28 },
  { 5082, 17, 29, 21, 2, -28 },
  { 5144, 16, 40, 22, 4, -28 },
  { 5224, 17, 40, 22, 2, -28 },
  { 5309, 9, 28, 14, 4, -28 },
  { 5341, 13, 29, 17, 2, -28 },
  { 5389, 9, 36, 11, 1, -35 },
  { 5430, 14, 29, 22, 4, -28 },
  { 5481, 15, 28, 16, 0, -28 },
  { 5534, 26, 28, 27, 1, -28 },
  { 5625, 15, 28, 17, 1, -28 },
  { 5678, 15, 41, 17, 1, -28 },
  { 5755, 10, 28, 14, 2, -28 },
  { 5790, 13, 46, 18, 3, -38 },
  { 5865, 2, 53, 20, 9, -40 },
  { 5879, 13, 46, 18, 3, -38 },
  { 5954, 18, 4, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_Thin53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN53PT7B_H_
