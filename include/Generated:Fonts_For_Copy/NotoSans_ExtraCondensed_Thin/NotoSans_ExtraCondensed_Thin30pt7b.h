#ifndef _NOTOSANS_EXTRACONDENSED_THIN30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin30pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x03, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x20,
  0x08, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x21, 0x3F, 0xF8, 0x88, 0x11,
  0x02, 0x20, 0x84, 0x10, 0x82, 0x11, 0xFF, 0x88, 0x41, 0x08, 0x22, 0x04,
  0x40, 0x88, 0x21, 0x04, 0x20, 0x08, 0x02, 0x03, 0xF1, 0x22, 0x88, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x12, 0x06, 0x80, 0x60, 0x0C, 0x02, 0xC0, 0x88,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0xBF, 0xC0, 0x80, 0x20, 0x08,
  0x00, 0x10, 0x00, 0x90, 0x41, 0x10, 0x84, 0x21, 0x08, 0x44, 0x10, 0x88,
  0x21, 0x10, 0x42, 0x40, 0x84, 0x81, 0x09, 0x71, 0x14, 0x92, 0x2A, 0x14,
  0x94, 0x22, 0x48, 0x40, 0x90, 0x81, 0x21, 0x04, 0x42, 0x08, 0x84, 0x11,
  0x08, 0x42, 0x10, 0x82, 0x41, 0x07, 0x00, 0x08, 0x04, 0x80, 0x88, 0x21,
  0x04, 0x20, 0x44, 0x08, 0x81, 0x10, 0x24, 0x03, 0x00, 0x40, 0x14, 0x04,
  0x80, 0x88, 0xA0, 0x94, 0x12, 0x81, 0x50, 0x32, 0x02, 0x40, 0xC4, 0x24,
  0x78, 0xC0, 0xFE, 0x19, 0x08, 0x84, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x04, 0x20, 0x84, 0x10, 0x40, 0xC2, 0x08, 0x41, 0x08,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x08, 0x84, 0x44,
  0x00, 0x08, 0x08, 0x08, 0xEF, 0x18, 0x14, 0x24, 0x42, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x00, 0x29, 0x25, 0x20, 0xFC, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0x40, 0x80, 0x80, 0x0C, 0x19, 0x08, 0x48, 0x14, 0x0A, 0x05, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x81, 0x40, 0xA0,
  0x50, 0x24, 0x22, 0x10, 0xF0, 0x19, 0xD3, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x80, 0x1C, 0x31, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10,
  0x10, 0x08, 0x08, 0x08, 0x08, 0x04, 0x07, 0xFC, 0x3C, 0x21, 0xA0, 0x40,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x01, 0x8F, 0x00, 0xC0, 0x10, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x17, 0xF0, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x08, 0x81, 0x08,
  0x10, 0x81, 0x08, 0x20, 0x82, 0x08, 0x40, 0x84, 0x08, 0xFF, 0xF0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x7F, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x7C, 0x10, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0xFE, 0x00, 0x07, 0x06, 0x21,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x27, 0x8A, 0x13, 0x02,
  0xC0, 0xA0, 0x28, 0x06, 0x01, 0x40, 0x50, 0x24, 0x09, 0x02, 0x21, 0x07,
  0xC0, 0xFF, 0x80, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02,
  0x00, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x21,
  0x04, 0x80, 0xC0, 0x48, 0x21, 0x10, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x05, 0x02, 0x40, 0x8F, 0xC0, 0x1C, 0x11, 0x10, 0x48, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x50, 0x28, 0x32, 0x28, 0xE4, 0x02, 0x01, 0x00,
  0x80, 0x80, 0x40, 0x20, 0x23, 0xE0, 0xC0, 0x03, 0x6C, 0x00, 0x00, 0x00,
  0x00, 0x52, 0x4A, 0x40, 0x00, 0x40, 0x20, 0x30, 0x30, 0x30, 0x30, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x40, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x03, 0x00, 0x80, 0x00, 0x72,
  0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x40,
  0x00, 0x00, 0x61, 0x80, 0x03, 0x80, 0x18, 0xC0, 0x40, 0x41, 0x00, 0x44,
  0x00, 0x88, 0x00, 0xA0, 0x01, 0x41, 0xE2, 0x84, 0x45, 0x10, 0x86, 0x21,
  0x0C, 0x42, 0x18, 0x84, 0x31, 0x08, 0x62, 0x10, 0xC4, 0x62, 0x88, 0xC5,
  0x0A, 0x92, 0x08, 0x44, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C,
  0x20, 0x07, 0x80, 0x04, 0x01, 0x40, 0x28, 0x05, 0x00, 0x90, 0x12, 0x04,
  0x40, 0x88, 0x11, 0x02, 0x10, 0x82, 0x10, 0x43, 0xF8, 0x40, 0x90, 0x12,
  0x02, 0x40, 0x48, 0x06, 0x00, 0xC0, 0x18, 0x02, 0xFF, 0x20, 0x28, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x3F, 0x88, 0x32, 0x02, 0x80,
  0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x04, 0xFE, 0x00, 0x07,
  0x06, 0x32, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80,
  0x30, 0x03, 0xF0, 0xFE, 0x10, 0x22, 0x02, 0x40, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x12, 0x02, 0x40, 0x8F, 0xE0, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x07, 0xC1, 0x83, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x1F, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x01, 0x30, 0x10, 0xFE, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xF8,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x1E, 0x80, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x20, 0x90,
  0x58, 0x2C, 0x19, 0x08, 0x84, 0x22, 0x11, 0x04, 0x82, 0x40, 0xA0, 0x50,
  0x18, 0x08, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1D, 0x00, 0x3A, 0x00, 0xB4, 0x01, 0x64, 0x02,
  0xC8, 0x05, 0x90, 0x13, 0x10, 0x26, 0x20, 0x4C, 0x41, 0x18, 0x42, 0x30,
  0x84, 0x61, 0x10, 0xC2, 0x21, 0x82, 0x43, 0x05, 0x06, 0x0A, 0x0C, 0x0C,
  0x18, 0x18, 0x20, 0xC0, 0x38, 0x06, 0x80, 0xD0, 0x19, 0x03, 0x20, 0x64,
  0x0C, 0x41, 0x88, 0x30, 0x86, 0x10, 0xC1, 0x18, 0x23, 0x02, 0x60, 0x4C,
  0x09, 0x80, 0xB0, 0x16, 0x01, 0xC0, 0x38, 0x02, 0x0E, 0x03, 0x18, 0x60,
  0x44, 0x04, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40,
  0x24, 0x04, 0x20, 0xC1, 0xF8, 0xFE, 0x40, 0xA0, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xA0, 0x9F, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x07, 0x03, 0x08, 0x20, 0x44, 0x04, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02, 0x40, 0x24, 0x04, 0x20,
  0xC1, 0xF0, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0xFE, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x20, 0x4F, 0xE2,
  0x20, 0x84, 0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x48, 0x12, 0x02, 0x80,
  0xC0, 0x0F, 0x18, 0x50, 0x08, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x17, 0xF0, 0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x14, 0x05, 0x02, 0x3F, 0x00, 0x80, 0x30, 0x05, 0x01,
  0x20, 0x24, 0x04, 0x80, 0x90, 0x21, 0x04, 0x20, 0x84, 0x10, 0x82, 0x08,
  0x81, 0x10, 0x22, 0x04, 0x40, 0x50, 0x0A, 0x01, 0x40, 0x28, 0x06, 0x00,
  0x40, 0x80, 0x40, 0x30, 0x08, 0x05, 0x01, 0x80, 0xA0, 0x50, 0x24, 0x0A,
  0x04, 0x81, 0x40, 0x88, 0x24, 0x11, 0x04, 0x82, 0x21, 0x10, 0x84, 0x22,
  0x10, 0x84, 0x42, 0x08, 0x88, 0x41, 0x10, 0x88, 0x24, 0x12, 0x04, 0x82,
  0x40, 0x90, 0x48, 0x0A, 0x09, 0x01, 0x40, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0x40, 0x60, 0x40, 0xC8, 0x22, 0x08, 0x84, 0x11, 0x04, 0x81, 0x20,
  0x28, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x0A, 0x04, 0x81, 0x20, 0x84, 0x21,
  0x08, 0x44, 0x09, 0x02, 0x80, 0x40, 0x80, 0xA0, 0x50, 0x28, 0x22, 0x11,
  0x08, 0x88, 0x24, 0x12, 0x0A, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04,
  0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40,
  0x80, 0x80, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04, 0x04, 0x04,
  0x02, 0x02, 0x02, 0x01, 0x01, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07,
  0xF0, 0x0C, 0x03, 0x01, 0x20, 0x48, 0x21, 0x08, 0x44, 0x09, 0x02, 0x80,
  0x60, 0x10, 0xFF, 0xF0, 0x82, 0x08, 0x20, 0x80, 0x3C, 0x42, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x1F, 0x21, 0x41, 0x81, 0x81, 0x81, 0x81, 0x43, 0x7D,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x3C, 0xA1, 0x60, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0D,
  0x0A, 0xF8, 0x1F, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x40, 0x40, 0x20, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x79, 0x21, 0x50, 0x34, 0x0D, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x14, 0x05, 0x03, 0x40, 0xC8, 0x53, 0xE4, 0x1E,
  0x10, 0x90, 0x48, 0x14, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x82, 0x3E, 0x0E, 0x20, 0x81, 0x02, 0x04, 0x08, 0x7C,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x00, 0x1E, 0x48, 0x54, 0x0D, 0x03, 0x40, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0xD0, 0x32, 0x14, 0x79, 0x00, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x47, 0xE0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x9E, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xFF, 0xFC, 0x24, 0x00, 0x09,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x82, 0x84, 0x84, 0x88, 0x88, 0x90, 0xB0, 0xB0, 0xC8,
  0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x83, 0xFF, 0xFF, 0xFE, 0xBC, 0x7B,
  0x0A, 0x1C, 0x30, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41,
  0x81, 0x06, 0x04, 0x18, 0x10, 0x60, 0x41, 0x81, 0x06, 0x04, 0x18, 0x10,
  0x60, 0x41, 0x9E, 0xA1, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x08, 0x44, 0x09, 0x02, 0x40,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0x90, 0x22,
  0x10, 0x7C, 0x9E, 0x50, 0xB0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0E, 0x06, 0x85, 0x7C, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x1E, 0x48, 0x54, 0x0D, 0x03, 0x40, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x05, 0x01, 0x40, 0xD0, 0x32, 0x14, 0x79,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x9E, 0x8C, 0x30,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3E, 0x82, 0x04,
  0x08, 0x10, 0x10, 0x18, 0x08, 0x08, 0x08, 0x10, 0x20, 0x60, 0xFE, 0x42,
  0x10, 0x8F, 0xA1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x70,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x7D, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x12, 0x10, 0x88,
  0x44, 0x22, 0x11, 0x09, 0x02, 0x81, 0x40, 0xA0, 0x20, 0x10, 0x81, 0x03,
  0x03, 0x05, 0x06, 0x0A, 0x0C, 0x24, 0x28, 0x48, 0x50, 0x88, 0x91, 0x11,
  0x22, 0x24, 0x48, 0x48, 0x90, 0x90, 0xA0, 0xA1, 0x41, 0x43, 0x03, 0x06,
  0x02, 0x0C, 0x04, 0x08, 0x81, 0x82, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10,
  0x18, 0x28, 0x24, 0x24, 0x44, 0x42, 0x82, 0x81, 0x40, 0xA0, 0x50, 0x28,
  0x22, 0x11, 0x08, 0x84, 0x44, 0x12, 0x09, 0x04, 0x82, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x83, 0x80, 0xFC, 0x10,
  0x82, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x3F, 0x0E, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x0C, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x08, 0x18, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x07, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x10, 0xE0, 0x70, 0x63, 0x10, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_Thin30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 7, 9, 2, -21 },
  { 12, 11, 21, 13, 1, -21 },
  { 41, 10, 25, 12, 1, -23 },
  { 73, 15, 22, 17, 1, -22 },
  { 115, 11, 22, 12, 1, -22 },
  { 146, 1, 7, 5, 2, -21 },
  { 147, 5, 26, 8, 2, -21 },
  { 164, 5, 26, 8, 1, -21 },
  { 181, 8, 8, 10, 1, -23 },
  { 189, 10, 13, 12, 1, -17 },
  { 206, 3, 7, 5, 1, -3 },
  { 209, 6, 1, 8, 1, -9 },
  { 210, 1, 2, 5, 2, -2 },
  { 211, 8, 21, 10, 1, -21 },
  { 232, 9, 22, 12, 1, -22 },
  { 257, 5, 21, 12, 2, -21 },
  { 271, 9, 22, 12, 1, -22 },
  { 296, 9, 22, 12, 1, -22 },
  { 321, 12, 22, 12, 0, -22 },
  { 354, 10, 21, 12, 1, -21 },
  { 381, 10, 22, 12, 1, -22 },
  { 409, 9, 21, 12, 1, -21 },
  { 433, 10, 22, 12, 1, -22 },
  { 461, 9, 22, 12, 1, -22 },
  { 486, 1, 16, 5, 2, -16 },
  { 488, 3, 20, 5, 1, -16 },
  { 496, 10, 13, 12, 1, -17 },
  { 513, 10, 7, 12, 1, -14 },
  { 522, 10, 13, 12, 1, -17 },
  { 539, 6, 22, 8, 1, -22 },
  { 556, 15, 25, 18, 2, -22 },
  { 603, 11, 21, 11, 0, -21 },
  { 632, 10, 21, 13, 2, -21 },
  { 659, 10, 22, 12, 2, -22 },
  { 687, 11, 21, 14, 2, -21 },
  { 716, 8, 21, 11, 2, -21 },
  { 737, 8, 21, 11, 2, -21 },
  { 758, 12, 22, 16, 2, -22 },
  { 791, 10, 21, 15, 2, -21 },
  { 818, 4, 21, 7, 1, -21 },
  { 829, 4, 26, 6, -1, -21 },
  { 842, 9, 21, 11, 2, -21 },
  { 866, 8, 21, 10, 2, -21 },
  { 887, 15, 21, 20, 2, -21 },
  { 927, 11, 21, 15, 2, -21 },
  { 956, 12, 22, 15, 2, -22 },
  { 989, 9, 21, 12, 2, -21 },
  { 1013, 12, 27, 15, 2, -22 },
  { 1054, 10, 21, 12, 2, -21 },
  { 1081, 9, 22, 12, 1, -22 },
  { 1106, 10, 21, 10, 0, -21 },
  { 1133, 10, 21, 15, 2, -21 },
  { 1160, 11, 21, 11, 0, -21 },
  { 1189, 19, 21, 19, 0, -21 },
  { 1239, 10, 21, 10, 0, -21 },
  { 1266, 9, 21, 9, 0, -21 },
  { 1290, 8, 21, 10, 1, -21 },
  { 1311, 5, 26, 9, 3, -21 },
  { 1328, 8, 21, 10, 1, -21 },
  { 1349, 6, 26, 9, 1, -21 },
  { 1369, 10, 10, 12, 1, -21 },
  { 1382, 12, 1, 12, 0, 3 },
  { 1384, 5, 5, 7, 1, -23 },
  { 1388, 8, 16, 11, 1, -16 },
  { 1404, 9, 23, 13, 2, -23 },
  { 1430, 8, 16, 9, 1, -16 },
  { 1446, 10, 23, 13, 1, -23 },
  { 1475, 9, 16, 11, 1, -16 },
  { 1493, 7, 23, 6, 0, -23 },
  { 1514, 10, 23, 13, 1, -16 },
  { 1543, 8, 23, 12, 2, -23 },
  { 1566, 1, 22, 5, 2, -22 },
  { 1569, 3, 29, 5, 0, -22 },
  { 1580, 8, 23, 10, 2, -23 },
  { 1603, 1, 23, 5, 2, -23 },
  { 1606, 14, 16, 18, 2, -16 },
  { 1634, 8, 16, 12, 2, -16 },
  { 1650, 10, 16, 12, 1, -16 },
  { 1670, 9, 23, 13, 2, -16 },
  { 1696, 10, 23, 13, 1, -16 },
  { 1725, 6, 16, 8, 2, -16 },
  { 1737, 7, 16, 9, 1, -16 },
  { 1751, 5, 20, 6, 1, -20 },
  { 1764, 8, 16, 12, 2, -16 },
  { 1780, 9, 16, 9, 0, -16 },
  { 1798, 15, 16, 15, 0, -16 },
  { 1828, 8, 16, 9, 1, -16 },
  { 1844, 9, 23, 9, 0, -16 },
  { 1870, 6, 16, 8, 1, -16 },
  { 1882, 7, 26, 10, 2, -21 },
  { 1905, 1, 30, 11, 5, -23 },
  { 1909, 8, 26, 10, 1, -21 },
  { 1935, 10, 3, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Thin30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN30PT7B_H_
