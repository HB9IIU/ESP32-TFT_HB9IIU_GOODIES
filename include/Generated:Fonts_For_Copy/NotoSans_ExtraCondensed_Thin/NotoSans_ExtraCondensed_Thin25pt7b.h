#ifndef _NOTOSANS_EXTRACONDENSED_THIN25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xC0, 0x99, 0x99, 0x99, 0x90, 0x08, 0x82, 0x20, 0x90,
  0x44, 0x11, 0x1F, 0xF1, 0x10, 0x44, 0x11, 0x04, 0x41, 0x13, 0x7E, 0x22,
  0x08, 0x82, 0x20, 0x88, 0x22, 0x08, 0x80, 0x10, 0x3C, 0x52, 0x90, 0x90,
  0x90, 0x90, 0x90, 0x50, 0x30, 0x1C, 0x12, 0x11, 0x11, 0x11, 0x11, 0x11,
  0xD6, 0x38, 0x10, 0x70, 0x88, 0x88, 0x88, 0x88, 0x90, 0x89, 0x08, 0x90,
  0x8A, 0x08, 0xA6, 0x8A, 0x98, 0xB1, 0x75, 0x10, 0x51, 0x05, 0x10, 0x91,
  0x09, 0x10, 0x91, 0x10, 0x91, 0x0E, 0x38, 0x22, 0x11, 0x08, 0x84, 0x42,
  0x20, 0xA0, 0x50, 0x30, 0x28, 0x22, 0x51, 0x28, 0x54, 0x2A, 0x09, 0x04,
  0x85, 0x3C, 0x40, 0xFE, 0x18, 0x88, 0x44, 0x21, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x08, 0x42, 0x08, 0x41, 0x0C, 0x84, 0x42, 0x21, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x12, 0x24, 0x48, 0x10, 0x4D, 0xCC, 0x29, 0x30, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x55, 0xA0,
  0xF8, 0xC0, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x00, 0x3C, 0x42, 0x42, 0x42, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x3C,
  0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x7C, 0x82, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20,
  0x40, 0x40, 0xFF, 0x7C, 0x82, 0x02, 0x02, 0x01, 0x02, 0x02, 0x04, 0x38,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x02, 0x00, 0x80,
  0x50, 0x14, 0x09, 0x02, 0x41, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x04,
  0x81, 0x3F, 0xF0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x7E, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0xF8, 0x86, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02,
  0x02, 0xFC, 0x1E, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0xBC, 0xC2, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xFF, 0x02, 0x02, 0x02,
  0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20,
  0x20, 0x20, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x82, 0x42, 0x24, 0x18, 0x24,
  0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x3C, 0x42, 0x82, 0x82,
  0x82, 0x81, 0x81, 0x81, 0x83, 0x43, 0x3D, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x78, 0x80, 0x18, 0x40, 0x00, 0x05, 0x5A, 0x01, 0x06, 0x18, 0x60,
  0x80, 0xC0, 0x20, 0x18, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x03, 0x04, 0x18, 0x60, 0x80, 0xF8, 0x10,
  0x41, 0x04, 0x10, 0x42, 0x10, 0x42, 0x08, 0x20, 0x80, 0x00, 0x20, 0x80,
  0x0F, 0x80, 0x82, 0x08, 0x08, 0x40, 0x24, 0x01, 0x21, 0xC5, 0x12, 0x31,
  0x11, 0x88, 0x8C, 0x44, 0x62, 0x23, 0x11, 0x18, 0x88, 0xC4, 0xC9, 0x19,
  0xC8, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x08, 0x06, 0x05,
  0x02, 0x81, 0x40, 0x90, 0x48, 0x44, 0x22, 0x10, 0x8F, 0xC8, 0x24, 0x12,
  0x05, 0x03, 0x01, 0x80, 0xC0, 0x40, 0xFC, 0x82, 0x82, 0x81, 0x81, 0x82,
  0x82, 0x86, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC,
  0x0F, 0x98, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x00, 0x40, 0x20, 0x0F, 0xC0, 0xF8, 0x84, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83,
  0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x0F, 0xC2, 0x04, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7E, 0x00, 0xC0, 0x18,
  0x02, 0x80, 0x50, 0x09, 0x01, 0x30, 0x21, 0xF8, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E, 0x82, 0x82,
  0x84, 0x88, 0x88, 0x90, 0x90, 0xA0, 0xE0, 0xE0, 0x90, 0x90, 0x88, 0x88,
  0x84, 0x84, 0x82, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x18, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3A, 0x03, 0xA0, 0x5A, 0x05, 0x90, 0x59, 0x09, 0x90, 0x98, 0x89,
  0x89, 0x18, 0x91, 0x89, 0x18, 0x51, 0x86, 0x18, 0x61, 0x80, 0xC0, 0x70,
  0x38, 0x1A, 0x0D, 0x06, 0x43, 0x21, 0x88, 0xC4, 0x62, 0x30, 0x98, 0x4C,
  0x16, 0x0B, 0x03, 0x81, 0xC0, 0x40, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x40,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x50, 0x14,
  0x05, 0x01, 0x20, 0x87, 0xC0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x85, 0x33, 0x84, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x1F, 0x08, 0x24,
  0x09, 0x01, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x14, 0x05, 0x01, 0x20, 0x87, 0xC0, 0x20, 0x04, 0x01, 0x00,
  0x20, 0xF0, 0x84, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x90,
  0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x83, 0x3E, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02,
  0xFC, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x3E, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x12, 0x09, 0x04, 0x42, 0x22, 0x11,
  0x08, 0x84, 0x41, 0x40, 0xA0, 0x50, 0x28, 0x08, 0x04, 0x00, 0x80, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x41, 0x82, 0x41, 0x82, 0x41, 0x42, 0x42, 0x42,
  0x22, 0x42, 0x22, 0x44, 0x22, 0x44, 0x22, 0x24, 0x24, 0x24, 0x14, 0x28,
  0x14, 0x28, 0x14, 0x28, 0x14, 0x18, 0x18, 0x10, 0x08, 0x10, 0x41, 0x41,
  0x22, 0x22, 0x22, 0x14, 0x14, 0x18, 0x08, 0x08, 0x14, 0x14, 0x24, 0x22,
  0x42, 0x42, 0x41, 0x81, 0x81, 0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x08,
  0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0x40,
  0x81, 0xFC, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x7C, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x40, 0x81, 0x01, 0x02, 0x04, 0x04, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x04, 0x06,
  0x04, 0x82, 0x42, 0x11, 0x09, 0x02, 0x81, 0x80, 0x80, 0xFF, 0xC0, 0x84,
  0x21, 0x7C, 0x10, 0x41, 0x04, 0x76, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x81,
  0x02, 0x04, 0x08, 0x13, 0x39, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x86, 0xF0, 0x3D, 0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04,
  0x10, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01, 0x19, 0x25, 0x43, 0x41, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x86, 0x0C,
  0x18, 0x3F, 0xE0, 0x40, 0x81, 0x01, 0x02, 0x03, 0xE0, 0x1C, 0x82, 0x08,
  0x20, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x3D, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43,
  0x3D, 0x01, 0x01, 0x01, 0x01, 0x02, 0x7C, 0x82, 0x08, 0x20, 0x82, 0x4E,
  0xE1, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0xC7, 0xFF,
  0xC0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x08,
  0x20, 0x82, 0x18, 0xA2, 0x92, 0x4A, 0x38, 0xA2, 0x49, 0x22, 0x8A, 0x28,
  0x40, 0xFF, 0xFF, 0xE0, 0xF9, 0xF0, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x42, 0xFE, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x3C, 0x42, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xFD, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x1B, 0xD0, 0x20, 0x40, 0x81,
  0x02, 0x00, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x80, 0x7E, 0x08, 0x20, 0x81, 0x03, 0x02, 0x04, 0x10,
  0x41, 0xF8, 0x44, 0x4F, 0x44, 0x44, 0x44, 0x44, 0x44, 0x47, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x83, 0x05, 0x0A, 0x24,
  0x48, 0x89, 0x12, 0x28, 0x50, 0xA0, 0x81, 0x00, 0x82, 0x0C, 0x10, 0x91,
  0x44, 0x8A, 0x24, 0x51, 0x22, 0x90, 0x94, 0x85, 0x14, 0x28, 0xA1, 0x45,
  0x0A, 0x30, 0x20, 0x81, 0x04, 0x00, 0x42, 0x84, 0x91, 0x21, 0x83, 0x04,
  0x0C, 0x24, 0x49, 0x12, 0x1C, 0x20, 0x41, 0x42, 0x42, 0x42, 0x22, 0x24,
  0x24, 0x24, 0x14, 0x18, 0x18, 0x18, 0x08, 0x10, 0x10, 0x10, 0x10, 0x20,
  0xC0, 0xF8, 0x44, 0x22, 0x10, 0x88, 0x42, 0x21, 0x0F, 0x80, 0x0C, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x38, 0x20, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x30, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x81, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x40, 0x83, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0x80,
  0x71, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_Thin25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 18, 5, 2, -18 },
  { 4, 4, 7, 7, 2, -18 },
  { 8, 10, 18, 11, 0, -18 },
  { 31, 8, 20, 10, 1, -19 },
  { 51, 12, 18, 14, 1, -18 },
  { 78, 9, 18, 10, 1, -18 },
  { 99, 1, 7, 4, 2, -18 },
  { 100, 5, 22, 7, 1, -18 },
  { 114, 4, 22, 7, 1, -18 },
  { 125, 6, 6, 8, 1, -19 },
  { 130, 8, 12, 10, 1, -15 },
  { 142, 2, 6, 4, 1, -3 },
  { 144, 5, 1, 7, 1, -7 },
  { 145, 1, 2, 5, 2, -2 },
  { 146, 7, 18, 8, 1, -18 },
  { 162, 8, 18, 10, 1, -18 },
  { 180, 4, 18, 10, 2, -18 },
  { 189, 8, 18, 10, 1, -18 },
  { 207, 8, 18, 10, 1, -18 },
  { 225, 10, 18, 10, 0, -18 },
  { 248, 8, 18, 10, 1, -18 },
  { 266, 8, 18, 10, 1, -18 },
  { 284, 8, 18, 10, 1, -18 },
  { 302, 8, 18, 10, 1, -18 },
  { 320, 8, 18, 10, 1, -18 },
  { 338, 1, 13, 5, 2, -13 },
  { 340, 2, 16, 4, 1, -13 },
  { 344, 8, 10, 10, 1, -14 },
  { 354, 8, 6, 10, 1, -12 },
  { 360, 8, 10, 10, 1, -14 },
  { 370, 6, 18, 7, 0, -18 },
  { 384, 13, 20, 15, 1, -18 },
  { 417, 9, 18, 9, 0, -18 },
  { 438, 8, 18, 11, 2, -18 },
  { 456, 9, 18, 10, 1, -18 },
  { 477, 8, 18, 12, 2, -18 },
  { 495, 6, 18, 10, 2, -18 },
  { 509, 6, 18, 9, 2, -18 },
  { 523, 11, 18, 13, 1, -18 },
  { 548, 8, 18, 12, 2, -18 },
  { 566, 4, 18, 5, 1, -18 },
  { 575, 4, 22, 5, -1, -18 },
  { 586, 8, 18, 9, 2, -18 },
  { 604, 6, 18, 9, 2, -18 },
  { 618, 12, 18, 16, 2, -18 },
  { 645, 9, 18, 13, 2, -18 },
  { 666, 10, 18, 13, 1, -18 },
  { 689, 7, 18, 10, 2, -18 },
  { 705, 10, 22, 13, 1, -18 },
  { 733, 8, 18, 10, 2, -18 },
  { 751, 8, 18, 10, 1, -18 },
  { 769, 8, 18, 8, 0, -18 },
  { 787, 8, 18, 12, 2, -18 },
  { 805, 9, 18, 9, 0, -18 },
  { 826, 16, 18, 16, 0, -18 },
  { 862, 8, 18, 8, 0, -18 },
  { 880, 8, 18, 8, 0, -18 },
  { 898, 7, 18, 8, 1, -18 },
  { 914, 5, 22, 8, 2, -18 },
  { 928, 7, 18, 8, 1, -18 },
  { 944, 5, 22, 8, 1, -18 },
  { 958, 9, 9, 10, 0, -18 },
  { 969, 10, 1, 10, 0, 2 },
  { 971, 4, 4, 6, 1, -19 },
  { 973, 6, 13, 9, 1, -13 },
  { 983, 7, 19, 11, 2, -19 },
  { 1000, 6, 13, 8, 1, -13 },
  { 1010, 8, 19, 11, 1, -19 },
  { 1029, 7, 13, 10, 1, -13 },
  { 1041, 6, 19, 5, 0, -19 },
  { 1056, 8, 19, 11, 1, -13 },
  { 1075, 6, 19, 10, 2, -19 },
  { 1090, 1, 18, 4, 2, -18 },
  { 1093, 3, 24, 4, 0, -18 },
  { 1102, 6, 19, 8, 2, -19 },
  { 1117, 1, 19, 4, 2, -19 },
  { 1120, 11, 13, 15, 2, -13 },
  { 1138, 6, 13, 10, 2, -13 },
  { 1148, 8, 13, 10, 1, -13 },
  { 1161, 7, 19, 11, 2, -13 },
  { 1178, 8, 19, 11, 1, -13 },
  { 1197, 4, 13, 7, 2, -13 },
  { 1204, 6, 13, 8, 1, -13 },
  { 1214, 4, 16, 5, 1, -16 },
  { 1222, 6, 13, 10, 2, -13 },
  { 1232, 7, 13, 7, 0, -13 },
  { 1244, 13, 13, 13, 0, -13 },
  { 1266, 7, 13, 8, 0, -13 },
  { 1278, 8, 19, 8, 0, -13 },
  { 1297, 5, 13, 6, 1, -13 },
  { 1306, 6, 22, 9, 1, -18 },
  { 1323, 1, 25, 9, 4, -19 },
  { 1327, 6, 22, 9, 1, -18 },
  { 1344, 8, 2, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Thin25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN25PT7B_H_
