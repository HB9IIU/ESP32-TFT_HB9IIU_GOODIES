#ifndef _NOTOSANS_EXTRACONDENSED_THIN47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00,
  0x03, 0xFC, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x20, 0x20, 0x08, 0x18,
  0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00,
  0x81, 0x07, 0xFF, 0xFC, 0x10, 0x10, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x40,
  0x80, 0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x20,
  0x08, 0x08, 0x02, 0x02, 0x0F, 0xFF, 0xF8, 0x20, 0x40, 0x08, 0x10, 0x02,
  0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x18, 0x10, 0x04, 0x04, 0x01, 0x03,
  0x00, 0x40, 0xC0, 0x10, 0x20, 0x04, 0x08, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x07, 0xF8, 0x1D, 0x0E, 0x31, 0x04, 0x61, 0x00, 0x41, 0x00,
  0x41, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0x41, 0x00, 0x41, 0x00,
  0x61, 0x00, 0x31, 0x00, 0x19, 0x00, 0x0D, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x01, 0x30, 0x01, 0x18, 0x01, 0x04, 0x01, 0x02, 0x01, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x01, 0x06,
  0x41, 0x0C, 0x79, 0x38, 0x0F, 0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x1C, 0x00, 0xC0, 0x44, 0x01, 0x01, 0x84, 0x02, 0x02, 0x08,
  0x0C, 0x04, 0x08, 0x10, 0x18, 0x10, 0x20, 0x20, 0x20, 0xC0, 0x40, 0x41,
  0x00, 0x80, 0x82, 0x01, 0x01, 0x0C, 0x02, 0x02, 0x10, 0x04, 0x04, 0x20,
  0x08, 0x08, 0xC0, 0x10, 0x11, 0x0C, 0x30, 0x22, 0x36, 0x60, 0x4C, 0x84,
  0x41, 0x91, 0x04, 0x82, 0x24, 0x09, 0x84, 0xC8, 0x11, 0x91, 0x10, 0x31,
  0xC2, 0x20, 0x60, 0x0C, 0x40, 0x40, 0x10, 0x80, 0x80, 0x21, 0x01, 0x00,
  0xC2, 0x02, 0x01, 0x04, 0x04, 0x02, 0x08, 0x18, 0x0C, 0x10, 0x30, 0x10,
  0x20, 0x40, 0x20, 0x40, 0x80, 0xC0, 0xC1, 0x01, 0x00, 0x82, 0x02, 0x01,
  0x88, 0x0C, 0x01, 0xE0, 0x07, 0x80, 0x06, 0x20, 0x02, 0x08, 0x03, 0x04,
  0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0xC0, 0x20, 0x60, 0x10, 0x20, 0x08,
  0x10, 0x02, 0x08, 0x01, 0x04, 0x00, 0x84, 0x00, 0x26, 0x00, 0x12, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x80, 0x04, 0x40, 0x06, 0x10, 0x02, 0x0C,
  0x12, 0x02, 0x09, 0x00, 0x84, 0x80, 0x42, 0x40, 0x13, 0x60, 0x09, 0x30,
  0x02, 0x88, 0x01, 0xC4, 0x00, 0x42, 0x00, 0x71, 0x80, 0x28, 0x40, 0x22,
  0x30, 0x21, 0x07, 0xE0, 0x40, 0xFF, 0xFA, 0xAA, 0x80, 0x01, 0x03, 0x02,
  0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04,
  0x02, 0x03, 0x80, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04,
  0x04, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x82, 0x17, 0x2E, 0x0F, 0x00, 0x60, 0x09, 0x01, 0x08, 0x30, 0x86,
  0x04, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x33, 0x22, 0x66, 0x44, 0x48,
  0x80, 0xFF, 0xC0, 0xFC, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x31, 0x81, 0x83, 0x0C, 0x04, 0x20,
  0x18, 0x80, 0x26, 0x00, 0x90, 0x03, 0x40, 0x0D, 0x00, 0x14, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x50, 0x01, 0x40, 0x05,
  0x00, 0x14, 0x00, 0xD8, 0x02, 0x60, 0x08, 0x80, 0x23, 0x01, 0x04, 0x04,
  0x08, 0x20, 0x1F, 0x00, 0x02, 0x0C, 0x38, 0xD2, 0x28, 0x60, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x1F, 0x81,
  0xC3, 0x84, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x1F, 0x81,
  0xC3, 0x8C, 0x03, 0x20, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x1F, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0xC0, 0x71, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80, 0x02, 0x40, 0x03,
  0x20, 0x01, 0x10, 0x01, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00,
  0x20, 0x80, 0x20, 0x40, 0x10, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x04, 0x02, 0x04, 0x01, 0x02, 0x00, 0x82, 0x00, 0x41, 0x00, 0x21, 0x00,
  0x10, 0x80, 0x08, 0x7F, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x3F,
  0xF8, 0xFF, 0xE2, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x05,
  0xFC, 0x1C, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0xC0, 0x61, 0xFF, 0x00, 0x00,
  0xF0, 0x1C, 0x60, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0xFE, 0x36, 0x04, 0xF0, 0x0B, 0x80, 0x2C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x05, 0x80, 0x32, 0x00, 0x8C, 0x06, 0x18, 0x30, 0x3F, 0x80, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x00, 0x07, 0xC0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0x44, 0x00, 0xC8, 0x00,
  0xB0, 0x01, 0x60, 0x02, 0x40, 0x04, 0x80, 0x09, 0x00, 0x33, 0x00, 0x43,
  0x01, 0x83, 0x06, 0x03, 0x18, 0x03, 0xC0, 0x03, 0x80, 0x19, 0x80, 0x60,
  0x81, 0x80, 0x86, 0x00, 0x88, 0x01, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x58, 0x00, 0x90, 0x03, 0x30,
  0x04, 0x30, 0x30, 0x3F, 0xC0, 0x0F, 0x80, 0x61, 0x82, 0x03, 0x18, 0x04,
  0x40, 0x19, 0x00, 0x2C, 0x00, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x00,
  0x52, 0x03, 0x4C, 0x19, 0x0F, 0xC4, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0xC1, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x22,
  0x66, 0x44, 0xC8, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x00, 0x80, 0x00, 0x3E, 0x30, 0xC0, 0x08, 0x03, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x38, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x1C, 0x03, 0x00, 0x60, 0x03,
  0x00, 0x80, 0x03, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x10, 0x00, 0x04,
  0x60, 0x00, 0x0C, 0x80, 0x00, 0x09, 0x00, 0xF8, 0x16, 0x03, 0x18, 0x2C,
  0x0C, 0x20, 0x70, 0x30, 0x40, 0xE0, 0x40, 0x80, 0xC0, 0x81, 0x01, 0x81,
  0x02, 0x03, 0x06, 0x04, 0x06, 0x0C, 0x08, 0x0C, 0x18, 0x10, 0x18, 0x20,
  0x20, 0x30, 0x40, 0x40, 0x60, 0xC0, 0x81, 0xC1, 0x83, 0x02, 0x81, 0x06,
  0x05, 0x02, 0x0C, 0x0A, 0x06, 0x24, 0x24, 0x06, 0xCF, 0xCC, 0x06, 0x06,
  0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x05, 0x80,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x12, 0x00, 0x08, 0x80, 0x02, 0x10, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x18, 0x40, 0x04, 0x18, 0x01, 0x02, 0x00, 0x40,
  0x80, 0x30, 0x20, 0x08, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x10,
  0x1F, 0xFE, 0x04, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x02, 0x08,
  0x00, 0xC2, 0x00, 0x10, 0x80, 0x04, 0x60, 0x01, 0x10, 0x00, 0x64, 0x00,
  0x09, 0x00, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x30, 0xFF, 0x03, 0xFF, 0x88,
  0x03, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x03, 0x20, 0x78,
  0xFF, 0x82, 0x01, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x01, 0xA0, 0x0C, 0x80, 0xE3, 0xFF, 0x00, 0x01, 0xFC, 0x0E, 0x0C,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x02, 0x07, 0xFC,
  0xF8, 0x00, 0xFF, 0xC0, 0x80, 0x60, 0x80, 0x10, 0x80, 0x18, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08,
  0x80, 0x18, 0x80, 0x30, 0x81, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xE8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFE, 0xFF, 0xE8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x78, 0x10, 0x01, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xB0, 0x00, 0x12, 0x00, 0x02, 0x60,
  0x00, 0x46, 0x00, 0x08, 0x60, 0x01, 0x06, 0x00, 0xE0, 0x3F, 0xF0, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x04, 0xFE, 0x60, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x8D, 0xF0, 0x80, 0x0A,
  0x00, 0x68, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x08, 0x0C, 0x20, 0x20,
  0x81, 0x82, 0x04, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02, 0x30, 0x08, 0x80,
  0x26, 0x00, 0xB8, 0x02, 0xB0, 0x0C, 0x40, 0x31, 0x80, 0x82, 0x02, 0x0C,
  0x08, 0x10, 0x20, 0x60, 0x80, 0x82, 0x03, 0x08, 0x04, 0x20, 0x18, 0x80,
  0x22, 0x00, 0xC8, 0x01, 0x20, 0x06, 0x80, 0x0A, 0x00, 0x30, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x5E, 0x00, 0x00, 0xB4,
  0x00, 0x01, 0x68, 0x00, 0x06, 0xD8, 0x00, 0x09, 0x90, 0x00, 0x13, 0x20,
  0x00, 0x66, 0x60, 0x00, 0x8C, 0x40, 0x01, 0x18, 0x80, 0x06, 0x31, 0x00,
  0x08, 0x63, 0x00, 0x10, 0xC2, 0x00, 0x21, 0x84, 0x00, 0xC3, 0x0C, 0x01,
  0x06, 0x08, 0x02, 0x0C, 0x10, 0x0C, 0x18, 0x30, 0x10, 0x30, 0x20, 0x20,
  0x60, 0x40, 0xC0, 0xC0, 0x81, 0x01, 0x81, 0x82, 0x03, 0x01, 0x0C, 0x06,
  0x02, 0x18, 0x0C, 0x06, 0x20, 0x18, 0x04, 0x40, 0x30, 0x09, 0x80, 0x60,
  0x1A, 0x00, 0xC0, 0x14, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x04, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xA0, 0x01, 0xA0, 0x01, 0x90,
  0x01, 0x90, 0x01, 0x98, 0x01, 0x88, 0x01, 0x8C, 0x01, 0x84, 0x01, 0x84,
  0x01, 0x82, 0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x01, 0x81, 0x81, 0x80,
  0x81, 0x80, 0xC1, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21, 0x80, 0x21, 0x80,
  0x31, 0x80, 0x11, 0x80, 0x19, 0x80, 0x09, 0x80, 0x09, 0x80, 0x05, 0x80,
  0x05, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x03, 0xF0, 0x03, 0x87, 0x01,
  0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00, 0x09, 0x00,
  0x02, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x02, 0x60, 0x00,
  0x88, 0x00, 0x43, 0x00, 0x30, 0x60, 0x08, 0x0C, 0x0C, 0x01, 0xFE, 0x00,
  0xF8, 0x07, 0xFC, 0x20, 0x19, 0x00, 0x68, 0x01, 0x40, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x50, 0x02, 0x80, 0x24, 0x03, 0x3F, 0xE1, 0xF8, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x87,
  0x01, 0x80, 0x60, 0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x64, 0x00, 0x09,
  0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x02, 0x60,
  0x00, 0x88, 0x00, 0x43, 0x00, 0x30, 0x60, 0x08, 0x0C, 0x0C, 0x01, 0xFE,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xF8, 0x03, 0xFE, 0x08, 0x06,
  0x20, 0x0C, 0x80, 0x12, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x1A, 0x00, 0x48, 0x01, 0x20, 0x0C, 0x80,
  0x62, 0x0F, 0x0F, 0xE0, 0x20, 0x80, 0x81, 0x02, 0x04, 0x08, 0x18, 0x20,
  0x20, 0x80, 0xC2, 0x01, 0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00, 0x48,
  0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x30, 0x07, 0xF0, 0x70, 0x73, 0x00,
  0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x80, 0x71, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x20,
  0x02, 0x30, 0x06, 0x18, 0x0C, 0x0F, 0xF0, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x68, 0x00, 0x24, 0x00, 0x12, 0x00, 0x09, 0x80, 0x04, 0x40, 0x06,
  0x20, 0x02, 0x10, 0x01, 0x0C, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80,
  0x20, 0x40, 0x10, 0x30, 0x18, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01,
  0x81, 0x00, 0x41, 0x80, 0x20, 0x80, 0x10, 0x40, 0x0C, 0x20, 0x02, 0x30,
  0x01, 0x10, 0x00, 0x88, 0x00, 0x44, 0x00, 0x36, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0xC0, 0x00, 0x40, 0x00, 0xC0, 0x03, 0x00, 0x07,
  0x00, 0x0C, 0x00, 0x14, 0x00, 0x30, 0x00, 0xD0, 0x00, 0xC0, 0x03, 0x40,
  0x03, 0x80, 0x09, 0x80, 0x0E, 0x00, 0x22, 0x00, 0x68, 0x00, 0x88, 0x01,
  0x20, 0x06, 0x20, 0x04, 0x80, 0x10, 0x80, 0x13, 0x00, 0x43, 0x00, 0x4C,
  0x01, 0x04, 0x03, 0x10, 0x0C, 0x10, 0x08, 0x40, 0x30, 0x40, 0x21, 0x00,
  0x81, 0x80, 0x86, 0x02, 0x06, 0x02, 0x18, 0x08, 0x08, 0x18, 0x20, 0x60,
  0x20, 0x40, 0x81, 0x00, 0x81, 0x02, 0x04, 0x03, 0x04, 0x0C, 0x10, 0x0C,
  0x10, 0x30, 0x40, 0x10, 0xC0, 0x43, 0x00, 0x42, 0x01, 0x08, 0x01, 0x08,
  0x04, 0x20, 0x06, 0x20, 0x10, 0x80, 0x08, 0x80, 0x66, 0x00, 0x26, 0x00,
  0x90, 0x00, 0x90, 0x02, 0x40, 0x03, 0x40, 0x09, 0x00, 0x0D, 0x00, 0x24,
  0x00, 0x14, 0x00, 0xF0, 0x00, 0x70, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x20, 0x02, 0x40, 0x0C, 0xC0, 0x10, 0x80, 0x21,
  0x00, 0xC3, 0x01, 0x02, 0x06, 0x04, 0x08, 0x04, 0x10, 0x08, 0x60, 0x18,
  0x80, 0x11, 0x00, 0x24, 0x00, 0x68, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x1A, 0x00, 0x24, 0x00, 0xCC, 0x01, 0x08, 0x02,
  0x10, 0x0C, 0x30, 0x10, 0x20, 0x60, 0x40, 0x80, 0x41, 0x00, 0x86, 0x01,
  0x88, 0x01, 0x30, 0x02, 0x40, 0x07, 0x80, 0x04, 0x80, 0x07, 0x80, 0x09,
  0x00, 0x12, 0x00, 0x26, 0x00, 0x84, 0x01, 0x08, 0x02, 0x18, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x60, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x8C, 0x01, 0x10,
  0x02, 0x20, 0x06, 0xC0, 0x05, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0x80, 0x01, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0xFF, 0xFF, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x50, 0x00, 0x2C, 0x00, 0x22, 0x00, 0x31,
  0x80, 0x10, 0x40, 0x18, 0x30, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x03, 0x06,
  0x00, 0x82, 0x00, 0x63, 0x00, 0x11, 0x00, 0x0D, 0x80, 0x02, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x81, 0x81, 0x81, 0x81, 0x01,
  0x01, 0x1F, 0x87, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x3F, 0x1C, 0x12, 0x01, 0x40, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x40, 0x56,
  0x0D, 0x3F, 0x90, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x3F, 0x0D, 0x83, 0x1A, 0x03, 0x38, 0x02, 0x70, 0x06, 0xC0, 0x05, 0x80,
  0x0B, 0x00, 0x16, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x58, 0x00, 0xB0,
  0x01, 0x70, 0x06, 0xE0, 0x09, 0x20, 0x32, 0x60, 0xC4, 0x7F, 0x00, 0x07,
  0xF0, 0xC1, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x81, 0x0F,
  0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x7E, 0x31,
  0x83, 0x66, 0x02, 0xC8, 0x03, 0xB0, 0x07, 0x40, 0x06, 0x80, 0x0D, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xA0,
  0x05, 0x20, 0x0A, 0x60, 0x24, 0x60, 0xC8, 0x7F, 0x10, 0x0F, 0xC0, 0x61,
  0x83, 0x03, 0x08, 0x04, 0x60, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x06, 0x0F, 0xF0, 0x03, 0xE0, 0xC4, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xC0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x0F, 0xE2, 0x30, 0x64, 0xC0,
  0x49, 0x00, 0x76, 0x00, 0xE8, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x34, 0x00, 0xE4, 0x01,
  0xC8, 0x05, 0x8C, 0x1B, 0x0F, 0xC6, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x31, 0x80,
  0xC1, 0xFE, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x8F, 0x8D, 0x86,
  0x68, 0x1B, 0x80, 0x5C, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x10, 0xFC, 0x00, 0x15, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x18,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC4, 0x2E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x02, 0xC0, 0x6C,
  0x04, 0xC0, 0x8C, 0x18, 0xC1, 0x0C, 0x30, 0xC2, 0x0C, 0x40, 0xCC, 0x0C,
  0xC0, 0xD4, 0x0F, 0x20, 0xE2, 0x0C, 0x30, 0xC1, 0x0C, 0x10, 0xC0, 0x8C,
  0x08, 0xC0, 0xCC, 0x04, 0xC0, 0x4C, 0x02, 0xC0, 0x2C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x83, 0xF2, 0x61, 0x18,
  0x6B, 0x02, 0x40, 0xA8, 0x0A, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x40, 0x1C,
  0x01, 0x00, 0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01,
  0x00, 0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01, 0x00,
  0x70, 0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x70,
  0x04, 0x01, 0xC0, 0x10, 0x07, 0x00, 0x40, 0x1C, 0x01, 0x00, 0x70, 0x04,
  0x01, 0xC0, 0x10, 0x04, 0x87, 0xC4, 0xC1, 0x24, 0x05, 0x40, 0x2A, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x0F, 0xE0, 0x30,
  0x60, 0xC0, 0x61, 0x00, 0x46, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x60, 0x02,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x09, 0x00, 0x12, 0x00, 0x26, 0x00,
  0xC4, 0x01, 0x0C, 0x06, 0x0C, 0x18, 0x0F, 0xE0, 0x87, 0xE1, 0x30, 0x62,
  0x40, 0x65, 0x00, 0x4A, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0x60, 0x02, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x2E, 0x00, 0xDC,
  0x01, 0x34, 0x06, 0x6C, 0x18, 0xCF, 0xE1, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xE2, 0x30, 0x64, 0xC0, 0x49, 0x00, 0x76,
  0x00, 0xE8, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0D, 0x00, 0x1A, 0x00, 0x36, 0x00, 0xE4, 0x01, 0xCC, 0x05, 0x8C,
  0x1B, 0x0F, 0xE6, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x87, 0xC4, 0x64, 0x14, 0x0A, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xCE, 0x0D, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x14, 0x06, 0x7F, 0x80, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x10, 0x10, 0x1F, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xA0, 0x15, 0x80,
  0xA4, 0x19, 0x3F, 0x88, 0xC0, 0x0D, 0x00, 0x24, 0x00, 0x90, 0x06, 0x40,
  0x19, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x30, 0xC0, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x60, 0x61, 0x00, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x32, 0x00,
  0x48, 0x01, 0x20, 0x05, 0x80, 0x14, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x40, 0x18, 0x02, 0x40, 0x18, 0x02, 0x40, 0x1C, 0x02,
  0x60, 0x14, 0x06, 0x20, 0x34, 0x04, 0x20, 0x24, 0x04, 0x20, 0x24, 0x04,
  0x30, 0x26, 0x04, 0x10, 0x62, 0x0C, 0x10, 0x62, 0x08, 0x10, 0x42, 0x08,
  0x10, 0x42, 0x08, 0x18, 0x43, 0x08, 0x08, 0xC1, 0x10, 0x08, 0x81, 0x10,
  0x08, 0x81, 0x10, 0x0C, 0x81, 0x90, 0x04, 0x80, 0xB0, 0x05, 0x80, 0xA0,
  0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0, 0x07, 0x00, 0xA0, 0x03, 0x00, 0x40,
  0x03, 0x00, 0x40, 0xC0, 0x1A, 0x00, 0x98, 0x0C, 0x40, 0x43, 0x06, 0x08,
  0x20, 0x41, 0x01, 0x10, 0x08, 0x80, 0x6C, 0x01, 0x40, 0x0E, 0x00, 0x20,
  0x02, 0x80, 0x14, 0x01, 0xB0, 0x08, 0x80, 0xC6, 0x04, 0x10, 0x60, 0x82,
  0x02, 0x30, 0x11, 0x00, 0xD8, 0x02, 0x80, 0x18, 0x40, 0x05, 0x80, 0x12,
  0x00, 0x48, 0x03, 0x20, 0x08, 0xC0, 0x21, 0x00, 0x84, 0x06, 0x10, 0x10,
  0x60, 0x40, 0x81, 0x02, 0x0C, 0x08, 0x20, 0x30, 0x80, 0x42, 0x01, 0x18,
  0x04, 0x40, 0x19, 0x00, 0x24, 0x00, 0xB0, 0x02, 0x80, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x3C, 0x00, 0x7F,
  0xC0, 0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x18, 0x04, 0x03, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x1F, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0xF0, 0x0F, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0F, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x00, 0xF0, 0x0F, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0xF8, 0x00, 0x08,
  0x00, 0x3F, 0x01, 0xC0, 0xC3, 0x80, 0x7E,
};

const GFXglyph NotoSans_ExtraCondensed_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 34, 9, 3, -34 },
  { 14, 8, 13, 14, 3, -34 },
  { 27, 18, 34, 20, 1, -34 },
  { 104, 16, 39, 19, 1, -36 },
  { 182, 23, 34, 27, 2, -34 },
  { 280, 17, 34, 18, 1, -34 },
  { 353, 2, 13, 8, 3, -34 },
  { 357, 8, 41, 12, 2, -34 },
  { 398, 8, 41, 12, 2, -34 },
  { 439, 12, 12, 16, 2, -36 },
  { 457, 16, 21, 19, 1, -27 },
  { 499, 4, 11, 8, 2, -5 },
  { 505, 10, 1, 12, 1, -13 },
  { 507, 2, 3, 8, 3, -3 },
  { 508, 14, 34, 15, 1, -34 },
  { 568, 14, 34, 19, 2, -34 },
  { 628, 7, 34, 19, 4, -34 },
  { 658, 14, 34, 19, 2, -34 },
  { 718, 14, 34, 19, 2, -34 },
  { 778, 17, 34, 19, 1, -34 },
  { 851, 14, 34, 19, 2, -34 },
  { 911, 14, 35, 19, 2, -34 },
  { 973, 14, 34, 19, 2, -34 },
  { 1033, 15, 34, 19, 2, -34 },
  { 1097, 14, 34, 19, 2, -34 },
  { 1157, 2, 25, 8, 3, -25 },
  { 1164, 4, 31, 8, 2, -25 },
  { 1180, 16, 19, 19, 1, -26 },
  { 1218, 16, 11, 19, 1, -22 },
  { 1240, 16, 19, 19, 1, -26 },
  { 1278, 10, 34, 12, 1, -34 },
  { 1321, 23, 38, 28, 3, -34 },
  { 1431, 18, 34, 18, 0, -34 },
  { 1508, 14, 34, 20, 4, -34 },
  { 1568, 15, 34, 20, 3, -34 },
  { 1632, 16, 34, 22, 4, -34 },
  { 1700, 12, 34, 18, 4, -34 },
  { 1751, 12, 34, 17, 4, -34 },
  { 1802, 19, 34, 24, 3, -34 },
  { 1883, 15, 34, 23, 4, -34 },
  { 1947, 7, 34, 10, 2, -34 },
  { 1977, 7, 42, 9, -2, -34 },
  { 2014, 14, 34, 18, 4, -34 },
  { 2074, 11, 34, 16, 4, -34 },
  { 2121, 23, 34, 31, 4, -34 },
  { 2219, 16, 34, 24, 4, -34 },
  { 2287, 18, 34, 24, 3, -34 },
  { 2364, 13, 34, 19, 4, -34 },
  { 2420, 18, 42, 24, 3, -34 },
  { 2515, 14, 34, 19, 4, -34 },
  { 2575, 14, 34, 18, 2, -34 },
  { 2635, 15, 34, 16, 0, -34 },
  { 2699, 16, 34, 23, 3, -34 },
  { 2767, 17, 34, 17, 0, -34 },
  { 2840, 30, 34, 30, 0, -34 },
  { 2968, 15, 34, 16, 0, -34 },
  { 3032, 15, 34, 15, 0, -34 },
  { 3096, 13, 34, 15, 1, -34 },
  { 3152, 9, 41, 14, 4, -34 },
  { 3199, 14, 34, 15, 1, -34 },
  { 3259, 8, 41, 14, 2, -34 },
  { 3300, 17, 17, 19, 1, -34 },
  { 3337, 19, 2, 18, 0, 4 },
  { 3342, 7, 8, 11, 2, -36 },
  { 3349, 12, 25, 17, 2, -25 },
  { 3387, 15, 36, 20, 3, -36 },
  { 3455, 12, 25, 15, 2, -25 },
  { 3493, 15, 36, 20, 2, -36 },
  { 3561, 14, 25, 18, 2, -25 },
  { 3605, 11, 36, 10, 0, -36 },
  { 3655, 15, 36, 20, 2, -25 },
  { 3723, 13, 36, 19, 3, -36 },
  { 3782, 2, 34, 8, 3, -34 },
  { 3791, 5, 45, 8, 0, -34 },
  { 3820, 12, 36, 15, 3, -36 },
  { 3874, 2, 36, 8, 3, -36 },
  { 3883, 22, 25, 29, 3, -25 },
  { 3952, 13, 25, 19, 3, -25 },
  { 3993, 15, 25, 19, 2, -25 },
  { 4040, 15, 36, 20, 3, -25 },
  { 4108, 15, 36, 20, 2, -25 },
  { 4176, 9, 25, 12, 3, -25 },
  { 4205, 11, 25, 15, 2, -25 },
  { 4240, 8, 31, 10, 1, -31 },
  { 4271, 13, 25, 19, 3, -25 },
  { 4312, 14, 25, 14, 0, -25 },
  { 4356, 24, 25, 24, 0, -25 },
  { 4431, 13, 25, 15, 1, -25 },
  { 4472, 14, 36, 15, 0, -25 },
  { 4535, 10, 25, 12, 1, -25 },
  { 4567, 12, 41, 16, 2, -34 },
  { 4629, 2, 47, 18, 8, -36 },
  { 4641, 12, 41, 16, 2, -34 },
  { 4703, 16, 4, 19, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Thin47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN47PT7B_H_
