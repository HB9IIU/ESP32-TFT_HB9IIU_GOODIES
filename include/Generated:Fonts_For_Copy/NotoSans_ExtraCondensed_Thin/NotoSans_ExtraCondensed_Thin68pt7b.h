#ifndef _NOTOSANS_EXTRACONDENSED_THIN68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin68pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x92, 0x49, 0x24, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xE0, 0x7E, 0x06, 0xE0,
  0x6E, 0x06, 0xE0, 0x66, 0x06, 0x40, 0x64, 0x06, 0x40, 0x64, 0x06, 0x40,
  0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x00,
  0x30, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x03,
  0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60,
  0x00, 0x20, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x06, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x10, 0x00, 0x18, 0x02, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x40, 0x18, 0x00, 0x08, 0x03, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x20, 0x00,
  0x30, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x06,
  0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x07, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x80, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x00, 0x01, 0x80, 0x20,
  0x00, 0x30, 0x0C, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10,
  0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x02, 0x00,
  0x03, 0x00, 0x40, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x00,
  0x60, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFC, 0x03, 0x8C, 0x3E, 0x0C, 0x18, 0x08, 0x30, 0x30, 0x00, 0xE0,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60,
  0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x60, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xF0, 0x00,
  0x0C, 0x70, 0x00, 0x18, 0x30, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x20, 0x0C, 0x0C,
  0x70, 0x18, 0x70, 0x7E, 0x37, 0xC0, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x0C, 0x60, 0x00, 0xC0, 0x0C, 0x18,
  0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x06, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x40, 0x08, 0x00, 0x80, 0x30, 0x0C, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x60, 0x0C, 0x02, 0x00, 0x30, 0x06, 0x03, 0x00, 0x18,
  0x03, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x80, 0x06, 0x00, 0x40, 0xC0, 0x03,
  0x00, 0x20, 0x60, 0x01, 0x80, 0x10, 0x20, 0x00, 0xC0, 0x08, 0x30, 0x00,
  0x60, 0x0C, 0x18, 0x00, 0x30, 0x06, 0x08, 0x00, 0x18, 0x03, 0x0C, 0x1E,
  0x0C, 0x01, 0x86, 0x1F, 0xC2, 0x00, 0xC2, 0x18, 0x61, 0x00, 0x63, 0x08,
  0x18, 0xC0, 0x21, 0x8C, 0x04, 0x60, 0x30, 0x84, 0x03, 0x30, 0x18, 0xC2,
  0x01, 0x8C, 0x0C, 0x63, 0x00, 0xC6, 0x0C, 0x21, 0x80, 0x21, 0xDC, 0x30,
  0xC0, 0x18, 0x7C, 0x18, 0x60, 0x0C, 0x00, 0x08, 0x20, 0x06, 0x00, 0x0C,
  0x10, 0x03, 0x00, 0x06, 0x08, 0x01, 0x80, 0x02, 0x04, 0x00, 0xC0, 0x03,
  0x02, 0x00, 0x60, 0x01, 0x81, 0x00, 0x30, 0x00, 0x80, 0x80, 0x18, 0x00,
  0xC0, 0x40, 0x0C, 0x00, 0x60, 0x20, 0x06, 0x00, 0x20, 0x18, 0x03, 0x00,
  0x30, 0x0C, 0x01, 0x00, 0x18, 0x06, 0x00, 0x80, 0x0C, 0x03, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x60, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x30, 0x10,
  0x03, 0x00, 0x0C, 0x18, 0x01, 0x80, 0x07, 0x18, 0x00, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x9C, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x08, 0x01, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x04,
  0x03, 0x00, 0x06, 0x02, 0x00, 0x06, 0x06, 0x00, 0x02, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x08, 0x00, 0x01, 0x98, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x10, 0x00, 0x30, 0x18, 0x06, 0x30, 0x08, 0x06, 0x60,
  0x0C, 0x06, 0x60, 0x04, 0x06, 0x40, 0x06, 0x06, 0xC0, 0x03, 0x04, 0xC0,
  0x03, 0x04, 0xC0, 0x01, 0x8C, 0xC0, 0x00, 0x8C, 0xC0, 0x00, 0xC8, 0xC0,
  0x00, 0x58, 0xC0, 0x00, 0x78, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x60,
  0x00, 0x78, 0x60, 0x00, 0xE8, 0x20, 0x00, 0xCC, 0x30, 0x01, 0x84, 0x18,
  0x03, 0x06, 0x0E, 0x0E, 0x02, 0x07, 0xFC, 0x03, 0x00, 0xE0, 0x00, 0xFF,
  0xF6, 0xDB, 0x49, 0x24, 0x92, 0x48, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x03,
  0x02, 0x06, 0xF1, 0x0E, 0x0E, 0xB8, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x6C,
  0x00, 0x23, 0x00, 0x20, 0x80, 0x30, 0x20, 0x30, 0x18, 0x30, 0x06, 0x10,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x18, 0xC6,
  0x33, 0x18, 0xC6, 0x33, 0x18, 0xC4, 0x63, 0x10, 0xFF, 0xFC, 0x7F, 0xF7,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1E, 0xF0, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x18,
  0x00, 0x08, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xC8, 0x00, 0x06, 0x40, 0x00, 0x36, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80,
  0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0B, 0x00, 0x00, 0x58, 0x00, 0x02, 0x40, 0x00, 0x32,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xC4, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x06,
  0x00, 0x10, 0x30, 0x01, 0x81, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0x71, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x20, 0x0C, 0x07, 0x81, 0xF0,
  0x76, 0x1C, 0xC7, 0x19, 0xC3, 0x60, 0x78, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x07, 0xF8, 0x00, 0xFD, 0xF0, 0x1E, 0x01, 0xC0, 0xC0, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0x70, 0x07, 0x0E, 0x00, 0x18, 0x80, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x80, 0x03, 0x8F, 0x80, 0xF0, 0x3F,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0x83, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x7F, 0x80, 0x3F, 0xFF, 0x01,
  0xC0, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x0E, 0x1F, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x70, 0x08, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x60, 0x04, 0x3F, 0xF0, 0x63, 0x81, 0xC3,
  0x30, 0x03, 0x1B, 0x00, 0x08, 0xD0, 0x00, 0x67, 0x80, 0x01, 0x38, 0x00,
  0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00, 0x0B, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x02, 0x60,
  0x00, 0x31, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x60, 0x30, 0x07, 0x00, 0xE0, 0x70, 0x03, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00, 0xC3, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00, 0x01, 0x88,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00,
  0x0C, 0x18, 0x00, 0x30, 0x30, 0x01, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x70,
  0x03, 0x83, 0x80, 0x07, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xEE, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x18, 0x03, 0x80, 0x30, 0x1C, 0x00,
  0x60, 0x60, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x36, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC0,
  0xC0, 0x0E, 0x01, 0xC0, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xE0, 0x1C, 0x03, 0x01, 0x80, 0x18, 0x30, 0x01, 0x86,
  0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0x73, 0x00, 0x0B, 0x30, 0x01, 0xB1, 0x80, 0x33, 0x0F, 0x1E, 0x30,
  0x7F, 0xC3, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x02, 0x03, 0x80, 0x3F,
  0xF0, 0x00, 0x78, 0x00, 0x7F, 0xF7, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x39, 0xCE,
  0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x63, 0x19, 0xCC, 0x63, 0x19, 0x8C, 0x66,
  0x31, 0x88, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xE3, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00,
  0x70, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x0F, 0x80, 0x31, 0x80, 0x0F, 0xF8, 0x06, 0x60,
  0x07, 0x06, 0x01, 0x98, 0x03, 0x01, 0x80, 0x64, 0x00, 0xC0, 0x60, 0x1B,
  0x00, 0x60, 0x18, 0x06, 0xC0, 0x18, 0x06, 0x00, 0xB0, 0x0C, 0x01, 0x80,
  0x2C, 0x03, 0x00, 0x60, 0x0B, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x20, 0x04,
  0x00, 0xF0, 0x08, 0x01, 0x00, 0x3C, 0x06, 0x00, 0xC0, 0x0F, 0x01, 0x80,
  0x30, 0x03, 0xC0, 0x60, 0x0C, 0x00, 0xF0, 0x18, 0x03, 0x00, 0x2C, 0x06,
  0x00, 0xC0, 0x0B, 0x01, 0x80, 0x30, 0x06, 0xC0, 0x60, 0x0C, 0x01, 0xB0,
  0x08, 0x03, 0x00, 0x6C, 0x03, 0x01, 0xC0, 0x1B, 0x00, 0xC0, 0x70, 0x04,
  0xC0, 0x30, 0x16, 0x03, 0x30, 0x06, 0x0D, 0x80, 0xCC, 0x01, 0x83, 0x30,
  0x61, 0x00, 0x3B, 0x8F, 0x70, 0x60, 0x07, 0xC1, 0xF8, 0x18, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x01, 0xE0, 0x06, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x04, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x18, 0x00, 0x30, 0x02, 0x00,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x01,
  0x00, 0x18, 0x00, 0x60, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xC0,
  0x01, 0x80, 0x30, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01,
  0x80, 0x00, 0xC0, 0x60, 0x00, 0x10, 0x18, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x30, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0C, 0x00, 0xF8, 0x30, 0x00, 0x70,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00,
  0x0E, 0x0C, 0x01, 0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x1F, 0x03, 0x00, 0x07,
  0x0C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x3C, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFD, 0xFC, 0x07, 0x80,
  0x30, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x80, 0x78, 0x0F, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x7C,
  0x06, 0x00, 0x1C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x18, 0x00, 0x38, 0x30, 0x01, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x30, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x70, 0x0F, 0x80, 0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xFF,
  0xFF, 0xC2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x18, 0xFF, 0x80, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x78, 0x3B, 0xFC, 0x7C, 0x00,
  0xC0, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06,
  0x00, 0x30, 0x30, 0x03, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xE0, 0x06, 0x06, 0x00, 0x30,
  0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x03, 0x1C, 0x00,
  0x19, 0xE0, 0x00, 0xCD, 0x80, 0x06, 0xCC, 0x00, 0x3C, 0x30, 0x01, 0xE1,
  0x80, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00,
  0x60, 0x60, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF4, 0x00, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x00, 0x2F,
  0x60, 0x00, 0x00, 0x1B, 0xC8, 0x00, 0x00, 0x06, 0xF3, 0x00, 0x00, 0x01,
  0x3C, 0xC0, 0x00, 0x00, 0xCF, 0x30, 0x00, 0x00, 0x33, 0xC6, 0x00, 0x00,
  0x0C, 0xF1, 0x80, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x01, 0x8F, 0x08, 0x00,
  0x00, 0x63, 0xC3, 0x00, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0x0C, 0x3C, 0x10,
  0x00, 0x03, 0x0F, 0x06, 0x00, 0x00, 0x83, 0xC1, 0x80, 0x00, 0x60, 0xF0,
  0x60, 0x00, 0x18, 0x3C, 0x0C, 0x00, 0x04, 0x0F, 0x03, 0x00, 0x03, 0x03,
  0xC0, 0xC0, 0x00, 0xC0, 0xF0, 0x18, 0x00, 0x30, 0x3C, 0x06, 0x00, 0x18,
  0x0F, 0x01, 0x80, 0x06, 0x03, 0xC0, 0x20, 0x01, 0x80, 0xF0, 0x0C, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0x30, 0x0F, 0x00, 0x40, 0x0C, 0x03, 0xC0, 0x18,
  0x02, 0x00, 0xF0, 0x06, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x60, 0x0F, 0x00,
  0x30, 0x18, 0x03, 0xC0, 0x0C, 0x0C, 0x00, 0xF0, 0x03, 0x03, 0x00, 0x3C,
  0x00, 0x40, 0xC0, 0x0F, 0x00, 0x18, 0x60, 0x03, 0xC0, 0x06, 0x18, 0x00,
  0xF0, 0x00, 0x86, 0x00, 0x3C, 0x00, 0x31, 0x00, 0x0F, 0x00, 0x0C, 0xC0,
  0x03, 0xC0, 0x03, 0x30, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xD8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCC,
  0x00, 0x03, 0xC4, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC2, 0x00, 0x03, 0xC3,
  0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0x80, 0x03, 0xC1, 0x80, 0x03, 0xC0,
  0x80, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x40, 0x03, 0xC0, 0x60, 0x03, 0xC0,
  0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x08, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x04, 0x03, 0xC0,
  0x06, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03, 0x03, 0xC0,
  0x01, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x00, 0x83, 0xC0, 0x00, 0xC3, 0xC0,
  0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x33, 0xC0,
  0x00, 0x33, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x0B, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x0E, 0x00, 0xE0,
  0x03, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x18, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xC0, 0x3E, 0x0C, 0x00,
  0x78, 0xC0, 0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00,
  0xCC, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x0C, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x30, 0x0F, 0x81, 0x80, 0x0F, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x63,
  0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x01, 0x30, 0x00, 0x19, 0x80, 0x00,
  0xCC, 0x00, 0x04, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x70, 0xC0,
  0x0F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x18, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0x80,
  0x0C, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x62, 0x00, 0x0E, 0x1F, 0x01, 0xE0, 0x7F,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x63, 0x00, 0x01, 0x83, 0x00, 0x06, 0x07, 0x00, 0x1C, 0x07,
  0x80, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x48, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x08, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x82, 0x00, 0x00, 0x81, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x30, 0x00, 0x10, 0x08, 0x00,
  0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00, 0x40,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x04, 0x00, 0x08, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x80, 0x80, 0x00, 0x40, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x02, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x31, 0x00, 0x00, 0x09, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xF0, 0x00, 0x06, 0x20, 0x00, 0x0F, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xB0,
  0x00, 0x0C, 0x30, 0x00, 0x19, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0x30, 0x00, 0x19, 0x80, 0x00, 0x81, 0x80, 0x01, 0x98, 0x00, 0x18,
  0x18, 0x00, 0x19, 0x80, 0x01, 0x81, 0x80, 0x03, 0x08, 0x00, 0x18, 0x18,
  0x00, 0x30, 0xC0, 0x01, 0x80, 0x80, 0x03, 0x0C, 0x00, 0x30, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x40, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x20, 0x04, 0x00, 0x60, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x00,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x10, 0x18,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00, 0x18, 0x30, 0x01, 0x81,
  0x00, 0x00, 0xC3, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x00,
  0xC2, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x02,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x61, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x20, 0x01, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x20, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x08, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x04, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x05, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x10, 0x00, 0x20, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x10, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x10, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x00, 0x10, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x0C, 0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x19, 0x80, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x26, 0x00, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x60, 0xC0, 0x02, 0x06,
  0x00, 0x30, 0x10, 0x01, 0x80, 0xC0, 0x08, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x20, 0x06, 0x03, 0x00, 0x10, 0x18, 0x00, 0xC0, 0x80, 0x06,
  0x0C, 0x00, 0x10, 0x60, 0x00, 0xC2, 0x00, 0x06, 0x30, 0x00, 0x11, 0x80,
  0x00, 0xC8, 0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x05, 0x80, 0x00, 0x06, 0x60, 0x00, 0x02, 0x30, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x18, 0x00,
  0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x07, 0xFC, 0x0F, 0x87, 0x86,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x7F, 0xC1, 0xF0, 0x63, 0xC0, 0x33,
  0x80, 0x1B, 0x80, 0x0D, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x05, 0xC0, 0x02, 0xB0, 0x03, 0x58, 0x03, 0x27, 0x03, 0x11, 0xFF, 0x08,
  0x1C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x04, 0x00, 0xC3, 0xFE, 0x06, 0x3C,
  0x38, 0x33, 0x00, 0x61, 0xB0, 0x01, 0x8D, 0x00, 0x0C, 0x78, 0x00, 0x33,
  0x80, 0x01, 0x9C, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x0D, 0x80, 0x00, 0x2C, 0x00, 0x01, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x02, 0xC0,
  0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6E, 0x00, 0x03,
  0x70, 0x00, 0x33, 0xC0, 0x01, 0x9A, 0x00, 0x18, 0x98, 0x00, 0xC4, 0x60,
  0x1C, 0x21, 0xC1, 0xC1, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x7F, 0xC0, 0xF0, 0xE0, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x30, 0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x04,
  0x03, 0x03, 0xFE, 0x18, 0x3C, 0x38, 0xC3, 0x80, 0x66, 0x38, 0x01, 0xB1,
  0x80, 0x05, 0x98, 0x00, 0x3C, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x76, 0x00, 0x03, 0x90, 0x00, 0x1C, 0xC0, 0x01, 0xA6, 0x00,
  0x09, 0x18, 0x00, 0xC8, 0x60, 0x0C, 0x43, 0xC1, 0xC2, 0x07, 0xFC, 0x10,
  0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x07, 0x0F, 0x00, 0xC0,
  0x30, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x60,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x2C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x02, 0x0E, 0x00, 0x60, 0x78, 0x1E, 0x01, 0xFF, 0x80,
  0x07, 0xC0, 0x00, 0xFC, 0x03, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x41, 0xE1, 0xC2,
  0x18, 0x03, 0x31, 0x80, 0x0D, 0x8C, 0x00, 0x3C, 0xC0, 0x00, 0xE6, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0x80, 0x00, 0x34,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xD0, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0x80,
  0x00, 0xE6, 0x00, 0x0F, 0x30, 0x00, 0xD8, 0xC0, 0x06, 0xC3, 0x00, 0x66,
  0x0E, 0x0E, 0x30, 0x3F, 0xE1, 0x80, 0x38, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x18, 0x00, 0xE0, 0xF8, 0x1E, 0x01, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x80,
  0xC3, 0xFC, 0x31, 0xC3, 0x8C, 0xC0, 0x33, 0x60, 0x06, 0xD0, 0x01, 0xBC,
  0x00, 0x2E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x7F, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0x0F,
  0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0xBC, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x60,
  0x18, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x9E, 0x00, 0xCD,
  0x80, 0x6C, 0xC0, 0x34, 0x20, 0x1E, 0x18, 0x0E, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x06, 0x18, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0x80, 0x87,
  0xF8, 0x0F, 0xF0, 0x8E, 0x1C, 0x1C, 0x38, 0x98, 0x06, 0x30, 0x1C, 0x90,
  0x06, 0x20, 0x0C, 0xB0, 0x03, 0x60, 0x06, 0xA0, 0x03, 0x40, 0x06, 0xA0,
  0x03, 0xC0, 0x02, 0xC0, 0x01, 0x80, 0x02, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0,
  0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x20, 0x20, 0xFF, 0x08, 0x70, 0xF2, 0x30, 0x0C, 0x98, 0x01, 0xA4, 0x00,
  0x6B, 0x00, 0x0E, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x01, 0xC1, 0xE0, 0x18, 0x03, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00,
  0x00, 0x98, 0x00, 0x06, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC6, 0x00, 0x04, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x03, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x3F, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x20, 0x04, 0x1F, 0xF0, 0x21, 0xE1, 0xC1, 0x18,
  0x03, 0x09, 0x80, 0x0C, 0x4C, 0x00, 0x62, 0xC0, 0x01, 0x94, 0x00, 0x0C,
  0xA0, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x01, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x70, 0x00, 0x13, 0x80, 0x01,
  0x9E, 0x00, 0x0C, 0xD0, 0x00, 0xC6, 0xC0, 0x0E, 0x33, 0x00, 0xE1, 0x8E,
  0x0E, 0x0C, 0x3F, 0xE0, 0x60, 0x38, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xF0, 0x41, 0xE1, 0xC2, 0x1C, 0x03, 0x31, 0xC0, 0x0D,
  0x8C, 0x00, 0x2C, 0xC0, 0x01, 0xE6, 0x00, 0x07, 0x20, 0x00, 0x3B, 0x00,
  0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x0B, 0x38,
  0x00, 0x58, 0xC0, 0x06, 0xC3, 0x00, 0x66, 0x0E, 0x0E, 0x30, 0x3F, 0xE1,
  0x80, 0x78, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x83, 0xF8, 0x7B, 0x8C, 0x09,
  0x80, 0x98, 0x09, 0x00, 0xB0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x03, 0xFF, 0x07, 0xC3, 0xE3, 0x00, 0x23, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x40,
  0x01, 0xB0, 0x01, 0x9F, 0x03, 0x83, 0xFF, 0x80, 0x3E, 0x00, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x07,
  0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x61, 0x07, 0xF0, 0x1E, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x5C, 0x00, 0x37, 0x80, 0x09, 0x60, 0x06, 0x5C, 0x03, 0x13,
  0x83, 0x84, 0x7F, 0xC1, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x62, 0x00, 0x0C, 0x30, 0x00,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC1, 0x00, 0x08, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x01, 0x80, 0x80, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x04, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x60, 0x40, 0x02, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x80,
  0x01, 0x18, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0x90,
  0x00, 0x0B, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x24, 0x00, 0x16, 0x00, 0x33, 0x00, 0x1B,
  0x00, 0x19, 0x80, 0x0D, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0x20, 0x03,
  0x20, 0x02, 0x10, 0x01, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x01, 0x86, 0x00,
  0xC6, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x40, 0x80, 0x30, 0x80, 0x20, 0x60,
  0x10, 0x60, 0x30, 0x30, 0x18, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x04,
  0x06, 0x04, 0x04, 0x02, 0x02, 0x03, 0x06, 0x01, 0x83, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x60, 0x80, 0x10, 0x60, 0x10, 0x40,
  0x0C, 0x20, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x30, 0x03, 0x18, 0x03, 0x18,
  0x00, 0x8C, 0x01, 0x88, 0x00, 0x66, 0x00, 0x4C, 0x00, 0x32, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0D, 0x00, 0x02, 0xC0, 0x02,
  0x80, 0x01, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x6C, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x02, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x04, 0x06, 0x00, 0xC0, 0xC0, 0x08, 0x30, 0x01, 0x86, 0x00, 0x31,
  0x80, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0xC6,
  0x00, 0x18, 0x60, 0x06, 0x0C, 0x00, 0xC0, 0x80, 0x10, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x30, 0x06, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x01, 0xE0, 0x00, 0x30, 0x40, 0x00, 0x36, 0x00,
  0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x20, 0x00, 0x63, 0x00, 0x04, 0x30,
  0x00, 0xC3, 0x00, 0x0C, 0x10, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x01, 0x81,
  0x80, 0x18, 0x08, 0x01, 0x80, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x04, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06, 0x00, 0x60, 0x60, 0x02, 0x06,
  0x00, 0x30, 0x40, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x0C, 0x00, 0x18,
  0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0x98, 0x00, 0x0D, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x9C, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00,
  0x3F, 0x00, 0x78, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xC0, 0x05, 0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x3C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 49, 13, 5, -49 },
  { 20, 12, 18, 20, 4, -49 },
  { 47, 27, 49, 29, 1, -49 },
  { 213, 23, 56, 27, 2, -52 },
  { 374, 33, 50, 39, 3, -49 },
  { 581, 24, 50, 26, 2, -49 },
  { 731, 3, 18, 11, 4, -49 },
  { 738, 12, 60, 18, 3, -49 },
  { 828, 11, 60, 18, 3, -49 },
  { 911, 17, 18, 23, 3, -52 },
  { 950, 23, 32, 27, 2, -40 },
  { 1042, 5, 16, 12, 3, -7 },
  { 1052, 14, 1, 18, 2, -19 },
  { 1054, 4, 4, 12, 4, -4 },
  { 1056, 19, 49, 22, 2, -49 },
  { 1173, 21, 49, 27, 3, -49 },
  { 1302, 11, 49, 27, 5, -49 },
  { 1370, 21, 49, 27, 3, -49 },
  { 1499, 20, 50, 27, 3, -49 },
  { 1624, 25, 49, 27, 1, -49 },
  { 1778, 21, 50, 27, 3, -49 },
  { 1910, 21, 50, 27, 3, -49 },
  { 2042, 20, 49, 27, 3, -49 },
  { 2165, 22, 50, 27, 2, -49 },
  { 2303, 20, 50, 27, 3, -49 },
  { 2428, 4, 36, 12, 4, -36 },
  { 2446, 5, 45, 12, 3, -36 },
  { 2475, 23, 28, 27, 2, -38 },
  { 2556, 23, 16, 27, 2, -32 },
  { 2602, 23, 28, 27, 2, -38 },
  { 2683, 15, 49, 18, 1, -49 },
  { 2775, 34, 55, 41, 4, -49 },
  { 3009, 26, 49, 26, 0, -49 },
  { 3169, 22, 49, 29, 5, -49 },
  { 3304, 23, 50, 28, 4, -49 },
  { 3448, 23, 49, 32, 5, -49 },
  { 3589, 18, 49, 26, 5, -49 },
  { 3700, 18, 49, 24, 5, -49 },
  { 3811, 28, 50, 35, 4, -49 },
  { 3986, 23, 49, 33, 5, -49 },
  { 4127, 9, 49, 15, 3, -49 },
  { 4183, 10, 61, 13, -3, -49 },
  { 4260, 21, 49, 26, 5, -49 },
  { 4389, 17, 49, 23, 5, -49 },
  { 4494, 34, 49, 44, 5, -49 },
  { 4703, 24, 49, 34, 5, -49 },
  { 4850, 27, 50, 35, 4, -49 },
  { 5019, 20, 49, 27, 5, -49 },
  { 5142, 27, 61, 35, 4, -49 },
  { 5348, 21, 49, 27, 5, -49 },
  { 5477, 21, 50, 26, 3, -49 },
  { 5609, 22, 49, 23, 0, -49 },
  { 5744, 23, 50, 33, 5, -49 },
  { 5888, 25, 49, 25, 0, -49 },
  { 6042, 44, 49, 44, 0, -49 },
  { 6312, 21, 49, 23, 1, -49 },
  { 6441, 21, 49, 21, 0, -49 },
  { 6570, 19, 49, 22, 2, -49 },
  { 6687, 12, 60, 21, 6, -49 },
  { 6777, 19, 49, 22, 2, -49 },
  { 6894, 13, 60, 21, 2, -49 },
  { 6992, 25, 23, 27, 1, -48 },
  { 7064, 27, 2, 27, 0, 6 },
  { 7071, 10, 11, 15, 3, -52 },
  { 7085, 17, 38, 25, 3, -37 },
  { 7166, 21, 53, 29, 5, -52 },
  { 7306, 17, 38, 21, 3, -37 },
  { 7387, 21, 53, 29, 3, -52 },
  { 7527, 20, 38, 26, 3, -37 },
  { 7622, 15, 52, 14, 1, -52 },
  { 7720, 21, 53, 29, 3, -37 },
  { 7860, 18, 52, 28, 5, -52 },
  { 7977, 4, 49, 12, 4, -49 },
  { 8002, 8, 65, 12, 0, -49 },
  { 8067, 17, 52, 22, 5, -52 },
  { 8178, 2, 52, 11, 5, -52 },
  { 8191, 32, 37, 41, 5, -37 },
  { 8339, 18, 37, 28, 5, -37 },
  { 8423, 21, 38, 27, 3, -37 },
  { 8523, 21, 53, 29, 5, -37 },
  { 8663, 21, 53, 29, 3, -37 },
  { 8803, 12, 36, 18, 5, -36 },
  { 8857, 17, 38, 21, 2, -37 },
  { 8938, 12, 46, 14, 1, -45 },
  { 9007, 18, 37, 28, 5, -36 },
  { 9091, 20, 36, 20, 0, -36 },
  { 9181, 33, 36, 35, 1, -36 },
  { 9330, 19, 36, 21, 1, -36 },
  { 9416, 20, 52, 21, 1, -36 },
  { 9546, 14, 36, 18, 2, -36 },
  { 9609, 16, 60, 24, 4, -49 },
  { 9729, 2, 68, 26, 12, -52 },
  { 9746, 17, 60, 24, 3, -49 },
  { 9874, 23, 6, 27, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Thin68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN68PT7B_H_
