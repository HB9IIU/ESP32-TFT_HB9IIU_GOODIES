#ifndef _NOTOSANS_EXTRACONDENSED_THIN18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC8, 0xB6, 0xDA, 0x14, 0x48, 0x91, 0x27, 0xE4, 0x89, 0x12,
  0xFE, 0x51, 0x22, 0x44, 0x80, 0x21, 0xEA, 0x28, 0xA2, 0x8E, 0x08, 0x38,
  0x92, 0x49, 0xA9, 0xC2, 0x00, 0xE2, 0xA4, 0xA4, 0x94, 0x98, 0xAB, 0xAD,
  0xF5, 0x15, 0x15, 0x25, 0x25, 0x27, 0x62, 0x49, 0x24, 0x51, 0x84, 0x28,
  0x96, 0x58, 0xA2, 0xF4, 0xF8, 0x29, 0x49, 0x24, 0x92, 0x48, 0x91, 0x91,
  0x22, 0x49, 0x24, 0x94, 0xA4, 0x22, 0xF6, 0x90, 0x20, 0x82, 0x08, 0xFC,
  0x82, 0x08, 0x20, 0xF0, 0xF0, 0x80, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08,
  0x21, 0x04, 0x10, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x17,
  0x00, 0x2E, 0x92, 0x49, 0x24, 0x92, 0xF0, 0x42, 0x10, 0x84, 0x42, 0x21,
  0x11, 0x0F, 0x80, 0xF0, 0x42, 0x10, 0x89, 0xC1, 0x08, 0x42, 0x1F, 0x00,
  0x08, 0x10, 0x50, 0xA2, 0x44, 0x91, 0x22, 0x85, 0xFC, 0x10, 0x20, 0x40,
  0xFC, 0x21, 0x08, 0x78, 0x21, 0x08, 0x42, 0x1F, 0x00, 0x3A, 0x21, 0x08,
  0x7A, 0x31, 0x8C, 0x63, 0x17, 0x80, 0xF8, 0x42, 0x11, 0x08, 0x44, 0x21,
  0x10, 0x84, 0x00, 0x74, 0x63, 0x18, 0xA9, 0xD1, 0x8C, 0x63, 0x17, 0x80,
  0x74, 0x63, 0x18, 0xC6, 0x2F, 0x08, 0x42, 0x2E, 0x00, 0xC0, 0x40, 0xC0,
  0xF0, 0x0C, 0xC4, 0x20, 0x40, 0xC0, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x81,
  0x81, 0x81, 0x19, 0x88, 0x00, 0xF1, 0x11, 0x11, 0x22, 0x44, 0x00, 0x40,
  0x1E, 0x30, 0x90, 0x50, 0x19, 0xCC, 0xA6, 0x93, 0x49, 0xA4, 0xD2, 0x66,
  0xD0, 0x04, 0x03, 0x00, 0x70, 0x10, 0x60, 0xA1, 0x42, 0x85, 0x11, 0x3C,
  0x44, 0x8A, 0x14, 0x18, 0x20, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0xA1, 0x86,
  0x18, 0x61, 0xF8, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10,
  0x3C, 0xF9, 0x0A, 0x14, 0x28, 0x30, 0x60, 0xC1, 0x83, 0x0A, 0x14, 0x2F,
  0x80, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x0F, 0x80, 0xFC, 0x21,
  0x08, 0x43, 0xF0, 0x84, 0x21, 0x08, 0x00, 0x3E, 0x82, 0x04, 0x08, 0x10,
  0x23, 0x41, 0x83, 0x06, 0x0A, 0x13, 0xE0, 0x86, 0x18, 0x61, 0x86, 0x1F,
  0xE1, 0x86, 0x18, 0x61, 0x84, 0xEA, 0xAA, 0xAA, 0xC0, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x4F, 0x86, 0x29, 0x24, 0xA2, 0x8E, 0x28, 0x92, 0x48, 0xA2,
  0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0x80, 0xE0,
  0x70, 0x38, 0x3A, 0x1D, 0x0E, 0x8B, 0x25, 0x92, 0xC9, 0x65, 0x31, 0x98,
  0x88, 0x83, 0x87, 0x0D, 0x1A, 0x32, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x38,
  0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x13,
  0xC0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0xBC, 0x82, 0x08, 0x20, 0x80, 0x38,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x13, 0x41, 0x01,
  0x02, 0xF2, 0x28, 0x61, 0x86, 0x2E, 0xA4, 0x92, 0x28, 0xA2, 0x84, 0x7C,
  0x21, 0x08, 0x20, 0x83, 0x08, 0x42, 0x1F, 0x00, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0x83, 0x06, 0x14, 0x24, 0x48, 0x92, 0x24, 0x28,
  0x50, 0xC0, 0x81, 0x00, 0x84, 0x18, 0x41, 0x84, 0x24, 0x62, 0x4A, 0x24,
  0xA2, 0x49, 0x44, 0x94, 0x29, 0x43, 0x14, 0x31, 0x41, 0x08, 0x10, 0x80,
  0x85, 0x14, 0x8A, 0x30, 0x41, 0x0C, 0x31, 0x24, 0x92, 0x84, 0x86, 0x24,
  0x92, 0x50, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20, 0x78, 0x42, 0x11, 0x08,
  0x84, 0x22, 0x10, 0x8F, 0x80, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x27, 0x81,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0xE4, 0x92, 0x49,
  0x24, 0x92, 0x4F, 0x10, 0x30, 0xA1, 0x24, 0x50, 0x40, 0xFE, 0xA4, 0x69,
  0x11, 0x3D, 0x99, 0x9F, 0x82, 0x08, 0x20, 0xB3, 0x28, 0x61, 0x86, 0x18,
  0x61, 0x87, 0xE0, 0x34, 0x88, 0x88, 0x88, 0x87, 0x08, 0x42, 0x17, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xBC, 0x74, 0x63, 0x1F, 0xC2, 0x10, 0x83, 0xC0,
  0x34, 0x44, 0xE4, 0x44, 0x44, 0x44, 0x44, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x8B, 0xC2, 0x10, 0xFC, 0x84, 0x21, 0x0B, 0x66, 0x31, 0x8C, 0x63, 0x18,
  0xC4, 0x8F, 0xF8, 0x40, 0x55, 0x55, 0x55, 0xC0, 0x84, 0x21, 0x08, 0x4A,
  0x54, 0xC5, 0x25, 0x29, 0x44, 0xFF, 0xFC, 0x33, 0x66, 0x62, 0x31, 0x18,
  0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0x36, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x40, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0x80, 0x33, 0x28, 0x61,
  0x86, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x00, 0x74, 0x63, 0x18, 0xC6,
  0x31, 0x8B, 0xC2, 0x10, 0x84, 0x3C, 0x88, 0x88, 0x88, 0x88, 0x78, 0x88,
  0xC2, 0x11, 0x1F, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x46, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x78, 0x8C, 0x52, 0xA5, 0x29, 0x44, 0x20, 0x88, 0xC4, 0x55,
  0x2A, 0xA5, 0x52, 0xA9, 0x4C, 0x44, 0x22, 0x00, 0xCA, 0x4C, 0x42, 0x19,
  0x49, 0x88, 0x85, 0x24, 0x92, 0x48, 0xC3, 0x0C, 0x20, 0x82, 0x08, 0xC0,
  0xE5, 0x25, 0x24, 0xE0, 0x12, 0x44, 0x44, 0x44, 0xC4, 0x44, 0x44, 0x21,
  0xFF, 0xFF, 0xC0, 0xC2, 0x22, 0x22, 0x22, 0x32, 0x22, 0x22, 0x2C, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Thin18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 13, 3, 1, -13 },
  { 3, 3, 5, 5, 1, -13 },
  { 5, 7, 13, 8, 0, -13 },
  { 17, 6, 15, 7, 1, -14 },
  { 29, 8, 13, 10, 1, -13 },
  { 42, 6, 13, 7, 1, -13 },
  { 52, 1, 5, 3, 1, -13 },
  { 53, 3, 16, 5, 1, -13 },
  { 59, 3, 16, 5, 1, -13 },
  { 65, 4, 5, 6, 1, -14 },
  { 68, 6, 9, 7, 1, -11 },
  { 75, 1, 4, 3, 1, -2 },
  { 76, 4, 1, 5, 0, -5 },
  { 77, 1, 1, 3, 1, -1 },
  { 78, 6, 13, 6, 0, -13 },
  { 88, 5, 13, 7, 1, -13 },
  { 97, 3, 13, 7, 1, -13 },
  { 102, 5, 13, 7, 1, -13 },
  { 111, 5, 13, 7, 1, -13 },
  { 120, 7, 13, 7, 0, -13 },
  { 132, 5, 13, 7, 1, -13 },
  { 141, 5, 13, 7, 1, -13 },
  { 150, 5, 13, 7, 1, -13 },
  { 159, 5, 13, 7, 1, -13 },
  { 168, 5, 13, 7, 1, -13 },
  { 177, 1, 10, 3, 1, -10 },
  { 179, 1, 12, 3, 1, -10 },
  { 181, 6, 7, 7, 1, -10 },
  { 187, 6, 5, 7, 1, -9 },
  { 191, 6, 7, 7, 1, -10 },
  { 197, 4, 13, 5, 0, -13 },
  { 204, 9, 15, 11, 1, -13 },
  { 221, 7, 13, 7, 0, -13 },
  { 233, 6, 13, 8, 1, -13 },
  { 243, 6, 13, 7, 1, -13 },
  { 253, 7, 13, 9, 1, -13 },
  { 265, 5, 13, 7, 1, -13 },
  { 274, 5, 13, 6, 1, -13 },
  { 283, 7, 13, 9, 1, -13 },
  { 295, 6, 13, 9, 1, -13 },
  { 305, 2, 13, 4, 1, -13 },
  { 309, 3, 16, 3, -1, -13 },
  { 315, 6, 13, 7, 1, -13 },
  { 325, 5, 13, 6, 1, -13 },
  { 334, 9, 13, 12, 1, -13 },
  { 349, 7, 13, 9, 1, -13 },
  { 361, 7, 13, 9, 1, -13 },
  { 373, 6, 13, 7, 1, -13 },
  { 383, 7, 16, 9, 1, -13 },
  { 397, 6, 13, 7, 1, -13 },
  { 407, 5, 13, 7, 1, -13 },
  { 416, 6, 13, 6, 0, -13 },
  { 426, 6, 13, 9, 1, -13 },
  { 436, 7, 13, 7, 0, -13 },
  { 448, 12, 13, 12, 0, -13 },
  { 468, 6, 13, 6, 0, -13 },
  { 478, 6, 13, 6, 0, -13 },
  { 488, 5, 13, 6, 0, -13 },
  { 497, 3, 16, 6, 2, -13 },
  { 503, 6, 13, 6, 0, -13 },
  { 513, 3, 16, 6, 1, -13 },
  { 519, 7, 6, 7, 0, -13 },
  { 525, 7, 1, 7, 0, 1 },
  { 526, 2, 3, 4, 1, -14 },
  { 527, 4, 10, 7, 1, -10 },
  { 532, 6, 14, 8, 1, -14 },
  { 543, 4, 10, 6, 1, -10 },
  { 548, 5, 14, 8, 1, -14 },
  { 557, 5, 10, 7, 1, -10 },
  { 564, 4, 14, 4, 0, -14 },
  { 571, 5, 14, 8, 1, -10 },
  { 580, 5, 14, 7, 1, -14 },
  { 589, 1, 13, 3, 1, -13 },
  { 591, 2, 17, 3, 0, -13 },
  { 596, 5, 14, 6, 1, -14 },
  { 605, 1, 14, 3, 1, -14 },
  { 607, 9, 10, 11, 1, -10 },
  { 619, 5, 10, 7, 1, -10 },
  { 626, 5, 10, 7, 1, -10 },
  { 633, 6, 14, 8, 1, -10 },
  { 644, 5, 14, 8, 1, -10 },
  { 653, 4, 10, 5, 1, -10 },
  { 658, 4, 10, 6, 1, -10 },
  { 663, 4, 12, 4, 0, -12 },
  { 669, 5, 9, 7, 1, -9 },
  { 675, 5, 9, 5, 0, -9 },
  { 681, 9, 9, 9, 0, -9 },
  { 692, 5, 9, 6, 0, -9 },
  { 698, 6, 13, 6, 0, -9 },
  { 708, 3, 9, 5, 1, -9 },
  { 712, 4, 16, 6, 1, -13 },
  { 720, 1, 18, 7, 3, -14 },
  { 723, 4, 16, 6, 1, -13 },
  { 731, 6, 1, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Thin18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN18PT7B_H_
