#ifndef _NOTOSANS_EXTRACONDENSED_THIN35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xE1, 0x80, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84,
  0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x84, 0x04, 0x20, 0x21, 0x1F,
  0xFF, 0x08, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x40, 0x42,
  0x02, 0x10, 0xFF, 0xF0, 0x84, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x84, 0x04, 0x20, 0x21, 0x00, 0x04, 0x00, 0x40, 0x0F, 0x03, 0x4E, 0x44,
  0x04, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x04, 0x40, 0x24,
  0x01, 0xC0, 0x06, 0x00, 0x58, 0x04, 0x40, 0x42, 0x04, 0x20, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x20, 0x42, 0x84, 0x47, 0xF8, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x78, 0x18, 0x88, 0x10, 0x84, 0x10, 0x84, 0x20, 0x84, 0x20, 0x84,
  0x20, 0x84, 0x40, 0x84, 0x40, 0x84, 0x40, 0x84, 0x80, 0x84, 0x9E, 0x84,
  0x91, 0x84, 0xA1, 0x89, 0x21, 0x79, 0x21, 0x01, 0x21, 0x02, 0x21, 0x02,
  0x21, 0x02, 0x21, 0x04, 0x21, 0x04, 0x21, 0x04, 0x21, 0x08, 0x21, 0x08,
  0x11, 0x18, 0x1E, 0x1E, 0x00, 0x88, 0x08, 0x40, 0x42, 0x02, 0x10, 0x10,
  0x80, 0x84, 0x04, 0x20, 0x11, 0x00, 0x90, 0x03, 0x00, 0x10, 0x01, 0x40,
  0x12, 0x01, 0x08, 0x48, 0x42, 0x81, 0x14, 0x08, 0xA0, 0x29, 0x01, 0x48,
  0x04, 0x40, 0x31, 0x02, 0x88, 0x32, 0x3E, 0x18, 0xFF, 0x80, 0x0C, 0x21,
  0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40, 0xC1, 0x82,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x08, 0x00, 0x08, 0x08,
  0x08, 0x91, 0x76, 0x18, 0x28, 0x24, 0x42, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x24, 0x94, 0x92, 0x80, 0xFE,
  0xF0, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x1E, 0x08, 0x44,
  0x09, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90,
  0x24, 0x08, 0x84, 0x1E, 0x00, 0x08, 0xCA, 0x98, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x3F, 0x08, 0x10,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x3F, 0x18, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x02, 0x03,
  0x81, 0xF0, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x14, 0x06, 0x7F, 0x00, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x02, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00, 0x48, 0x04, 0x40, 0x22, 0x02,
  0x10, 0x10, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04, 0x08, 0x40, 0x42, 0x02,
  0x3F, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x7F, 0x90, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x0F, 0xE2, 0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x20, 0x0A, 0x04, 0xFE, 0x00, 0x0F, 0x84, 0x02, 0x01,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xF2, 0x82, 0xC0,
  0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14,
  0x09, 0x82, 0x3F, 0x00, 0xFF, 0xC0, 0x10, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x1F, 0x82, 0x04, 0x40, 0x44, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02,
  0x20, 0x43, 0x08, 0x19, 0x00, 0x60, 0x0B, 0x01, 0x08, 0x20, 0x44, 0x06,
  0x40, 0x28, 0x02, 0x80, 0x38, 0x02, 0x80, 0x24, 0x02, 0x40, 0x22, 0x04,
  0x1F, 0x80, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24, 0x05, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x05, 0x00, 0xA0, 0x34, 0x06, 0x41, 0x47, 0xC8, 0x01,
  0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x7E,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x2C, 0x80, 0x00, 0x00, 0x00, 0x01,
  0x24, 0xA4, 0x94, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x00, 0x80, 0x00, 0xFC, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x41, 0x82, 0x08, 0x10, 0x20, 0x40, 0x80, 0x00, 0x00, 0x00, 0x10,
  0x20, 0x03, 0xF0, 0x06, 0x04, 0x06, 0x01, 0x02, 0x00, 0x42, 0x00, 0x12,
  0x00, 0x09, 0x00, 0x04, 0x81, 0xE1, 0x41, 0x10, 0xC1, 0x08, 0x61, 0x04,
  0x30, 0x82, 0x18, 0x41, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x08, 0x41, 0x84,
  0x20, 0xC2, 0x10, 0x61, 0x0C, 0x30, 0x4A, 0x28, 0x38, 0xE2, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x04, 0x00, 0xFE,
  0x00, 0x02, 0x00, 0x18, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x40, 0x22,
  0x01, 0x10, 0x08, 0x80, 0x42, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20,
  0xFF, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x30, 0x01, 0x80, 0x08, 0xFE, 0x10, 0x32, 0x02, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x12, 0x06, 0x7F, 0x08, 0x31,
  0x01, 0x20, 0x14, 0x02, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x05, 0x00,
  0xA0, 0x34, 0x0C, 0xFE, 0x00, 0x07, 0xF1, 0x80, 0x30, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x01, 0x81, 0x07, 0xF0, 0xFE, 0x08, 0x10, 0x80, 0x88,
  0x04, 0x80, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x48, 0x04, 0x80, 0x88, 0x10, 0xFE, 0x00, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xE8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x07, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x20, 0x11, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x04, 0x80, 0x11, 0x00, 0x46,
  0x01, 0x07, 0xF8, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x2F, 0x80, 0x80, 0x60, 0x28, 0x12, 0x04, 0x82,
  0x20, 0x88, 0x42, 0x20, 0x88, 0x24, 0x09, 0x02, 0xC0, 0xD0, 0x32, 0x08,
  0x82, 0x10, 0x84, 0x20, 0x88, 0x22, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x01,
  0x80, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x2D, 0x00, 0x16, 0x80, 0x0B, 0x40, 0x09, 0x90, 0x04, 0xC8, 0x02,
  0x64, 0x02, 0x31, 0x01, 0x18, 0x80, 0x8C, 0x40, 0x46, 0x20, 0x43, 0x08,
  0x21, 0x84, 0x10, 0xC2, 0x10, 0x60, 0x88, 0x30, 0x44, 0x18, 0x24, 0x0C,
  0x0A, 0x06, 0x05, 0x03, 0x02, 0x81, 0x80, 0x80, 0x80, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0xA0, 0x1A, 0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x81,
  0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18, 0x11, 0x81, 0x18, 0x09,
  0x80, 0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38, 0x03, 0x80, 0x10, 0x0F,
  0xC0, 0x40, 0x82, 0x01, 0x10, 0x06, 0x40, 0x09, 0x00, 0x28, 0x00, 0xA0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x90, 0x02, 0x40, 0x09,
  0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0xFC, 0x20, 0xC8, 0x0A, 0x02,
  0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x81, 0x3F,
  0x88, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x00, 0x0F, 0xC0, 0x40, 0x82, 0x01, 0x10, 0x02, 0x40, 0x09,
  0x00, 0x28, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x90, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0F, 0xC0, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0xFC, 0x20,
  0xC8, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A,
  0x04, 0x86, 0x3E, 0x08, 0x42, 0x10, 0x82, 0x20, 0x88, 0x22, 0x04, 0x81,
  0x20, 0x28, 0x0A, 0x01, 0x80, 0x40, 0x1F, 0xE4, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x14, 0x06, 0x7F, 0x00, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x1A,
  0x02, 0x3F, 0x80, 0x80, 0x0C, 0x00, 0x50, 0x04, 0x80, 0x24, 0x01, 0x20,
  0x09, 0x00, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x10, 0x20, 0x81, 0x04,
  0x08, 0x20, 0x42, 0x01, 0x10, 0x08, 0x80, 0x44, 0x02, 0x20, 0x12, 0x00,
  0x50, 0x02, 0x80, 0x14, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x10, 0x06, 0x00,
  0x40, 0x14, 0x03, 0x00, 0x50, 0x0C, 0x01, 0x40, 0x28, 0x09, 0x00, 0xA0,
  0x22, 0x02, 0x80, 0x88, 0x12, 0x02, 0x20, 0x48, 0x08, 0x81, 0x10, 0x42,
  0x04, 0x41, 0x04, 0x11, 0x04, 0x10, 0x84, 0x10, 0x42, 0x10, 0x41, 0x08,
  0x22, 0x04, 0x20, 0x88, 0x08, 0x82, 0x20, 0x24, 0x08, 0x80, 0x90, 0x24,
  0x02, 0x40, 0x50, 0x05, 0x01, 0x40, 0x14, 0x05, 0x00, 0x60, 0x14, 0x01,
  0x80, 0x60, 0x06, 0x00, 0x80, 0x40, 0x24, 0x04, 0x81, 0x10, 0x21, 0x04,
  0x21, 0x02, 0x20, 0x48, 0x09, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x02, 0x40, 0x48, 0x09, 0x02, 0x10, 0x42, 0x08, 0x42, 0x04, 0x40, 0x90,
  0x12, 0x01, 0xC0, 0x20, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x41,
  0x08, 0x21, 0x04, 0x11, 0x02, 0x20, 0x44, 0x05, 0x00, 0xA0, 0x14, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0xFF, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0x80,
  0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x04, 0x00,
  0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x02, 0x00, 0x40, 0xFE, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x02,
  0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x81, 0x08, 0x20, 0x42, 0x04, 0x40,
  0x24, 0x02, 0x80, 0x38, 0x01, 0xFF, 0xFC, 0xC2, 0x08, 0x20, 0x84, 0x1E,
  0x10, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x03, 0x8E, 0x48, 0x28,
  0x14, 0x0C, 0x06, 0x03, 0x01, 0x41, 0xA0, 0xCF, 0xA0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8F, 0x12, 0x12, 0x81,
  0x60, 0x2C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xA0, 0x54, 0x1A, 0x7E, 0x00, 0x0F,
  0x31, 0x60, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x60, 0x3F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x1E, 0x48, 0x54, 0x0D, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x40, 0xD0, 0x53, 0xF4, 0x1E, 0x08, 0xC4, 0x11, 0x02, 0x80, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x7F, 0xE8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x08, 0x21, 0xF8, 0x07, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x30, 0xDC, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1E, 0x08, 0x54, 0x0D, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x40, 0xD0, 0x53, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0xA0, 0x2F, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x8E, 0x24, 0x6A, 0x0B, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0xF0, 0x01, 0x55, 0x55, 0x55, 0x55, 0x40, 0x33, 0x00,
  0x00, 0x01, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x22, 0xE0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0xA0, 0x90, 0x48, 0x44, 0x22, 0x21, 0x20, 0x98, 0x54, 0x29,
  0x18, 0x88, 0x44, 0x12, 0x09, 0x02, 0x81, 0x40, 0x60, 0x20, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x1E, 0x48, 0x91, 0xA8, 0x30, 0x58, 0x18, 0x1C, 0x08,
  0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x0E, 0x24, 0x6A, 0x0B, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x1E, 0x04, 0x21, 0x02, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x06, 0x00, 0xC0, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x40, 0x8C, 0x10, 0xFC, 0x00, 0x0F, 0x12,
  0x12, 0x81, 0x50, 0x2C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x02, 0xA0, 0x56, 0x12, 0x7C,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x00,
  0x1E, 0x0C, 0x54, 0x0D, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0xD8, 0x53, 0xF4,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0D, 0x26,
  0x85, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x00, 0x1E, 0x10, 0xD0, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x10, 0x04, 0x02, 0x01, 0x01, 0x40, 0x9F,
  0x80, 0x21, 0x04, 0x10, 0x7F, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x40, 0x83, 0xC0, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x14, 0x0D, 0x03, 0x41, 0x4F, 0x90, 0x80, 0x50, 0x14, 0x09, 0x02, 0x40,
  0x88, 0x22, 0x10, 0x84, 0x21, 0x08, 0x41, 0x20, 0x48, 0x12, 0x04, 0x80,
  0xA0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0xC0, 0xD0, 0x30, 0x24, 0x0C, 0x09,
  0x03, 0x02, 0x41, 0x20, 0x88, 0x48, 0x42, 0x12, 0x10, 0x84, 0x84, 0x21,
  0x11, 0x04, 0x84, 0x81, 0x21, 0x20, 0x48, 0x48, 0x12, 0x12, 0x04, 0x82,
  0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x80, 0xA0,
  0x90, 0x44, 0x42, 0x20, 0x90, 0x50, 0x18, 0x08, 0x06, 0x05, 0x02, 0x82,
  0x21, 0x11, 0x04, 0x82, 0x80, 0xC0, 0x40, 0x40, 0x28, 0x09, 0x01, 0x10,
  0x22, 0x04, 0x41, 0x08, 0x20, 0x84, 0x10, 0x82, 0x20, 0x44, 0x04, 0x80,
  0xA0, 0x14, 0x02, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x10, 0x1E, 0x00, 0xFE, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0xFC, 0x07,
  0x08, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0xE0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x08, 0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0x10, 0x10, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x04, 0x03, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0x70, 0x80, 0x38, 0x1C, 0x61, 0x81, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 25, 7, 3, -25 },
  { 5, 6, 9, 10, 2, -25 },
  { 12, 13, 25, 15, 1, -25 },
  { 53, 12, 29, 14, 1, -27 },
  { 97, 16, 25, 20, 2, -25 },
  { 147, 13, 25, 13, 1, -25 },
  { 188, 1, 9, 6, 2, -25 },
  { 190, 6, 31, 9, 2, -25 },
  { 214, 6, 31, 9, 1, -25 },
  { 238, 8, 9, 12, 2, -27 },
  { 247, 12, 16, 14, 1, -20 },
  { 271, 3, 9, 6, 1, -4 },
  { 275, 7, 1, 9, 1, -10 },
  { 276, 2, 2, 6, 2, -2 },
  { 277, 10, 25, 11, 1, -25 },
  { 309, 10, 25, 14, 2, -25 },
  { 341, 5, 25, 14, 3, -25 },
  { 357, 11, 25, 14, 1, -25 },
  { 392, 11, 25, 14, 1, -25 },
  { 427, 13, 25, 14, 0, -25 },
  { 468, 10, 25, 14, 2, -25 },
  { 500, 10, 25, 14, 2, -25 },
  { 532, 10, 25, 14, 2, -25 },
  { 564, 12, 25, 14, 1, -25 },
  { 602, 11, 25, 14, 1, -25 },
  { 637, 2, 19, 6, 2, -19 },
  { 642, 3, 24, 6, 1, -19 },
  { 651, 12, 15, 14, 1, -20 },
  { 674, 12, 9, 14, 1, -17 },
  { 688, 12, 15, 14, 1, -20 },
  { 711, 7, 25, 9, 1, -25 },
  { 733, 17, 28, 21, 2, -25 },
  { 793, 13, 25, 13, 0, -25 },
  { 834, 11, 25, 15, 3, -25 },
  { 869, 12, 25, 15, 2, -25 },
  { 907, 12, 25, 17, 3, -25 },
  { 945, 9, 25, 13, 3, -25 },
  { 974, 9, 25, 12, 3, -25 },
  { 1003, 14, 25, 18, 2, -25 },
  { 1047, 11, 25, 17, 3, -25 },
  { 1082, 5, 25, 8, 1, -25 },
  { 1098, 6, 31, 7, -2, -25 },
  { 1122, 10, 25, 13, 3, -25 },
  { 1154, 8, 25, 12, 3, -25 },
  { 1179, 17, 25, 23, 3, -25 },
  { 1233, 12, 25, 18, 3, -25 },
  { 1271, 14, 25, 18, 2, -25 },
  { 1315, 10, 25, 14, 3, -25 },
  { 1347, 14, 31, 18, 2, -25 },
  { 1402, 10, 25, 14, 3, -25 },
  { 1434, 11, 25, 14, 1, -25 },
  { 1469, 11, 25, 12, 0, -25 },
  { 1504, 11, 25, 17, 3, -25 },
  { 1539, 13, 25, 13, 0, -25 },
  { 1580, 22, 25, 23, 0, -25 },
  { 1649, 11, 25, 12, 0, -25 },
  { 1684, 11, 25, 11, 0, -25 },
  { 1719, 10, 25, 11, 1, -25 },
  { 1751, 6, 31, 11, 3, -25 },
  { 1775, 10, 25, 11, 1, -25 },
  { 1807, 7, 31, 11, 1, -25 },
  { 1835, 12, 12, 14, 1, -25 },
  { 1853, 14, 1, 14, 0, 3 },
  { 1855, 5, 6, 8, 1, -27 },
  { 1859, 9, 19, 13, 1, -19 },
  { 1881, 11, 27, 15, 2, -27 },
  { 1919, 8, 19, 11, 2, -19 },
  { 1938, 10, 27, 15, 2, -27 },
  { 1972, 10, 19, 13, 2, -19 },
  { 1996, 8, 27, 7, 0, -27 },
  { 2023, 10, 27, 15, 2, -19 },
  { 2057, 10, 27, 14, 2, -27 },
  { 2091, 2, 25, 6, 2, -25 },
  { 2098, 4, 33, 6, 0, -25 },
  { 2115, 9, 27, 11, 2, -27 },
  { 2146, 1, 27, 6, 2, -27 },
  { 2150, 17, 19, 21, 2, -19 },
  { 2191, 10, 19, 14, 2, -19 },
  { 2215, 11, 19, 14, 2, -19 },
  { 2242, 11, 27, 15, 2, -19 },
  { 2280, 10, 27, 15, 2, -19 },
  { 2314, 7, 19, 9, 2, -19 },
  { 2331, 9, 19, 11, 1, -19 },
  { 2353, 6, 23, 7, 1, -23 },
  { 2371, 10, 18, 14, 2, -18 },
  { 2394, 10, 18, 10, 0, -18 },
  { 2417, 18, 18, 18, 0, -18 },
  { 2458, 9, 18, 11, 1, -18 },
  { 2479, 11, 26, 11, 0, -18 },
  { 2515, 7, 18, 9, 1, -18 },
  { 2531, 8, 31, 12, 2, -25 },
  { 2562, 1, 35, 13, 6, -27 },
  { 2567, 8, 31, 12, 2, -25 },
  { 2598, 12, 3, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Thin35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN35PT7B_H_
