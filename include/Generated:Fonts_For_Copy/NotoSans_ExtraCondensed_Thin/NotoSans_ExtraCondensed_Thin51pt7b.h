#ifndef _NOTOSANS_EXTRACONDENSED_THIN51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x82, 0xC1, 0x20, 0x90, 0x48, 0x24,
  0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01,
  0x01, 0x00, 0x10, 0x30, 0x03, 0x03, 0x00, 0x30, 0x20, 0x02, 0x02, 0x00,
  0x20, 0x20, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x02, 0x02, 0x00, 0x20, 0x20,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x40, 0x40, 0x04, 0x04,
  0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x0F, 0xFF,
  0xFC, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08,
  0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x10, 0x10, 0x01, 0x01, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0xFE, 0x01, 0xD3, 0xE1, 0x88, 0x31, 0x84, 0x01, 0x82, 0x00,
  0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x10, 0x04, 0x08,
  0x02, 0x04, 0x01, 0x82, 0x00, 0x61, 0x00, 0x18, 0x80, 0x06, 0x40, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x04, 0xE0, 0x02, 0x18, 0x01, 0x06,
  0x00, 0x81, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x0C, 0x04,
  0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x81, 0x80, 0x41, 0x98, 0x21, 0x8F,
  0xD7, 0x80, 0x7E, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x19, 0x80, 0x10, 0x08, 0x60, 0x18, 0x0C, 0x10,
  0x08, 0x04, 0x08, 0x04, 0x02, 0x06, 0x06, 0x01, 0x01, 0x02, 0x01, 0x80,
  0x81, 0x00, 0xC0, 0x41, 0x80, 0x60, 0x20, 0x80, 0x30, 0x10, 0x40, 0x18,
  0x08, 0x60, 0x0C, 0x04, 0x20, 0x06, 0x02, 0x10, 0x03, 0x01, 0x18, 0x00,
  0x80, 0x88, 0x78, 0x40, 0x44, 0x42, 0x20, 0x66, 0x61, 0x90, 0x22, 0x20,
  0x4C, 0x11, 0x10, 0x22, 0x19, 0x98, 0x11, 0x98, 0x8C, 0x0C, 0x78, 0x44,
  0x06, 0x00, 0x62, 0x01, 0x00, 0x21, 0x00, 0x80, 0x10, 0x80, 0x40, 0x18,
  0x40, 0x20, 0x08, 0x20, 0x10, 0x04, 0x10, 0x08, 0x06, 0x08, 0x0C, 0x02,
  0x06, 0x06, 0x01, 0x03, 0x02, 0x01, 0x80, 0x81, 0x00, 0x80, 0x40, 0x80,
  0x40, 0x30, 0xC0, 0x60, 0x08, 0x40, 0x20, 0x03, 0xC0, 0x07, 0x80, 0x03,
  0x30, 0x01, 0x86, 0x00, 0x40, 0x80, 0x10, 0x20, 0x0C, 0x0C, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80,
  0x18, 0x20, 0x02, 0x10, 0x00, 0x8C, 0x00, 0x12, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x64, 0x00, 0x31, 0x00, 0x18, 0x20, 0x64, 0x0C,
  0x1B, 0x01, 0x06, 0x80, 0x61, 0x20, 0x08, 0x48, 0x01, 0x12, 0x00, 0x44,
  0x80, 0x0A, 0x20, 0x02, 0x88, 0x00, 0x62, 0x00, 0x18, 0xC0, 0x0E, 0x10,
  0x06, 0xC6, 0x03, 0x10, 0xC1, 0x82, 0x1F, 0xC0, 0xC0, 0x80, 0x00, 0xFF,
  0xFD, 0x55, 0x40, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40,
  0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80,
  0x40, 0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08, 0x20, 0xB1, 0x1C, 0x7F,
  0x00, 0x40, 0x05, 0x00, 0x64, 0x02, 0x10, 0x20, 0xC2, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x33, 0x33, 0x22, 0x66, 0x44, 0xC8, 0xFF,
  0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xC0, 0x06, 0x70, 0x08, 0x18, 0x18, 0x08, 0x30, 0x0C, 0x20, 0x04,
  0x20, 0x04, 0x60, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x02, 0x60, 0x06,
  0x20, 0x06, 0x20, 0x04, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x18, 0x0C, 0x30,
  0x07, 0xE0, 0x03, 0x07, 0x0D, 0x19, 0x31, 0xC1, 0x81, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x0F, 0xC0, 0x3C, 0xF0, 0x60, 0x18, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0x0F, 0xC0, 0x3C, 0xF0, 0xE0, 0x18, 0x80, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x30, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0xC0, 0x38, 0x7F, 0xE0, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x48, 0x00, 0x09,
  0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0x80, 0x02, 0x10, 0x00, 0xC2,
  0x00, 0x10, 0x40, 0x06, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20, 0x04, 0x04,
  0x01, 0x80, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00, 0x40, 0x60, 0x08,
  0x08, 0x01, 0x03, 0x00, 0x20, 0x40, 0x04, 0x18, 0x00, 0x82, 0x00, 0x10,
  0x7F, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x3F, 0xFC, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x47, 0x80, 0x7F, 0xF0, 0x40, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x80, 0x18, 0xE0, 0x30, 0x7F, 0xE0,
  0x00, 0x78, 0x03, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47, 0xF0, 0x4C, 0x18, 0x50, 0x0C,
  0x70, 0x04, 0x60, 0x06, 0xE0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03,
  0x60, 0x02, 0x20, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x0C, 0x18, 0x18,
  0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0x03, 0xE0, 0x0F, 0x78, 0x10, 0x0C, 0x30, 0x04, 0x60, 0x06, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x06,
  0x20, 0x06, 0x30, 0x0C, 0x18, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x01, 0x80,
  0x03, 0xC0, 0x0C, 0x30, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x04, 0x40, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x30, 0x04, 0x18, 0x18,
  0x0F, 0xF0, 0x01, 0x80, 0x07, 0xC0, 0x38, 0xE0, 0x40, 0x61, 0x00, 0x46,
  0x00, 0xC8, 0x00, 0x90, 0x01, 0x60, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x06,
  0x80, 0x0D, 0x00, 0x1B, 0x00, 0x53, 0x01, 0xA3, 0x8E, 0x41, 0xF0, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x07, 0x03,
  0xF8, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x33, 0x33, 0x22, 0x64, 0x44, 0x88, 0x00, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x00, 0x3E, 0x1E, 0x72, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x40, 0x01, 0x80,
  0x40, 0x00, 0x60, 0x60, 0x00, 0x10, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x02,
  0x10, 0x00, 0x01, 0x98, 0x00, 0x00, 0x48, 0x03, 0xF0, 0x24, 0x03, 0x08,
  0x1A, 0x03, 0x04, 0x0F, 0x03, 0x02, 0x07, 0x81, 0x01, 0x01, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x10,
  0x18, 0x0C, 0x08, 0x0C, 0x06, 0x04, 0x06, 0x03, 0x02, 0x03, 0x01, 0x81,
  0x01, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x50, 0x10, 0x50, 0x2C,
  0x08, 0x28, 0x36, 0x02, 0x26, 0x31, 0x01, 0xF1, 0xF0, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x01,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0x58, 0x00, 0x19, 0x00, 0x03, 0x20, 0x00, 0x44,
  0x00, 0x08, 0x80, 0x01, 0x18, 0x00, 0x61, 0x00, 0x08, 0x20, 0x01, 0x04,
  0x00, 0x20, 0xC0, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x06, 0x00, 0x40, 0x80, 0x08, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x02,
  0x10, 0x00, 0x42, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x12, 0x00, 0x02,
  0x40, 0x00, 0x48, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x10, 0xFF, 0xF0,
  0x80, 0x38, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04,
  0x80, 0x0C, 0x80, 0x08, 0x80, 0x30, 0xFF, 0xE0, 0x81, 0xF0, 0x80, 0x18,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x06, 0x80, 0x04, 0x80, 0x1C, 0x80, 0x78, 0xFF, 0xE0, 0x00, 0xFE,
  0x01, 0xE3, 0xC1, 0x80, 0x21, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x1F, 0xF0, 0x00, 0x80, 0xFF, 0xE0, 0x40, 0x38, 0x20,
  0x06, 0x10, 0x01, 0x88, 0x00, 0x64, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x02,
  0x80, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x34, 0x00, 0x12, 0x00,
  0x19, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x1C, 0x20, 0x3C, 0x1F, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xFF, 0xF4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x3F, 0xFD, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0x1F, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34,
  0x00, 0x01, 0xB0, 0x00, 0x0C, 0x80, 0x00, 0x66, 0x00, 0x03, 0x18, 0x00,
  0x18, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x70, 0x0F, 0xFE, 0x00,
  0x06, 0x00, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x47, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0xDC, 0xF8,
  0x80, 0x07, 0x00, 0x1A, 0x00, 0x24, 0x00, 0x88, 0x03, 0x10, 0x04, 0x20,
  0x18, 0x40, 0x20, 0x80, 0xC1, 0x03, 0x02, 0x04, 0x04, 0x18, 0x08, 0x20,
  0x10, 0xC0, 0x23, 0x00, 0x44, 0x00, 0x9C, 0x01, 0x28, 0x02, 0x98, 0x07,
  0x10, 0x0C, 0x30, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0x80, 0xC1, 0x00,
  0x82, 0x01, 0x84, 0x01, 0x08, 0x03, 0x10, 0x02, 0x20, 0x06, 0x40, 0x04,
  0x80, 0x0D, 0x00, 0x0A, 0x00, 0x1C, 0x00, 0x10, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF4,
  0x00, 0x00, 0x5A, 0x00, 0x00, 0x2D, 0x80, 0x00, 0x36, 0x40, 0x00, 0x1B,
  0x20, 0x00, 0x09, 0x98, 0x00, 0x04, 0xC4, 0x00, 0x06, 0x62, 0x00, 0x02,
  0x31, 0x80, 0x01, 0x18, 0xC0, 0x01, 0x8C, 0x20, 0x00, 0x86, 0x10, 0x00,
  0x43, 0x0C, 0x00, 0x61, 0x82, 0x00, 0x30, 0xC1, 0x00, 0x10, 0x60, 0xC0,
  0x18, 0x30, 0x20, 0x0C, 0x18, 0x10, 0x04, 0x0C, 0x0C, 0x02, 0x06, 0x02,
  0x03, 0x03, 0x01, 0x01, 0x01, 0x80, 0xC0, 0x80, 0xC0, 0x60, 0xC0, 0x60,
  0x10, 0x40, 0x30, 0x08, 0x20, 0x18, 0x06, 0x30, 0x0C, 0x01, 0x18, 0x06,
  0x00, 0x88, 0x03, 0x00, 0x64, 0x01, 0x80, 0x16, 0x00, 0xC0, 0x0A, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x10, 0xC0, 0x00, 0xF0, 0x00, 0x3A,
  0x00, 0x0E, 0x80, 0x03, 0xB0, 0x00, 0xE4, 0x00, 0x39, 0x80, 0x0E, 0x20,
  0x03, 0x8C, 0x00, 0xE1, 0x00, 0x38, 0x40, 0x0E, 0x18, 0x03, 0x82, 0x00,
  0xE0, 0xC0, 0x38, 0x10, 0x0E, 0x06, 0x03, 0x80, 0x80, 0xE0, 0x20, 0x38,
  0x04, 0x0E, 0x01, 0x03, 0x80, 0x60, 0xE0, 0x08, 0x38, 0x03, 0x0E, 0x00,
  0x43, 0x80, 0x18, 0xE0, 0x02, 0x38, 0x00, 0x8E, 0x00, 0x13, 0x80, 0x04,
  0xE0, 0x01, 0xB8, 0x00, 0x2E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x01, 0xF8, 0x00, 0x79, 0xE0, 0x0C, 0x03, 0x01,
  0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x06,
  0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x34,
  0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x04,
  0x30, 0x00, 0xC1, 0x80, 0x08, 0x0C, 0x01, 0x80, 0xE0, 0x70, 0x03, 0xFC,
  0x00, 0x02, 0x00, 0xFF, 0xC2, 0x01, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1A, 0x00, 0x48, 0x06,
  0x3F, 0xF0, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x79, 0xE0, 0x0C,
  0x03, 0x01, 0x80, 0x18, 0x10, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x66,
  0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x24, 0x00, 0x02, 0x60, 0x00, 0x62,
  0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x08, 0x08, 0x01, 0x80, 0x60, 0x70,
  0x03, 0xFC, 0x00, 0x02, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x08, 0xFF, 0xC0, 0x80, 0x70, 0x80, 0x18, 0x80, 0x08, 0x80, 0x0C, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x06, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x10, 0x80,
  0x70, 0xFF, 0xC0, 0xFF, 0x00, 0x81, 0x80, 0x81, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80,
  0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80,
  0x03, 0x03, 0xF8, 0x0F, 0x1E, 0x18, 0x02, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0xC0,
  0x38, 0x7F, 0xE0, 0x02, 0x00, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0F, 0x00, 0x04, 0x80, 0x02, 0x60, 0x03, 0x18, 0x03, 0x06, 0x03,
  0x01, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x09, 0x00, 0x01,
  0x20, 0x00, 0x64, 0x00, 0x0C, 0xC0, 0x01, 0x08, 0x00, 0x21, 0x00, 0x0C,
  0x20, 0x01, 0x86, 0x00, 0x20, 0x40, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30,
  0x30, 0x04, 0x06, 0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80,
  0x30, 0x10, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x08, 0x18, 0x01, 0x82, 0x00,
  0x10, 0x40, 0x02, 0x18, 0x00, 0x43, 0x00, 0x0C, 0x40, 0x01, 0x88, 0x00,
  0x11, 0x00, 0x02, 0x60, 0x00, 0x48, 0x00, 0x0D, 0x00, 0x00, 0xA0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0xA0,
  0x00, 0xC0, 0x00, 0x90, 0x00, 0x70, 0x00, 0x48, 0x00, 0x28, 0x00, 0x66,
  0x00, 0x14, 0x00, 0x31, 0x00, 0x0A, 0x00, 0x10, 0x80, 0x0D, 0x00, 0x08,
  0x40, 0x06, 0xC0, 0x04, 0x30, 0x02, 0x60, 0x06, 0x18, 0x01, 0x10, 0x03,
  0x04, 0x00, 0x88, 0x01, 0x02, 0x00, 0xC4, 0x00, 0x81, 0x00, 0x63, 0x00,
  0xC0, 0xC0, 0x21, 0x80, 0x60, 0x60, 0x10, 0x40, 0x20, 0x10, 0x08, 0x20,
  0x10, 0x08, 0x0C, 0x10, 0x08, 0x04, 0x06, 0x0C, 0x0C, 0x03, 0x02, 0x06,
  0x06, 0x01, 0x81, 0x01, 0x02, 0x00, 0x40, 0x80, 0x81, 0x00, 0x20, 0xC0,
  0x40, 0x80, 0x18, 0x60, 0x30, 0xC0, 0x0C, 0x20, 0x18, 0x40, 0x02, 0x10,
  0x04, 0x20, 0x01, 0x08, 0x02, 0x10, 0x00, 0x8C, 0x01, 0x18, 0x00, 0x66,
  0x00, 0xCC, 0x00, 0x32, 0x00, 0x64, 0x00, 0x09, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x09, 0x00, 0x02, 0xC0, 0x05, 0x80, 0x01, 0xE0, 0x02, 0xC0, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x40, 0x02, 0xC0, 0x0C, 0x80, 0x11, 0x80, 0x61, 0x00, 0x82, 0x01, 0x06,
  0x06, 0x04, 0x08, 0x08, 0x10, 0x18, 0x60, 0x10, 0x80, 0x23, 0x00, 0x64,
  0x00, 0x48, 0x00, 0xF0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x16, 0x00, 0x24, 0x00, 0xC8, 0x01, 0x18, 0x06, 0x10, 0x08, 0x20, 0x10,
  0x60, 0x60, 0x40, 0x80, 0x83, 0x01, 0x86, 0x01, 0x08, 0x02, 0x30, 0x06,
  0x40, 0x04, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x10, 0xC0, 0x03, 0x40, 0x02,
  0x40, 0x02, 0x60, 0x06, 0x20, 0x04, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08,
  0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20,
  0x04, 0x20, 0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFC, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0xFF, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x3F, 0xF0, 0x00, 0xC0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x04,
  0xC0, 0x03, 0x10, 0x00, 0x86, 0x00, 0x60, 0x80, 0x10, 0x30, 0x0C, 0x04,
  0x02, 0x01, 0x81, 0x80, 0x20, 0x40, 0x0C, 0x30, 0x01, 0x08, 0x00, 0x66,
  0x00, 0x19, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0xC0,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x1F, 0xC1, 0x81, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x3F, 0x8E, 0x04, 0xC0, 0x2C, 0x01, 0x40, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x40, 0x2B, 0x02, 0x4F,
  0xE2, 0x04, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0xFE, 0x13, 0x06, 0x2C, 0x06, 0x50, 0x06, 0xC0, 0x05, 0x80,
  0x0B, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x15, 0x00, 0x6B, 0x01,
  0x93, 0x06, 0x23, 0xF8, 0x00, 0x80, 0x03, 0xF8, 0x70, 0x46, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x41, 0xFE, 0x01, 0x80, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x07, 0xF1, 0x0C, 0x19, 0x18, 0x0D, 0x30, 0x05,
  0x20, 0x07, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03,
  0x20, 0x05, 0x20, 0x05, 0x30, 0x0D, 0x18, 0x19, 0x0F, 0xF1, 0x01, 0x80,
  0x07, 0xE0, 0x18, 0x60, 0x40, 0x61, 0x80, 0x62, 0x00, 0x4C, 0x00, 0x90,
  0x01, 0x20, 0x03, 0x40, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x02, 0x18,
  0x18, 0x1F, 0xE0, 0x06, 0x00, 0x03, 0xE1, 0xC4, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x0F, 0xF0, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x07,
  0xF1, 0x1C, 0x19, 0x10, 0x0D, 0x30, 0x05, 0x20, 0x03, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x20, 0x05, 0x20, 0x05, 0x10,
  0x09, 0x18, 0x19, 0x0F, 0xE1, 0x01, 0x81, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x40,
  0x0C, 0x60, 0x38, 0x3F, 0xE0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0xFE, 0x4C, 0x3A, 0xC0, 0x54, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x7F, 0xA0, 0x00,
  0x01, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x08,
  0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0x84, 0xF0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x38, 0x06, 0x80, 0x48, 0x08,
  0x81, 0x88, 0x10, 0x83, 0x08, 0x20, 0x84, 0x08, 0xC0, 0x8C, 0x09, 0xC0,
  0xB4, 0x0A, 0x60, 0xE2, 0x0C, 0x30, 0x81, 0x08, 0x10, 0x81, 0x88, 0x08,
  0x80, 0xC8, 0x04, 0x80, 0x48, 0x06, 0x80, 0x28, 0x03, 0x80, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x8F, 0xC1, 0xF9, 0x20, 0xC6, 0x1A, 0x80, 0x90,
  0x1E, 0x01, 0x20, 0x3C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x08, 0x8F, 0xE4,
  0xC1, 0xAC, 0x05, 0x40, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x07, 0xF0, 0x1C, 0x18, 0x10, 0x0C,
  0x30, 0x06, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0x40, 0x03, 0x40, 0x01,
  0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03,
  0x60, 0x02, 0x20, 0x02, 0x30, 0x06, 0x10, 0x0C, 0x1C, 0x18, 0x07, 0xF0,
  0x00, 0x80, 0x8F, 0xE1, 0x30, 0x62, 0xC0, 0x65, 0x00, 0x6C, 0x00, 0x58,
  0x00, 0xB0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x03, 0x50, 0x04, 0xB0,
  0x19, 0x30, 0x62, 0x3F, 0x84, 0x08, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x00, 0x07, 0xF1, 0x0C, 0x19, 0x18, 0x0D, 0x30, 0x05,
  0x20, 0x05, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0x40, 0x01, 0x40, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03,
  0x20, 0x05, 0x30, 0x05, 0x10, 0x09, 0x1C, 0x19, 0x07, 0xF1, 0x01, 0x81,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x8F, 0xCC,
  0x6C, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x00, 0x1F, 0xE3, 0x03, 0x60, 0x0C, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x80, 0x2C, 0x0E, 0x7F, 0x80, 0x40, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x83, 0xFE, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x0F,
  0x81, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x05, 0xC0, 0x6B, 0x06, 0x4F, 0xE2, 0x08, 0x00,
  0xC0, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x66, 0x00, 0xC4, 0x01, 0x08,
  0x02, 0x10, 0x04, 0x30, 0x18, 0x60, 0x20, 0x40, 0x40, 0x80, 0x81, 0x83,
  0x03, 0x04, 0x02, 0x08, 0x04, 0x10, 0x08, 0x60, 0x18, 0xC0, 0x11, 0x00,
  0x22, 0x00, 0x4C, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xA0, 0x06, 0x00,
  0x58, 0x03, 0x80, 0x2C, 0x01, 0x40, 0x32, 0x01, 0xA0, 0x11, 0x00, 0x90,
  0x08, 0x80, 0x4C, 0x04, 0x60, 0x26, 0x06, 0x10, 0x31, 0x03, 0x08, 0x18,
  0x81, 0x04, 0x08, 0x40, 0x83, 0x04, 0x30, 0x40, 0x82, 0x08, 0x60, 0x43,
  0x04, 0x20, 0x21, 0x82, 0x10, 0x10, 0x81, 0x08, 0x0C, 0x40, 0xC4, 0x02,
  0x20, 0x26, 0x01, 0x30, 0x12, 0x00, 0x90, 0x09, 0x00, 0x68, 0x04, 0x80,
  0x14, 0x03, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x88, 0x04, 0x30,
  0x30, 0x40, 0x81, 0x82, 0x02, 0x18, 0x0C, 0x40, 0x13, 0x00, 0x48, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xA0, 0x04, 0x80, 0x33, 0x00,
  0x84, 0x06, 0x18, 0x10, 0x20, 0xC0, 0xC2, 0x01, 0x18, 0x06, 0x40, 0x09,
  0x00, 0x2C, 0x00, 0xC0, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x12, 0x00, 0x66,
  0x00, 0xC4, 0x01, 0x08, 0x02, 0x10, 0x0C, 0x30, 0x18, 0x60, 0x20, 0x40,
  0x40, 0x81, 0x81, 0x83, 0x03, 0x04, 0x02, 0x08, 0x04, 0x30, 0x0C, 0x60,
  0x18, 0x80, 0x11, 0x00, 0x26, 0x00, 0x68, 0x00, 0xD0, 0x00, 0xA0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x13, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x30, 0x06,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x18, 0x0F, 0x00, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0F, 0x01, 0xF0, 0x30, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x38, 0x0E, 0x00, 0x3E, 0x00, 0xE1, 0xC0, 0x60, 0x38, 0xD0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 36, 10, 4, -36 },
  { 10, 9, 13, 15, 3, -36 },
  { 25, 20, 36, 22, 1, -36 },
  { 115, 17, 42, 20, 2, -39 },
  { 205, 25, 37, 29, 2, -37 },
  { 321, 18, 38, 20, 2, -37 },
  { 407, 2, 13, 8, 3, -36 },
  { 411, 8, 44, 13, 3, -36 },
  { 455, 9, 44, 13, 2, -36 },
  { 505, 13, 13, 17, 2, -39 },
  { 527, 18, 24, 20, 1, -30 },
  { 581, 4, 12, 9, 2, -5 },
  { 587, 11, 2, 13, 1, -15 },
  { 590, 3, 3, 9, 3, -3 },
  { 592, 15, 36, 17, 1, -36 },
  { 660, 16, 37, 20, 2, -37 },
  { 734, 8, 36, 20, 4, -36 },
  { 770, 16, 37, 20, 2, -37 },
  { 844, 16, 38, 20, 2, -37 },
  { 920, 19, 37, 20, 1, -37 },
  { 1008, 16, 36, 20, 2, -36 },
  { 1080, 16, 38, 20, 2, -37 },
  { 1156, 15, 36, 20, 2, -36 },
  { 1224, 16, 38, 20, 2, -37 },
  { 1300, 15, 38, 20, 2, -37 },
  { 1372, 3, 27, 9, 3, -27 },
  { 1383, 4, 34, 9, 2, -27 },
  { 1400, 18, 20, 20, 1, -28 },
  { 1445, 18, 12, 20, 1, -24 },
  { 1472, 18, 20, 20, 1, -28 },
  { 1517, 11, 37, 13, 1, -37 },
  { 1568, 25, 42, 31, 3, -37 },
  { 1700, 19, 36, 19, 0, -36 },
  { 1786, 16, 36, 22, 4, -36 },
  { 1858, 17, 38, 21, 3, -37 },
  { 1939, 17, 36, 24, 4, -36 },
  { 2016, 13, 36, 19, 4, -36 },
  { 2075, 13, 36, 18, 4, -36 },
  { 2134, 21, 38, 27, 3, -37 },
  { 2234, 17, 36, 25, 4, -36 },
  { 2311, 7, 36, 11, 2, -36 },
  { 2343, 8, 45, 9, -2, -36 },
  { 2388, 15, 36, 19, 4, -36 },
  { 2456, 12, 36, 17, 4, -36 },
  { 2510, 25, 36, 33, 4, -36 },
  { 2623, 18, 36, 26, 4, -36 },
  { 2704, 20, 38, 26, 3, -37 },
  { 2799, 14, 36, 20, 4, -36 },
  { 2862, 20, 46, 26, 3, -37 },
  { 2977, 16, 36, 21, 4, -36 },
  { 3049, 16, 38, 20, 2, -37 },
  { 3125, 17, 36, 17, 0, -36 },
  { 3202, 17, 37, 25, 4, -36 },
  { 3281, 19, 36, 19, 0, -36 },
  { 3367, 33, 36, 33, 0, -36 },
  { 3516, 15, 36, 17, 1, -36 },
  { 3584, 16, 36, 16, 0, -36 },
  { 3656, 14, 36, 16, 1, -36 },
  { 3719, 10, 44, 16, 4, -36 },
  { 3774, 15, 36, 17, 1, -36 },
  { 3842, 9, 44, 16, 2, -36 },
  { 3892, 18, 17, 20, 1, -36 },
  { 3931, 20, 1, 20, 0, 5 },
  { 3934, 7, 8, 11, 2, -39 },
  { 3941, 13, 28, 19, 2, -27 },
  { 3987, 15, 40, 22, 4, -39 },
  { 4062, 13, 28, 16, 2, -27 },
  { 4108, 16, 40, 22, 2, -39 },
  { 4188, 15, 28, 19, 2, -27 },
  { 4241, 11, 39, 11, 1, -39 },
  { 4295, 16, 39, 22, 2, -27 },
  { 4373, 13, 39, 21, 4, -39 },
  { 4437, 3, 37, 9, 3, -37 },
  { 4451, 6, 49, 9, 0, -37 },
  { 4488, 12, 39, 17, 4, -39 },
  { 4547, 1, 39, 9, 4, -39 },
  { 4552, 23, 27, 31, 4, -27 },
  { 4630, 13, 27, 21, 4, -27 },
  { 4674, 16, 28, 21, 2, -27 },
  { 4730, 15, 39, 22, 4, -27 },
  { 4804, 16, 39, 22, 2, -27 },
  { 4882, 9, 27, 13, 4, -27 },
  { 4913, 12, 28, 16, 2, -27 },
  { 4955, 9, 34, 11, 1, -33 },
  { 4994, 13, 28, 21, 4, -27 },
  { 5040, 15, 27, 15, 0, -27 },
  { 5091, 25, 27, 26, 1, -27 },
  { 5176, 14, 27, 16, 1, -27 },
  { 5224, 15, 39, 16, 1, -27 },
  { 5298, 11, 27, 13, 1, -27 },
  { 5336, 12, 44, 18, 3, -36 },
  { 5402, 1, 51, 19, 9, -39 },
  { 5409, 12, 44, 18, 3, -36 },
  { 5475, 17, 4, 20, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Thin51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN51PT7B_H_
