#ifndef _NOTOSANS_EXTRACONDENSED_THIN16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x24, 0x92, 0x9F, 0x28, 0xA4, 0xBF, 0x49,
  0x24, 0x80, 0x31, 0x79, 0x24, 0x91, 0xC1, 0x07, 0x14, 0x51, 0x5E, 0x10,
  0x41, 0x4A, 0xA5, 0x4A, 0x96, 0xEE, 0xAD, 0x2A, 0x54, 0xAA, 0x30, 0x45,
  0x25, 0x2A, 0x23, 0x15, 0x9C, 0xA5, 0xD0, 0xF0, 0x6A, 0x49, 0x24, 0x92,
  0x24, 0x40, 0x95, 0x55, 0x55, 0xA0, 0x4F, 0x4A, 0x10, 0x41, 0x3F, 0x10,
  0x41, 0x00, 0xF0, 0xF0, 0x80, 0x08, 0x44, 0x22, 0x10, 0x88, 0x42, 0x20,
  0x64, 0xA5, 0x18, 0xC6, 0x31, 0x8C, 0x64, 0xE0, 0x74, 0x92, 0x49, 0x24,
  0x80, 0xE0, 0x84, 0x11, 0x08, 0x44, 0x22, 0x21, 0xF0, 0x64, 0x82, 0x11,
  0x09, 0xC2, 0x08, 0x43, 0xE0, 0x08, 0x61, 0x8A, 0x29, 0x24, 0xBF, 0x08,
  0x20, 0x80, 0xF4, 0x21, 0x0E, 0x08, 0x21, 0x08, 0xBC, 0x32, 0x21, 0x08,
  0x7A, 0x31, 0x8C, 0x63, 0xE0, 0xF1, 0x11, 0x22, 0x24, 0x44, 0x40, 0x64,
  0xA3, 0x19, 0x31, 0x92, 0x8C, 0x63, 0xE0, 0x69, 0x99, 0x99, 0x97, 0x11,
  0x1E, 0xC0, 0x80, 0xC1, 0xE0, 0x04, 0x66, 0x30, 0x30, 0x20, 0x40, 0xFC,
  0x00, 0x3F, 0xC0, 0xC0, 0x83, 0x11, 0x88, 0x00, 0x69, 0x11, 0x12, 0x24,
  0x40, 0x04, 0x7E, 0x42, 0x81, 0x9D, 0xA5, 0xA9, 0xA9, 0xA9, 0xAF, 0x90,
  0x80, 0x78, 0x30, 0xC3, 0x12, 0x49, 0x27, 0x92, 0x86, 0x18, 0x40, 0xFC,
  0x63, 0x1F, 0x46, 0x31, 0x8C, 0x7C, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x10, 0x70, 0xFA, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x2F, 0x00, 0xF8,
  0x88, 0xF8, 0x88, 0x88, 0xF0, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x80, 0x3D,
  0x08, 0x20, 0x82, 0x08, 0xE1, 0x86, 0x14, 0x4F, 0x86, 0x18, 0x61, 0xFE,
  0x18, 0x61, 0x86, 0x18, 0x40, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49, 0x24,
  0x93, 0x80, 0x8C, 0xA9, 0x4C, 0x52, 0x92, 0x94, 0x62, 0x88, 0x88, 0x88,
  0x88, 0x88, 0xF0, 0x81, 0x81, 0xC3, 0xC3, 0xA3, 0xA5, 0xA5, 0x95, 0x95,
  0x99, 0x89, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x8E, 0x18, 0x40, 0x31,
  0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0xF4, 0x63, 0x18, 0xFA,
  0x10, 0x84, 0x20, 0x31, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5A,
  0x10, 0x20, 0x80, 0xF4, 0x63, 0x18, 0xFA, 0x92, 0x94, 0x62, 0x74, 0x21,
  0x08, 0x20, 0x82, 0x08, 0x43, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0x80, 0x86, 0x18,
  0x92, 0x49, 0x24, 0x8C, 0x30, 0xC2, 0x00, 0x84, 0x61, 0x18, 0xC5, 0x31,
  0x4A, 0x94, 0xA5, 0x29, 0x4A, 0x32, 0x88, 0x42, 0x10, 0x4A, 0x54, 0x62,
  0x10, 0xCA, 0x4C, 0x62, 0x8C, 0x54, 0xA5, 0x10, 0x84, 0x21, 0x08, 0x78,
  0x84, 0x22, 0x10, 0x88, 0x42, 0x3E, 0xF2, 0x49, 0x24, 0x92, 0x49, 0xC0,
  0x82, 0x10, 0x42, 0x10, 0x42, 0x10, 0x42, 0xE4, 0x92, 0x49, 0x24, 0x93,
  0xC0, 0x10, 0xA4, 0x91, 0x84, 0xFC, 0x90, 0xE1, 0x11, 0x79, 0x99, 0xF0,
  0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x63, 0xE0, 0x78, 0x88, 0x88, 0x88,
  0x70, 0x08, 0x42, 0xD9, 0xC6, 0x31, 0x8C, 0x63, 0xF0, 0x69, 0x99, 0xF8,
  0x88, 0x70, 0x74, 0x4E, 0x44, 0x44, 0x44, 0x44, 0x64, 0xE3, 0x18, 0xC6,
  0x31, 0xF8, 0x42, 0x1F, 0x00, 0x88, 0x8E, 0x99, 0x99, 0x99, 0x99, 0xCF,
  0xF0, 0x50, 0x55, 0x55, 0x56, 0x88, 0x88, 0x9A, 0xCA, 0xAA, 0x99, 0xFF,
  0xF0, 0x66, 0x99, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x69, 0x99,
  0x99, 0x99, 0x90, 0x64, 0xA3, 0x18, 0xC6, 0x31, 0xF0, 0x36, 0x63, 0x18,
  0xC6, 0x31, 0xF4, 0x21, 0x08, 0x00, 0x64, 0xE3, 0x18, 0xC6, 0x31, 0xF8,
  0x42, 0x10, 0x80, 0x72, 0x49, 0x24, 0x80, 0x72, 0x44, 0x49, 0xE0, 0x4B,
  0xA4, 0x92, 0x49, 0x80, 0x99, 0x99, 0x99, 0x9F, 0x8C, 0xA4, 0xA5, 0x31,
  0x84, 0x89, 0x89, 0x59, 0x56, 0x56, 0x66, 0x26, 0x24, 0xCA, 0x94, 0x42,
  0x29, 0x51, 0x8A, 0x54, 0xA5, 0x10, 0x84, 0x21, 0x11, 0x80, 0x72, 0x22,
  0x44, 0x4F, 0x74, 0x44, 0x44, 0x84, 0x44, 0x44, 0x43, 0xFF, 0xFF, 0xC4,
  0x44, 0x44, 0x34, 0x44, 0x44, 0x48, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 6, 11, 7, 0, -11 },
  { 14, 6, 13, 6, 0, -12 },
  { 24, 7, 12, 9, 1, -12 },
  { 35, 5, 12, 6, 1, -12 },
  { 43, 1, 4, 3, 1, -11 },
  { 44, 3, 14, 4, 1, -11 },
  { 50, 2, 14, 4, 1, -11 },
  { 54, 4, 4, 5, 1, -12 },
  { 56, 6, 7, 6, 0, -9 },
  { 62, 1, 4, 3, 1, -2 },
  { 63, 4, 1, 4, 0, -5 },
  { 64, 1, 1, 3, 1, -1 },
  { 65, 5, 11, 5, 0, -11 },
  { 72, 5, 12, 6, 1, -12 },
  { 80, 3, 11, 6, 1, -11 },
  { 85, 5, 12, 6, 1, -12 },
  { 93, 5, 12, 6, 1, -12 },
  { 101, 6, 11, 6, 0, -11 },
  { 110, 5, 11, 6, 1, -11 },
  { 117, 5, 12, 6, 1, -12 },
  { 125, 4, 11, 6, 1, -11 },
  { 131, 5, 12, 6, 1, -12 },
  { 139, 4, 12, 6, 1, -12 },
  { 145, 1, 9, 3, 1, -9 },
  { 147, 1, 11, 3, 1, -9 },
  { 149, 6, 7, 6, 0, -9 },
  { 155, 6, 4, 6, 0, -8 },
  { 158, 6, 7, 6, 0, -9 },
  { 164, 4, 12, 4, 0, -12 },
  { 170, 8, 12, 10, 1, -11 },
  { 182, 6, 11, 6, 0, -11 },
  { 191, 5, 11, 7, 1, -11 },
  { 198, 5, 12, 7, 1, -12 },
  { 206, 6, 11, 8, 1, -11 },
  { 215, 4, 11, 6, 1, -11 },
  { 221, 4, 11, 6, 1, -11 },
  { 227, 6, 12, 8, 1, -12 },
  { 236, 6, 11, 8, 1, -11 },
  { 245, 2, 11, 4, 1, -11 },
  { 248, 3, 14, 3, -1, -11 },
  { 254, 5, 11, 6, 1, -11 },
  { 261, 4, 11, 5, 1, -11 },
  { 267, 8, 11, 10, 1, -11 },
  { 278, 6, 11, 8, 1, -11 },
  { 287, 6, 12, 8, 1, -12 },
  { 296, 5, 11, 6, 1, -11 },
  { 303, 6, 15, 8, 1, -12 },
  { 315, 5, 11, 6, 1, -11 },
  { 322, 5, 12, 6, 1, -12 },
  { 330, 5, 11, 5, 0, -11 },
  { 337, 6, 11, 8, 1, -11 },
  { 346, 6, 11, 6, 0, -11 },
  { 355, 10, 11, 10, 0, -11 },
  { 369, 5, 11, 5, 0, -11 },
  { 376, 5, 11, 5, 0, -11 },
  { 383, 5, 11, 5, 0, -11 },
  { 390, 3, 14, 5, 1, -11 },
  { 396, 5, 11, 5, 0, -11 },
  { 403, 3, 14, 5, 1, -11 },
  { 409, 6, 5, 6, 0, -11 },
  { 413, 6, 1, 6, 0, 1 },
  { 414, 2, 2, 4, 1, -12 },
  { 415, 4, 9, 6, 1, -9 },
  { 420, 5, 12, 7, 1, -12 },
  { 428, 4, 9, 5, 1, -9 },
  { 433, 5, 12, 7, 1, -12 },
  { 441, 4, 9, 6, 1, -9 },
  { 446, 4, 12, 3, 0, -12 },
  { 452, 5, 13, 7, 1, -9 },
  { 461, 4, 12, 7, 1, -12 },
  { 467, 1, 12, 3, 1, -12 },
  { 469, 2, 16, 3, 0, -12 },
  { 473, 4, 12, 5, 1, -12 },
  { 479, 1, 12, 3, 1, -12 },
  { 481, 8, 9, 10, 1, -9 },
  { 490, 4, 9, 7, 1, -9 },
  { 495, 5, 9, 6, 1, -9 },
  { 501, 5, 13, 7, 1, -9 },
  { 510, 5, 13, 7, 1, -9 },
  { 519, 3, 9, 4, 1, -9 },
  { 523, 3, 9, 5, 1, -9 },
  { 527, 3, 11, 3, 0, -11 },
  { 532, 4, 8, 7, 1, -8 },
  { 536, 5, 8, 5, 0, -8 },
  { 541, 8, 8, 8, 0, -8 },
  { 549, 5, 8, 5, 0, -8 },
  { 554, 5, 12, 5, 0, -8 },
  { 562, 4, 8, 4, 0, -8 },
  { 566, 4, 14, 6, 1, -11 },
  { 573, 1, 16, 6, 3, -12 },
  { 575, 4, 14, 6, 1, -11 },
  { 582, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Thin16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN16PT7B_H_
