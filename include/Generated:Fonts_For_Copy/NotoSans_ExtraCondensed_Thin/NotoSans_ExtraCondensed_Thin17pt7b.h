#ifndef _NOTOSANS_EXTRACONDENSED_THIN17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xF2, 0x45, 0x0A, 0x5E,
  0x48, 0x91, 0x22, 0x40, 0x22, 0xE9, 0x4A, 0x51, 0x06, 0x29, 0x4A, 0x5F,
  0x10, 0xE4, 0xA4, 0xA8, 0xA8, 0xAA, 0xB5, 0xB5, 0x59, 0x19, 0x29, 0x25,
  0x27, 0xE2, 0x49, 0x24, 0x61, 0x0A, 0x2A, 0x9A, 0x28, 0xBD, 0xF0, 0x2A,
  0x49, 0x24, 0x92, 0x44, 0x88, 0x91, 0x22, 0x49, 0x25, 0x25, 0x20, 0x4D,
  0x6F, 0x10, 0x41, 0x04, 0xFC, 0x41, 0x04, 0xF0, 0xF0, 0x80, 0x08, 0x42,
  0x21, 0x08, 0x84, 0x42, 0x11, 0x00, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x62, 0xE0, 0x2E, 0x92, 0x49, 0x24, 0x90, 0xF0, 0x42, 0x10, 0x88, 0x44,
  0x22, 0x21, 0xF0, 0xF0, 0x42, 0x11, 0x30, 0x41, 0x08, 0x43, 0xE0, 0x08,
  0x30, 0x61, 0x42, 0x89, 0x12, 0x44, 0xFE, 0x10, 0x20, 0x40, 0xF4, 0x21,
  0x08, 0x78, 0x21, 0x08, 0x43, 0xE0, 0x74, 0x21, 0x0A, 0x6E, 0x31, 0x8C,
  0x62, 0xE0, 0xF8, 0x44, 0x21, 0x10, 0x84, 0x22, 0x10, 0x80, 0xF4, 0x63,
  0x1D, 0x11, 0x51, 0x8C, 0x63, 0xE0, 0xF4, 0x63, 0x18, 0xC6, 0x6D, 0x08,
  0x45, 0xC0, 0x80, 0x80, 0x81, 0xE0, 0x0C, 0xCC, 0x18, 0x10, 0x30, 0xFC,
  0x00, 0x3F, 0xE0, 0x60, 0x43, 0x13, 0x80, 0xF1, 0x11, 0x12, 0x24, 0x40,
  0x04, 0x3E, 0x41, 0x81, 0x8D, 0x95, 0xA5, 0xA5, 0xA5, 0xA5, 0x9F, 0x80,
  0x40, 0x40, 0x3C, 0x10, 0xC3, 0x0A, 0x49, 0x24, 0x9D, 0x46, 0x18, 0x61,
  0xFA, 0x18, 0x61, 0x8B, 0xC8, 0xA1, 0x86, 0x18, 0x7E, 0x3D, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x04, 0x0F, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0xBC, 0xFC, 0x21, 0x08, 0x7A, 0x10, 0x84, 0x21, 0xF0, 0xFC,
  0x21, 0x08, 0x43, 0xD0, 0x84, 0x21, 0x00, 0x3E, 0x82, 0x04, 0x08, 0x10,
  0x23, 0xC1, 0x83, 0x05, 0x09, 0xF0, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61,
  0x86, 0x18, 0x61, 0xEA, 0xAA, 0xAB, 0x24, 0x92, 0x49, 0x24, 0x92, 0x70,
  0x8C, 0x65, 0x4A, 0x62, 0x94, 0x94, 0xA3, 0x10, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x8F, 0x80, 0xC0, 0x70, 0x78, 0x3A, 0x2D, 0x16, 0x8B, 0x29, 0x94,
  0xCA, 0x65, 0x31, 0x10, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x65, 0x8E, 0x38,
  0x61, 0x7D, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x13, 0xC0,
  0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x21, 0x00, 0x7D, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x05, 0x13, 0xC0, 0x81, 0x01, 0x00, 0xF2, 0x28,
  0xA2, 0x8A, 0x2F, 0x24, 0x92, 0x28, 0xA1, 0xFC, 0x21, 0x08, 0x30, 0x41,
  0x08, 0x43, 0xE0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x86, 0x18, 0x51,
  0x49, 0x24, 0x92, 0x30, 0xC3, 0x04, 0x84, 0x30, 0x86, 0x30, 0xA5, 0x24,
  0xA4, 0x94, 0x92, 0x92, 0x94, 0x31, 0x86, 0x30, 0xC6, 0x10, 0x80, 0x4A,
  0x52, 0x63, 0x10, 0xC6, 0x52, 0x63, 0x10, 0x8C, 0x52, 0xA5, 0x10, 0x84,
  0x21, 0x08, 0x40, 0x78, 0x44, 0x21, 0x10, 0x84, 0x42, 0x11, 0xF0, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x82, 0x10, 0x82, 0x10, 0x42,
  0x10, 0x42, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x78, 0x10, 0xA2, 0x91,
  0x46, 0x10, 0xFE, 0x94, 0xF1, 0x11, 0x79, 0x99, 0xF0, 0x84, 0x21, 0x0F,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0x80, 0x78, 0x88, 0x88, 0x88, 0x70, 0x08,
  0x42, 0x17, 0xC6, 0x31, 0x8C, 0x63, 0x17, 0x80, 0x74, 0x63, 0x1F, 0x42,
  0x10, 0x78, 0x34, 0x44, 0xE4, 0x44, 0x44, 0x44, 0x40, 0x7C, 0x63, 0x18,
  0xC6, 0x31, 0x78, 0x42, 0x1F, 0x00, 0x84, 0x21, 0x0F, 0x46, 0x31, 0x8C,
  0x63, 0x18, 0x80, 0x9F, 0xF0, 0x41, 0x55, 0x55, 0x57, 0x88, 0x88, 0x99,
  0xAC, 0xAA, 0x99, 0x90, 0xFF, 0xF8, 0xF7, 0x89, 0x89, 0x89, 0x89, 0x89,
  0x89, 0x89, 0x89, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x88, 0x74, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0xFC, 0x63, 0x18, 0xC6, 0x31, 0xFC, 0x21, 0x08, 0x00,
  0x7C, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x42, 0x10, 0x80, 0xF2, 0x49, 0x24,
  0x80, 0xF8, 0x88, 0x61, 0x11, 0xE0, 0x4B, 0xA4, 0x92, 0x49, 0x80, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x78, 0x8C, 0x62, 0xA5, 0x29, 0x44, 0x20, 0x88,
  0xC4, 0xA6, 0x4A, 0xA5, 0x52, 0xA9, 0x98, 0x44, 0x22, 0x00, 0x8A, 0x54,
  0x42, 0x11, 0x49, 0x88, 0x8C, 0x52, 0x95, 0x28, 0xC4, 0x21, 0x08, 0x4C,
  0x00, 0x71, 0x22, 0x24, 0x44, 0xF0, 0x34, 0x44, 0x44, 0x48, 0x44, 0x44,
  0x44, 0x30, 0xFF, 0xFF, 0x80, 0xC2, 0x22, 0x22, 0x23, 0x22, 0x22, 0x24,
  0x80, 0xCD, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 3, 4, 5, 1, -12 },
  { 5, 7, 12, 7, 0, -12 },
  { 16, 5, 14, 7, 1, -13 },
  { 25, 8, 12, 10, 1, -12 },
  { 37, 6, 12, 7, 1, -12 },
  { 46, 1, 4, 3, 1, -12 },
  { 47, 3, 15, 4, 1, -12 },
  { 53, 3, 15, 4, 1, -12 },
  { 59, 4, 4, 6, 1, -13 },
  { 61, 6, 8, 7, 0, -10 },
  { 67, 1, 4, 3, 1, -2 },
  { 68, 4, 1, 4, 0, -5 },
  { 69, 1, 1, 3, 1, -1 },
  { 70, 5, 12, 6, 0, -12 },
  { 78, 5, 12, 7, 1, -12 },
  { 86, 3, 12, 7, 1, -12 },
  { 91, 5, 12, 7, 1, -12 },
  { 99, 5, 12, 7, 1, -12 },
  { 107, 7, 12, 7, 0, -12 },
  { 118, 5, 12, 7, 1, -12 },
  { 126, 5, 12, 7, 1, -12 },
  { 134, 5, 12, 7, 1, -12 },
  { 142, 5, 12, 7, 1, -12 },
  { 150, 5, 12, 7, 1, -12 },
  { 158, 1, 9, 3, 1, -9 },
  { 160, 1, 11, 3, 1, -9 },
  { 162, 6, 6, 7, 0, -9 },
  { 167, 6, 4, 7, 0, -8 },
  { 170, 6, 6, 7, 0, -9 },
  { 175, 4, 12, 4, 0, -12 },
  { 181, 8, 14, 10, 1, -12 },
  { 195, 6, 12, 6, 0, -12 },
  { 204, 6, 12, 7, 1, -12 },
  { 213, 6, 12, 7, 1, -12 },
  { 222, 6, 12, 8, 1, -12 },
  { 231, 5, 12, 6, 1, -12 },
  { 239, 5, 12, 6, 1, -12 },
  { 247, 7, 12, 9, 1, -12 },
  { 258, 6, 12, 8, 1, -12 },
  { 267, 2, 12, 4, 1, -12 },
  { 270, 3, 15, 3, -1, -12 },
  { 276, 5, 12, 6, 1, -12 },
  { 284, 4, 12, 6, 1, -12 },
  { 290, 9, 12, 11, 1, -12 },
  { 304, 6, 12, 9, 1, -12 },
  { 313, 7, 12, 9, 1, -12 },
  { 324, 5, 12, 7, 1, -12 },
  { 332, 7, 15, 9, 1, -12 },
  { 346, 6, 12, 7, 1, -12 },
  { 355, 5, 12, 7, 1, -12 },
  { 363, 6, 12, 6, 0, -12 },
  { 372, 6, 12, 8, 1, -12 },
  { 381, 6, 12, 6, 0, -12 },
  { 390, 11, 12, 11, 0, -12 },
  { 407, 5, 12, 6, 0, -12 },
  { 415, 5, 12, 5, 0, -12 },
  { 423, 5, 12, 5, 0, -12 },
  { 431, 4, 15, 5, 1, -12 },
  { 439, 5, 12, 6, 0, -12 },
  { 447, 3, 15, 5, 1, -12 },
  { 453, 6, 6, 7, 0, -12 },
  { 458, 7, 1, 7, 0, 1 },
  { 459, 2, 3, 4, 1, -13 },
  { 460, 4, 9, 6, 1, -9 },
  { 465, 5, 13, 7, 1, -13 },
  { 474, 4, 9, 5, 1, -9 },
  { 479, 5, 13, 7, 1, -13 },
  { 488, 5, 9, 6, 1, -9 },
  { 494, 4, 13, 4, 0, -13 },
  { 501, 5, 13, 7, 1, -9 },
  { 510, 5, 13, 7, 1, -13 },
  { 519, 1, 12, 3, 1, -12 },
  { 521, 2, 16, 3, 0, -12 },
  { 525, 4, 13, 6, 1, -13 },
  { 532, 1, 13, 3, 1, -13 },
  { 534, 8, 9, 10, 1, -9 },
  { 543, 5, 9, 7, 1, -9 },
  { 549, 5, 9, 7, 1, -9 },
  { 555, 5, 13, 7, 1, -9 },
  { 564, 5, 13, 7, 1, -9 },
  { 573, 3, 9, 4, 1, -9 },
  { 577, 4, 9, 5, 1, -9 },
  { 582, 3, 11, 4, 0, -11 },
  { 587, 5, 9, 7, 1, -9 },
  { 593, 5, 9, 5, 0, -9 },
  { 599, 9, 9, 9, 0, -9 },
  { 610, 5, 9, 5, 0, -9 },
  { 616, 5, 13, 5, 0, -9 },
  { 625, 4, 9, 4, 0, -9 },
  { 630, 4, 15, 6, 1, -12 },
  { 638, 1, 17, 6, 3, -13 },
  { 641, 4, 15, 6, 1, -12 },
  { 649, 5, 2, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_Thin17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN17PT7B_H_
