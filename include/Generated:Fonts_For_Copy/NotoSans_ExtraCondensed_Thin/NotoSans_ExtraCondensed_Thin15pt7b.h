#ifndef _NOTOSANS_EXTRACONDENSED_THIN15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xFF, 0x28, 0xA2, 0x9F, 0x28, 0xA4, 0xBF, 0x51, 0x45,
  0x00, 0x3B, 0x29, 0x46, 0x18, 0xA5, 0x2D, 0x5C, 0x40, 0xC9, 0x52, 0xA5,
  0x8B, 0x57, 0x74, 0x95, 0x2A, 0x55, 0x38, 0x21, 0x45, 0x14, 0x20, 0x85,
  0x65, 0x8A, 0x27, 0x40, 0xF0, 0x5A, 0xAA, 0xAA, 0x40, 0xA5, 0x55, 0x56,
  0x80, 0x5E, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xF0, 0xF0, 0x80,
  0x08, 0x44, 0x22, 0x10, 0x88, 0x42, 0x20, 0x69, 0x99, 0x99, 0x99, 0x99,
  0x60, 0x2E, 0x92, 0x49, 0x24, 0x80, 0xE1, 0x11, 0x11, 0x22, 0x48, 0xF0,
  0xE1, 0x11, 0x16, 0x11, 0x11, 0xF0, 0x08, 0x41, 0x0A, 0x29, 0x24, 0xA2,
  0x7C, 0x20, 0x80, 0xF8, 0x88, 0xE1, 0x11, 0x11, 0xE0, 0x78, 0x88, 0xE9,
  0x99, 0x99, 0xF0, 0xF1, 0x11, 0x22, 0x24, 0x44, 0x80, 0x69, 0x99, 0x96,
  0x99, 0x99, 0xF0, 0x69, 0x99, 0x99, 0x71, 0x11, 0xE0, 0x81, 0x83, 0xC0,
  0x1D, 0x88, 0x18, 0x18, 0x10, 0xFC, 0x00, 0x3F, 0xE0, 0x40, 0xC6, 0x62,
  0x00, 0xE1, 0x11, 0x22, 0x44, 0x00, 0x40, 0x38, 0x8A, 0x0C, 0xDA, 0xB5,
  0x6A, 0xD5, 0xAB, 0x2A, 0x03, 0xC0, 0x20, 0x83, 0x14, 0x51, 0x27, 0x92,
  0x8A, 0x18, 0x40, 0xF4, 0x63, 0x19, 0x7A, 0x31, 0x8C, 0x7C, 0x3A, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x1E, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7C,
  0xF8, 0x88, 0x8F, 0x88, 0x88, 0xF0, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x80,
  0x3D, 0x08, 0x20, 0x82, 0x68, 0x61, 0x86, 0x17, 0xC0, 0x8C, 0x63, 0x18,
  0xFE, 0x31, 0x8C, 0x62, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49, 0x24, 0x93,
  0x80, 0x8C, 0xA9, 0x4C, 0x62, 0x94, 0x94, 0xA2, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x81, 0x81, 0x83, 0xC3, 0xC5, 0xA5, 0xA5, 0xA5, 0x99, 0x99,
  0x91, 0x8C, 0x73, 0x9A, 0xD6, 0x73, 0x8C, 0x62, 0x72, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x17, 0x80, 0xE9, 0x99, 0x99, 0xE8, 0x88, 0x80, 0x72,
  0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x16, 0x84, 0x08, 0x20, 0xE4, 0xA3,
  0x18, 0xEA, 0x94, 0x94, 0xA2, 0x78, 0x88, 0x86, 0x11, 0x11, 0xF0, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x5E, 0x8C, 0x63, 0x14, 0xA5, 0x4A, 0x31, 0x08, 0x88, 0x62, 0x18, 0x8A,
  0x32, 0x4C, 0x95, 0x25, 0x29, 0x4C, 0x23, 0x08, 0xC2, 0x20, 0x8A, 0x54,
  0xA2, 0x10, 0x8A, 0x54, 0x62, 0x8C, 0x64, 0xA5, 0x30, 0x84, 0x21, 0x08,
  0x70, 0x84, 0x22, 0x10, 0x88, 0x42, 0x3E, 0xF2, 0x49, 0x24, 0x92, 0x4E,
  0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0xD5, 0x55, 0x55, 0xC0, 0x10,
  0xC4, 0x92, 0x8C, 0xFC, 0x90, 0xE4, 0xBB, 0x6F, 0x84, 0x21, 0xE8, 0xC6,
  0x31, 0x8C, 0x7C, 0x72, 0x49, 0x27, 0x11, 0x1F, 0x99, 0x99, 0x99, 0xF0,
  0xE9, 0x9F, 0x88, 0x8F, 0x74, 0x4E, 0x44, 0x44, 0x44, 0x40, 0xF9, 0x99,
  0x99, 0x9F, 0x11, 0x1E, 0x88, 0x8F, 0x99, 0x99, 0x99, 0x90, 0x9F, 0xE0,
  0x41, 0x55, 0x55, 0x58, 0x88, 0x89, 0xAC, 0xCA, 0xAA, 0x90, 0xFF, 0xE0,
  0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xF9, 0x99, 0x99, 0x99, 0xF9,
  0x99, 0x99, 0x9F, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0x79, 0x99,
  0x99, 0x9F, 0x11, 0x10, 0xF2, 0x49, 0x24, 0xF2, 0x46, 0x4F, 0x4B, 0xA4,
  0x92, 0x4C, 0x99, 0x99, 0x99, 0x9F, 0x99, 0x95, 0x56, 0x22, 0x91, 0x91,
  0x9A, 0x5A, 0x6A, 0x64, 0x24, 0x24, 0x95, 0x52, 0x25, 0x59, 0x8C, 0x54,
  0xA5, 0x28, 0x84, 0x21, 0x11, 0x00, 0x72, 0x22, 0x44, 0x4F, 0x29, 0x24,
  0xA2, 0x49, 0x26, 0xFF, 0xFE, 0x89, 0x24, 0x8A, 0x49, 0x2C, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_Thin15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 2, 4, 4, 1, -11 },
  { 4, 6, 11, 6, 0, -11 },
  { 13, 5, 12, 6, 0, -11 },
  { 21, 7, 11, 9, 1, -11 },
  { 31, 6, 11, 6, 0, -11 },
  { 40, 1, 4, 2, 1, -11 },
  { 41, 2, 13, 4, 1, -11 },
  { 45, 2, 13, 4, 1, -11 },
  { 49, 3, 3, 5, 1, -11 },
  { 51, 6, 7, 6, 0, -9 },
  { 57, 1, 4, 3, 1, -2 },
  { 58, 4, 1, 4, 0, -5 },
  { 59, 1, 1, 3, 1, -1 },
  { 60, 5, 11, 5, 0, -11 },
  { 67, 4, 11, 6, 1, -11 },
  { 73, 3, 11, 6, 1, -11 },
  { 78, 4, 11, 6, 1, -11 },
  { 84, 4, 11, 6, 1, -11 },
  { 90, 6, 11, 6, 0, -11 },
  { 99, 4, 11, 6, 1, -11 },
  { 105, 4, 11, 6, 1, -11 },
  { 111, 4, 11, 6, 1, -11 },
  { 117, 4, 11, 6, 1, -11 },
  { 123, 4, 11, 6, 1, -11 },
  { 129, 1, 8, 3, 1, -8 },
  { 130, 1, 10, 3, 1, -8 },
  { 132, 6, 6, 6, 0, -8 },
  { 137, 6, 4, 6, 0, -7 },
  { 140, 6, 6, 6, 0, -8 },
  { 145, 4, 11, 4, 0, -11 },
  { 151, 7, 12, 9, 1, -11 },
  { 162, 6, 11, 6, 0, -11 },
  { 171, 5, 11, 6, 1, -11 },
  { 178, 5, 11, 6, 1, -11 },
  { 185, 5, 11, 7, 1, -11 },
  { 192, 4, 11, 6, 1, -11 },
  { 198, 4, 11, 5, 1, -11 },
  { 204, 6, 11, 8, 1, -11 },
  { 213, 5, 11, 7, 1, -11 },
  { 220, 2, 11, 3, 1, -11 },
  { 223, 3, 14, 3, -1, -11 },
  { 229, 5, 11, 6, 1, -11 },
  { 236, 4, 11, 5, 1, -11 },
  { 242, 8, 11, 10, 1, -11 },
  { 253, 5, 11, 8, 1, -11 },
  { 260, 6, 11, 8, 1, -11 },
  { 269, 4, 11, 6, 1, -11 },
  { 275, 6, 14, 8, 1, -11 },
  { 286, 5, 11, 6, 1, -11 },
  { 293, 4, 11, 6, 1, -11 },
  { 299, 5, 11, 5, 0, -11 },
  { 306, 5, 11, 7, 1, -11 },
  { 313, 5, 11, 5, 0, -11 },
  { 320, 10, 11, 10, 0, -11 },
  { 334, 5, 11, 5, 0, -11 },
  { 341, 5, 11, 5, 0, -11 },
  { 348, 5, 11, 5, 0, -11 },
  { 355, 3, 13, 5, 1, -11 },
  { 360, 5, 11, 5, 0, -11 },
  { 367, 2, 13, 5, 1, -11 },
  { 371, 6, 5, 6, 0, -11 },
  { 375, 6, 1, 6, 0, 1 },
  { 376, 2, 2, 3, 1, -11 },
  { 377, 3, 8, 5, 1, -8 },
  { 380, 5, 11, 6, 1, -11 },
  { 387, 3, 8, 5, 1, -8 },
  { 390, 4, 11, 6, 1, -11 },
  { 396, 4, 8, 6, 1, -8 },
  { 400, 4, 11, 3, 0, -11 },
  { 406, 4, 12, 6, 1, -8 },
  { 412, 4, 11, 6, 1, -11 },
  { 418, 1, 11, 3, 1, -11 },
  { 420, 2, 15, 3, 0, -11 },
  { 424, 4, 11, 5, 1, -11 },
  { 430, 1, 11, 3, 1, -11 },
  { 432, 7, 8, 9, 1, -8 },
  { 439, 4, 8, 6, 1, -8 },
  { 443, 4, 8, 6, 1, -8 },
  { 447, 5, 11, 6, 1, -8 },
  { 454, 4, 11, 6, 1, -8 },
  { 460, 3, 8, 4, 1, -8 },
  { 463, 3, 8, 5, 1, -8 },
  { 466, 3, 10, 3, 0, -10 },
  { 470, 4, 8, 6, 1, -8 },
  { 474, 4, 8, 4, 0, -8 },
  { 478, 8, 8, 8, 0, -8 },
  { 486, 4, 8, 5, 0, -8 },
  { 490, 5, 12, 5, 0, -8 },
  { 498, 4, 8, 4, 0, -8 },
  { 502, 3, 13, 5, 1, -11 },
  { 507, 1, 15, 6, 2, -11 },
  { 509, 3, 13, 5, 1, -11 },
  { 514, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_Thin15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN15PT7B_H_
