#ifndef _NOTOSANS_EXTRACONDENSED_THIN58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin58pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x00, 0x00, 0xBF, 0xE0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x00, 0xC0,
  0x60, 0x03, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20, 0x10, 0x00, 0x80, 0x40,
  0x02, 0x01, 0x00, 0x08, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x03, 0x00, 0x18, 0x08, 0x00, 0x40, 0x20, 0x7F, 0xFF, 0xFC, 0x04, 0x02,
  0x00, 0x10, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0x60, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x20,
  0x10, 0x00, 0x80, 0x40, 0x06, 0x01, 0x00, 0x18, 0x0C, 0x0F, 0xFF, 0xFF,
  0x81, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x10, 0x08, 0x00, 0x40, 0x20, 0x01,
  0x00, 0x80, 0x04, 0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x20, 0x18, 0x00, 0x80, 0x40, 0x02, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xF0, 0x31, 0x83, 0x0C, 0x30, 0x03, 0x06, 0x00, 0x40, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x40, 0x60, 0x08, 0x0C, 0x01, 0x01, 0x80,
  0x20, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x1C, 0x60, 0x01, 0xCC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x00, 0x19, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C,
  0x01, 0x80, 0x80, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x81, 0x80, 0x30, 0x34,
  0x06, 0x0C, 0xF0, 0xC7, 0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x30,
  0x01, 0x80, 0x61, 0x80, 0x10, 0x04, 0x0C, 0x01, 0x00, 0x40, 0xC0, 0x30,
  0x0C, 0x04, 0x02, 0x00, 0xC0, 0x40, 0x20, 0x08, 0x06, 0x06, 0x00, 0x80,
  0x60, 0x40, 0x08, 0x06, 0x04, 0x00, 0x80, 0x60, 0xC0, 0x08, 0x06, 0x0C,
  0x00, 0x80, 0x60, 0x80, 0x08, 0x06, 0x18, 0x00, 0x80, 0x61, 0x80, 0x08,
  0x06, 0x10, 0x00, 0x80, 0x63, 0x00, 0x08, 0x06, 0x31, 0xF8, 0x80, 0x62,
  0x30, 0x8C, 0x04, 0x62, 0x0C, 0xC0, 0x46, 0x60, 0x44, 0x0C, 0x46, 0x06,
  0x60, 0xCC, 0x40, 0x66, 0x18, 0xC4, 0x02, 0x3B, 0x08, 0x40, 0x21, 0xE1,
  0x84, 0x02, 0x00, 0x18, 0xC0, 0x20, 0x01, 0x0C, 0x03, 0x00, 0x30, 0xC0,
  0x30, 0x03, 0x0C, 0x03, 0x00, 0x20, 0xC0, 0x30, 0x02, 0x0C, 0x03, 0x00,
  0x60, 0xC0, 0x20, 0x04, 0x04, 0x02, 0x00, 0x40, 0x40, 0x20, 0x0C, 0x04,
  0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x06, 0x06, 0x01, 0x80, 0x60, 0x40,
  0x10, 0x02, 0x04, 0x01, 0x00, 0x10, 0x80, 0x30, 0x01, 0xF8, 0x00, 0x00,
  0x04, 0x00, 0x03, 0xC0, 0x00, 0x77, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x80,
  0x18, 0x08, 0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x08,
  0x01, 0x00, 0x80, 0x18, 0x08, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00, 0x81,
  0x80, 0x0C, 0x10, 0x00, 0x43, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x03,
  0x04, 0x00, 0x20, 0x60, 0x26, 0x02, 0x02, 0x40, 0x30, 0x2C, 0x01, 0x02,
  0xC0, 0x18, 0x28, 0x00, 0x86, 0x80, 0x04, 0x48, 0x00, 0x64, 0x80, 0x02,
  0xC8, 0x00, 0x38, 0x80, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x84, 0x00,
  0x2C, 0x60, 0x06, 0x43, 0x00, 0xC2, 0x18, 0x38, 0x30, 0xFE, 0x01, 0x01,
  0x00, 0x00, 0xFF, 0xFF, 0xAA, 0xA8, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x06, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0xE0, 0x08, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x38, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0x08, 0x33, 0xA7,
  0x03, 0xE0, 0x03, 0x00, 0x16, 0x00, 0xCC, 0x06, 0x10, 0x10, 0x20, 0x80,
  0x46, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x01, 0xFF, 0xFF,
  0xC0, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18,
  0xC6, 0x23, 0x18, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xBC, 0x03, 0x07, 0x03, 0x01, 0x83, 0x00,
  0x61, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x06, 0x60, 0x03, 0x20, 0x00, 0x90,
  0x00, 0x58, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x02, 0x40, 0x01,
  0x20, 0x00, 0x98, 0x00, 0xCC, 0x00, 0x62, 0x00, 0x21, 0x80, 0x30, 0x60,
  0x10, 0x30, 0x18, 0x0E, 0x38, 0x03, 0xF8, 0x00, 0x00, 0xC0, 0xF0, 0x7C,
  0x33, 0x18, 0xCC, 0x3E, 0x0D, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x07, 0xF0, 0x07, 0xDF, 0x07, 0x00, 0xE0, 0x80, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x3F, 0xFF, 0xF0, 0x07,
  0xE0, 0x07, 0xDF, 0x07, 0x00, 0xE3, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x32, 0x00, 0x18, 0xF0, 0x1C, 0x0F, 0xFE, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00,
  0xD0, 0x00, 0x04, 0x80, 0x00, 0x64, 0x00, 0x02, 0x20, 0x00, 0x31, 0x00,
  0x01, 0x88, 0x00, 0x18, 0x40, 0x00, 0xC2, 0x00, 0x0C, 0x10, 0x00, 0x60,
  0x80, 0x02, 0x04, 0x00, 0x30, 0x20, 0x01, 0x01, 0x00, 0x18, 0x08, 0x00,
  0x80, 0x40, 0x0C, 0x02, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x04,
  0x03, 0x00, 0x20, 0x10, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0xC0,
  0x02, 0x04, 0x00, 0x10, 0x60, 0x00, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xFE, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC7, 0xC0, 0x7F, 0xFC, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x32,
  0x00, 0x31, 0xC0, 0x70, 0x7F, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0x81, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x63, 0xFC, 0x33,
  0x87, 0x13, 0x00, 0xCB, 0x00, 0x25, 0x00, 0x1B, 0x80, 0x05, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xD0, 0x00, 0x68,
  0x00, 0x36, 0x00, 0x11, 0x00, 0x18, 0xC0, 0x08, 0x20, 0x0C, 0x1C, 0x0C,
  0x07, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0x80, 0x70, 0x18, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x40, 0x01, 0x18,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x62, 0x00, 0x08, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x0C,
  0x06, 0x00, 0xC1, 0x80, 0x0C, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x06,
  0x70, 0x01, 0x83, 0x00, 0x60, 0x30, 0x18, 0x03, 0x06, 0x00, 0x31, 0x80,
  0x02, 0x30, 0x00, 0x64, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x24, 0x00,
  0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x61, 0xC0, 0x18, 0x1C, 0x06, 0x00, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFE, 0x01, 0x80, 0xC0, 0x40,
  0x18, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x11, 0x80, 0x06, 0x40, 0x01,
  0x90, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x80,
  0x07, 0x60, 0x01, 0xC8, 0x00, 0xF3, 0x00, 0x2C, 0x60, 0x1B, 0x0E, 0x3C,
  0xC1, 0xFC, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x20, 0x70,
  0x0F, 0xF8, 0x00, 0x60, 0x00, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x6F, 0xF8, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31, 0x88,
  0xC6, 0x21, 0x18, 0xC4, 0x60, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x08,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x07, 0xDE, 0x30, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x10, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x60, 0x00, 0x00, 0x62, 0x00, 0x1C,
  0x03, 0x30, 0x07, 0xF8, 0x09, 0x80, 0x60, 0xC0, 0x4C, 0x02, 0x06, 0x03,
  0x40, 0x30, 0x30, 0x1A, 0x01, 0x01, 0x80, 0xF0, 0x18, 0x0C, 0x07, 0x80,
  0xC0, 0x60, 0x3C, 0x04, 0x03, 0x01, 0xE0, 0x20, 0x18, 0x0F, 0x01, 0x00,
  0xC0, 0x78, 0x18, 0x04, 0x03, 0xC0, 0xC0, 0x20, 0x1E, 0x06, 0x01, 0x00,
  0xF0, 0x30, 0x08, 0x07, 0x81, 0x80, 0xC0, 0x3C, 0x04, 0x06, 0x01, 0xE0,
  0x20, 0x30, 0x0B, 0x01, 0x01, 0x80, 0xC8, 0x0C, 0x1A, 0x06, 0x40, 0x20,
  0x90, 0x62, 0x01, 0x8C, 0xC7, 0x18, 0x07, 0xC3, 0xF0, 0xC0, 0x08, 0x04,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x12, 0x00, 0x00, 0x48, 0x00, 0x03, 0x20, 0x00, 0x0C, 0xC0,
  0x00, 0x21, 0x00, 0x00, 0x84, 0x00, 0x06, 0x10, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0xC0, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x04, 0x01, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x08, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x20, 0x01, 0x01, 0x80, 0x04, 0x06, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x40, 0x00, 0x83, 0x00, 0x02, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30,
  0x80, 0x00, 0x42, 0x00, 0x01, 0x18, 0x00, 0x06, 0x60, 0x00, 0x19, 0x00,
  0x00, 0x24, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xF0,
  0x20, 0x07, 0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x03, 0x20, 0x00, 0x48,
  0x00, 0x1A, 0x00, 0x06, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x1A, 0x00,
  0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x08, 0x80, 0x06,
  0x20, 0x03, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x80, 0x1C, 0x20, 0x01, 0x88,
  0x00, 0x32, 0x00, 0x04, 0x80, 0x01, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xA0, 0x00, 0x28, 0x00, 0x1A, 0x00, 0x06, 0x80, 0x03, 0x20, 0x01, 0xC8,
  0x00, 0xE2, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xBF,
  0x03, 0x80, 0x20, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x01, 0x01,
  0xC0, 0x70, 0x07, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xE0, 0x10, 0x0F, 0x02,
  0x00, 0x30, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x03, 0x20, 0x00, 0x64,
  0x00, 0x04, 0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x01, 0x40, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x34, 0x00, 0x06, 0x80,
  0x00, 0xD0, 0x00, 0x32, 0x00, 0x06, 0x40, 0x01, 0x88, 0x00, 0x21, 0x00,
  0x1C, 0x20, 0x07, 0x04, 0x1F, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0xFC, 0x01, 0xC0, 0x0F, 0x03, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x20, 0x00, 0x03,
  0x30, 0x00, 0x03, 0x10, 0x00, 0x03, 0x18, 0x00, 0x03, 0x08, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x03, 0x80, 0x03, 0x01, 0xE0, 0x0F,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0xFF, 0x84, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0xFF, 0x80, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x73, 0x9F, 0x80, 0x80, 0x03, 0x40, 0x01, 0x20, 0x01, 0x90,
  0x01, 0x88, 0x00, 0x84, 0x00, 0xC2, 0x00, 0x41, 0x00, 0x60, 0x80, 0x60,
  0x40, 0x20, 0x20, 0x30, 0x10, 0x10, 0x08, 0x18, 0x04, 0x18, 0x02, 0x0C,
  0x01, 0x0C, 0x00, 0x84, 0x00, 0x46, 0x00, 0x27, 0x00, 0x12, 0x80, 0x0B,
  0x60, 0x05, 0x10, 0x03, 0x0C, 0x01, 0x82, 0x00, 0x81, 0x80, 0x40, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x08, 0x06, 0x04, 0x01, 0x02, 0x00, 0xC1, 0x00,
  0x20, 0x80, 0x18, 0x40, 0x04, 0x20, 0x03, 0x10, 0x00, 0x88, 0x00, 0x64,
  0x00, 0x12, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01, 0x80, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x05, 0xA0,
  0x00, 0x00, 0x5B, 0x00, 0x00, 0x0D, 0xB0, 0x00, 0x00, 0x99, 0x00, 0x00,
  0x09, 0x90, 0x00, 0x01, 0x99, 0x80, 0x00, 0x19, 0x88, 0x00, 0x01, 0x18,
  0x80, 0x00, 0x31, 0x8C, 0x00, 0x03, 0x18, 0xC0, 0x00, 0x21, 0x84, 0x00,
  0x06, 0x18, 0x60, 0x00, 0x61, 0x86, 0x00, 0x04, 0x18, 0x20, 0x00, 0x41,
  0x83, 0x00, 0x0C, 0x18, 0x30, 0x00, 0xC1, 0x81, 0x00, 0x08, 0x18, 0x10,
  0x01, 0x81, 0x81, 0x80, 0x18, 0x18, 0x18, 0x01, 0x01, 0x80, 0x80, 0x30,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80,
  0x60, 0x60, 0x18, 0x06, 0x06, 0x01, 0x80, 0x20, 0x40, 0x18, 0x02, 0x0C,
  0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x08, 0x01, 0x80, 0x11, 0x80, 0x18,
  0x01, 0x98, 0x01, 0x80, 0x19, 0x00, 0x18, 0x00, 0xB0, 0x01, 0x80, 0x0F,
  0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x10, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3A, 0x00, 0x03, 0xA0, 0x00, 0x3B, 0x00, 0x03,
  0x90, 0x00, 0x39, 0x80, 0x03, 0x88, 0x00, 0x38, 0xC0, 0x03, 0x84, 0x00,
  0x38, 0x60, 0x03, 0x86, 0x00, 0x38, 0x20, 0x03, 0x83, 0x00, 0x38, 0x10,
  0x03, 0x81, 0x80, 0x38, 0x08, 0x03, 0x80, 0xC0, 0x38, 0x04, 0x03, 0x80,
  0x60, 0x38, 0x06, 0x03, 0x80, 0x20, 0x38, 0x03, 0x03, 0x80, 0x10, 0x38,
  0x01, 0x83, 0x80, 0x08, 0x38, 0x00, 0xC3, 0x80, 0x04, 0x38, 0x00, 0x63,
  0x80, 0x06, 0x38, 0x00, 0x23, 0x80, 0x03, 0x38, 0x00, 0x13, 0x80, 0x01,
  0xB8, 0x00, 0x0B, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x30, 0x00, 0x7E, 0x00, 0x01, 0xEF, 0x80, 0x07, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x04, 0x60, 0x00, 0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x08, 0x18, 0x00, 0x18, 0x18, 0x00, 0x10, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x03, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xFF, 0xE0, 0x80, 0x78, 0x80, 0x1C, 0x80, 0x0C, 0x80, 0x06, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80,
  0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x18, 0x80, 0xF0, 0xFF, 0xC0, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x10, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03,
  0x81, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0xFF,
  0xE0, 0x40, 0x3C, 0x20, 0x07, 0x10, 0x00, 0x88, 0x00, 0x64, 0x00, 0x12,
  0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x68, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x04, 0x80, 0x06, 0x40,
  0x03, 0x20, 0x03, 0x10, 0x03, 0x08, 0x0F, 0x07, 0xFE, 0x02, 0x06, 0x01,
  0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x18, 0x10, 0x0C, 0x08, 0x03,
  0x04, 0x01, 0x82, 0x00, 0x41, 0x00, 0x30, 0x80, 0x08, 0x40, 0x06, 0x20,
  0x01, 0x10, 0x00, 0xC8, 0x00, 0x64, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xFE, 0x01, 0xF7, 0xF0, 0xC0, 0x08, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x32, 0x00, 0x1C, 0xF0, 0x1E, 0x1F,
  0xFE, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x06,
  0x20, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x30, 0x07, 0xFE,
  0x00, 0x0F, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80,
  0x00, 0x26, 0x00, 0x01, 0x30, 0x00, 0x18, 0x80, 0x00, 0xC4, 0x00, 0x04,
  0x30, 0x00, 0x21, 0x80, 0x03, 0x04, 0x00, 0x18, 0x20, 0x00, 0x81, 0x00,
  0x04, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x01, 0x00, 0x10, 0x08, 0x00, 0x80,
  0x60, 0x04, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x03, 0x00,
  0x80, 0x18, 0x0C, 0x00, 0x40, 0x60, 0x02, 0x02, 0x00, 0x10, 0x10, 0x00,
  0xC1, 0x80, 0x06, 0x0C, 0x00, 0x10, 0x40, 0x00, 0x82, 0x00, 0x06, 0x30,
  0x00, 0x31, 0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x01,
  0xB0, 0x00, 0x05, 0x80, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1A, 0x00, 0x01, 0x80, 0x00,
  0xD0, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x26, 0x00, 0x05,
  0x00, 0x01, 0x10, 0x00, 0x2C, 0x00, 0x18, 0x80, 0x01, 0x60, 0x00, 0xC6,
  0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0xC8, 0x00, 0x21, 0x80, 0x06, 0x40,
  0x03, 0x04, 0x00, 0x23, 0x00, 0x18, 0x20, 0x01, 0x18, 0x00, 0xC1, 0x80,
  0x18, 0xC0, 0x04, 0x0C, 0x00, 0xC2, 0x00, 0x20, 0x60, 0x06, 0x10, 0x03,
  0x01, 0x00, 0x20, 0xC0, 0x18, 0x08, 0x01, 0x06, 0x00, 0xC0, 0x60, 0x18,
  0x30, 0x04, 0x03, 0x00, 0xC0, 0x80, 0x60, 0x08, 0x06, 0x04, 0x03, 0x00,
  0x40, 0x20, 0x30, 0x18, 0x03, 0x01, 0x01, 0x80, 0x80, 0x18, 0x18, 0x0C,
  0x04, 0x00, 0xC0, 0xC0, 0x20, 0x60, 0x02, 0x06, 0x01, 0x03, 0x00, 0x10,
  0x20, 0x0C, 0x18, 0x00, 0xC1, 0x00, 0x60, 0x80, 0x06, 0x18, 0x03, 0x04,
  0x00, 0x30, 0xC0, 0x08, 0x60, 0x00, 0x86, 0x00, 0x43, 0x00, 0x04, 0x20,
  0x03, 0x10, 0x00, 0x31, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x04, 0xC0, 0x02, 0x60, 0x00, 0x26, 0x00, 0x13, 0x00, 0x01, 0x20, 0x00,
  0x90, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC8, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x03,
  0x06, 0x00, 0x80, 0x80, 0x60, 0x20, 0x18, 0x0C, 0x04, 0x01, 0x03, 0x00,
  0x60, 0x80, 0x18, 0x60, 0x02, 0x18, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x04,
  0xC0, 0x01, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x78, 0x00, 0x1A, 0x00, 0x04, 0x80, 0x03, 0x30, 0x00, 0x84, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x04, 0x08, 0x03, 0x03, 0x00, 0x80, 0xC0, 0x60,
  0x10, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x20, 0x80, 0x0C, 0x60, 0x03,
  0x18, 0x00, 0x44, 0x00, 0x1B, 0x00, 0x06, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0xD0, 0x00, 0x36, 0x00, 0x09, 0x80, 0x06, 0x20, 0x01, 0x8C, 0x00, 0x43,
  0x00, 0x30, 0x40, 0x0C, 0x10, 0x02, 0x06, 0x01, 0x80, 0x80, 0x60, 0x20,
  0x10, 0x0C, 0x0C, 0x01, 0x03, 0x00, 0x40, 0x80, 0x18, 0x20, 0x02, 0x18,
  0x00, 0x84, 0x00, 0x31, 0x00, 0x04, 0xC0, 0x01, 0x20, 0x00, 0x68, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x1F, 0xFC, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0xFC, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x16, 0x00, 0x01,
  0x90, 0x00, 0x08, 0xC0, 0x00, 0xC2, 0x00, 0x04, 0x18, 0x00, 0x60, 0x40,
  0x02, 0x03, 0x00, 0x30, 0x18, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x40, 0x01, 0x86, 0x00, 0x0C, 0x20, 0x00, 0x33,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x07, 0xF0,
  0x7C, 0x70, 0x40, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x7F, 0x87, 0x81, 0x18, 0x02, 0x60, 0x05, 0x80, 0x0B, 0x00, 0x14,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00,
  0x3A, 0x00, 0x56, 0x01, 0xA6, 0x06, 0x47, 0xF8, 0x81, 0x80, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0xFC, 0x0C, 0x71, 0xC3, 0x20, 0x18, 0xD0, 0x03,
  0x3C, 0x00, 0x4E, 0x00, 0x1B, 0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0xB8, 0x00, 0x6E,
  0x00, 0x1B, 0x80, 0x04, 0xD0, 0x03, 0x26, 0x01, 0x88, 0xC0, 0xC2, 0x1F,
  0xE0, 0x00, 0x80, 0x00, 0x03, 0xF8, 0x1E, 0x70, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x10, 0x7F, 0xC0, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xFC, 0x30, 0xE3, 0x8C, 0x60, 0x33,
  0x30, 0x06, 0xC8, 0x00, 0xB6, 0x00, 0x1D, 0x80, 0x07, 0x40, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xD0,
  0x00, 0x76, 0x00, 0x1D, 0x80, 0x0B, 0x20, 0x02, 0xCC, 0x01, 0x31, 0xC1,
  0xCC, 0x3F, 0xC3, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x0E, 0x78, 0x18, 0x0C,
  0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x01, 0x0C, 0x06, 0x07, 0xFC, 0x00, 0x40, 0x03, 0xF8,
  0x30, 0x81, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0xE3, 0xFF, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x07, 0xF0,
  0x87, 0x9E, 0x46, 0x01, 0x26, 0x00, 0x52, 0x00, 0x3B, 0x00, 0x0D, 0x00,
  0x06, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x40, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0xA4, 0x00, 0xD3, 0x00, 0xC8,
  0xE0, 0xC4, 0x3F, 0xC2, 0x01, 0x81, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x03, 0x10, 0x03, 0x0F, 0x9F, 0x01, 0xFE, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC3, 0xF0, 0xCF, 0x38, 0xCC, 0x0C, 0xD0, 0x06, 0xF0, 0x06, 0xE0, 0x02,
  0xE0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xDF, 0xE0, 0x00, 0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x0C, 0x1C, 0x38, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC3, 0x2E, 0x78, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x01, 0xB0, 0x04, 0xC0,
  0x33, 0x00, 0x8C, 0x06, 0x30, 0x30, 0xC0, 0x83, 0x06, 0x0C, 0x30, 0x30,
  0xC0, 0xC6, 0x03, 0x18, 0x0C, 0xE0, 0x36, 0xC0, 0xD1, 0x03, 0xC6, 0x0E,
  0x18, 0x30, 0x20, 0xC0, 0xC3, 0x01, 0x0C, 0x06, 0x30, 0x18, 0xC0, 0x23,
  0x00, 0xCC, 0x01, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xE0, 0x3F, 0x11, 0xC6, 0x0C, 0x72, 0x60, 0x63, 0x03, 0x48, 0x04, 0xC0,
  0x2A, 0x00, 0xD0, 0x07, 0x40, 0x0C, 0x00, 0xF0, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x08, 0x83, 0xF0, 0x8E, 0x38,
  0x98, 0x0C, 0x90, 0x06, 0xB0, 0x06, 0xA0, 0x02, 0xA0, 0x02, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x07, 0xF0,
  0x03, 0x8F, 0x01, 0x80, 0x60, 0xC0, 0x08, 0x20, 0x03, 0x18, 0x00, 0x44,
  0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x28, 0x00, 0x0A, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xB0, 0x00, 0x2C,
  0x00, 0x0B, 0x00, 0x06, 0x40, 0x01, 0x98, 0x00, 0x46, 0x00, 0x30, 0xC0,
  0x0C, 0x18, 0x06, 0x07, 0x03, 0x00, 0x7F, 0x80, 0x02, 0x00, 0x83, 0xF0,
  0x21, 0xC7, 0x08, 0xC0, 0x62, 0x60, 0x0C, 0xB0, 0x03, 0x28, 0x00, 0x6A,
  0x00, 0x1B, 0x80, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C,
  0x00, 0x0B, 0x00, 0x02, 0xE0, 0x01, 0xB8, 0x00, 0x6F, 0x00, 0x33, 0x40,
  0x0C, 0xD8, 0x06, 0x33, 0x83, 0x0C, 0x7F, 0x83, 0x03, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF0, 0x87, 0x9C, 0x46, 0x03, 0x26, 0x00, 0xD3, 0x00, 0x2B,
  0x00, 0x0D, 0x80, 0x06, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x40, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xA6, 0x00,
  0xD3, 0x80, 0xC8, 0xE0, 0xC4, 0x1F, 0xC2, 0x01, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x83,
  0xF0, 0xFA, 0x30, 0x4C, 0x09, 0x01, 0x40, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0F, 0xF0, 0x78, 0xF3, 0x00, 0x58,
  0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x80, 0x1B, 0x80, 0xC7, 0xFE,
  0x01, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xFF,
  0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0xF0, 0x18, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x60, 0x0B, 0x60,
  0x1B, 0x30, 0x73, 0x1F, 0xE3, 0x02, 0x00, 0xC0, 0x01, 0xA0, 0x00, 0x90,
  0x00, 0x4C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x10, 0x80, 0x08, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x04, 0x01, 0x02, 0x01, 0x81, 0x80, 0xC0, 0xC0,
  0x60, 0x20, 0x20, 0x10, 0x10, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x04, 0x00,
  0x82, 0x00, 0x63, 0x00, 0x31, 0x80, 0x08, 0x80, 0x04, 0x40, 0x02, 0x60,
  0x01, 0xB0, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x3C,
  0x00, 0x70, 0x02, 0xC0, 0x0F, 0x00, 0x24, 0x00, 0xD0, 0x02, 0x40, 0x09,
  0x00, 0x66, 0x00, 0x90, 0x06, 0x60, 0x19, 0x80, 0x42, 0x01, 0x98, 0x04,
  0x20, 0x18, 0x80, 0xC3, 0x01, 0x08, 0x0C, 0x30, 0x10, 0x80, 0x83, 0x03,
  0x0C, 0x08, 0x10, 0x30, 0xC0, 0x81, 0x02, 0x04, 0x18, 0x18, 0x20, 0x41,
  0x81, 0x86, 0x06, 0x10, 0x08, 0x60, 0x61, 0x00, 0x86, 0x06, 0x30, 0x0C,
  0x40, 0x23, 0x00, 0xC4, 0x02, 0x20, 0x04, 0xC0, 0x32, 0x00, 0x4C, 0x03,
  0x20, 0x04, 0xC0, 0x16, 0x00, 0x68, 0x01, 0x60, 0x06, 0x80, 0x14, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x40, 0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C,
  0x10, 0x0C, 0x18, 0x08, 0x08, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x20,
  0x02, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x0C, 0x10,
  0x18, 0x18, 0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x06,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0x4C, 0x00,
  0x66, 0x00, 0x31, 0x00, 0x10, 0x80, 0x08, 0x60, 0x0C, 0x30, 0x06, 0x08,
  0x02, 0x04, 0x01, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x40, 0x40, 0x20, 0x20,
  0x18, 0x30, 0x0C, 0x18, 0x02, 0x08, 0x01, 0x04, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x11, 0x00, 0x08, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x17,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x7C, 0x01, 0xF0, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x07, 0x03, 0x81, 0xC0, 0x1F, 0xE8,
  0x00, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Thin58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 41, 11, 4, -41 },
  { 17, 9, 15, 17, 4, -41 },
  { 34, 22, 41, 25, 1, -41 },
  { 147, 19, 47, 23, 2, -44 },
  { 259, 28, 43, 33, 3, -42 },
  { 410, 20, 43, 22, 2, -42 },
  { 518, 2, 15, 9, 4, -41 },
  { 522, 10, 50, 15, 3, -41 },
  { 585, 10, 50, 15, 2, -41 },
  { 648, 14, 15, 20, 3, -44 },
  { 675, 19, 27, 23, 2, -34 },
  { 740, 5, 13, 10, 2, -6 },
  { 749, 12, 2, 15, 2, -17 },
  { 752, 3, 4, 10, 4, -4 },
  { 754, 17, 41, 19, 1, -41 },
  { 842, 17, 42, 23, 3, -42 },
  { 932, 10, 41, 23, 4, -41 },
  { 984, 18, 42, 23, 2, -42 },
  { 1079, 18, 43, 23, 2, -42 },
  { 1176, 21, 42, 23, 1, -42 },
  { 1287, 17, 42, 23, 3, -41 },
  { 1377, 17, 43, 23, 3, -42 },
  { 1469, 17, 41, 23, 3, -41 },
  { 1557, 19, 43, 23, 2, -42 },
  { 1660, 18, 43, 23, 2, -42 },
  { 1757, 3, 31, 10, 4, -31 },
  { 1769, 5, 38, 10, 2, -31 },
  { 1793, 19, 23, 23, 2, -32 },
  { 1848, 19, 14, 23, 2, -27 },
  { 1882, 19, 23, 23, 2, -32 },
  { 1937, 13, 42, 15, 1, -42 },
  { 2006, 29, 47, 35, 3, -42 },
  { 2177, 22, 41, 22, 0, -41 },
  { 2290, 18, 41, 25, 5, -41 },
  { 2383, 20, 43, 24, 3, -42 },
  { 2491, 19, 41, 27, 5, -41 },
  { 2589, 14, 41, 22, 5, -41 },
  { 2661, 14, 41, 20, 5, -41 },
  { 2733, 24, 43, 30, 3, -42 },
  { 2862, 19, 41, 28, 5, -41 },
  { 2960, 9, 41, 13, 2, -41 },
  { 3007, 9, 51, 11, -3, -41 },
  { 3065, 17, 41, 22, 5, -41 },
  { 3153, 14, 41, 20, 5, -41 },
  { 3225, 28, 41, 38, 5, -41 },
  { 3369, 20, 41, 29, 5, -41 },
  { 3472, 24, 43, 30, 3, -42 },
  { 3601, 16, 41, 23, 5, -41 },
  { 3683, 24, 52, 30, 3, -42 },
  { 3839, 17, 41, 23, 5, -41 },
  { 3927, 18, 43, 23, 2, -42 },
  { 4024, 19, 41, 19, 0, -41 },
  { 4122, 20, 42, 28, 4, -41 },
  { 4227, 21, 41, 21, 0, -41 },
  { 4335, 37, 41, 38, 0, -41 },
  { 4525, 18, 41, 19, 1, -41 },
  { 4618, 18, 41, 18, 0, -41 },
  { 4711, 16, 41, 19, 2, -41 },
  { 4793, 11, 50, 18, 5, -41 },
  { 4862, 17, 41, 19, 1, -41 },
  { 4950, 11, 50, 18, 2, -41 },
  { 5019, 21, 19, 23, 1, -41 },
  { 5069, 23, 2, 23, 0, 5 },
  { 5075, 9, 9, 13, 2, -44 },
  { 5086, 15, 32, 21, 2, -31 },
  { 5146, 18, 45, 25, 4, -44 },
  { 5248, 14, 32, 18, 3, -31 },
  { 5304, 18, 45, 25, 3, -44 },
  { 5406, 16, 32, 22, 3, -31 },
  { 5470, 13, 44, 12, 1, -44 },
  { 5542, 17, 45, 24, 3, -31 },
  { 5638, 16, 44, 24, 4, -44 },
  { 5726, 3, 42, 10, 4, -42 },
  { 5742, 7, 56, 10, 0, -42 },
  { 5791, 14, 44, 19, 4, -44 },
  { 5868, 2, 44, 10, 4, -44 },
  { 5879, 27, 31, 35, 4, -31 },
  { 5984, 16, 31, 24, 4, -31 },
  { 6046, 18, 32, 23, 3, -31 },
  { 6118, 18, 44, 25, 4, -31 },
  { 6217, 17, 44, 24, 3, -31 },
  { 6311, 11, 31, 15, 4, -31 },
  { 6354, 14, 32, 18, 2, -31 },
  { 6410, 10, 39, 12, 1, -38 },
  { 6459, 16, 32, 24, 4, -31 },
  { 6523, 17, 31, 17, 0, -31 },
  { 6589, 28, 31, 30, 1, -31 },
  { 6698, 16, 31, 18, 1, -31 },
  { 6760, 17, 45, 18, 1, -31 },
  { 6856, 12, 31, 15, 2, -31 },
  { 6903, 14, 50, 20, 3, -41 },
  { 6991, 2, 58, 22, 10, -44 },
  { 7006, 14, 50, 20, 3, -41 },
  { 7094, 19, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Thin58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN58PT7B_H_
