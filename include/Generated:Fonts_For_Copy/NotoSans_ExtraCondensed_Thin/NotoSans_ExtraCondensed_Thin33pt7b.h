#ifndef _NOTOSANS_EXTRACONDENSED_THIN33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin33pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x50, 0x0F, 0x8E, 0x28, 0x61, 0x8A, 0x18,
  0x62, 0x88, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08,
  0x4F, 0xFF, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x10,
  0x8F, 0xFF, 0x20, 0x82, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21,
  0x02, 0x10, 0x04, 0x00, 0x80, 0xFE, 0x32, 0x24, 0x41, 0x08, 0x21, 0x04,
  0x20, 0x84, 0x10, 0x81, 0x10, 0x12, 0x01, 0xC0, 0x0C, 0x01, 0x60, 0x22,
  0x04, 0x40, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0xA1, 0x33, 0xF8, 0x04,
  0x00, 0x80, 0x10, 0x00, 0x30, 0x11, 0x10, 0x42, 0x20, 0x84, 0x21, 0x08,
  0x44, 0x10, 0x88, 0x21, 0x10, 0x42, 0x40, 0x84, 0x81, 0x09, 0x12, 0x14,
  0xD4, 0x29, 0x18, 0x94, 0x29, 0x28, 0x4C, 0x90, 0x81, 0x21, 0x02, 0x42,
  0x08, 0x84, 0x11, 0x08, 0x22, 0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x88,
  0x0E, 0x1C, 0x01, 0x20, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x02,
  0x10, 0x22, 0x01, 0x20, 0x14, 0x01, 0x80, 0x28, 0x04, 0x40, 0x42, 0x28,
  0x22, 0x81, 0x28, 0x12, 0x80, 0xC8, 0x0C, 0x80, 0x44, 0x0C, 0x41, 0x23,
  0xE1, 0xFF, 0x80, 0x08, 0x44, 0x42, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x41, 0x08, 0x21, 0x04, 0x20, 0x80, 0x81, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0xC0, 0x08, 0x04, 0x02, 0x1D,
  0x71, 0xC0, 0xA0, 0x48, 0xC6, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x07, 0xFF, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x25, 0x24, 0xA0, 0xFE, 0xF0, 0x00, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x1C, 0x11,
  0x10, 0x48, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x14, 0x0A, 0x08, 0x84,
  0x7C, 0x08, 0xCA, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x1E, 0x18, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0xFF, 0x3E, 0x10,
  0x68, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x20, 0x10,
  0x78, 0x03, 0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x18, 0x09, 0xFC, 0x00, 0x40, 0x06, 0x00, 0x30, 0x02, 0x80, 0x14,
  0x01, 0x20, 0x09, 0x00, 0x88, 0x04, 0x40, 0x42, 0x02, 0x10, 0x20, 0x81,
  0x04, 0x10, 0x20, 0x81, 0x08, 0x08, 0x40, 0x47, 0xFF, 0xC0, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x7F, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x0F, 0xE2, 0x04, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x48, 0x33,
  0xF8, 0x0F, 0x04, 0x22, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0B, 0xF3, 0x04, 0x80, 0xA0, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x02, 0x80, 0x90, 0x24, 0x10, 0xF8, 0xFF, 0xC0, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x0F, 0x06, 0x11, 0x01, 0x20, 0x24, 0x04, 0x80, 0x90, 0x12, 0x02,
  0x20, 0x86, 0x10, 0x6C, 0x02, 0x01, 0xB0, 0x41, 0x10, 0x32, 0x02, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x04, 0x80, 0x98, 0x20, 0xF8, 0x1E, 0x08,
  0x44, 0x09, 0x02, 0x40, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05,
  0x01, 0x40, 0xC8, 0x51, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x31, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x2C, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x29, 0x25, 0x00, 0x00, 0x60, 0x10, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x04, 0x03, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x00, 0x79, 0x08, 0x10, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x08, 0x20, 0x41, 0x04, 0x08, 0x10, 0x20, 0x40, 0x00, 0x00, 0x00,
  0x18, 0x30, 0x03, 0xC0, 0x0C, 0x30, 0x18, 0x08, 0x30, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x41, 0xE1, 0x82, 0x21, 0x84, 0x21, 0x84, 0x21,
  0x84, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88, 0x21, 0x88, 0x21, 0x84, 0x61,
  0x84, 0x61, 0x84, 0x62, 0x83, 0x9E, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x10, 0x07, 0xE0, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x50, 0x05, 0x00, 0x90, 0x09, 0x00, 0x88, 0x08, 0x81, 0x08, 0x10,
  0x81, 0x04, 0x10, 0x42, 0x04, 0x3F, 0xC2, 0x04, 0x20, 0x24, 0x02, 0x40,
  0x24, 0x02, 0x40, 0x14, 0x01, 0x80, 0x18, 0x01, 0xFC, 0x20, 0xC8, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0xA0, 0x28, 0x13, 0xF8, 0x83,
  0x20, 0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xA0, 0x28,
  0x13, 0xF8, 0x07, 0xC3, 0x04, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xF8,
  0x10, 0xC2, 0x04, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0A,
  0x01, 0x40, 0x28, 0x09, 0x03, 0x20, 0xC7, 0xE0, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x03, 0xE0, 0x60, 0xC4,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x0F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x50, 0x02, 0x80, 0x12, 0x00, 0x90, 0x04, 0x40, 0x21, 0xFF, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x9F, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x21, 0x70, 0x80, 0xA0, 0x28, 0x12, 0x08, 0x82, 0x21, 0x08, 0x42,
  0x20, 0x90, 0x24, 0x0A, 0x02, 0x80, 0xD0, 0x24, 0x08, 0x82, 0x20, 0x84,
  0x21, 0x08, 0x22, 0x08, 0x81, 0x20, 0x48, 0x0A, 0x03, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x05, 0xC0, 0x05, 0xA0, 0x05, 0xA0,
  0x09, 0xA0, 0x09, 0x90, 0x09, 0x90, 0x09, 0x90, 0x11, 0x88, 0x11, 0x88,
  0x11, 0x88, 0x21, 0x88, 0x21, 0x84, 0x21, 0x84, 0x41, 0x84, 0x41, 0x82,
  0x41, 0x82, 0x81, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x40, 0x68, 0x0C, 0x81, 0x90, 0x31, 0x06, 0x20,
  0xC2, 0x18, 0x43, 0x08, 0x60, 0x8C, 0x11, 0x81, 0x30, 0x26, 0x02, 0xC0,
  0x58, 0x0B, 0x00, 0xE0, 0x1C, 0x01, 0x0F, 0x80, 0x82, 0x08, 0x08, 0x80,
  0x24, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x04, 0x80, 0x24, 0x01, 0x10, 0x10, 0xC1, 0x83, 0xF0, 0xE0, 0x47, 0x20,
  0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x28, 0x27,
  0xE2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x0F, 0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x24, 0x01, 0x10, 0x10,
  0xC1, 0x81, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0xE0, 0x23, 0x88, 0x12, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80,
  0xA0, 0x28, 0x12, 0x0C, 0xFC, 0x22, 0x08, 0x82, 0x10, 0x84, 0x20, 0x88,
  0x22, 0x04, 0x81, 0x20, 0x28, 0x0A, 0x03, 0x0F, 0x8C, 0x16, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0B,
  0xFC, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x02, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8, 0x80, 0x18,
  0x01, 0x80, 0x14, 0x02, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x20, 0x42,
  0x04, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x10, 0x81, 0x08, 0x09, 0x00,
  0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x50, 0x08, 0x02, 0x80, 0x60, 0x14, 0x05, 0x01, 0x20,
  0x28, 0x09, 0x01, 0x40, 0x44, 0x09, 0x02, 0x20, 0x48, 0x21, 0x04, 0x41,
  0x08, 0x22, 0x08, 0x41, 0x10, 0x41, 0x08, 0x82, 0x08, 0x42, 0x20, 0x44,
  0x11, 0x02, 0x20, 0x88, 0x09, 0x04, 0x40, 0x48, 0x24, 0x02, 0x40, 0xA0,
  0x14, 0x05, 0x00, 0xA0, 0x28, 0x03, 0x01, 0x40, 0x18, 0x0C, 0x00, 0xC0,
  0x20, 0x40, 0x28, 0x08, 0x81, 0x10, 0x41, 0x08, 0x21, 0x04, 0x40, 0x48,
  0x09, 0x01, 0x40, 0x18, 0x02, 0x00, 0x60, 0x14, 0x02, 0x80, 0x48, 0x11,
  0x02, 0x20, 0x82, 0x10, 0x42, 0x08, 0x80, 0x90, 0x14, 0x03, 0x80, 0x60,
  0x14, 0x05, 0x02, 0x40, 0x88, 0x22, 0x10, 0x84, 0x11, 0x04, 0x81, 0x20,
  0x28, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x08, 0x02, 0x01, 0xFC, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x04, 0x00, 0xC0, 0x28, 0x04, 0x81,
  0x10, 0x21, 0x08, 0x21, 0x04, 0x40, 0x48, 0x0A, 0x00, 0xC0, 0x10, 0xFF,
  0xF8, 0xC3, 0x08, 0x20, 0x80, 0x1C, 0x31, 0x80, 0x40, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x0F, 0x98, 0x50, 0x28, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x41,
  0x9F, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x70, 0x91, 0x94, 0x13, 0x01, 0x60, 0x28, 0x05, 0x00, 0xA0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x40, 0x2C, 0x05, 0x80, 0xB0, 0x25, 0x04, 0x9F,
  0x00, 0x0E, 0x31, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x71, 0x23, 0x50, 0x58, 0x0E, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0D,
  0x05, 0x3E, 0x40, 0x1C, 0x11, 0x10, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01,
  0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x9F, 0x80,
  0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x1C, 0x08, 0xD4, 0x16, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x41, 0x4F, 0x90,
  0x04, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x81, 0x1F, 0x80, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x1C, 0x91, 0x50, 0x70, 0x38, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x80, 0xF0, 0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0x33, 0x00, 0x00,
  0x02, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x2C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x84,
  0x84, 0x88, 0x90, 0x90, 0xA8, 0xA8, 0xC8, 0x84, 0x84, 0x82, 0x82, 0x81,
  0x81, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x18, 0xB2, 0x26, 0xA1, 0x42,
  0xC1, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x0E, 0x58, 0xA8, 0x38, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x1C, 0x08, 0xC4, 0x12, 0x02, 0x80, 0xA0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x0A, 0x02, 0x41,
  0x0F, 0x80, 0x0E, 0x24, 0x6A, 0x0B, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x02, 0xA0, 0xA7,
  0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x1C,
  0x08, 0xD4, 0x16, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0F, 0x03, 0x41, 0x4F, 0x90, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0E, 0x5A, 0x30, 0xC3,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x1C, 0x61,
  0x40, 0x80, 0x80, 0x80, 0x40, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x83, 0xFE, 0x42, 0x10, 0x84, 0x7D, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x1C, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x06, 0x85,
  0x3E, 0x80, 0x80, 0xD0, 0x24, 0x09, 0x02, 0x41, 0x10, 0x42, 0x10, 0x84,
  0x22, 0x08, 0x81, 0x20, 0x48, 0x14, 0x05, 0x00, 0xC0, 0x30, 0x08, 0x00,
  0x80, 0x81, 0xA0, 0x40, 0x90, 0x50, 0x48, 0x28, 0x24, 0x14, 0x11, 0x0A,
  0x10, 0x84, 0x88, 0x44, 0x44, 0x22, 0x22, 0x11, 0x12, 0x04, 0x89, 0x02,
  0x82, 0x81, 0x41, 0x40, 0xA0, 0xA0, 0x30, 0x60, 0x18, 0x10, 0x08, 0x08,
  0x00, 0x81, 0xA0, 0x90, 0x84, 0x42, 0x40, 0xA0, 0x50, 0x30, 0x18, 0x0C,
  0x05, 0x04, 0x82, 0x22, 0x11, 0x05, 0x02, 0x80, 0x80, 0x40, 0x50, 0x14,
  0x08, 0x82, 0x20, 0x88, 0x22, 0x10, 0x44, 0x11, 0x04, 0x41, 0x20, 0x28,
  0x0A, 0x02, 0x80, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x01, 0x00, 0x40, 0xE0, 0x00, 0xFE, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x04, 0x08, 0x10, 0x40, 0xFE, 0x03, 0x0C, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0x60,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x60, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x08, 0x08, 0x07, 0x0C, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xE0, 0x78,
  0x30, 0xC6, 0x07, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Thin33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 24, 6, 2, -24 },
  { 7, 6, 9, 10, 2, -24 },
  { 14, 12, 24, 14, 1, -24 },
  { 50, 11, 27, 13, 1, -25 },
  { 88, 15, 24, 19, 2, -24 },
  { 133, 12, 24, 13, 1, -24 },
  { 169, 1, 9, 5, 2, -24 },
  { 171, 5, 29, 9, 2, -24 },
  { 190, 6, 29, 9, 1, -24 },
  { 212, 9, 8, 11, 1, -25 },
  { 221, 11, 15, 13, 1, -19 },
  { 242, 3, 7, 6, 1, -3 },
  { 245, 7, 1, 9, 1, -9 },
  { 246, 2, 2, 6, 2, -2 },
  { 247, 9, 24, 11, 1, -24 },
  { 274, 9, 24, 13, 2, -24 },
  { 301, 5, 24, 13, 3, -24 },
  { 316, 10, 24, 13, 1, -24 },
  { 346, 10, 24, 13, 1, -24 },
  { 376, 13, 24, 13, 0, -24 },
  { 415, 10, 24, 13, 2, -24 },
  { 445, 10, 24, 13, 2, -24 },
  { 475, 10, 24, 13, 1, -24 },
  { 505, 11, 24, 13, 1, -24 },
  { 538, 10, 24, 13, 1, -24 },
  { 568, 2, 18, 6, 2, -18 },
  { 573, 3, 22, 6, 1, -18 },
  { 582, 11, 13, 13, 1, -18 },
  { 600, 11, 8, 13, 1, -16 },
  { 611, 11, 13, 13, 1, -18 },
  { 629, 7, 24, 9, 1, -24 },
  { 650, 16, 27, 20, 2, -24 },
  { 704, 12, 24, 12, 0, -24 },
  { 740, 10, 24, 14, 3, -24 },
  { 770, 11, 24, 14, 2, -24 },
  { 803, 11, 24, 16, 3, -24 },
  { 836, 8, 24, 13, 3, -24 },
  { 860, 8, 24, 12, 3, -24 },
  { 884, 13, 24, 17, 2, -24 },
  { 923, 10, 24, 16, 3, -24 },
  { 953, 5, 24, 7, 1, -24 },
  { 968, 5, 30, 6, -1, -24 },
  { 987, 10, 24, 13, 3, -24 },
  { 1017, 8, 24, 11, 3, -24 },
  { 1041, 16, 24, 22, 3, -24 },
  { 1089, 11, 24, 17, 3, -24 },
  { 1122, 13, 24, 17, 2, -24 },
  { 1161, 9, 24, 13, 3, -24 },
  { 1188, 13, 30, 17, 2, -24 },
  { 1237, 10, 24, 13, 3, -24 },
  { 1267, 10, 24, 13, 1, -24 },
  { 1297, 11, 24, 11, 0, -24 },
  { 1330, 12, 24, 16, 2, -24 },
  { 1366, 12, 24, 12, 0, -24 },
  { 1402, 21, 24, 21, 0, -24 },
  { 1465, 11, 24, 11, 0, -24 },
  { 1498, 10, 24, 10, 0, -24 },
  { 1528, 9, 24, 11, 1, -24 },
  { 1555, 6, 29, 10, 3, -24 },
  { 1577, 9, 24, 11, 1, -24 },
  { 1604, 6, 29, 10, 1, -24 },
  { 1626, 11, 12, 13, 1, -24 },
  { 1643, 13, 1, 13, 0, 3 },
  { 1645, 5, 5, 7, 1, -25 },
  { 1649, 9, 18, 12, 1, -18 },
  { 1670, 11, 25, 14, 2, -25 },
  { 1705, 8, 18, 10, 2, -18 },
  { 1723, 10, 25, 14, 2, -25 },
  { 1755, 9, 18, 13, 2, -18 },
  { 1776, 8, 25, 7, 0, -25 },
  { 1801, 10, 26, 14, 2, -18 },
  { 1834, 9, 25, 13, 2, -25 },
  { 1863, 2, 24, 6, 2, -24 },
  { 1869, 4, 32, 6, 0, -24 },
  { 1885, 8, 25, 11, 2, -25 },
  { 1910, 1, 25, 6, 2, -25 },
  { 1914, 16, 18, 20, 2, -18 },
  { 1950, 9, 18, 13, 2, -18 },
  { 1971, 10, 18, 13, 2, -18 },
  { 1994, 10, 26, 14, 2, -18 },
  { 2027, 10, 26, 14, 2, -18 },
  { 2060, 6, 18, 9, 2, -18 },
  { 2074, 8, 18, 10, 1, -18 },
  { 2092, 5, 22, 7, 1, -22 },
  { 2106, 9, 17, 13, 2, -17 },
  { 2126, 10, 17, 10, 0, -17 },
  { 2148, 17, 17, 17, 0, -17 },
  { 2185, 9, 17, 10, 1, -17 },
  { 2205, 10, 25, 10, 0, -17 },
  { 2237, 7, 17, 9, 1, -17 },
  { 2252, 8, 29, 11, 2, -24 },
  { 2281, 1, 33, 12, 6, -25 },
  { 2286, 8, 29, 11, 2, -24 },
  { 2315, 11, 3, 13, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_Thin33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN33PT7B_H_
