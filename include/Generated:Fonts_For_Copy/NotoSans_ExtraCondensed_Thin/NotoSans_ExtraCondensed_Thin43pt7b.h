#ifndef _NOTOSANS_EXTRACONDENSED_THIN43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_THIN43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x00, 0x7C, 0x87, 0x0E, 0x1C,
  0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x02, 0x04, 0x02, 0x08, 0x02,
  0x08, 0x02, 0x08, 0x06, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04,
  0x08, 0x7F, 0xFF, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08,
  0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0xFF,
  0xFE, 0x08, 0x20, 0x18, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10,
  0x20, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x30, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x7F, 0x83, 0x11, 0x84, 0x20, 0x10, 0x40, 0x20, 0x80,
  0xC1, 0x01, 0x82, 0x03, 0x04, 0x06, 0x08, 0x04, 0x10, 0x0C, 0x20, 0x08,
  0x40, 0x0C, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x09, 0x80, 0x11,
  0x80, 0x21, 0x80, 0x41, 0x00, 0x82, 0x01, 0x06, 0x02, 0x0C, 0x04, 0x10,
  0x08, 0x20, 0x10, 0xD0, 0x21, 0x38, 0x4C, 0x0F, 0xE0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x3C, 0x01, 0x03, 0x10, 0x10, 0x10, 0x80,
  0x80, 0x82, 0x04, 0x08, 0x10, 0x40, 0x40, 0x82, 0x02, 0x04, 0x10, 0x10,
  0x21, 0x80, 0x81, 0x08, 0x04, 0x08, 0x40, 0x20, 0x46, 0x01, 0x02, 0x20,
  0x08, 0x11, 0x1C, 0x40, 0x99, 0x12, 0x04, 0x98, 0xC8, 0x24, 0x82, 0x42,
  0x64, 0x13, 0x32, 0x20, 0x8F, 0x13, 0x04, 0x01, 0x90, 0x10, 0x08, 0x80,
  0x80, 0x44, 0x04, 0x02, 0x20, 0x20, 0x21, 0x01, 0x01, 0x08, 0x18, 0x08,
  0x20, 0x80, 0x81, 0x04, 0x04, 0x08, 0x20, 0x20, 0x41, 0x02, 0x01, 0x10,
  0x10, 0x0F, 0x80, 0x07, 0x80, 0x08, 0x80, 0x10, 0x40, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x08,
  0x40, 0x08, 0x80, 0x09, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x13,
  0x00, 0x21, 0x00, 0x60, 0x82, 0x40, 0x82, 0x40, 0x42, 0x40, 0x44, 0xC0,
  0x24, 0x80, 0x24, 0x80, 0x1C, 0xC0, 0x18, 0x40, 0x18, 0x40, 0x14, 0x60,
  0x24, 0x30, 0x42, 0x1F, 0x83, 0xFF, 0xE0, 0x03, 0x06, 0x04, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60,
  0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x06, 0x03, 0x80, 0x81, 0x81,
  0x03, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0xC1, 0x02,
  0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x0C, 0x46, 0x7F, 0x01, 0x00, 0x50, 0x11, 0x04, 0x21, 0x82, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x25, 0xA4, 0xB4, 0x90, 0xFF, 0x80, 0xFC, 0x00, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x00, 0x0F, 0x80, 0xC6, 0x0C, 0x18,
  0x40, 0x46, 0x03, 0x20, 0x09, 0x00, 0x48, 0x02, 0xC0, 0x16, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0x00, 0x68, 0x02, 0x40, 0x12,
  0x00, 0x98, 0x04, 0x40, 0x43, 0x02, 0x0C, 0x20, 0x3E, 0x00, 0x02, 0x0C,
  0x28, 0x92, 0x38, 0x50, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0x1F, 0x87, 0x06, 0x10, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x03, 0xFF, 0xE0, 0x3F, 0x83, 0x06, 0x20, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x1C, 0x03, 0xF0, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x02, 0x40, 0x33, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x50, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x90, 0x01, 0x10,
  0x03, 0x10, 0x02, 0x10, 0x06, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10,
  0x18, 0x10, 0x10, 0x10, 0x30, 0x10, 0x20, 0x10, 0x60, 0x10, 0x40, 0x10,
  0x40, 0x10, 0x80, 0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x7F, 0xE2,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x7F, 0xC1, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x40, 0x61, 0xFE,
  0x00, 0x03, 0xF0, 0x70, 0x86, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x78, 0x4E, 0x62,
  0xC0, 0x94, 0x02, 0xC0, 0x16, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x22, 0x03,
  0x18, 0x10, 0x7F, 0x00, 0xC0, 0xFF, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x0F, 0x81, 0x83, 0x18,
  0x0C, 0x80, 0x24, 0x01, 0x60, 0x0E, 0x00, 0x30, 0x03, 0xC0, 0x1A, 0x00,
  0x98, 0x04, 0x40, 0x41, 0x04, 0x06, 0xC0, 0x1C, 0x01, 0xA0, 0x18, 0xC1,
  0x03, 0x10, 0x0D, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x34, 0x01, 0x10, 0x10, 0x7F, 0x00, 0x1F,
  0x81, 0x86, 0x18, 0x18, 0x80, 0x4C, 0x03, 0x40, 0x0A, 0x00, 0x50, 0x02,
  0x80, 0x14, 0x00, 0xA0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x68,
  0x07, 0x40, 0x39, 0x06, 0xC7, 0xE4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC1,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x6D, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x12, 0xDA, 0x5A, 0x48, 0x00, 0x02, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x7E, 0x41,
  0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x80, 0xC0, 0x00, 0x7C, 0x00,
  0x06, 0x1C, 0x00, 0x60, 0x08, 0x03, 0x00, 0x10, 0x08, 0x00, 0x20, 0x40,
  0x00, 0xC1, 0x00, 0x01, 0x08, 0x00, 0x04, 0x20, 0x00, 0x09, 0x80, 0xF8,
  0x24, 0x04, 0x20, 0x90, 0x20, 0x82, 0x41, 0x82, 0x0D, 0x04, 0x08, 0x3C,
  0x10, 0x20, 0x70, 0x40, 0x81, 0xC1, 0x02, 0x06, 0x0C, 0x18, 0x18, 0x30,
  0x60, 0x60, 0xC1, 0x83, 0xC1, 0x06, 0x0B, 0x04, 0x18, 0x24, 0x10, 0x60,
  0x90, 0x42, 0x86, 0x40, 0x8B, 0x11, 0x03, 0xC7, 0x84, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x30, 0x0C, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x08, 0x1F, 0xF8,
  0x10, 0x08, 0x30, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0xFF, 0x02, 0x07, 0x88, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x01,
  0x8F, 0xFC, 0x20, 0x78, 0x80, 0x32, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x28, 0x00, 0xA0,
  0x06, 0x80, 0x12, 0x01, 0x8F, 0xFC, 0x00, 0x01, 0xFC, 0x0C, 0x0C, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x40, 0xFF, 0x00, 0xFE, 0x01, 0x07, 0x82, 0x01, 0x84,
  0x00, 0x88, 0x00, 0x90, 0x01, 0x20, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0,
  0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x02,
  0x10, 0x18, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x3F, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F, 0xF8,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x70,
  0x40, 0x08, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x1F, 0xE0, 0x00, 0x1C,
  0x00, 0x05, 0x00, 0x01, 0x40, 0x00, 0x50, 0x00, 0x14, 0x00, 0x05, 0x80,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x11, 0x00, 0x04, 0x60, 0x01, 0x0C, 0x00,
  0x41, 0x80, 0x30, 0x1F, 0xF8, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x8F, 0xC0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20,
  0x5F, 0x08, 0x00, 0x80, 0x1C, 0x00, 0xA0, 0x0D, 0x00, 0x48, 0x04, 0x40,
  0x62, 0x02, 0x10, 0x30, 0x81, 0x04, 0x10, 0x21, 0x81, 0x08, 0x08, 0xC0,
  0x44, 0x02, 0x60, 0x17, 0x80, 0xA4, 0x06, 0x30, 0x30, 0x81, 0x06, 0x08,
  0x10, 0x40, 0xC2, 0x02, 0x10, 0x18, 0x80, 0x44, 0x03, 0x20, 0x09, 0x00,
  0x68, 0x01, 0x40, 0x0E, 0x00, 0x20, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x3F,
  0xF8, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3A, 0x00, 0x01, 0x68, 0x00, 0x05,
  0xA0, 0x00, 0x16, 0xC0, 0x00, 0xD9, 0x00, 0x02, 0x64, 0x00, 0x09, 0x90,
  0x00, 0x66, 0x20, 0x01, 0x18, 0x80, 0x04, 0x62, 0x00, 0x11, 0x84, 0x00,
  0x86, 0x10, 0x02, 0x18, 0x40, 0x08, 0x61, 0x80, 0x61, 0x82, 0x01, 0x06,
  0x08, 0x04, 0x18, 0x30, 0x30, 0x60, 0x40, 0x81, 0x81, 0x02, 0x06, 0x04,
  0x08, 0x18, 0x08, 0x40, 0x60, 0x21, 0x01, 0x80, 0x84, 0x06, 0x03, 0x30,
  0x18, 0x04, 0x80, 0x60, 0x12, 0x01, 0x80, 0x78, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0xC0, 0x03, 0x80, 0x06, 0x80, 0x0D, 0x00, 0x1B, 0x00,
  0x32, 0x00, 0x64, 0x00, 0xC4, 0x01, 0x88, 0x03, 0x08, 0x06, 0x10, 0x0C,
  0x30, 0x18, 0x20, 0x30, 0x60, 0x60, 0x40, 0xC0, 0x81, 0x80, 0x83, 0x01,
  0x06, 0x01, 0x0C, 0x02, 0x18, 0x06, 0x30, 0x04, 0x60, 0x08, 0xC0, 0x09,
  0x80, 0x13, 0x00, 0x16, 0x00, 0x2C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x80, 0x03, 0xF0, 0x03, 0x03, 0x01, 0x80, 0x60, 0x40, 0x08, 0x20,
  0x01, 0x08, 0x00, 0x46, 0x00, 0x19, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0x40,
  0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x88, 0x00,
  0x42, 0x00, 0x10, 0x40, 0x0C, 0x18, 0x06, 0x03, 0x03, 0x00, 0x7F, 0x80,
  0xFC, 0x04, 0x3E, 0x20, 0x19, 0x00, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x90, 0x0C, 0x81, 0xC7, 0xF8, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x03, 0xF0, 0x03, 0x83, 0x01, 0x80, 0x60, 0x40, 0x08,
  0x20, 0x01, 0x08, 0x00, 0x46, 0x00, 0x19, 0x00, 0x02, 0x40, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x88,
  0x00, 0x42, 0x00, 0x10, 0x40, 0x08, 0x18, 0x06, 0x03, 0x03, 0x00, 0x7F,
  0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0xFE, 0x02, 0x0F, 0x08, 0x06, 0x20, 0x0C,
  0x80, 0x12, 0x00, 0x48, 0x01, 0x20, 0x06, 0x80, 0x1A, 0x00, 0x68, 0x01,
  0x20, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x06, 0x20, 0x30, 0xFF, 0x02, 0x08,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x82, 0x02, 0x08, 0x0C, 0x20, 0x10, 0x80,
  0x62, 0x00, 0x88, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x28, 0x00, 0xC0,
  0x0F, 0xE1, 0x80, 0x98, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x03, 0x40,
  0x33, 0xFE, 0x00, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x22, 0x00, 0x86, 0x03, 0x03, 0xF8, 0x00, 0x80, 0x01, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20,
  0x04, 0x20, 0x04, 0x20, 0x0C, 0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x0C,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x80,
  0x04, 0x00, 0x3C, 0x00, 0x60, 0x02, 0x40, 0x06, 0x00, 0x24, 0x00, 0x60,
  0x02, 0x40, 0x0E, 0x00, 0x64, 0x00, 0xA0, 0x04, 0x20, 0x0B, 0x00, 0x42,
  0x00, 0x90, 0x04, 0x20, 0x09, 0x00, 0x42, 0x01, 0x90, 0x0C, 0x30, 0x11,
  0x00, 0x81, 0x01, 0x18, 0x08, 0x10, 0x10, 0x80, 0x81, 0x01, 0x08, 0x08,
  0x10, 0x30, 0x81, 0x81, 0x82, 0x08, 0x10, 0x08, 0x20, 0xC1, 0x00, 0x82,
  0x04, 0x10, 0x08, 0x20, 0x43, 0x00, 0xC6, 0x04, 0x20, 0x04, 0x40, 0x42,
  0x00, 0x44, 0x06, 0x20, 0x04, 0x40, 0x22, 0x00, 0x44, 0x02, 0x60, 0x06,
  0x40, 0x24, 0x00, 0x28, 0x02, 0x40, 0x02, 0x80, 0x34, 0x00, 0x28, 0x01,
  0xC0, 0x02, 0x80, 0x18, 0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x04, 0x80, 0x22, 0x00, 0x84, 0x06, 0x10, 0x10, 0x60, 0x40, 0x82,
  0x02, 0x08, 0x0C, 0x60, 0x11, 0x00, 0x44, 0x00, 0xB0, 0x02, 0x80, 0x0A,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x10, 0x04,
  0x40, 0x21, 0x00, 0x82, 0x06, 0x08, 0x10, 0x30, 0x40, 0x42, 0x01, 0x08,
  0x06, 0x60, 0x09, 0x00, 0x2C, 0x00, 0xC0, 0x80, 0x0F, 0x00, 0x24, 0x00,
  0x90, 0x06, 0x60, 0x10, 0x80, 0x42, 0x03, 0x0C, 0x08, 0x10, 0x20, 0x41,
  0x81, 0x84, 0x02, 0x10, 0x08, 0xC0, 0x32, 0x00, 0x48, 0x01, 0x60, 0x05,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x7F, 0xF0, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF,
  0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00,
  0x44, 0x00, 0x8C, 0x02, 0x08, 0x04, 0x18, 0x10, 0x10, 0x20, 0x30, 0x80,
  0x21, 0x00, 0x64, 0x00, 0x48, 0x00, 0xE0, 0x00, 0x80, 0xFF, 0xFF, 0x80,
  0x83, 0x06, 0x08, 0x10, 0x20, 0x40, 0x1F, 0x0C, 0x10, 0x01, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x1F, 0x8C, 0x16, 0x02,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0A, 0x81,
  0x4F, 0xC8, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x23, 0xE1, 0x30, 0xCA, 0x03, 0x50,
  0x0B, 0x00, 0x58, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x01, 0x60, 0x0A, 0x80, 0xD2, 0x0C, 0x8F, 0xC0, 0x07, 0xC3, 0x04, 0xC0,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x43, 0xE2, 0x30, 0x92,
  0x02, 0xB0, 0x0D, 0x00, 0x68, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x14, 0x01, 0xA0, 0x0C, 0x80, 0xA6, 0x0D, 0x1F, 0xC8, 0x0F, 0x81,
  0x8C, 0x20, 0x66, 0x02, 0x40, 0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0x03, 0x0F, 0xE0, 0x03, 0xC1, 0x10,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x0F, 0xF0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x00, 0x0F, 0x88, 0xC3, 0x48, 0x0A, 0xC0, 0x34, 0x01, 0xA0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0xD0, 0x06, 0x80, 0x32,
  0x02, 0x98, 0x34, 0x7E, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC8, 0x0C, 0x7F, 0xC0, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x8F, 0x89, 0x8C, 0xA0, 0x6A, 0x02, 0xC0, 0x2C, 0x02, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0xF8,
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x18, 0xC4, 0x00, 0x00, 0x00,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0xE0, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x01,
  0x40, 0x48, 0x09, 0x02, 0x20, 0xC4, 0x10, 0x84, 0x11, 0x82, 0x20, 0x4C,
  0x09, 0xC1, 0x48, 0x39, 0x06, 0x10, 0x82, 0x10, 0x62, 0x04, 0x40, 0x88,
  0x09, 0x01, 0x20, 0x34, 0x02, 0x80, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x8F, 0x07, 0xC9, 0x08, 0x86, 0xA0, 0x50, 0x2C, 0x05, 0x01, 0xC0, 0x60,
  0x1C, 0x06, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02,
  0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80,
  0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x18,
  0x02, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x20, 0x10, 0x8F, 0x89,
  0x8C, 0xA0, 0x6A, 0x02, 0xC0, 0x2C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x0F, 0x80, 0x83,
  0x08, 0x0C, 0xC0, 0x24, 0x01, 0x20, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0A, 0x00, 0x50, 0x06, 0x80, 0x22, 0x03, 0x18, 0x30, 0x7F, 0x00, 0x8F,
  0x84, 0xC3, 0x2C, 0x09, 0x40, 0x2C, 0x01, 0x60, 0x0F, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x05, 0x40, 0x2A, 0x02, 0x48, 0x32, 0x3F,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x0F, 0x88, 0xC3, 0x48, 0x0A, 0xC0, 0x34,
  0x01, 0xA0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0x50, 0x06,
  0x80, 0x32, 0x02, 0x98, 0x34, 0x7F, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x8F,
  0x99, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3F, 0x98,
  0x3C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0xA0, 0x6F, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xC0, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x34, 0x06, 0xC1, 0x4F, 0xC8,
  0x80, 0x1C, 0x01, 0x40, 0x14, 0x03, 0x40, 0x26, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x42, 0x04, 0x10, 0x41, 0x04, 0x10, 0x81, 0x08, 0x08, 0x80, 0x88,
  0x09, 0x80, 0x90, 0x05, 0x00, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x30, 0x0D, 0x00, 0xC0, 0x24, 0x03, 0x00, 0x90, 0x0C, 0x02, 0x40, 0x28,
  0x08, 0x81, 0xA0, 0x42, 0x04, 0x81, 0x08, 0x12, 0x04, 0x20, 0x4C, 0x10,
  0xC1, 0x10, 0xC1, 0x08, 0x42, 0x04, 0x21, 0x08, 0x10, 0x84, 0x20, 0x42,
  0x18, 0x80, 0x98, 0x24, 0x02, 0x40, 0x90, 0x09, 0x02, 0x40, 0x24, 0x09,
  0x00, 0xD0, 0x14, 0x01, 0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x60, 0x18, 0x00, 0x80, 0x34, 0x02, 0x40, 0x62, 0x04, 0x20, 0xC1, 0x08,
  0x10, 0x81, 0x90, 0x09, 0x00, 0xA0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xA0,
  0x09, 0x01, 0x10, 0x10, 0x83, 0x08, 0x20, 0x46, 0x04, 0x40, 0x6C, 0x02,
  0x80, 0x30, 0x40, 0x0A, 0x00, 0x48, 0x06, 0x40, 0x22, 0x01, 0x10, 0x08,
  0x40, 0xC2, 0x04, 0x10, 0x20, 0x81, 0x06, 0x18, 0x10, 0x80, 0x84, 0x04,
  0x20, 0x33, 0x00, 0x90, 0x04, 0x80, 0x24, 0x01, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x06, 0x03, 0xFE, 0x00, 0x60,
  0x78, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x03, 0xC0,
  0x78, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x0F, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x07, 0x00,
  0xF0, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x03, 0x81,
  0xC0, 0x00, 0x3C, 0x02, 0xC6, 0x06, 0x03, 0xF0, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 31, 8, 3, -31 },
  { 9, 7, 11, 13, 3, -31 },
  { 19, 16, 31, 18, 1, -31 },
  { 81, 15, 36, 17, 1, -33 },
  { 149, 21, 31, 25, 2, -31 },
  { 231, 16, 31, 17, 1, -31 },
  { 293, 1, 11, 7, 3, -31 },
  { 295, 8, 38, 11, 2, -31 },
  { 333, 7, 38, 11, 2, -31 },
  { 367, 11, 11, 15, 2, -33 },
  { 383, 15, 20, 17, 1, -25 },
  { 421, 3, 10, 8, 2, -4 },
  { 425, 9, 1, 11, 1, -12 },
  { 427, 2, 3, 8, 3, -3 },
  { 428, 12, 31, 14, 1, -31 },
  { 475, 13, 31, 17, 2, -31 },
  { 526, 7, 31, 17, 3, -31 },
  { 554, 13, 31, 17, 2, -31 },
  { 605, 13, 31, 17, 2, -31 },
  { 656, 16, 31, 17, 1, -31 },
  { 718, 13, 31, 17, 2, -31 },
  { 769, 13, 32, 17, 2, -31 },
  { 821, 13, 31, 17, 2, -31 },
  { 872, 13, 31, 17, 2, -31 },
  { 923, 13, 31, 17, 2, -31 },
  { 974, 2, 23, 8, 3, -23 },
  { 980, 3, 29, 8, 2, -23 },
  { 991, 15, 18, 17, 1, -24 },
  { 1025, 15, 10, 17, 1, -20 },
  { 1044, 15, 18, 17, 1, -24 },
  { 1078, 9, 31, 11, 1, -31 },
  { 1113, 22, 35, 26, 2, -31 },
  { 1210, 16, 31, 16, 0, -31 },
  { 1272, 14, 31, 18, 3, -31 },
  { 1327, 15, 31, 18, 2, -31 },
  { 1386, 15, 31, 20, 3, -31 },
  { 1445, 11, 31, 16, 3, -31 },
  { 1488, 11, 31, 15, 3, -31 },
  { 1531, 18, 31, 22, 2, -31 },
  { 1601, 15, 31, 21, 3, -31 },
  { 1660, 6, 31, 9, 2, -31 },
  { 1684, 7, 39, 8, -2, -31 },
  { 1719, 13, 31, 16, 3, -31 },
  { 1770, 11, 31, 15, 3, -31 },
  { 1813, 22, 31, 28, 3, -31 },
  { 1899, 15, 31, 22, 3, -31 },
  { 1958, 18, 31, 22, 2, -31 },
  { 2028, 13, 31, 17, 3, -31 },
  { 2079, 18, 38, 22, 2, -31 },
  { 2165, 14, 31, 17, 3, -31 },
  { 2220, 13, 31, 17, 2, -31 },
  { 2271, 14, 31, 14, 0, -31 },
  { 2326, 15, 31, 21, 3, -31 },
  { 2385, 16, 31, 16, 0, -31 },
  { 2447, 28, 31, 28, 0, -31 },
  { 2556, 14, 31, 14, 0, -31 },
  { 2611, 14, 31, 14, 0, -31 },
  { 2666, 12, 31, 14, 1, -31 },
  { 2713, 8, 38, 13, 4, -31 },
  { 2751, 12, 31, 14, 1, -31 },
  { 2798, 8, 38, 13, 2, -31 },
  { 2836, 15, 15, 17, 1, -31 },
  { 2865, 17, 1, 17, 0, 4 },
  { 2868, 6, 7, 10, 2, -33 },
  { 2874, 11, 23, 16, 2, -23 },
  { 2906, 13, 33, 18, 3, -33 },
  { 2960, 11, 23, 13, 2, -23 },
  { 2992, 13, 33, 18, 2, -33 },
  { 3046, 12, 23, 16, 2, -23 },
  { 3081, 10, 33, 9, 0, -33 },
  { 3123, 13, 33, 18, 2, -23 },
  { 3177, 12, 33, 18, 3, -33 },
  { 3227, 2, 31, 8, 3, -31 },
  { 3235, 5, 41, 8, 0, -31 },
  { 3261, 11, 33, 14, 3, -33 },
  { 3307, 1, 33, 7, 3, -33 },
  { 3312, 20, 23, 26, 3, -23 },
  { 3370, 12, 23, 18, 3, -23 },
  { 3405, 13, 23, 17, 2, -23 },
  { 3443, 13, 33, 18, 3, -23 },
  { 3497, 13, 33, 18, 2, -23 },
  { 3551, 8, 23, 11, 3, -23 },
  { 3574, 10, 23, 13, 2, -23 },
  { 3603, 7, 28, 9, 1, -28 },
  { 3628, 11, 23, 18, 3, -23 },
  { 3660, 12, 23, 13, 0, -23 },
  { 3695, 22, 23, 22, 0, -23 },
  { 3759, 12, 23, 14, 1, -23 },
  { 3794, 13, 33, 14, 0, -23 },
  { 3848, 9, 23, 11, 1, -23 },
  { 3874, 11, 38, 15, 2, -31 },
  { 3927, 1, 43, 16, 8, -33 },
  { 3933, 11, 38, 15, 2, -31 },
  { 3986, 15, 4, 17, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Thin43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Thin43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Thin43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_THIN43PT7B_H_
