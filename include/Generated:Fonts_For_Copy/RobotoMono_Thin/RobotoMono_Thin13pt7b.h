#ifndef _ROBOTOMONO_THIN13PT7B_H_
#define _ROBOTOMONO_THIN13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xFC, 0x12, 0x29, 0xF9, 0x22, 0x44, 0xBE, 0x94, 0x48,
  0x10, 0xC4, 0xA1, 0x81, 0x03, 0x81, 0x86, 0x16, 0x84, 0xE0, 0x94, 0x98,
  0x68, 0x10, 0x16, 0x29, 0x29, 0x06, 0x71, 0x25, 0x08, 0x62, 0x58, 0xE1,
  0x7C, 0xE0, 0x6A, 0xAA, 0xAA, 0x40, 0xC8, 0x92, 0x49, 0x24, 0xA8, 0x13,
  0x73, 0x0C, 0x48, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xE0, 0xF0, 0x80,
  0x11, 0x22, 0x24, 0x48, 0x88, 0x7A, 0x18, 0xE5, 0xA7, 0x18, 0x61, 0x78,
  0x79, 0x11, 0x11, 0x11, 0x10, 0xFC, 0x42, 0x11, 0x10, 0x88, 0xF8, 0xFC,
  0x42, 0x13, 0x06, 0x31, 0x78, 0x10, 0x42, 0x92, 0x4A, 0x27, 0xC2, 0x08,
  0x7D, 0x04, 0x1E, 0x04, 0x10, 0x61, 0x78, 0x39, 0x08, 0x3E, 0x86, 0x18,
  0x61, 0x78, 0xFC, 0x20, 0x82, 0x10, 0x42, 0x08, 0x40, 0x7A, 0x18, 0x52,
  0x7A, 0x18, 0x61, 0x78, 0x7A, 0x18, 0x61, 0x85, 0xF0, 0x42, 0x70, 0x82,
  0x83, 0x80, 0x0C, 0xCC, 0x18, 0x1C, 0xFC, 0x0F, 0xC0, 0xC0, 0xC0, 0xC6,
  0xE0, 0xF9, 0x11, 0x24, 0x00, 0x40, 0x3E, 0x96, 0xDD, 0x3A, 0x75, 0x6B,
  0xA8, 0x3C, 0x20, 0xC3, 0x12, 0x49, 0x2B, 0x61, 0x84, 0xFA, 0x18, 0x62,
  0xFA, 0x18, 0x61, 0xF8, 0x7A, 0x18, 0x60, 0x82, 0x08, 0x61, 0x78, 0xFA,
  0x18, 0x61, 0x86, 0x18, 0x61, 0xF8, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20,
  0xFC, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x80, 0x7A, 0x18, 0x20, 0x9A,
  0x18, 0x61, 0x78, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0xF8, 0x08, 0x42, 0x10, 0x86, 0x31, 0x78, 0x86, 0x29,
  0x28, 0xE2, 0x48, 0xA1, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x86,
  0x1C, 0xF5, 0xB6, 0x98, 0x61, 0x84, 0x86, 0x1C, 0x69, 0xA6, 0x58, 0xE1,
  0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xFC, 0x63, 0x1F, 0x42,
  0x10, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0x20, 0x40, 0xFA,
  0x18, 0x61, 0xEA, 0x48, 0xA1, 0x84, 0x7A, 0x18, 0x10, 0x38, 0x10, 0x61,
  0x78, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x78, 0x86, 0x18, 0x92, 0x49, 0x23, 0x0C, 0x20, 0x96, 0x5B,
  0x6D, 0xB7, 0x3C, 0x92, 0x48, 0x85, 0x24, 0x8C, 0x10, 0xC4, 0xA1, 0x84,
  0x86, 0x24, 0x94, 0x20, 0x82, 0x08, 0x20, 0xF8, 0x21, 0x04, 0x21, 0x04,
  0x20, 0xFC, 0xEA, 0xAA, 0xAA, 0xC0, 0x88, 0x44, 0x42, 0x22, 0x11, 0xD5,
  0x55, 0x55, 0xC0, 0x46, 0x99, 0x90, 0xFC, 0x90, 0x7A, 0x10, 0x5E, 0x86,
  0x1F, 0xC0, 0x82, 0x08, 0x3E, 0x86, 0x18, 0x61, 0x87, 0xE0, 0x7A, 0x18,
  0x20, 0x82, 0x17, 0x80, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8B, 0xC0, 0x7A,
  0x18, 0x7E, 0x82, 0x07, 0xC0, 0x1C, 0x82, 0x3E, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x8B, 0x80, 0x82, 0x08, 0x3E, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x20, 0x38, 0x42, 0x10, 0x84, 0xF8, 0x10, 0x71,
  0x11, 0x11, 0x11, 0x1E, 0x84, 0x21, 0x3A, 0x63, 0x14, 0x94, 0x40, 0xC1,
  0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0xFE, 0x9A, 0x69, 0xA6, 0x9A, 0x40,
  0xFA, 0x18, 0x61, 0x86, 0x18, 0x40, 0x7A, 0x18, 0x61, 0x86, 0x17, 0x80,
  0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x00, 0x7C, 0x63, 0x18, 0xC5,
  0xE1, 0x08, 0x40, 0xBE, 0x21, 0x08, 0x42, 0x00, 0x7A, 0x1C, 0x0E, 0x06,
  0x17, 0x80, 0x21, 0x3E, 0x42, 0x10, 0x84, 0x38, 0x8C, 0x63, 0x18, 0xC5,
  0xE0, 0x86, 0x18, 0x92, 0x50, 0xC2, 0x00, 0x93, 0x25, 0x6A, 0xD6, 0x44,
  0x89, 0x00, 0x85, 0x23, 0x08, 0x31, 0x28, 0x40, 0x86, 0x18, 0x92, 0x48,
  0xC2, 0x08, 0x23, 0x00, 0xFC, 0x21, 0x08, 0x41, 0x0F, 0xC0, 0x12, 0x22,
  0x24, 0x84, 0x22, 0x22, 0x10, 0xFF, 0xE0, 0xC2, 0x22, 0x22, 0x12, 0x22,
  0x24, 0x80, 0x73, 0x1C,
};

const GFXglyph RobotoMono_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 1, 9, 8, 3, -9 },
  { 3, 2, 3, 8, 3, -10 },
  { 4, 7, 9, 8, 0, -9 },
  { 12, 6, 12, 8, 1, -11 },
  { 21, 8, 9, 8, 0, -9 },
  { 30, 6, 9, 8, 1, -9 },
  { 37, 1, 3, 8, 3, -10 },
  { 38, 2, 13, 8, 3, -10 },
  { 42, 3, 13, 8, 2, -10 },
  { 47, 6, 5, 8, 1, -9 },
  { 51, 6, 7, 8, 1, -8 },
  { 57, 1, 3, 8, 3, -1 },
  { 58, 4, 1, 8, 2, -5 },
  { 59, 1, 1, 8, 4, -1 },
  { 60, 4, 10, 8, 2, -9 },
  { 65, 6, 9, 8, 1, -9 },
  { 72, 4, 9, 8, 1, -9 },
  { 77, 5, 9, 8, 1, -9 },
  { 83, 5, 9, 8, 1, -9 },
  { 89, 6, 9, 8, 1, -9 },
  { 96, 6, 9, 8, 1, -9 },
  { 103, 6, 9, 8, 1, -9 },
  { 110, 6, 9, 8, 1, -9 },
  { 117, 6, 9, 8, 1, -9 },
  { 124, 6, 9, 8, 1, -9 },
  { 131, 1, 7, 8, 4, -7 },
  { 132, 1, 9, 8, 4, -7 },
  { 134, 6, 5, 8, 1, -7 },
  { 138, 6, 3, 8, 1, -6 },
  { 141, 6, 5, 8, 1, -7 },
  { 145, 4, 9, 8, 2, -9 },
  { 150, 7, 9, 8, 0, -9 },
  { 158, 6, 9, 8, 1, -9 },
  { 165, 6, 9, 8, 1, -9 },
  { 172, 6, 9, 8, 1, -9 },
  { 179, 6, 9, 8, 1, -9 },
  { 186, 6, 9, 8, 1, -9 },
  { 193, 6, 9, 8, 1, -9 },
  { 200, 6, 9, 8, 1, -9 },
  { 207, 6, 9, 8, 1, -9 },
  { 214, 5, 9, 8, 1, -9 },
  { 220, 5, 9, 8, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 5, 9, 8, 2, -9 },
  { 239, 6, 9, 8, 1, -9 },
  { 246, 6, 9, 8, 1, -9 },
  { 253, 6, 9, 8, 1, -9 },
  { 260, 5, 9, 8, 2, -9 },
  { 266, 6, 11, 8, 1, -9 },
  { 275, 6, 9, 8, 1, -9 },
  { 282, 6, 9, 8, 1, -9 },
  { 289, 6, 9, 8, 1, -9 },
  { 296, 6, 9, 8, 1, -9 },
  { 303, 6, 9, 8, 1, -9 },
  { 310, 6, 9, 8, 1, -9 },
  { 317, 6, 9, 8, 1, -9 },
  { 324, 6, 9, 8, 1, -9 },
  { 331, 6, 9, 8, 1, -9 },
  { 338, 2, 13, 8, 3, -11 },
  { 342, 4, 10, 8, 2, -9 },
  { 347, 2, 13, 8, 3, -11 },
  { 351, 4, 5, 8, 2, -9 },
  { 354, 6, 1, 8, 1, 0 },
  { 355, 2, 2, 8, 3, -10 },
  { 356, 6, 7, 8, 1, -7 },
  { 362, 6, 10, 8, 1, -10 },
  { 370, 6, 7, 8, 1, -7 },
  { 376, 5, 10, 8, 1, -10 },
  { 383, 6, 7, 8, 1, -7 },
  { 389, 6, 10, 8, 1, -10 },
  { 397, 5, 10, 8, 1, -7 },
  { 404, 6, 10, 8, 1, -10 },
  { 412, 5, 9, 8, 2, -9 },
  { 418, 4, 12, 8, 1, -9 },
  { 424, 5, 10, 8, 2, -10 },
  { 431, 5, 10, 8, 2, -10 },
  { 438, 6, 7, 8, 1, -7 },
  { 444, 6, 7, 8, 1, -7 },
  { 450, 6, 7, 8, 1, -7 },
  { 456, 6, 10, 8, 1, -7 },
  { 464, 5, 10, 8, 1, -7 },
  { 471, 5, 7, 8, 2, -7 },
  { 476, 6, 7, 8, 1, -7 },
  { 482, 5, 9, 8, 1, -9 },
  { 488, 5, 7, 8, 1, -7 },
  { 493, 6, 7, 8, 1, -7 },
  { 499, 7, 7, 8, 0, -7 },
  { 506, 6, 7, 8, 1, -7 },
  { 512, 6, 10, 8, 1, -7 },
  { 520, 6, 7, 8, 1, -7 },
  { 526, 4, 13, 8, 2, -10 },
  { 533, 1, 11, 8, 3, -9 },
  { 535, 4, 13, 8, 2, -10 },
  { 542, 7, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_Thin13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin13pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_THIN13PT7B_H_
