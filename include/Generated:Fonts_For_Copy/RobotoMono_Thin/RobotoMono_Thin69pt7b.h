#ifndef _ROBOTOMONO_THIN69PT7B_H_
#define _ROBOTOMONO_THIN69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin69pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x7F, 0x70, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0x60, 0x2C, 0x05, 0x80, 0x80, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x00, 0x30, 0x01,
  0x80, 0x07, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x80, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00,
  0x18, 0x03, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x60, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x0C, 0x00, 0x01, 0xC0, 0x70, 0x18,
  0x00, 0x01, 0xC1, 0xC0, 0x60, 0x00, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0x00,
  0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0xFC, 0x00, 0x00, 0x18,
  0x07, 0xFC, 0x00, 0x00, 0x30, 0x1C, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x18, 0x00, 0x0C,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x08, 0x00, 0x18, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x40, 0x03, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x00, 0x30, 0x38, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0xC3, 0x00, 0x1C, 0x00, 0x31, 0x80, 0x03, 0x00,
  0x0C, 0x60, 0x00, 0x60, 0x03, 0x30, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0x01,
  0x80, 0x63, 0x00, 0x00, 0x70, 0x18, 0x80, 0x00, 0x0E, 0x0E, 0x20, 0x00,
  0x01, 0x83, 0x08, 0x00, 0x00, 0x30, 0xC2, 0x00, 0x00, 0x06, 0x60, 0xC0,
  0x00, 0x00, 0xD8, 0x30, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0x07, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0xD8, 0x0C, 0x00, 0x00, 0x63,
  0x01, 0xC0, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x07, 0xC0, 0xF8,
  0x03, 0x00, 0x7F, 0xF8, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x40, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x01, 0xFF, 0x00, 0xC0,
  0x7E, 0x3F, 0x06, 0x1F, 0x80, 0x3F, 0x33, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x01,
  0x80, 0x00, 0x60, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C,
  0x62, 0x31, 0x98, 0xCC, 0x20, 0xFF, 0xFF, 0xFF, 0x6F, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x32, 0xC0, 0x00, 0x01, 0x8B, 0x00,
  0x00, 0x0C, 0x3C, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0x18, 0x0F, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x30,
  0x03, 0xC0, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0xF0, 0x03, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x3C,
  0x06, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0F, 0x0C,
  0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x06, 0xD8, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x04, 0x20, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3F, 0x01, 0xF3, 0x07, 0x83, 0x1E, 0x03, 0x78, 0x03, 0xE0, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x02, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xE0, 0x03, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x08,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x3F, 0x80, 0x03, 0x1F,
  0xFF, 0x00, 0x37, 0x80, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02,
  0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x0E,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x01, 0xFF, 0x80, 0x18, 0x1F,
  0xFF, 0x80, 0x61, 0xE0, 0x07, 0x01, 0x9C, 0x00, 0x0E, 0x04, 0xE0, 0x00,
  0x0C, 0x17, 0x00, 0x00, 0x18, 0xD8, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60,
  0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x23, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x46, 0x00, 0x00, 0x19,
  0x0C, 0x00, 0x00, 0xEC, 0x18, 0x00, 0x07, 0x30, 0x30, 0x00, 0x38, 0xC0,
  0x70, 0x03, 0x83, 0x00, 0xFF, 0xFC, 0x0C, 0x00, 0xFF, 0xC0, 0x20, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFE, 0x0C, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x38, 0x61, 0x81, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x07,
  0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x00, 0x03, 0x03, 0x00, 0x1F, 0xC0, 0x0C, 0x18, 0x01, 0xFF, 0xC0, 0x30,
  0x60, 0x0E, 0x03, 0x80, 0x63, 0x00, 0x70, 0x06, 0x01, 0x8C, 0x01, 0x80,
  0x18, 0x06, 0x30, 0x0C, 0x00, 0x60, 0x19, 0x80, 0x30, 0x01, 0x80, 0x66,
  0x01, 0x80, 0x04, 0x01, 0x98, 0x06, 0x00, 0x10, 0x02, 0x40, 0x10, 0x00,
  0xC0, 0x0B, 0x00, 0xC0, 0x03, 0x00, 0x2C, 0x03, 0x00, 0x0C, 0x00, 0xB0,
  0x0C, 0x00, 0x30, 0x02, 0xC0, 0x30, 0x00, 0xC0, 0x0B, 0x00, 0x80, 0x03,
  0x00, 0x2C, 0x06, 0x00, 0x0C, 0x01, 0xB0, 0x18, 0x00, 0x20, 0x06, 0xC0,
  0x60, 0x00, 0x80, 0x1B, 0x01, 0x80, 0x06, 0x00, 0x6C, 0x06, 0x00, 0x18,
  0x01, 0xB0, 0x18, 0x00, 0xE0, 0x06, 0xC0, 0x20, 0x03, 0x80, 0x13, 0x00,
  0xC0, 0x0E, 0x00, 0xCC, 0x03, 0x00, 0x78, 0x03, 0x30, 0x0C, 0x03, 0x30,
  0x18, 0x60, 0x10, 0x0C, 0xC0, 0x61, 0x80, 0x60, 0x63, 0x03, 0x06, 0x00,
  0xC7, 0x07, 0x38, 0x1C, 0x01, 0xF8, 0x0F, 0xC0, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xCF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x31,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01,
  0x82, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x02, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x03, 0xC0,
  0x30, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x00, 0x3C, 0x0C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x0F, 0x80, 0x20, 0x00,
  0x07, 0x00, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0x18, 0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x03,
  0x08, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0E, 0x02,
  0x00, 0x00, 0x70, 0x08, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0E, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x60, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x01, 0x30, 0x00,
  0x00, 0x02, 0x70, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x08, 0x60, 0x00,
  0x00, 0x10, 0xE0, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x1C, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1C, 0x80, 0x00, 0x00, 0x38, 0x80, 0x00, 0x00, 0x70, 0x80, 0x00, 0x00,
  0xE0, 0x80, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x80, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x06, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0x60, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x03, 0x80, 0x00, 0x80, 0x07, 0x00,
  0x00, 0x80, 0x0E, 0x00, 0x00, 0x80, 0x1C, 0x00, 0x00, 0x80, 0x18, 0x00,
  0x00, 0x80, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x80, 0xC0, 0x00,
  0x00, 0x81, 0xC0, 0x00, 0x00, 0x83, 0x60, 0x00, 0x00, 0x86, 0x30, 0x00,
  0x00, 0x8C, 0x38, 0x00, 0x00, 0x98, 0x1C, 0x00, 0x00, 0xB0, 0x0C, 0x00,
  0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x03, 0x80,
  0x00, 0x80, 0x01, 0xC0, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x80, 0x00, 0x38, 0x00, 0x80, 0x00, 0x1C,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x06, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x03, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x80, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x00, 0x60, 0x80, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00,
  0x38, 0x80, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xD8, 0x00, 0x00, 0x6F,
  0x60, 0x00, 0x01, 0xBD, 0x80, 0x00, 0x0E, 0xF3, 0x00, 0x00, 0x33, 0xCC,
  0x00, 0x00, 0xCF, 0x18, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x18, 0xF1, 0x80,
  0x00, 0xC3, 0xC3, 0x00, 0x03, 0x0F, 0x0C, 0x00, 0x0C, 0x3C, 0x18, 0x00,
  0x60, 0xF0, 0x60, 0x01, 0x83, 0xC1, 0x80, 0x0C, 0x0F, 0x03, 0x00, 0x30,
  0x3C, 0x0C, 0x00, 0xC0, 0xF0, 0x10, 0x06, 0x03, 0xC0, 0x60, 0x18, 0x0F,
  0x01, 0x80, 0xC0, 0x3C, 0x03, 0x03, 0x00, 0xF0, 0x0C, 0x08, 0x03, 0xC0,
  0x30, 0x60, 0x0F, 0x00, 0x61, 0x80, 0x3C, 0x01, 0x8C, 0x00, 0xF0, 0x02,
  0x30, 0x03, 0xC0, 0x0C, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1D,
  0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x07, 0x20, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0x03, 0x86, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0xE0, 0x40, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x00, 0x80,
  0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80,
  0x01, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x01,
  0x80, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x40, 0xE0,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00,
  0x9C, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x03,
  0x00, 0x01, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x1C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x02, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x03, 0x80, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0x46, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x00, 0xC0, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x07, 0xC0, 0x20, 0x00, 0x03,
  0x80, 0x80, 0x00, 0x07, 0x02, 0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x1C,
  0x20, 0x00, 0x00, 0x30, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x07, 0x08, 0x00, 0x00, 0x18,
  0x20, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0E, 0x02, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x80, 0x00, 0xC0, 0x02, 0x00,
  0x01, 0x80, 0x08, 0x00, 0x06, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0x30, 0x02, 0x00, 0x00, 0x60, 0x08, 0x00, 0x01, 0xC0, 0x20, 0x00, 0x03,
  0x00, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00, 0x30,
  0x20, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x01, 0x82, 0x00, 0x00, 0x07, 0x08,
  0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x00, 0xC8, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x06, 0x20, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x06, 0x18, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x08, 0x03, 0x00,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0x60, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x01, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x1A, 0x00, 0x03, 0x80, 0x00, 0x90, 0x00, 0x1C, 0x00, 0x0C, 0xC0, 0x00,
  0xE0, 0x00, 0x66, 0x00, 0x07, 0x00, 0x03, 0x30, 0x00, 0x28, 0x00, 0x19,
  0x80, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x04, 0x20, 0x00, 0xD8,
  0x00, 0x21, 0x80, 0x06, 0xC0, 0x03, 0x0C, 0x00, 0x22, 0x00, 0x18, 0x60,
  0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00,
  0x20, 0x40, 0x06, 0x30, 0x01, 0x02, 0x00, 0x20, 0x80, 0x18, 0x18, 0x03,
  0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0x30, 0x06, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x60, 0x08, 0x04, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x20, 0x18, 0x08, 0x01, 0x03, 0x00, 0x60,
  0x40, 0x08, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x03, 0x06,
  0x00, 0xC1, 0x80, 0x18, 0x20, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x40,
  0x06, 0x18, 0x00, 0xC2, 0x00, 0x10, 0xC0, 0x06, 0x10, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x06, 0x20, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0x90, 0x00, 0x26, 0x00, 0x0C,
  0x80, 0x01, 0x20, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x01, 0xCC,
  0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0xE0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00, 0x60, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00,
  0x86, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x64, 0x00, 0x00, 0x46, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x18, 0x30, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x60, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x20, 0xE0, 0x00, 0x01,
  0x1C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x39, 0x00, 0x00, 0x03,
  0x4C, 0x00, 0x00, 0x3B, 0x70, 0x00, 0x03, 0x99, 0xC0, 0x00, 0x38, 0xC7,
  0x00, 0x07, 0x06, 0x1F, 0x01, 0xF0, 0x30, 0x3F, 0xFE, 0x01, 0x80, 0x3C,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x81, 0xFF, 0xF0, 0x10,
  0xF0, 0x0F, 0x02, 0x38, 0x00, 0x70, 0x4C, 0x00, 0x03, 0x0B, 0x00, 0x00,
  0x31, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0A,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x03, 0x38, 0x00, 0x00, 0xC5, 0x80, 0x00, 0x38, 0x98, 0x00, 0x0E, 0x11,
  0xC0, 0x03, 0x82, 0x1F, 0x03, 0xE0, 0x40, 0xFF, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xC0,
  0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x00, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x03, 0xFC, 0x03, 0x00, 0xFF, 0xF8, 0x30, 0x3C, 0x01, 0xC3, 0x07, 0x00,
  0x06, 0x30, 0xE0, 0x00, 0x33, 0x1C, 0x00, 0x01, 0xB1, 0x80, 0x00, 0x0F,
  0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07,
  0x18, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0x1B, 0x06, 0x00, 0x03, 0xB0, 0x38,
  0x00, 0xE3, 0x01, 0xE0, 0x7C, 0x30, 0x07, 0xFF, 0x03, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x1C,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x83, 0x03, 0xC0,
  0x1C, 0x30, 0x70, 0x00, 0x63, 0x0E, 0x00, 0x03, 0x30, 0xC0, 0x00, 0x1B,
  0x18, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07,
  0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0xB0, 0x60,
  0x00, 0x3B, 0x03, 0x80, 0x0E, 0x30, 0x1E, 0x07, 0xC3, 0x00, 0x7F, 0xF0,
  0x30, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x80,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01, 0xFF,
  0x00, 0xC0, 0x7F, 0xFC, 0x0C, 0x1E, 0x00, 0xF0, 0xC3, 0x80, 0x03, 0x8C,
  0x70, 0x00, 0x18, 0xCC, 0x00, 0x00, 0xCC, 0xC0, 0x00, 0x0E, 0xD8, 0x00,
  0x00, 0x6F, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xC0, 0x70, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C,
  0x78, 0x00, 0x00, 0xCF, 0xC0, 0x00, 0x0D, 0xCE, 0x00, 0x00, 0xF8, 0x70,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x0C, 0x7F, 0xF0, 0x3F, 0xF8,
  0xDC, 0x03, 0x8E, 0x01, 0xCD, 0x80, 0x19, 0xC0, 0x0C, 0xF0, 0x00, 0xD8,
  0x00, 0x6E, 0x00, 0x0F, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0x00, 0x6C, 0x00,
  0x06, 0x00, 0x02, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1F, 0xF0, 0x0C, 0x07, 0xFF, 0xC0, 0xC1, 0xE0, 0x0F,
  0x0C, 0x38, 0x00, 0x38, 0xC7, 0x00, 0x01, 0x8C, 0xC0, 0x00, 0x0C, 0xC8,
  0x00, 0x00, 0xCD, 0x80, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0C,
  0x0F, 0xFF, 0x80, 0xC3, 0xC0, 0x3C, 0x0C, 0x70, 0x00, 0xE0, 0xCC, 0x00,
  0x03, 0x0D, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x0C,
  0xE0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x18,
  0xD8, 0x00, 0x03, 0x0C, 0xC0, 0x00, 0x70, 0xC7, 0x00, 0x0E, 0x0C, 0x3E,
  0x07, 0x80, 0xC0, 0xFF, 0xF0, 0x0C, 0x00, 0x68, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0x83, 0x03, 0xC0, 0x3C, 0x30, 0x70, 0x00, 0x73, 0x0E, 0x00, 0x03,
  0x31, 0xC0, 0x00, 0x1B, 0x18, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x07, 0x30,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0F, 0x0C,
  0x00, 0x01, 0xB0, 0x60, 0x00, 0x3B, 0x03, 0x80, 0x0E, 0x30, 0x1E, 0x07,
  0xC3, 0x00, 0x7F, 0xF0, 0x30, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF,
  0x03, 0xC0, 0x06, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x19, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x69, 0xC0,
  0x00, 0x19, 0x1C, 0x00, 0x06, 0x21, 0xC0, 0x03, 0x8C, 0x1E, 0x03, 0xE1,
  0x80, 0xFF, 0xF0, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18,
  0x0E, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0x60, 0x00, 0xF0, 0x00, 0x66, 0x00,
  0x09, 0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06,
  0x30, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x10, 0x03, 0x0C, 0x01, 0x81, 0x80,
  0x20, 0xC0, 0x18, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0x60, 0x60, 0x18,
  0x18, 0x06, 0x06, 0x01, 0x00, 0xC0, 0x40, 0x60, 0x30, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x60,
  0x80, 0x10, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0x21, 0x00, 0x08, 0x40, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x32,
  0x00, 0x04, 0x80, 0x01, 0x60, 0x00, 0x68, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x70, 0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x00, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x1C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC7, 0x01,
  0xE0, 0x00, 0x06, 0x70, 0x03, 0x80, 0x00, 0x33, 0x00, 0x0E, 0x00, 0x03,
  0x30, 0x00, 0x38, 0x00, 0x19, 0x80, 0x00, 0xE0, 0x01, 0xCC, 0x00, 0x01,
  0xC0, 0x0C, 0x40, 0x00, 0x07, 0x01, 0xC6, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_Thin69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 4, 49, 41, 18, -49 },
  { 26, 11, 14, 41, 15, -52 },
  { 46, 38, 49, 41, 2, -49 },
  { 279, 30, 63, 41, 6, -56 },
  { 516, 39, 51, 41, 1, -50 },
  { 765, 34, 51, 41, 6, -50 },
  { 982, 2, 14, 41, 18, -52 },
  { 986, 14, 71, 41, 14, -55 },
  { 1111, 15, 71, 41, 12, -55 },
  { 1245, 29, 27, 41, 7, -49 },
  { 1343, 34, 36, 41, 4, -41 },
  { 1496, 5, 14, 41, 14, -5 },
  { 1505, 24, 1, 41, 9, -23 },
  { 1508, 4, 4, 41, 20, -4 },
  { 1510, 23, 53, 41, 10, -49 },
  { 1663, 30, 51, 41, 6, -50 },
  { 1855, 16, 49, 41, 8, -49 },
  { 1953, 30, 50, 41, 4, -50 },
  { 2141, 31, 51, 41, 3, -50 },
  { 2339, 34, 49, 41, 3, -49 },
  { 2548, 28, 50, 41, 8, -49 },
  { 2723, 30, 51, 41, 5, -50 },
  { 2915, 31, 49, 41, 5, -49 },
  { 3105, 31, 51, 41, 6, -50 },
  { 3303, 30, 51, 41, 5, -50 },
  { 3495, 4, 34, 41, 22, -34 },
  { 3512, 7, 43, 41, 19, -34 },
  { 3550, 30, 27, 41, 5, -36 },
  { 3652, 30, 15, 41, 6, -30 },
  { 3709, 29, 27, 41, 6, -36 },
  { 3807, 26, 50, 41, 8, -50 },
  { 3970, 38, 50, 41, 2, -50 },
  { 4208, 34, 49, 41, 4, -49 },
  { 4417, 30, 49, 41, 7, -49 },
  { 4601, 31, 51, 41, 5, -50 },
  { 4799, 30, 49, 41, 7, -49 },
  { 4983, 28, 49, 41, 7, -49 },
  { 5155, 28, 49, 41, 8, -49 },
  { 5327, 31, 51, 41, 5, -50 },
  { 5525, 29, 49, 41, 6, -49 },
  { 5703, 27, 49, 41, 7, -49 },
  { 5869, 30, 50, 41, 4, -49 },
  { 6057, 32, 49, 41, 8, -49 },
  { 6253, 28, 49, 41, 8, -49 },
  { 6425, 30, 49, 41, 6, -49 },
  { 6609, 29, 49, 41, 6, -49 },
  { 6787, 32, 51, 41, 5, -50 },
  { 6991, 30, 49, 41, 8, -49 },
  { 7175, 34, 59, 41, 4, -50 },
  { 7426, 30, 49, 41, 8, -49 },
  { 7610, 32, 51, 41, 5, -50 },
  { 7814, 34, 49, 41, 4, -49 },
  { 8023, 30, 50, 41, 6, -49 },
  { 8211, 34, 49, 41, 4, -49 },
  { 8420, 37, 49, 41, 3, -49 },
  { 8647, 34, 49, 41, 4, -49 },
  { 8856, 34, 49, 41, 3, -49 },
  { 9065, 30, 49, 41, 5, -49 },
  { 9249, 10, 67, 41, 16, -56 },
  { 9333, 23, 53, 41, 9, -49 },
  { 9486, 10, 67, 41, 15, -56 },
  { 9570, 24, 27, 41, 9, -49 },
  { 9651, 29, 2, 41, 6, 0 },
  { 9659, 8, 9, 41, 17, -51 },
  { 9668, 29, 38, 41, 6, -37 },
  { 9806, 27, 53, 41, 8, -52 },
  { 9985, 29, 38, 41, 6, -37 },
  { 10123, 28, 53, 41, 6, -52 },
  { 10309, 30, 38, 41, 6, -37 },
  { 10452, 30, 52, 41, 7, -52 },
  { 10647, 28, 52, 41, 6, -37 },
  { 10829, 28, 52, 41, 7, -52 },
  { 11011, 28, 49, 41, 8, -49 },
  { 11183, 21, 64, 41, 6, -49 },
  { 11351, 28, 52, 41, 9, -52 },
  { 11533, 28, 52, 41, 8, -52 },
  { 11715, 36, 37, 41, 3, -37 },
  { 11882, 28, 37, 41, 7, -37 },
  { 12012, 32, 38, 41, 5, -37 },
  { 12164, 28, 51, 41, 7, -37 },
  { 12343, 28, 51, 41, 6, -37 },
  { 12522, 23, 37, 41, 13, -37 },
  { 12629, 29, 38, 41, 7, -37 },
  { 12767, 27, 47, 41, 7, -46 },
  { 12926, 27, 37, 41, 7, -36 },
  { 13051, 33, 36, 41, 4, -36 },
  { 13200, 36, 36, 41, 3, -36 },
  { 13362, 32, 36, 41, 5, -36 },
  { 13506, 35, 51, 41, 3, -36 },
  { 13730, 32, 36, 41, 5, -36 },
  { 13874, 22, 69, 41, 11, -54 },
  { 14064, 2, 58, 41, 20, -49 },
  { 14079, 22, 69, 41, 11, -54 },
  { 14269, 37, 11, 41, 2, -26 },
};

const GFXfont RobotoMono_Thin69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin69pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_THIN69PT7B_H_
