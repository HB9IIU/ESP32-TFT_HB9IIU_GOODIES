#ifndef _ROBOTOMONO_THIN47PT7B_H_
#define _ROBOTOMONO_THIN47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin47pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x00,
  0x07, 0x60, 0xC3, 0xC3, 0xC3, 0xC2, 0xC2, 0xC2, 0xC2, 0xC2, 0xC2, 0x00,
  0x10, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x20,
  0x00, 0x20, 0x08, 0x00, 0x08, 0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80,
  0x40, 0x00, 0x60, 0x10, 0x0F, 0xFF, 0xFF, 0xF0, 0x04, 0x01, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x08, 0x00, 0x0C, 0x02, 0x00,
  0x02, 0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x18, 0x00, 0x08, 0x04,
  0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0x40, 0x10, 0x0F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00,
  0x20, 0x08, 0x00, 0x08, 0x02, 0x00, 0x02, 0x01, 0x80, 0x00, 0x80, 0x40,
  0x00, 0x60, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0,
  0x01, 0xE3, 0x80, 0x30, 0x06, 0x03, 0x00, 0x08, 0x10, 0x00, 0x61, 0x00,
  0x01, 0x08, 0x00, 0x0C, 0x40, 0x00, 0x22, 0x00, 0x01, 0x10, 0x00, 0x08,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x02, 0x60,
  0x00, 0x11, 0x00, 0x01, 0x8C, 0x00, 0x08, 0x30, 0x00, 0xC0, 0xE0, 0x18,
  0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x01, 0x00, 0x00, 0xC0, 0x60, 0x18, 0x20, 0x08, 0x04, 0x08,
  0x02, 0x03, 0x02, 0x00, 0x80, 0x80, 0x80, 0x20, 0x60, 0x20, 0x08, 0x10,
  0x08, 0x02, 0x08, 0x03, 0x01, 0x82, 0x00, 0x40, 0x41, 0x00, 0x18, 0x30,
  0xC0, 0x03, 0xF8, 0x20, 0x00, 0x38, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0xF8, 0x00, 0x10, 0x63,
  0x00, 0x08, 0x30, 0x60, 0x02, 0x08, 0x08, 0x01, 0x06, 0x03, 0x00, 0xC1,
  0x00, 0x40, 0x20, 0x40, 0x10, 0x18, 0x10, 0x04, 0x04, 0x04, 0x01, 0x03,
  0x01, 0x00, 0x40, 0x80, 0x60, 0x10, 0x60, 0x08, 0x0C, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x41, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x40, 0x30, 0x01, 0x80, 0x20, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x06, 0x00, 0x20, 0x08, 0x00,
  0x60, 0x30, 0x00, 0x40, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0x8C, 0x00, 0x00,
  0xA0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0x19, 0x00, 0x00, 0x61,
  0x00, 0x01, 0x81, 0x00, 0x22, 0x03, 0x00, 0xC8, 0x03, 0x01, 0xB0, 0x03,
  0x02, 0x40, 0x02, 0x04, 0x80, 0x02, 0x09, 0x00, 0x06, 0x32, 0x00, 0x06,
  0x44, 0x00, 0x07, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x34,
  0x18, 0x00, 0xCC, 0x18, 0x06, 0x0C, 0x1F, 0xF0, 0x0C, 0x55, 0x5F, 0xC0,
  0x00, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x10, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x04, 0x02, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x01, 0xE0, 0x60, 0xF3, 0xC6, 0x38, 0x07, 0xDC, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x19, 0x00, 0x01, 0x08, 0x00, 0x20, 0xC0, 0x06,
  0x06, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x81, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x24, 0x92, 0xD2,
  0x90, 0xFF, 0xFF, 0xBC, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x78, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x08, 0x30, 0x00,
  0x42, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x61, 0x80,
  0x0C, 0x18, 0x01, 0x81, 0x80, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x18,
  0x18, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01,
  0xF0, 0x00, 0x16, 0x00, 0x01, 0x40, 0x00, 0x34, 0x00, 0x02, 0x60, 0x00,
  0x62, 0x00, 0x04, 0x10, 0x00, 0xC1, 0x80, 0x18, 0x0E, 0x03, 0x00, 0x3F,
  0xE0, 0x00, 0x60, 0x34, 0x38, 0x9C, 0x1E, 0x03, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x03,
  0xF0, 0x00, 0xF1, 0xE0, 0x18, 0x03, 0x03, 0x00, 0x18, 0x60, 0x00, 0x84,
  0x00, 0x04, 0xC0, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x68, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x1C, 0x38, 0x03, 0x00, 0x70, 0x30, 0x00, 0x83, 0x00,
  0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0x4C, 0x00, 0x02, 0x40, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80,
  0x00, 0x16, 0x00, 0x01, 0x10, 0x00, 0x08, 0xC0, 0x00, 0x83, 0x00, 0x0C,
  0x0E, 0x01, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x30, 0x00, 0x08, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC1, 0x80, 0x01,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0xC0,
  0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x03,
  0x00, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10, 0x00, 0x30,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xE1, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x23,
  0xF8, 0x02, 0xE0, 0xE0, 0x30, 0x03, 0x06, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x02, 0x40, 0x00,
  0x24, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x01, 0x80, 0xC0,
  0x30, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC1, 0xF8,
  0x08, 0x78, 0xE0, 0x98, 0x01, 0x8B, 0x00, 0x0C, 0xE0, 0x00, 0x4C, 0x00,
  0x06, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x62, 0x00, 0x04, 0x30, 0x00, 0xC1, 0x80, 0x18,
  0x0E, 0x03, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x3C, 0x78, 0x03, 0x00, 0x60, 0x30, 0x00, 0x83, 0x00,
  0x02, 0x10, 0x00, 0x19, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x00, 0x12,
  0x00, 0x00, 0x90, 0x00, 0x04, 0xC0, 0x00, 0x22, 0x00, 0x03, 0x18, 0x00,
  0x30, 0x60, 0x03, 0x01, 0xC0, 0x30, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0x00, 0x70, 0x20, 0x00, 0xC2, 0x00, 0x03, 0x20, 0x00, 0x09, 0x00, 0x00,
  0x78, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x14, 0x00, 0x01, 0xB0, 0x00, 0x08, 0x80, 0x00, 0xC3, 0x00, 0x0C,
  0x0E, 0x01, 0xC0, 0x1F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x79, 0xE0, 0x0C,
  0x03, 0x01, 0x00, 0x18, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x40, 0x00, 0x2C,
  0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x34, 0x00, 0x03, 0x60, 0x00, 0x53, 0x00, 0x09, 0x18, 0x01, 0x90, 0xE0,
  0xE1, 0x03, 0xF8, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x5F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x05, 0xF0, 0x11, 0xCC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x42, 0x10, 0x84, 0x21, 0x11, 0x88, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x07, 0x1C, 0x0C, 0x01, 0x8C, 0x00, 0x44,
  0x00, 0x16, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0x80, 0x00, 0x18, 0x60, 0x1C, 0x06, 0x30, 0x1F, 0xC0, 0x88, 0x0C, 0x18,
  0x22, 0x04, 0x06, 0x0D, 0x83, 0x01, 0x03, 0x40, 0x80, 0x40, 0x50, 0x20,
  0x10, 0x14, 0x18, 0x04, 0x07, 0x04, 0x01, 0x01, 0xC1, 0x00, 0x40, 0x70,
  0x40, 0x10, 0x18, 0x10, 0x04, 0x0E, 0x04, 0x03, 0x03, 0x81, 0x00, 0xC0,
  0xB0, 0x40, 0x20, 0x2C, 0x10, 0x18, 0x09, 0x04, 0x07, 0x06, 0x41, 0x82,
  0x41, 0x10, 0x21, 0x90, 0xC6, 0x07, 0xC3, 0xE0, 0x80, 0x40, 0x20, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x40,
  0x03, 0x80, 0x70, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x04, 0xC0, 0x00, 0x08, 0x80,
  0x00, 0x31, 0x00, 0x00, 0x43, 0x00, 0x00, 0x82, 0x00, 0x01, 0x04, 0x00,
  0x04, 0x0C, 0x00, 0x08, 0x08, 0x00, 0x10, 0x10, 0x00, 0x40, 0x30, 0x00,
  0x80, 0x20, 0x01, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x40, 0x03, 0x00, 0x80, 0x02, 0x01, 0x00, 0x04, 0x07, 0xFF,
  0xFC, 0x08, 0x00, 0x08, 0x10, 0x00, 0x10, 0x60, 0x00, 0x30, 0x80, 0x00,
  0x21, 0x00, 0x00, 0x46, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x90, 0x00, 0x01,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x02, 0xFF, 0xF8, 0x08, 0x00, 0xE0, 0x80,
  0x01, 0x08, 0x00, 0x08, 0x80, 0x00, 0xC8, 0x00, 0x04, 0x80, 0x00, 0x68,
  0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04,
  0x80, 0x00, 0x88, 0x00, 0x18, 0x80, 0x06, 0x0F, 0xFF, 0x80, 0xFF, 0xFE,
  0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x68, 0x00, 0x0C, 0x80, 0x01, 0x88,
  0x00, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x1C, 0x00, 0x60,
  0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0x40, 0x00, 0x42, 0x00, 0x01,
  0x88, 0x00, 0x02, 0x60, 0x00, 0x09, 0x00, 0x00, 0x34, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0x88, 0x00, 0x02, 0x30, 0x00,
  0x18, 0x40, 0x00, 0xC1, 0x80, 0x02, 0x03, 0x00, 0x10, 0x07, 0x01, 0x80,
  0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x08, 0x01, 0xC0, 0x80, 0x06, 0x08, 0x00,
  0x10, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x02, 0x80,
  0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00,
  0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x06, 0x08, 0x03, 0xC0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x07, 0xFF, 0xFC, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0x90, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x1E, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x42, 0x00, 0x01, 0x98,
  0x00, 0x02, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x34, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x07, 0xFF, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00,
  0x05, 0x00, 0x00, 0x16, 0x00, 0x00, 0x48, 0x00, 0x01, 0x30, 0x00, 0x04,
  0x40, 0x00, 0x10, 0x80, 0x00, 0xC3, 0x00, 0x06, 0x03, 0x00, 0x60, 0x07,
  0xFE, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x24,
  0x00, 0x02, 0x40, 0x00, 0x42, 0x00, 0x0C, 0x10, 0x01, 0x80, 0xC0, 0x70,
  0x07, 0xFC, 0x00, 0x80, 0x00, 0x3A, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20,
  0x00, 0x20, 0x80, 0x01, 0x02, 0x00, 0x0C, 0x08, 0x00, 0x60, 0x20, 0x03,
  0x00, 0x80, 0x18, 0x02, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x20, 0x30, 0x00,
  0x81, 0x80, 0x02, 0x0C, 0x00, 0x08, 0x20, 0x00, 0x21, 0xC0, 0x00, 0x89,
  0x80, 0x02, 0x43, 0x00, 0x0A, 0x04, 0x00, 0x30, 0x08, 0x00, 0x80, 0x30,
  0x02, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x20, 0x01, 0x00, 0x80, 0x02, 0x02,
  0x00, 0x0C, 0x08, 0x00, 0x18, 0x20, 0x00, 0x30, 0x80, 0x00, 0x42, 0x00,
  0x00, 0x88, 0x00, 0x03, 0x20, 0x00, 0x06, 0x80, 0x00, 0x0C, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x05, 0xD0,
  0x00, 0x5D, 0x00, 0x0D, 0xD8, 0x00, 0x9C, 0x80, 0x19, 0xC8, 0x01, 0x1C,
  0x40, 0x11, 0xC4, 0x02, 0x1C, 0x60, 0x21, 0xC2, 0x06, 0x1C, 0x20, 0x41,
  0xC3, 0x04, 0x1C, 0x10, 0x81, 0xC1, 0x88, 0x1C, 0x09, 0x81, 0xC0, 0x90,
  0x1C, 0x0D, 0x01, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x10,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xA0, 0x00, 0x1B, 0x00, 0x01, 0x90, 0x00,
  0x19, 0x80, 0x01, 0x88, 0x00, 0x18, 0x40, 0x01, 0x84, 0x00, 0x18, 0x20,
  0x01, 0x82, 0x00, 0x18, 0x10, 0x01, 0x81, 0x80, 0x18, 0x08, 0x01, 0x80,
  0xC0, 0x18, 0x04, 0x01, 0x80, 0x20, 0x18, 0x02, 0x01, 0x80, 0x10, 0x18,
  0x01, 0x81, 0x80, 0x08, 0x18, 0x00, 0xC1, 0x80, 0x04, 0x18, 0x00, 0x21,
  0x80, 0x02, 0x18, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00,
  0xD8, 0x00, 0x05, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00,
  0x7C, 0x00, 0x0F, 0x1C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x10, 0x18, 0x00,
  0x20, 0x40, 0x00, 0xC2, 0x00, 0x01, 0x08, 0x00, 0x06, 0x60, 0x00, 0x09,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x50, 0x00, 0x03, 0x40, 0x00, 0x09, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x88, 0x00, 0x04, 0x30, 0x00, 0x10, 0x40, 0x00, 0x81, 0x80, 0x06,
  0x03, 0x00, 0x30, 0x07, 0x01, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFC, 0x08,
  0x00, 0x70, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x02,
  0x80, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00,
  0x0C, 0x80, 0x03, 0x88, 0x01, 0xE0, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0x8E, 0x00, 0x18, 0x03, 0x00, 0x40, 0x03, 0x01, 0x00, 0x03, 0x06, 0x00,
  0x02, 0x08, 0x00, 0x06, 0x30, 0x00, 0x04, 0x40, 0x00, 0x0D, 0x80, 0x00,
  0x0A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x42, 0x00, 0x01, 0x86, 0x00, 0x02, 0x06, 0x00,
  0x08, 0x06, 0x00, 0x20, 0x07, 0x01, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0xFF, 0xFC, 0x04, 0x00, 0x30, 0x20, 0x00, 0x61, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x00, 0x90, 0x00, 0x04,
  0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x48, 0x00,
  0x06, 0x40, 0x00, 0x22, 0x00, 0x03, 0x10, 0x00, 0x30, 0x80, 0x03, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x40, 0x02,
  0x02, 0x00, 0x18, 0x10, 0x00, 0x40, 0x80, 0x03, 0x04, 0x00, 0x0C, 0x20,
  0x00, 0x21, 0x00, 0x01, 0x88, 0x00, 0x04, 0x40, 0x00, 0x32, 0x00, 0x00,
  0x90, 0x00, 0x06, 0x80, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x3E, 0x78, 0x07,
  0x00, 0x70, 0x60, 0x00, 0xC2, 0x00, 0x02, 0x20, 0x00, 0x19, 0x00, 0x00,
  0x48, 0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x00, 0x50, 0x00, 0x00, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xA0, 0x00,
  0x08, 0x80, 0x00, 0xC7, 0x00, 0x0C, 0x0E, 0x01, 0xC0, 0x1F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00,
  0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x02, 0x20, 0x00, 0x63,
  0x00, 0x0C, 0x18, 0x01, 0x80, 0xE0, 0x30, 0x03, 0xFC, 0x00, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x20, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x10, 0x00, 0x08, 0x18, 0x00,
  0x18, 0x08, 0x00, 0x10, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00,
  0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60, 0x02, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x03, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x01, 0x81,
  0x80, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0x42,
  0x00, 0x00, 0x42, 0x00, 0x00, 0x42, 0x00, 0x00, 0x64, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x08, 0x00, 0xA0, 0x06, 0x00, 0x50, 0x07, 0x00, 0x48, 0x02,
  0x80, 0x24, 0x01, 0x40, 0x12, 0x00, 0xA0, 0x09, 0x80, 0x58, 0x04, 0xC0,
  0x6C, 0x02, 0x20, 0x22, 0x03, 0x10, 0x11, 0x01, 0x08, 0x08, 0x80, 0x84,
  0x04, 0x60, 0x42, 0x06, 0x30, 0x21, 0x83, 0x08, 0x10, 0x41, 0x04, 0x18,
  0x20, 0x82, 0x08, 0x10, 0x41, 0x84, 0x08, 0x60, 0xC2, 0x04, 0x30, 0x21,
  0x03, 0x10, 0x10, 0x80, 0x88, 0x08, 0xC0, 0x44, 0x06, 0x40, 0x26, 0x03,
  0x20, 0x13, 0x00, 0x90, 0x09, 0x00, 0x48, 0x06, 0x80, 0x24, 0x01, 0x40,
  0x16, 0x00, 0xA0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x06,
  0x40, 0x00, 0x18, 0xC0, 0x00, 0x60, 0x80, 0x00, 0x81, 0x80, 0x03, 0x01,
  0x80, 0x04, 0x01, 0x00, 0x10, 0x03, 0x00, 0x60, 0x02, 0x00, 0x80, 0x02,
  0x02, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x04, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x0A, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x50,
  0x00, 0x01, 0x90, 0x00, 0x02, 0x30, 0x00, 0x08, 0x20, 0x00, 0x30, 0x60,
  0x00, 0x40, 0x40, 0x01, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x20, 0x00, 0x80, 0xC0, 0x01, 0x81, 0x00, 0x01, 0x06, 0x00, 0x03, 0x08,
  0x00, 0x03, 0x20, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x08, 0x80, 0x00, 0x31, 0x80, 0x00, 0x41, 0x00, 0x01, 0x83, 0x00,
  0x02, 0x02, 0x00, 0x0C, 0x06, 0x00, 0x10, 0x04, 0x00, 0x60, 0x0C, 0x00,
  0x80, 0x08, 0x03, 0x00, 0x18, 0x04, 0x00, 0x10, 0x10, 0x00, 0x30, 0x20,
  0x00, 0x20, 0x80, 0x00, 0x21, 0x00, 0x00, 0x44, 0x00, 0x00, 0x48, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00,
  0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x0F, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x1F, 0xE0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40,
  0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x10,
  0x18, 0x18, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x04, 0x60, 0x06,
  0x40, 0x02, 0x40, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0xC1, 0x82, 0x04,
  0x18, 0x30, 0x03, 0xFE, 0x00, 0xE0, 0x38, 0x18, 0x00, 0xC3, 0x00, 0x04,
  0x60, 0x00, 0x64, 0x00, 0x02, 0x40, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xFE, 0x07, 0xE0, 0x21, 0x80,
  0x02, 0x30, 0x00, 0x26, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x02, 0x80,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x64, 0x00, 0x0B, 0x60, 0x03, 0x33,
  0x80, 0xE3, 0x0F, 0xF8, 0x10, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x0F, 0xE0, 0x46, 0x07, 0x09, 0x80, 0x31,
  0x40, 0x03, 0x38, 0x00, 0x26, 0x00, 0x06, 0xC0, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x27, 0x00, 0x0C, 0xB0, 0x03, 0x13,
  0x80, 0xC2, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x30, 0x08, 0x01,
  0x81, 0x00, 0x04, 0x30, 0x00, 0x66, 0x00, 0x02, 0x40, 0x00, 0x34, 0x00,
  0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x01, 0x40, 0x00, 0x36, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x04,
  0x18, 0x00, 0xC0, 0xE0, 0x38, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x0F, 0xE0, 0x87, 0x03,
  0x11, 0x80, 0x12, 0x60, 0x01, 0x48, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00,
  0x28, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x02, 0xC0, 0x00, 0x48, 0x00, 0x19, 0x80, 0x07,
  0x18, 0x01, 0xA1, 0x80, 0xE4, 0x0F, 0xF0, 0x80, 0x01, 0xFE, 0x00, 0x70,
  0x30, 0x0C, 0x01, 0x81, 0x00, 0x04, 0x30, 0x00, 0x66, 0x00, 0x02, 0x40,
  0x00, 0x34, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x1C, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0x80, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x01, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF8,
  0x21, 0xC0, 0xC4, 0x60, 0x04, 0x88, 0x00, 0x52, 0x00, 0x06, 0xC0, 0x00,
  0xD0, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xB0, 0x00, 0x12, 0x00, 0x06,
  0x60, 0x01, 0xC6, 0x00, 0x68, 0x60, 0x39, 0x03, 0xFC, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x88, 0x00, 0x31,
  0x80, 0x0C, 0x18, 0x03, 0x01, 0xE1, 0xC0, 0x07, 0xE0, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x07, 0xF0,
  0x43, 0x01, 0x88, 0xC0, 0x19, 0x20, 0x01, 0x28, 0x00, 0x17, 0x00, 0x02,
  0xC0, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x07, 0xF8, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x03,
  0x40, 0x00, 0xC8, 0x00, 0x31, 0x00, 0x18, 0x20, 0x06, 0x04, 0x01, 0x80,
  0x80, 0x60, 0x10, 0x18, 0x02, 0x06, 0x00, 0x41, 0x00, 0x08, 0xC0, 0x01,
  0x3C, 0x00, 0x2C, 0xC0, 0x07, 0x0C, 0x00, 0x80, 0x80, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x18, 0x08, 0x01, 0x81, 0x00, 0x18, 0x20, 0x01, 0x84,
  0x00, 0x18, 0x80, 0x01, 0x90, 0x00, 0x1A, 0x00, 0x01, 0x80, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xF0, 0x8F, 0xC1, 0xFC, 0xB0, 0x63, 0x06, 0xA0, 0x14, 0x02, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x81, 0xFC, 0x10, 0xC0, 0x62, 0x20, 0x06,
  0x48, 0x00, 0x4A, 0x00, 0x0D, 0xC0, 0x00, 0xB0, 0x00, 0x16, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x18, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01,
  0x90, 0x00, 0x02, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00, 0x00, 0x88, 0x00, 0x04,
  0x30, 0x00, 0x30, 0x60, 0x00, 0x80, 0xC0, 0x0C, 0x01, 0xC0, 0x60, 0x01,
  0xFF, 0x00, 0x83, 0xF8, 0x11, 0x81, 0xC2, 0x60, 0x0C, 0x50, 0x00, 0xCC,
  0x00, 0x09, 0x80, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x01, 0x40,
  0x00, 0x6C, 0x00, 0x09, 0xC0, 0x03, 0x2C, 0x00, 0xC4, 0xE0, 0x30, 0x87,
  0xFC, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x21, 0xC0, 0xC4, 0x60, 0x04, 0x98, 0x00, 0x52,
  0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x05, 0x00, 0x00, 0xB0,
  0x00, 0x12, 0x00, 0x06, 0x60, 0x01, 0xC6, 0x00, 0x68, 0x60, 0x39, 0x03,
  0xFC, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x81, 0xFF, 0x87, 0x00, 0x8C, 0x00, 0x98, 0x00, 0xB0, 0x00,
  0xA0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x07, 0xFC, 0x03, 0x80, 0xE0, 0xC0, 0x06, 0x30,
  0x00, 0x24, 0x00, 0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x80, 0x00, 0xD8, 0x00, 0x31, 0xC0,
  0x1C, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x03, 0xFF, 0xFE, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x03, 0x40, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x34, 0x60, 0x39, 0x0F, 0xF8,
  0x40, 0x80, 0x00, 0x07, 0x00, 0x00, 0x34, 0x00, 0x00, 0x98, 0x00, 0x02,
  0x20, 0x00, 0x18, 0x80, 0x00, 0x43, 0x00, 0x03, 0x04, 0x00, 0x08, 0x18,
  0x00, 0x60, 0x20, 0x01, 0x00, 0xC0, 0x04, 0x01, 0x00, 0x30, 0x04, 0x00,
  0x80, 0x18, 0x06, 0x00, 0x20, 0x10, 0x00, 0xC0, 0xC0, 0x01, 0x02, 0x00,
  0x06, 0x18, 0x00, 0x08, 0x40, 0x00, 0x21, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0x20, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x80, 0x08,
  0x01, 0xC0, 0x0C, 0x00, 0xF0, 0x06, 0x00, 0x48, 0x03, 0x80, 0x24, 0x01,
  0x40, 0x12, 0x01, 0xA0, 0x19, 0x80, 0x90, 0x08, 0xC0, 0x4C, 0x04, 0x20,
  0x22, 0x02, 0x10, 0x31, 0x03, 0x08, 0x10, 0x81, 0x06, 0x08, 0x60, 0x81,
  0x04, 0x10, 0x40, 0x86, 0x08, 0x60, 0x42, 0x04, 0x30, 0x31, 0x03, 0x10,
  0x08, 0x80, 0x88, 0x04, 0xC0, 0x44, 0x02, 0x40, 0x26, 0x01, 0x20, 0x0A,
  0x00, 0xD0, 0x05, 0x00, 0x38, 0x02, 0x80, 0x18, 0x01, 0x40, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x00, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x61, 0x00,
  0x03, 0x02, 0x00, 0x08, 0x0C, 0x00, 0x40, 0x18, 0x03, 0x00, 0x30, 0x18,
  0x00, 0x40, 0xC0, 0x00, 0x82, 0x00, 0x03, 0x10, 0x00, 0x06, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xA0, 0x00, 0x04, 0xC0, 0x00, 0x31,
  0x80, 0x01, 0x83, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x08, 0x01, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x60, 0x00, 0xC3, 0x00, 0x01, 0x08, 0x00, 0x02, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x18,
  0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x04, 0x00, 0x30, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x03, 0x00, 0x40, 0x01, 0x00, 0xC0, 0x01,
  0x80, 0x80, 0x00, 0x81, 0x80, 0x00, 0xC1, 0x00, 0x00, 0x43, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x62, 0x00, 0x00, 0x26, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x9D, 0xE0,
  0x00, 0x98, 0x18, 0x00, 0x48, 0x06, 0x00, 0x28, 0x00, 0xC0, 0x34, 0x00,
  0x30, 0x32, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xE0,
};

const GFXglyph RobotoMono_Thin47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 3, 33, 28, 12, -33 },
  { 14, 8, 9, 28, 10, -35 },
  { 23, 26, 33, 28, 1, -33 },
  { 131, 21, 43, 28, 4, -38 },
  { 244, 26, 34, 28, 1, -34 },
  { 355, 23, 34, 28, 4, -34 },
  { 453, 2, 9, 28, 12, -35 },
  { 456, 10, 48, 28, 9, -37 },
  { 516, 10, 48, 28, 8, -37 },
  { 576, 20, 18, 28, 5, -33 },
  { 621, 23, 25, 28, 3, -28 },
  { 693, 3, 10, 28, 10, -4 },
  { 697, 16, 1, 28, 6, -16 },
  { 699, 2, 3, 28, 14, -3 },
  { 700, 15, 36, 28, 7, -33 },
  { 768, 20, 34, 28, 4, -34 },
  { 853, 11, 33, 28, 5, -33 },
  { 899, 20, 34, 28, 3, -34 },
  { 984, 21, 34, 28, 2, -34 },
  { 1074, 23, 33, 28, 2, -33 },
  { 1169, 20, 33, 28, 5, -33 },
  { 1252, 20, 34, 28, 4, -34 },
  { 1337, 22, 33, 28, 3, -33 },
  { 1428, 21, 34, 28, 4, -34 },
  { 1518, 20, 34, 28, 4, -34 },
  { 1603, 3, 23, 28, 15, -23 },
  { 1612, 5, 29, 28, 13, -23 },
  { 1631, 20, 19, 28, 4, -25 },
  { 1679, 20, 11, 28, 4, -21 },
  { 1707, 20, 19, 28, 4, -25 },
  { 1755, 17, 34, 28, 6, -34 },
  { 1828, 26, 34, 28, 1, -34 },
  { 1939, 23, 33, 28, 3, -33 },
  { 2034, 20, 33, 28, 5, -33 },
  { 2117, 22, 34, 28, 3, -34 },
  { 2211, 20, 33, 28, 5, -33 },
  { 2294, 19, 33, 28, 5, -33 },
  { 2373, 19, 33, 28, 5, -33 },
  { 2452, 22, 34, 28, 3, -34 },
  { 2546, 20, 33, 28, 4, -33 },
  { 2629, 18, 33, 28, 5, -33 },
  { 2704, 20, 33, 28, 3, -33 },
  { 2787, 22, 33, 28, 5, -33 },
  { 2878, 18, 33, 28, 6, -33 },
  { 2953, 20, 33, 28, 4, -33 },
  { 3036, 20, 33, 28, 4, -33 },
  { 3119, 22, 34, 28, 3, -34 },
  { 3213, 20, 33, 28, 6, -33 },
  { 3296, 23, 40, 28, 3, -34 },
  { 3411, 21, 33, 28, 5, -33 },
  { 3498, 21, 34, 28, 4, -34 },
  { 3588, 23, 33, 28, 3, -33 },
  { 3683, 20, 33, 28, 4, -33 },
  { 3766, 24, 33, 28, 2, -33 },
  { 3865, 25, 33, 28, 2, -33 },
  { 3969, 23, 33, 28, 3, -33 },
  { 4064, 23, 33, 28, 2, -33 },
  { 4159, 21, 33, 28, 3, -33 },
  { 4246, 7, 45, 28, 11, -38 },
  { 4286, 16, 36, 28, 6, -33 },
  { 4358, 7, 45, 28, 10, -38 },
  { 4398, 16, 18, 28, 6, -33 },
  { 4434, 20, 1, 28, 4, 0 },
  { 4437, 6, 6, 28, 11, -35 },
  { 4442, 20, 25, 28, 4, -25 },
  { 4505, 19, 35, 28, 5, -35 },
  { 4589, 20, 25, 28, 4, -25 },
  { 4652, 19, 35, 28, 4, -35 },
  { 4736, 20, 25, 28, 4, -25 },
  { 4799, 21, 36, 28, 5, -36 },
  { 4894, 19, 35, 28, 4, -25 },
  { 4978, 19, 35, 28, 5, -35 },
  { 5062, 20, 34, 28, 5, -34 },
  { 5147, 15, 44, 28, 4, -34 },
  { 5230, 19, 35, 28, 6, -35 },
  { 5314, 20, 35, 28, 5, -35 },
  { 5402, 24, 25, 28, 2, -25 },
  { 5477, 19, 25, 28, 5, -25 },
  { 5537, 22, 25, 28, 3, -25 },
  { 5606, 19, 35, 28, 5, -25 },
  { 5690, 19, 35, 28, 4, -25 },
  { 5774, 16, 25, 28, 9, -25 },
  { 5824, 19, 25, 28, 5, -25 },
  { 5884, 18, 32, 28, 5, -32 },
  { 5956, 18, 25, 28, 5, -25 },
  { 6013, 22, 25, 28, 3, -25 },
  { 6082, 25, 25, 28, 2, -25 },
  { 6161, 22, 25, 28, 3, -25 },
  { 6230, 24, 35, 28, 2, -25 },
  { 6335, 23, 25, 28, 3, -25 },
  { 6407, 15, 47, 28, 8, -37 },
  { 6496, 2, 39, 28, 13, -33 },
  { 6506, 15, 47, 28, 8, -37 },
  { 6595, 25, 8, 28, 2, -18 },
};

const GFXfont RobotoMono_Thin47pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin47pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOMONO_THIN47PT7B_H_
