#ifndef _ROBOTOMONO_THIN11PT7B_H_
#define _ROBOTOMONO_THIN11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF0, 0x24, 0xA7, 0xCA, 0x2B, 0xF4, 0x94, 0x22, 0xA3, 0x04,
  0x18, 0x31, 0x51, 0x00, 0xE2, 0xAA, 0x94, 0x14, 0xB5, 0x43, 0x64, 0xA8,
  0x8A, 0x4E, 0x3F, 0xC0, 0x2A, 0x49, 0x24, 0x91, 0x10, 0x95, 0x55, 0x5A,
  0x25, 0x5C, 0xA0, 0x21, 0x3E, 0x42, 0x00, 0xC0, 0xF0, 0x80, 0x24, 0xA4,
  0xA4, 0x80, 0x74, 0x67, 0x5C, 0xC6, 0x2E, 0x74, 0x92, 0x49, 0xE9, 0x11,
  0x24, 0x4F, 0xF9, 0x11, 0x71, 0x9F, 0x08, 0x62, 0x8A, 0x4B, 0xF0, 0x82,
  0xFC, 0x20, 0xE0, 0x86, 0x2E, 0x74, 0x21, 0xE8, 0xC6, 0x3E, 0xF8, 0x44,
  0x22, 0x11, 0x08, 0x74, 0x63, 0x2F, 0x46, 0x3E, 0x74, 0x63, 0x19, 0xB4,
  0x4C, 0x84, 0x86, 0x1B, 0x20, 0xE0, 0x80, 0xF8, 0x3E, 0x83, 0x06, 0xC8,
  0x00, 0x79, 0x11, 0x22, 0x02, 0x39, 0x5A, 0xEB, 0xCE, 0xDA, 0x9E, 0x23,
  0x14, 0xA9, 0x7A, 0x31, 0xF4, 0x63, 0xE8, 0xC6, 0x3E, 0x74, 0x63, 0x08,
  0x42, 0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0xFC, 0x21, 0xE8, 0x42, 0x1F,
  0xFC, 0x21, 0x0F, 0x42, 0x10, 0x74, 0x61, 0x0B, 0xC6, 0x2F, 0x8C, 0x63,
  0xF8, 0xC6, 0x31, 0xF2, 0x22, 0x22, 0x2F, 0x11, 0x11, 0x11, 0x9F, 0x8C,
  0xA9, 0x8A, 0x4A, 0x51, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x8C, 0x67, 0xBE,
  0xC6, 0x31, 0x8C, 0x73, 0x9A, 0xCE, 0x31, 0x74, 0x63, 0x18, 0xC6, 0x2E,
  0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74, 0x63, 0x18, 0xC6, 0x3E, 0x18, 0xF4,
  0x63, 0x1F, 0x4A, 0x31, 0x74, 0x60, 0x83, 0x06, 0x3F, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0x8C, 0x63, 0x25, 0x29, 0x84,
  0xAD, 0x7B, 0xBD, 0xEA, 0x52, 0x8C, 0x54, 0x42, 0x2A, 0x51, 0x85, 0x14,
  0x8A, 0x10, 0x41, 0x04, 0xF8, 0x84, 0x44, 0x22, 0x1F, 0xFF, 0xE0, 0x92,
  0x44, 0x89, 0x20, 0xD5, 0x55, 0x5C, 0x26, 0x59, 0xF8, 0x80, 0x74, 0x4F,
  0x98, 0xFC, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x74, 0x61, 0x08, 0xB8, 0x11,
  0x79, 0x99, 0x9F, 0x74, 0x7F, 0x08, 0x3C, 0x3A, 0x3C, 0x84, 0x21, 0x08,
  0x79, 0x99, 0x9F, 0x1F, 0x84, 0x3D, 0x18, 0xC6, 0x31, 0x20, 0x38, 0x42,
  0x10, 0x9F, 0x21, 0x92, 0x49, 0x3C, 0x84, 0x23, 0x6C, 0x52, 0x51, 0xE1,
  0x08, 0x42, 0x10, 0x9F, 0xFE, 0x59, 0x65, 0x96, 0x50, 0xF4, 0x63, 0x18,
  0xC4, 0x74, 0x63, 0x18, 0xF8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x79, 0x99,
  0x9F, 0x11, 0xF8, 0x88, 0x88, 0x74, 0x70, 0x60, 0xFC, 0x4F, 0x44, 0x44,
  0x30, 0x99, 0x99, 0x9F, 0x8C, 0x64, 0xA6, 0x10, 0x96, 0x57, 0x5B, 0x49,
  0x20, 0x8A, 0x98, 0xC5, 0x44, 0x85, 0x14, 0x8A, 0x28, 0x41, 0x18, 0xF8,
  0x88, 0x88, 0x7C, 0x29, 0x25, 0x12, 0x48, 0x80, 0xFF, 0x80, 0x89, 0x24,
  0x4A, 0x4B, 0x00, 0xF6, 0x20,
};

const GFXglyph RobotoMono_Thin11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 8, 7, 3, -8 },
  { 2, 2, 2, 7, 2, -8 },
  { 3, 6, 8, 7, 0, -8 },
  { 9, 5, 10, 7, 1, -9 },
  { 16, 6, 8, 7, 0, -8 },
  { 22, 5, 8, 7, 1, -8 },
  { 27, 1, 2, 7, 3, -8 },
  { 28, 3, 12, 7, 2, -9 },
  { 33, 2, 12, 7, 2, -9 },
  { 36, 5, 4, 7, 1, -8 },
  { 39, 5, 5, 7, 1, -6 },
  { 43, 1, 2, 7, 2, -1 },
  { 44, 4, 1, 7, 1, -4 },
  { 45, 1, 1, 7, 3, -1 },
  { 46, 3, 9, 7, 2, -8 },
  { 50, 5, 8, 7, 1, -8 },
  { 55, 3, 8, 7, 1, -8 },
  { 58, 4, 8, 7, 1, -8 },
  { 62, 4, 8, 7, 1, -8 },
  { 66, 6, 8, 7, 0, -8 },
  { 72, 5, 8, 7, 1, -8 },
  { 77, 5, 8, 7, 1, -8 },
  { 82, 5, 8, 7, 1, -8 },
  { 87, 5, 8, 7, 1, -8 },
  { 92, 5, 8, 7, 1, -8 },
  { 97, 1, 6, 7, 3, -6 },
  { 98, 1, 7, 7, 3, -6 },
  { 99, 5, 5, 7, 1, -6 },
  { 103, 5, 3, 7, 1, -5 },
  { 105, 5, 5, 7, 1, -6 },
  { 109, 4, 8, 7, 1, -8 },
  { 113, 6, 8, 7, 0, -8 },
  { 119, 5, 8, 7, 1, -8 },
  { 124, 5, 8, 7, 1, -8 },
  { 129, 5, 8, 7, 1, -8 },
  { 134, 5, 8, 7, 1, -8 },
  { 139, 5, 8, 7, 1, -8 },
  { 144, 5, 8, 7, 1, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 4, 8, 7, 1, -8 },
  { 163, 4, 8, 7, 1, -8 },
  { 167, 5, 8, 7, 1, -8 },
  { 172, 5, 8, 7, 1, -8 },
  { 177, 5, 8, 7, 1, -8 },
  { 182, 5, 8, 7, 1, -8 },
  { 187, 5, 8, 7, 1, -8 },
  { 192, 5, 8, 7, 1, -8 },
  { 197, 5, 9, 7, 1, -8 },
  { 203, 5, 8, 7, 1, -8 },
  { 208, 5, 8, 7, 1, -8 },
  { 213, 5, 8, 7, 1, -8 },
  { 218, 5, 8, 7, 1, -8 },
  { 223, 5, 8, 7, 1, -8 },
  { 228, 5, 8, 7, 1, -8 },
  { 233, 5, 8, 7, 1, -8 },
  { 238, 6, 8, 7, 0, -8 },
  { 244, 5, 8, 7, 1, -8 },
  { 249, 1, 11, 7, 3, -9 },
  { 251, 3, 9, 7, 2, -8 },
  { 255, 2, 11, 7, 2, -9 },
  { 258, 4, 4, 7, 1, -8 },
  { 260, 5, 1, 7, 1, 0 },
  { 261, 1, 1, 7, 3, -8 },
  { 262, 5, 6, 7, 1, -6 },
  { 266, 5, 8, 7, 1, -8 },
  { 271, 5, 6, 7, 1, -6 },
  { 275, 4, 8, 7, 1, -8 },
  { 279, 5, 6, 7, 1, -6 },
  { 283, 5, 8, 7, 1, -8 },
  { 288, 4, 8, 7, 1, -6 },
  { 292, 5, 8, 7, 1, -8 },
  { 297, 5, 8, 7, 1, -8 },
  { 302, 3, 10, 7, 1, -8 },
  { 306, 5, 8, 7, 1, -8 },
  { 311, 5, 8, 7, 1, -8 },
  { 316, 6, 6, 7, 0, -6 },
  { 321, 5, 6, 7, 1, -6 },
  { 325, 5, 6, 7, 1, -6 },
  { 329, 5, 8, 7, 1, -6 },
  { 334, 4, 8, 7, 1, -6 },
  { 338, 4, 6, 7, 2, -6 },
  { 341, 5, 6, 7, 1, -6 },
  { 345, 4, 7, 7, 1, -7 },
  { 349, 4, 6, 7, 1, -6 },
  { 352, 5, 6, 7, 1, -6 },
  { 356, 6, 6, 7, 0, -6 },
  { 361, 5, 6, 7, 1, -6 },
  { 365, 6, 8, 7, 0, -6 },
  { 371, 5, 6, 7, 1, -6 },
  { 375, 3, 11, 7, 2, -9 },
  { 380, 1, 9, 7, 3, -8 },
  { 382, 3, 11, 7, 2, -9 },
  { 387, 6, 2, 7, 0, -4 },
};

const GFXfont RobotoMono_Thin11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin11pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_THIN11PT7B_H_
