#ifndef _ROBOTOMONO_THIN62PT7B_H_
#define _ROBOTOMONO_THIN62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF7, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x03, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x04,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x20, 0x00, 0x01, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x04, 0x00, 0x00, 0x20,
  0x03, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x60, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0E,
  0x30, 0x00, 0x01, 0x88, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x30, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x38, 0x03, 0xC0, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x06, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0x40, 0x18, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x10, 0x01, 0x01, 0x80, 0x03, 0x00, 0x60, 0x30, 0x00, 0x60, 0x0C, 0x0C,
  0x00, 0x06, 0x03, 0x01, 0x00, 0x00, 0x60, 0xE0, 0x60, 0x00, 0x07, 0xF0,
  0x08, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x06, 0x03, 0xF8, 0x00, 0x01, 0x80,
  0xC1, 0x80, 0x00, 0x20, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x01,
  0x01, 0x80, 0x30, 0x00, 0x60, 0x20, 0x02, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x03, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x30, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x80, 0x18, 0x00, 0xC0, 0x30, 0x03,
  0x00, 0x18, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x80, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0x80, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x61, 0x80, 0x18, 0x00, 0xC2, 0x00, 0x18,
  0x01, 0x8C, 0x00, 0x18, 0x03, 0x10, 0x00, 0x18, 0x06, 0x60, 0x00, 0x38,
  0x18, 0xC0, 0x00, 0x30, 0x31, 0x80, 0x00, 0x30, 0x63, 0x00, 0x00, 0x31,
  0x86, 0x00, 0x00, 0x33, 0x0C, 0x00, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x78,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x01, 0xE0, 0x30, 0x00, 0x06, 0x60,
  0x70, 0x00, 0x18, 0x60, 0x70, 0x00, 0xE0, 0x60, 0x3C, 0x07, 0x80, 0xC0,
  0x1F, 0xFC, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x55, 0x55, 0xFF, 0xC0,
  0x00, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x60, 0x04, 0x01, 0xFF, 0x80, 0x80, 0xF8,
  0x3E, 0x10, 0xF8, 0x00, 0xFA, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x20, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x33, 0x33, 0x33, 0x32, 0x66, 0xCC, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0x60, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x1C, 0x80, 0x00, 0x06, 0xD0, 0x00, 0x01, 0x9E, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x18, 0x78, 0x00, 0x06, 0x0F, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x60, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x06, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x1A, 0x70, 0x00, 0x03, 0x5C, 0x00, 0x00, 0x6F, 0x00, 0x00,
  0x09, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xD8,
  0x1E, 0x30, 0xF0, 0x67, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x60, 0x01, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x84, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0xC0, 0x00, 0x70,
  0x30, 0x00, 0x07, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x20, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x30, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x18, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x18, 0x01, 0xF0, 0x1E, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x3E, 0x00, 0x08,
  0xFF, 0xF0, 0x02, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x01, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x18, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x06, 0x00, 0x38, 0x0F, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x40, 0x3F, 0x80, 0x08, 0x3F, 0xFE, 0x03, 0x0E, 0x00, 0xE0, 0x67,
  0x00, 0x06, 0x0D, 0x80, 0x00, 0x61, 0xE0, 0x00, 0x06, 0x28, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x18, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x3C, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x10, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x18, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x40,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x39, 0x00, 0x00, 0x0F, 0x30, 0x00, 0x01, 0x63, 0x00,
  0x00, 0x6C, 0x30, 0x00, 0x19, 0x87, 0x00, 0x0E, 0x20, 0x38, 0x07, 0x04,
  0x03, 0xFF, 0xC0, 0x80, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1C, 0x71,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC2,
  0x18, 0xC1, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xF0, 0x1C, 0x06,
  0x00, 0x18, 0x30, 0x00, 0x31, 0x80, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x1F, 0xC0, 0x30, 0xE0, 0x1E, 0x38, 0x06, 0x30, 0x0E,
  0x03, 0x01, 0x8C, 0x03, 0x00, 0xC0, 0x66, 0x01, 0x80, 0x30, 0x19, 0x80,
  0xC0, 0x0C, 0x02, 0x40, 0x30, 0x03, 0x00, 0x90, 0x08, 0x00, 0x80, 0x2C,
  0x06, 0x00, 0x20, 0x0B, 0x01, 0x80, 0x08, 0x02, 0xC0, 0x40, 0x02, 0x00,
  0xB0, 0x10, 0x01, 0x80, 0x28, 0x0C, 0x00, 0x60, 0x0A, 0x03, 0x00, 0x18,
  0x02, 0x80, 0xC0, 0x06, 0x00, 0xA0, 0x30, 0x01, 0x80, 0x68, 0x0C, 0x00,
  0x60, 0x1A, 0x03, 0x00, 0x30, 0x06, 0x80, 0xC0, 0x0C, 0x01, 0xA0, 0x30,
  0x03, 0x00, 0x4C, 0x04, 0x01, 0xE0, 0x33, 0x01, 0x00, 0x58, 0x0C, 0xC0,
  0x60, 0x36, 0x02, 0x30, 0x08, 0x18, 0x81, 0x86, 0x03, 0x0C, 0x30, 0xC1,
  0x80, 0x7E, 0x07, 0xE0, 0x60, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x04,
  0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x02, 0x18,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x80, 0x40, 0x00,
  0x06, 0x01, 0x80, 0x00, 0x18, 0x06, 0x00, 0x00, 0x40, 0x08, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x20, 0x01, 0x00, 0x01, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x08, 0x00, 0x04, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x02, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x46, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x08, 0x00,
  0x0F, 0x02, 0x00, 0x00, 0xE0, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x88,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0x80, 0x00, 0x03, 0x20, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20,
  0x00, 0x03, 0x08, 0x00, 0x01, 0x82, 0x00, 0x01, 0xC0, 0x80, 0x0F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x08, 0x00, 0x0F, 0x02, 0x00, 0x00, 0x70, 0x80, 0x00,
  0x06, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x0E, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x88, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x18, 0x00,
  0xE0, 0x01, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0xE0,
  0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x07, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x38, 0x0C, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x0C, 0x10, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x01, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x40, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x03, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x70, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x00,
  0x60, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x30, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x0C, 0x3C, 0x00, 0x00, 0x63, 0x70, 0x00, 0x03, 0x31, 0x80, 0x00,
  0x1B, 0x06, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x07, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x03, 0x00, 0x18, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x0D,
  0xB0, 0x00, 0x03, 0x6C, 0x00, 0x00, 0x99, 0x80, 0x00, 0x66, 0x60, 0x00,
  0x19, 0x88, 0x00, 0x0C, 0x63, 0x00, 0x03, 0x18, 0xC0, 0x01, 0x86, 0x10,
  0x00, 0x61, 0x86, 0x00, 0x10, 0x60, 0x80, 0x0C, 0x18, 0x30, 0x03, 0x06,
  0x0C, 0x01, 0x81, 0x81, 0x00, 0x60, 0x60, 0x60, 0x10, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x10, 0x60, 0x18, 0x06,
  0x10, 0x06, 0x01, 0x8C, 0x01, 0x80, 0x22, 0x00, 0x60, 0x0D, 0x80, 0x18,
  0x01, 0x60, 0x06, 0x00, 0x70, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x02, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3D,
  0x80, 0x00, 0x07, 0x90, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1E, 0x20, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x78, 0x40, 0x00, 0x0F, 0x0C, 0x00, 0x01, 0xE0,
  0xC0, 0x00, 0x3C, 0x18, 0x00, 0x07, 0x81, 0x80, 0x00, 0xF0, 0x10, 0x00,
  0x1E, 0x03, 0x00, 0x03, 0xC0, 0x20, 0x00, 0x78, 0x06, 0x00, 0x0F, 0x00,
  0x40, 0x01, 0xE0, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0x80, 0x08, 0x00,
  0xF0, 0x01, 0x80, 0x1E, 0x00, 0x10, 0x03, 0xC0, 0x03, 0x00, 0x78, 0x00,
  0x20, 0x0F, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x60, 0x3C, 0x00, 0x04, 0x07,
  0x80, 0x00, 0xC0, 0xF0, 0x00, 0x08, 0x1E, 0x00, 0x01, 0x83, 0xC0, 0x00,
  0x10, 0x78, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x06, 0x3C,
  0x00, 0x00, 0x67, 0x80, 0x00, 0x04, 0xF0, 0x00, 0x00, 0xDE, 0x00, 0x00,
  0x0B, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x38,
  0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x07, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x40, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x09, 0x00, 0x00, 0x00, 0x48, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x01, 0x88, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0x00, 0x00, 0xF0,
  0x60, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x86, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xE0, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x02, 0x00, 0x01, 0xC0,
  0x40, 0x00, 0x0C, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x19, 0x00, 0x00,
  0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x03, 0x08, 0x00, 0x00,
  0xC1, 0x00, 0x00, 0x30, 0x20, 0x00, 0x1C, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x20, 0x02, 0x00, 0x06, 0x00, 0x40, 0x00, 0x60,
  0x08, 0x00, 0x0C, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x18, 0x04, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x10, 0x10, 0x00, 0x03, 0x02, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x06, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x08, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x23,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x01, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x01, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x06, 0x08, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00,
  0x00, 0x60, 0x20, 0x00, 0x00, 0x80, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x08, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x02, 0x00, 0x00, 0x80, 0x06, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x80, 0x08, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x08, 0x00, 0x00, 0x10, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x01, 0x10, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xB0, 0x00,
  0x70, 0x00, 0x58, 0x00, 0x38, 0x00, 0x64, 0x00, 0x1C, 0x00, 0x32, 0x00,
  0x1A, 0x00, 0x19, 0x80, 0x0D, 0x00, 0x08, 0xC0, 0x06, 0xC0, 0x04, 0x60,
  0x02, 0x60, 0x02, 0x30, 0x01, 0x30, 0x01, 0x08, 0x01, 0x98, 0x01, 0x84,
  0x00, 0xC4, 0x00, 0xC3, 0x00, 0x63, 0x00, 0x61, 0x80, 0x21, 0x80, 0x20,
  0xC0, 0x10, 0xC0, 0x10, 0x60, 0x18, 0x60, 0x08, 0x10, 0x0C, 0x10, 0x0C,
  0x08, 0x06, 0x0C, 0x06, 0x04, 0x02, 0x06, 0x03, 0x03, 0x01, 0x03, 0x01,
  0x01, 0x81, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x60, 0x30,
  0x60, 0x10, 0x20, 0x18, 0x30, 0x08, 0x10, 0x0C, 0x18, 0x06, 0x18, 0x06,
  0x08, 0x03, 0x0C, 0x01, 0x04, 0x01, 0x86, 0x00, 0xC2, 0x00, 0xC3, 0x00,
  0x63, 0x00, 0x21, 0x00, 0x31, 0x80, 0x11, 0x80, 0x18, 0xC0, 0x0C, 0xC0,
  0x04, 0x40, 0x06, 0x60, 0x03, 0x20, 0x03, 0x30, 0x01, 0x90, 0x01, 0x90,
  0x00, 0xD8, 0x00, 0x58, 0x00, 0x6C, 0x00, 0x2C, 0x00, 0x16, 0x00, 0x1E,
  0x00, 0x0B, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x20, 0x00, 0x00, 0x21, 0x80, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x21, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x10, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x10, 0x0C, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x40, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x03,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x04, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x3F, 0xE0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x14, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0x80, 0x00,
  0x46, 0x00, 0x06, 0x30, 0x00, 0x20, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x10,
  0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x02, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x80, 0x03, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC1, 0x81,
  0x81, 0x83, 0x03, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0xE0, 0x01,
  0xC0, 0x60, 0x00, 0x38, 0x30, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x11, 0x00, 0x00, 0x06, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x01, 0x87, 0x80,
  0x00, 0x63, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1E, 0xC0, 0x00,
  0x0D, 0x98, 0x00, 0x06, 0x63, 0x80, 0x07, 0x18, 0x78, 0x0F, 0x03, 0x07,
  0xFF, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x03, 0xFE, 0x01, 0x07, 0x87, 0xC0, 0x8E, 0x00, 0x70, 0x4C,
  0x00, 0x1C, 0x2C, 0x00, 0x07, 0x14, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03,
  0x40, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x04, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x2C, 0x00, 0x03, 0x17, 0x00, 0x03, 0x09,
  0xC0, 0x07, 0x04, 0x3C, 0x0F, 0x02, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x38, 0x01, 0xC0, 0x18, 0x00,
  0x18, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0x4C, 0x00, 0x00,
  0x31, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x03,
  0xFF, 0x02, 0x03, 0xC3, 0xE1, 0x07, 0x00, 0x38, 0x87, 0x00, 0x06, 0x43,
  0x00, 0x01, 0xA3, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x60, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x28, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x04, 0x80, 0x00, 0x02, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0xE1, 0xC0, 0x01, 0xD0, 0x70, 0x01, 0xC8,
  0x1E, 0x07, 0x84, 0x03, 0xFF, 0x82, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x80, 0xF0, 0xF8, 0x40, 0xC0, 0x0E, 0x21, 0xC0,
  0x01, 0x90, 0xC0, 0x00, 0x68, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x05, 0x80, 0x00,
  0x02, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x34, 0x1C,
  0x00, 0x72, 0x07, 0x80, 0xE1, 0x00, 0xFF, 0xE0, 0x80, 0x06, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x30, 0x00, 0x02, 0x0C, 0x00, 0x03,
  0x03, 0x80, 0x03, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0xFF, 0x81,
  0x81, 0xE0, 0xF0, 0xC3, 0x80, 0x1C, 0x63, 0x80, 0x03, 0x33, 0x00, 0x00,
  0xD9, 0x00, 0x00, 0x6D, 0x80, 0x00, 0x17, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x06, 0x0F, 0x80, 0xFF,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1D, 0x00, 0x00, 0x18, 0x80, 0x00, 0x18, 0x40, 0x00, 0x18, 0x20, 0x00,
  0x18, 0x10, 0x00, 0x38, 0x08, 0x00, 0x38, 0x04, 0x00, 0x38, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x30, 0x00, 0x80, 0x30, 0x00, 0x40, 0x70, 0x00, 0x20,
  0x70, 0x00, 0x10, 0x70, 0x00, 0x08, 0x70, 0x00, 0x04, 0x6C, 0x00, 0x02,
  0x63, 0x00, 0x01, 0x60, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x40, 0x1C, 0x00,
  0x20, 0x07, 0x00, 0x10, 0x01, 0xC0, 0x08, 0x00, 0x60, 0x04, 0x00, 0x18,
  0x02, 0x00, 0x06, 0x01, 0x00, 0x01, 0x80, 0x80, 0x00, 0x60, 0x40, 0x00,
  0x18, 0x20, 0x00, 0x06, 0x10, 0x00, 0x01, 0x88, 0x00, 0x00, 0xE4, 0x00,
  0x00, 0x3A, 0x00, 0x00, 0x0E, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x87, 0xF8, 0x0F, 0xF0, 0x9E, 0x1C, 0x1C, 0x38, 0xB8, 0x06,
  0x70, 0x0C, 0xB0, 0x03, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x06, 0xC0, 0x03,
  0x80, 0x02, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01, 0x00, 0x03, 0x80, 0x01,
  0x00, 0x03, 0xC0, 0x3F, 0xE0, 0x60, 0x78, 0x3C, 0x30, 0xE0, 0x07, 0x18,
  0xE0, 0x00, 0xCC, 0xC0, 0x00, 0x36, 0x40, 0x00, 0x1B, 0x40, 0x00, 0x05,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x23, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x81, 0xFF, 0x80, 0x43, 0xE1, 0xE0, 0x23, 0x80, 0x1C, 0x13,
  0x00, 0x07, 0x0B, 0x00, 0x01, 0x87, 0x00, 0x00, 0x63, 0x80, 0x00, 0x19,
  0x80, 0x00, 0x0C, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x03, 0x30,
  0x00, 0x01, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC5, 0xC0, 0x00, 0xC2,
  0x70, 0x01, 0xC1, 0x0F, 0x03, 0xC0, 0x81, 0xFF, 0x80, 0x40, 0x0C, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0xF0, 0xF8, 0x41, 0xC0, 0x0E, 0x21,
  0xC0, 0x01, 0x90, 0xC0, 0x00, 0x68, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x06,
  0x60, 0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x80,
  0x00, 0x02, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x00, 0x98, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x34,
  0x1C, 0x00, 0x72, 0x07, 0x81, 0xE1, 0x00, 0xFF, 0xC0, 0x80, 0x06, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x80, 0x3F, 0xFC, 0x07, 0xC0, 0xA0, 0xE0, 0x01, 0x8C, 0x00,
  0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0xE0, 0x01, 0xE0, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x88, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x09, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0x1E, 0x01,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x0F, 0x60,
  0x00, 0x1B, 0x30, 0x00, 0x3B, 0x18, 0x00, 0x73, 0x0E, 0x03, 0xC3, 0x07,
  0xFF, 0x83, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x10, 0x18,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x08, 0x08, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xA0, 0x00, 0x60, 0x00, 0xD8, 0x00, 0x30, 0x00, 0x6C, 0x00, 0x38,
  0x00, 0x36, 0x00, 0x1E, 0x00, 0x11, 0x00, 0x0B, 0x00, 0x18, 0xC0, 0x04,
  0x80, 0x0C, 0x60, 0x06, 0x40, 0x06, 0x30, 0x03, 0x30, 0x02, 0x18, 0x01,
  0x18, 0x01, 0x04, 0x00, 0x8C, 0x01, 0x83, 0x00, 0xC2, 0x00, 0xC1, 0x80,
  0x61, 0x80, 0x60, 0xC0, 0x20, 0xC0, 0x20, 0x20, 0x10, 0x20, 0x30, 0x18,
  0x18, 0x10, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x06, 0x04, 0x06, 0x04, 0x01,
  0x02, 0x01, 0x06, 0x00, 0x83, 0x00, 0x83, 0x00, 0x61, 0x80, 0x61, 0x80,
  0x30, 0x80, 0x30, 0x80, 0x18, 0x40, 0x08, 0x40, 0x04, 0x60, 0x04, 0x60,
  0x03, 0x30, 0x03, 0x30, 0x01, 0x90, 0x01, 0x98, 0x00, 0xC8, 0x00, 0x48,
  0x00, 0x2C, 0x00, 0x24, 0x00, 0x16, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x06,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x1C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x0C, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20,
  0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x47, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x8E,
  0x1E, 0x00, 0x00, 0xCC, 0x01, 0x80, 0x00, 0x6C, 0x00, 0x70, 0x00, 0x36,
  0x00, 0x1C, 0x00, 0x32, 0x00, 0x07, 0x00, 0x1B, 0x00, 0x00, 0xC0, 0x19,
  0x80, 0x00, 0x38, 0x38, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00,
};

const GFXglyph RobotoMono_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 4, 44, 37, 16, -44 },
  { 23, 9, 13, 37, 14, -47 },
  { 38, 34, 44, 37, 2, -44 },
  { 225, 26, 56, 37, 6, -50 },
  { 407, 35, 46, 37, 1, -45 },
  { 609, 31, 46, 37, 5, -45 },
  { 788, 2, 13, 37, 16, -47 },
  { 792, 13, 63, 37, 12, -49 },
  { 895, 13, 63, 37, 11, -49 },
  { 998, 27, 24, 37, 6, -44 },
  { 1079, 30, 33, 37, 4, -37 },
  { 1203, 4, 13, 37, 13, -5 },
  { 1210, 21, 2, 37, 8, -21 },
  { 1216, 3, 3, 37, 18, -3 },
  { 1218, 20, 48, 37, 9, -44 },
  { 1338, 27, 46, 37, 5, -45 },
  { 1494, 15, 44, 37, 7, -44 },
  { 1577, 28, 45, 37, 3, -45 },
  { 1735, 27, 46, 37, 3, -45 },
  { 1891, 30, 44, 37, 3, -44 },
  { 2056, 26, 45, 37, 7, -44 },
  { 2203, 27, 46, 37, 5, -45 },
  { 2359, 28, 44, 37, 4, -44 },
  { 2513, 28, 46, 37, 5, -45 },
  { 2674, 27, 46, 37, 5, -45 },
  { 2830, 3, 30, 37, 20, -30 },
  { 2842, 6, 38, 37, 17, -30 },
  { 2871, 26, 24, 37, 5, -32 },
  { 2949, 27, 14, 37, 5, -27 },
  { 2997, 26, 24, 37, 6, -32 },
  { 3075, 22, 45, 37, 8, -45 },
  { 3199, 34, 45, 37, 2, -45 },
  { 3391, 30, 44, 37, 4, -44 },
  { 3556, 26, 44, 37, 7, -44 },
  { 3699, 29, 46, 37, 4, -45 },
  { 3866, 28, 44, 37, 6, -44 },
  { 4020, 25, 44, 37, 7, -44 },
  { 4158, 25, 44, 37, 7, -44 },
  { 4296, 29, 46, 37, 4, -45 },
  { 4463, 27, 44, 37, 5, -44 },
  { 4612, 25, 44, 37, 6, -44 },
  { 4750, 26, 45, 37, 4, -44 },
  { 4897, 29, 44, 37, 7, -44 },
  { 5057, 25, 44, 37, 7, -44 },
  { 5195, 26, 44, 37, 6, -44 },
  { 5338, 27, 44, 37, 5, -44 },
  { 5487, 29, 46, 37, 4, -45 },
  { 5654, 27, 44, 37, 7, -44 },
  { 5803, 30, 53, 37, 4, -45 },
  { 6002, 27, 44, 37, 7, -44 },
  { 6151, 28, 46, 37, 5, -45 },
  { 6312, 31, 44, 37, 3, -44 },
  { 6483, 27, 45, 37, 5, -44 },
  { 6635, 31, 44, 37, 3, -44 },
  { 6806, 33, 44, 37, 3, -44 },
  { 6988, 30, 44, 37, 4, -44 },
  { 7153, 30, 44, 37, 3, -44 },
  { 7318, 28, 44, 37, 4, -44 },
  { 7472, 9, 59, 37, 14, -50 },
  { 7539, 20, 48, 37, 9, -44 },
  { 7659, 9, 59, 37, 14, -50 },
  { 7726, 21, 24, 37, 8, -44 },
  { 7789, 25, 2, 37, 6, 0 },
  { 7796, 7, 8, 37, 15, -46 },
  { 7803, 26, 34, 37, 6, -33 },
  { 7914, 25, 48, 37, 7, -47 },
  { 8064, 26, 34, 37, 5, -33 },
  { 8175, 25, 48, 37, 5, -47 },
  { 8325, 27, 34, 37, 5, -33 },
  { 8440, 28, 47, 37, 6, -47 },
  { 8605, 25, 46, 37, 5, -33 },
  { 8749, 25, 47, 37, 6, -47 },
  { 8896, 26, 44, 37, 7, -44 },
  { 9039, 20, 57, 37, 5, -44 },
  { 9182, 25, 47, 37, 8, -47 },
  { 9329, 26, 47, 37, 7, -47 },
  { 9482, 32, 33, 37, 3, -33 },
  { 9614, 25, 33, 37, 6, -33 },
  { 9718, 29, 34, 37, 4, -33 },
  { 9842, 25, 46, 37, 7, -33 },
  { 9986, 25, 46, 37, 5, -33 },
  { 10130, 21, 33, 37, 12, -33 },
  { 10217, 26, 34, 37, 6, -33 },
  { 10328, 25, 43, 37, 6, -42 },
  { 10463, 24, 34, 37, 7, -33 },
  { 10565, 30, 33, 37, 4, -33 },
  { 10689, 33, 33, 37, 2, -33 },
  { 10826, 28, 33, 37, 5, -33 },
  { 10942, 32, 46, 37, 3, -33 },
  { 11126, 30, 33, 37, 4, -33 },
  { 11250, 20, 61, 37, 10, -48 },
  { 11403, 1, 52, 37, 18, -44 },
  { 11410, 20, 61, 37, 10, -48 },
  { 11563, 33, 10, 37, 2, -23 },
};

const GFXfont RobotoMono_Thin62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin62pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_THIN62PT7B_H_
