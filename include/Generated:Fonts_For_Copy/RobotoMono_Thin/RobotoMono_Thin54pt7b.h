#ifndef _ROBOTOMONO_THIN54PT7B_H_
#define _ROBOTOMONO_THIN54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin54pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x00, 0x2E, 0xC0, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x83, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x00, 0x30, 0x00, 0x08, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x08, 0x01, 0x80, 0x00, 0x40, 0x08, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x40, 0x00, 0x10, 0x02, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02,
  0x00, 0x40, 0x00, 0x10, 0x02, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0xFD, 0xF0, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x62, 0x00, 0x00, 0x4C, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x14, 0x00, 0x00, 0x28, 0x00, 0x00, 0xD8, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x18, 0x00, 0x18, 0x18, 0x00, 0x70, 0x1C, 0x03,
  0x80, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x10, 0x00,
  0x03, 0x00, 0x40, 0x0C, 0x0C, 0x01, 0x80, 0x20, 0x30, 0x06, 0x01, 0x80,
  0xC0, 0x18, 0x04, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x30,
  0x06, 0x04, 0x00, 0xC0, 0x10, 0x30, 0x01, 0x00, 0x40, 0x80, 0x06, 0x03,
  0x06, 0x00, 0x0C, 0x18, 0x10, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x3E, 0x02,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x7E, 0x00, 0x03, 0x03, 0x0C,
  0x00, 0x08, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x20, 0x01, 0x02, 0x00, 0xC0,
  0x0C, 0x08, 0x03, 0x00, 0x20, 0x20, 0x04, 0x01, 0x80, 0x80, 0x10, 0x04,
  0x02, 0x00, 0x40, 0x30, 0x08, 0x01, 0x01, 0x80, 0x20, 0x04, 0x04, 0x00,
  0x80, 0x30, 0x30, 0x02, 0x00, 0xC0, 0x40, 0x0C, 0x02, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x40, 0x0C, 0x00, 0x18, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x18, 0x00, 0x30, 0x02,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x83, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x02, 0x00, 0x31, 0x80, 0x60, 0x06, 0x20, 0x06, 0x00,
  0x8C, 0x00, 0x60, 0x11, 0x00, 0x06, 0x02, 0x20, 0x00, 0x60, 0xCC, 0x00,
  0x04, 0x19, 0x80, 0x00, 0xC2, 0x30, 0x00, 0x0C, 0xC6, 0x00, 0x00, 0xD0,
  0x40, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x68, 0x18, 0x00,
  0x19, 0x81, 0x80, 0x06, 0x18, 0x1C, 0x03, 0x81, 0x80, 0xFF, 0xC0, 0x18,
  0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0xC0,
  0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x10, 0x06, 0x00, 0xF8, 0x0C,
  0x0F, 0x3E, 0x18, 0x78, 0x07, 0xB7, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC0, 0xC0,
  0x01, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x33, 0x33,
  0x33, 0x26, 0x4C, 0x80, 0xFF, 0xFF, 0xE0, 0xDF, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x38, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x00, 0x03, 0x06, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x04, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x0C, 0xE0, 0x00,
  0x31, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x1C,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20,
  0x00, 0x06, 0x60, 0x00, 0x08, 0x40, 0x00, 0x30, 0xC0, 0x00, 0x40, 0xC0,
  0x01, 0x80, 0xC0, 0x06, 0x00, 0xE0, 0x38, 0x00, 0x7F, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x07, 0xC0, 0xE6, 0x1C, 0x37, 0x81, 0xF0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x0E, 0x00, 0xC0,
  0x18, 0x00, 0x60, 0x30, 0x00, 0x30, 0x20, 0x00, 0x18, 0x60, 0x00, 0x08,
  0x40, 0x00, 0x08, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x01, 0x81,
  0x00, 0x01, 0x86, 0x00, 0x01, 0x18, 0x00, 0x03, 0x20, 0x00, 0x02, 0x40,
  0x00, 0x04, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40, 0x00, 0x06, 0xC0,
  0x00, 0x08, 0x80, 0x00, 0x31, 0xC0, 0x00, 0xC1, 0xC0, 0x03, 0x00, 0xE0,
  0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x68, 0x00, 0x00, 0x19, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x30, 0x80, 0x00, 0x04,
  0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x60, 0x40, 0x00, 0x08, 0x08, 0x00,
  0x03, 0x01, 0x00, 0x00, 0xC0, 0x20, 0x00, 0x10, 0x04, 0x00, 0x06, 0x00,
  0x80, 0x01, 0x80, 0x10, 0x00, 0x20, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xFC, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x1F, 0xE0, 0x0B, 0xC1, 0xE0,
  0x38, 0x00, 0xC1, 0xC0, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60, 0x00, 0x18, 0xC0,
  0x00, 0x61, 0x80, 0x03, 0x03, 0x00, 0x18, 0x07, 0x01, 0xC0, 0x07, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0xFF,
  0x00, 0x43, 0xC1, 0xC0, 0x4E, 0x00, 0x70, 0xD8, 0x00, 0x38, 0xF0, 0x00,
  0x08, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x08, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x30, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x08, 0x18, 0x00,
  0x38, 0x0E, 0x00, 0x60, 0x03, 0xC3, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0x81,
  0xE0, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00,
  0x38, 0x0F, 0x00, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x04, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x02, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x20, 0x00,
  0x07, 0x30, 0x00, 0x0B, 0x18, 0x00, 0x1B, 0x0C, 0x00, 0x72, 0x07, 0x01,
  0xC2, 0x01, 0xFF, 0x82, 0x00, 0x3C, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x19, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x31,
  0x8C, 0x62, 0x31, 0x98, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x60, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0x80, 0x00, 0xB0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x00,
  0x60, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x04,
  0x08, 0x01, 0xE0, 0x18, 0x60, 0x1F, 0xC0, 0x61, 0x00, 0xC1, 0x80, 0x8C,
  0x06, 0x03, 0x02, 0x20, 0x30, 0x08, 0x0C, 0x80, 0x80, 0x20, 0x36, 0x06,
  0x00, 0x80, 0xD8, 0x10, 0x02, 0x03, 0x40, 0x40, 0x08, 0x0D, 0x03, 0x00,
  0x20, 0x34, 0x0C, 0x01, 0x80, 0xD0, 0x30, 0x06, 0x03, 0xC0, 0x80, 0x18,
  0x0F, 0x02, 0x00, 0x40, 0x3C, 0x08, 0x01, 0x00, 0xF0, 0x20, 0x04, 0x02,
  0xC0, 0x80, 0x30, 0x09, 0x02, 0x00, 0xC0, 0x24, 0x0C, 0x07, 0x01, 0x90,
  0x30, 0x14, 0x04, 0x60, 0x40, 0xD8, 0x31, 0x81, 0x86, 0x21, 0x82, 0x03,
  0xF0, 0xFC, 0x0C, 0x02, 0x00, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x06,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x22, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x84, 0x00,
  0x00, 0x20, 0x80, 0x00, 0x04, 0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x20,
  0x20, 0x00, 0x04, 0x06, 0x00, 0x01, 0x80, 0x40, 0x00, 0x20, 0x08, 0x00,
  0x04, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00, 0x18, 0x01,
  0x80, 0x03, 0x00, 0x20, 0x00, 0x20, 0x04, 0x00, 0x06, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x04, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0x20,
  0x00, 0x02, 0x04, 0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x84, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x01, 0x00, 0x0F, 0x02,
  0x00, 0x03, 0x04, 0x00, 0x03, 0x08, 0x00, 0x03, 0x10, 0x00, 0x02, 0x20,
  0x00, 0x06, 0x40, 0x00, 0x04, 0x80, 0x00, 0x09, 0x00, 0x00, 0x12, 0x00,
  0x00, 0x24, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x02, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x30, 0x80, 0x01, 0xC1, 0x00, 0x3E, 0x03, 0xFF, 0xFC,
  0x04, 0x00, 0x0E, 0x08, 0x00, 0x07, 0x10, 0x00, 0x03, 0x20, 0x00, 0x02,
  0x40, 0x00, 0x06, 0x80, 0x00, 0x05, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x40,
  0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x32, 0x00, 0x00, 0xC4, 0x00,
  0x07, 0x08, 0x00, 0xFC, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x07, 0x00, 0x80, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03,
  0x20, 0x00, 0x01, 0x90, 0x00, 0x00, 0x58, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x09, 0x80, 0x00, 0x0C, 0x40, 0x00, 0x04,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00, 0x03, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0xFF, 0xFE, 0x00, 0xC0, 0x07, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00,
  0x60, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x08, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xC0, 0x01,
  0x80, 0xC0, 0x1F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0x70, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00,
  0x02, 0x60, 0x00, 0x03, 0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60, 0x00,
  0x01, 0x30, 0x00, 0x01, 0x10, 0x00, 0x01, 0x18, 0x00, 0x01, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x08,
  0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01,
  0xB0, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x60, 0x00, 0x30, 0x60, 0x00, 0x60,
  0x60, 0x03, 0x80, 0x70, 0x1C, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x07, 0x40, 0x00, 0x06, 0x20, 0x00, 0x06, 0x10, 0x00, 0x06,
  0x08, 0x00, 0x06, 0x04, 0x00, 0x06, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03,
  0x00, 0x80, 0x03, 0x00, 0x40, 0x03, 0x00, 0x20, 0x03, 0x00, 0x10, 0x03,
  0x00, 0x08, 0x03, 0x00, 0x04, 0x03, 0x00, 0x02, 0x03, 0x00, 0x01, 0x03,
  0x00, 0x00, 0x83, 0x00, 0x00, 0x43, 0xC0, 0x00, 0x23, 0x20, 0x00, 0x13,
  0x18, 0x00, 0x09, 0x06, 0x00, 0x05, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01,
  0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x20, 0x00, 0xC0,
  0x10, 0x00, 0x30, 0x08, 0x00, 0x08, 0x04, 0x00, 0x06, 0x02, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x40, 0x00, 0x04, 0x20, 0x00,
  0x03, 0x10, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x80, 0x00, 0x2D, 0x00, 0x00, 0xDB, 0x00, 0x01, 0xB2, 0x00,
  0x02, 0x66, 0x00, 0x0C, 0xCC, 0x00, 0x11, 0x88, 0x00, 0x63, 0x18, 0x00,
  0x86, 0x10, 0x01, 0x0C, 0x30, 0x06, 0x18, 0x60, 0x08, 0x30, 0x40, 0x30,
  0x60, 0xC0, 0x40, 0xC0, 0x80, 0x81, 0x81, 0x03, 0x03, 0x03, 0x04, 0x06,
  0x02, 0x18, 0x0C, 0x06, 0x20, 0x18, 0x04, 0xC0, 0x30, 0x09, 0x80, 0x60,
  0x1A, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1D, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x72, 0x00, 0x00, 0xE2, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x84, 0x00, 0x07,
  0x0C, 0x00, 0x0E, 0x08, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x10, 0x00, 0x70,
  0x10, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x20, 0x03, 0x80, 0x60, 0x07, 0x00,
  0x40, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0x80, 0x38, 0x01, 0x80, 0x70, 0x01,
  0x00, 0xE0, 0x01, 0x01, 0xC0, 0x03, 0x03, 0x80, 0x02, 0x07, 0x00, 0x06,
  0x0E, 0x00, 0x04, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x08, 0x70, 0x00, 0x08,
  0xE0, 0x00, 0x19, 0xC0, 0x00, 0x13, 0x80, 0x00, 0x37, 0x00, 0x00, 0x2E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x38, 0x01, 0x80, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x40, 0x00,
  0x0C, 0x60, 0x00, 0x02, 0x20, 0x00, 0x01, 0x10, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x05, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x24, 0x00, 0x00, 0x32, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x08, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x18, 0x00, 0x06, 0x06, 0x00,
  0x02, 0x01, 0x80, 0x03, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x01, 0xE0, 0xC0,
  0x00, 0x30, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x18, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x04, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x08, 0x20, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00, 0xB0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x08, 0x00, 0x00, 0x21, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18, 0x03, 0x00, 0x06,
  0x00, 0x70, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x71, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0xFF,
  0xFE, 0x01, 0x00, 0x0F, 0x02, 0x00, 0x03, 0x04, 0x00, 0x03, 0x08, 0x00,
  0x03, 0x10, 0x00, 0x03, 0x20, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00,
  0x0D, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x14, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xD0, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x11,
  0x00, 0x00, 0x42, 0x00, 0x01, 0x04, 0x00, 0x0C, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x20, 0x01, 0x80, 0x40, 0x01, 0x00, 0x80, 0x03, 0x01, 0x00,
  0x02, 0x02, 0x00, 0x06, 0x04, 0x00, 0x06, 0x08, 0x00, 0x04, 0x10, 0x00,
  0x0C, 0x20, 0x00, 0x08, 0x40, 0x00, 0x18, 0x80, 0x00, 0x11, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x34, 0x00, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x40, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xC0, 0x0C, 0x01, 0x80,
  0x03, 0x81, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x30, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x8C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x3C, 0x03, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xB0, 0x00, 0x03, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x70,
  0x1C, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x09, 0x80, 0x00, 0x02, 0x60, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x43, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x0C, 0x10, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x20, 0x00, 0x18, 0x08,
  0x00, 0x04, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x00, 0x20,
  0x06, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x00, 0x30, 0x00, 0x40, 0x08, 0x00, 0x18, 0x06, 0x00, 0x02,
  0x01, 0x80, 0x00, 0x80, 0x40, 0x00, 0x30, 0x30, 0x00, 0x04, 0x0C, 0x00,
  0x01, 0x02, 0x00, 0x00, 0x60, 0x80, 0x00, 0x18, 0x60, 0x00, 0x02, 0x10,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x04, 0x80, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x2C, 0x00,
  0xE0, 0x02, 0xC0, 0x0E, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0x40, 0x0B, 0x00,
  0x24, 0x00, 0x90, 0x06, 0x40, 0x19, 0x00, 0x64, 0x01, 0x90, 0x04, 0x60,
  0x11, 0x80, 0x46, 0x01, 0x18, 0x04, 0x20, 0x10, 0x80, 0x42, 0x03, 0x08,
  0x0C, 0x20, 0x30, 0x80, 0xC2, 0x02, 0x0C, 0x08, 0x30, 0x20, 0xC0, 0x83,
  0x02, 0x04, 0x08, 0x10, 0x60, 0x40, 0x81, 0x06, 0x04, 0x18, 0x10, 0x40,
  0x61, 0x81, 0x04, 0x06, 0x10, 0x18, 0x40, 0x61, 0x01, 0x8C, 0x02, 0x10,
  0x08, 0xC0, 0x21, 0x00, 0x88, 0x03, 0x10, 0x08, 0x80, 0x33, 0x00, 0x88,
  0x03, 0x20, 0x0D, 0x80, 0x12, 0x00, 0xD8, 0x01, 0x20, 0x0D, 0x00, 0x1A,
  0x00, 0x50, 0x01, 0xA0, 0x05, 0x00, 0x1E, 0x00, 0x50, 0x00, 0xE0, 0x07,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x10, 0x40, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x02, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0x41, 0x80,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x01, 0x06, 0x00, 0x00, 0x60,
  0x40, 0x00, 0x18, 0x0C, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xC0, 0x08, 0x00,
  0x30, 0x01, 0x80, 0x04, 0x00, 0x18, 0x01, 0x80, 0x01, 0x00, 0x60, 0x00,
  0x30, 0x08, 0x00, 0x03, 0x03, 0x00, 0x00, 0x20, 0x40, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xC0, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x06, 0x03, 0x00, 0x00, 0x80, 0x20, 0x00,
  0x30, 0x06, 0x00, 0x04, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x0C, 0x00, 0x18, 0x01, 0x00, 0x01, 0x00, 0x60, 0x00, 0x30, 0x08,
  0x00, 0x02, 0x03, 0x00, 0x00, 0x60, 0x40, 0x00, 0x04, 0x18, 0x00, 0x00,
  0xC2, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x01, 0x90, 0x00, 0x00, 0x14, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x06, 0x80, 0x00, 0x98, 0x00, 0x13, 0x00, 0x06, 0x20, 0x00, 0x86,
  0x00, 0x30, 0x40, 0x04, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x10, 0x04, 0x03,
  0x01, 0x80, 0x20, 0x20, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x08, 0x20, 0x01,
  0x8C, 0x00, 0x11, 0x00, 0x03, 0x60, 0x00, 0x28, 0x00, 0x06, 0xFF, 0xFF,
  0xFC, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0x40, 0x00, 0xFE, 0x00, 0x0F, 0x8F,
  0x80, 0x30, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x01,
  0x10, 0x00, 0x03, 0x20, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0x81,
  0xFF, 0xFF, 0x0F, 0x00, 0x02, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x09, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01, 0xA0, 0x00,
  0x03, 0x40, 0x00, 0x0E, 0xC0, 0x00, 0x34, 0xC0, 0x00, 0xC8, 0xC0, 0x03,
  0x10, 0xE0, 0x3C, 0x20, 0xFF, 0xE0, 0x60, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x81, 0xFC, 0x02, 0x1E, 0x3C,
  0x08, 0xC0, 0x18, 0x26, 0x00, 0x30, 0xB0, 0x00, 0x63, 0x80, 0x00, 0xCC,
  0x00, 0x01, 0x30, 0x00, 0x06, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x28, 0x00,
  0x00, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x30, 0x00,
  0x0C, 0xE0, 0x00, 0x22, 0xC0, 0x01, 0x89, 0x80, 0x0C, 0x23, 0x80, 0xE0,
  0x83, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0x1E, 0x00,
  0xE0, 0x0E, 0x06, 0x00, 0x0C, 0x10, 0x00, 0x18, 0xC0, 0x00, 0x26, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x16, 0x00, 0x00, 0xC8, 0x00, 0x03,
  0x30, 0x00, 0x18, 0x60, 0x00, 0x40, 0xC0, 0x07, 0x01, 0xC0, 0x70, 0x01,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x01, 0xFC, 0x0C, 0x1F, 0x3C, 0x30, 0xC0, 0x1C, 0xC6, 0x00,
  0x1B, 0x30, 0x00, 0x3C, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D,
  0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x30, 0x00, 0x1C, 0x60,
  0x00, 0xF0, 0xC0, 0x0E, 0xC1, 0x80, 0xE3, 0x03, 0xFF, 0x0C, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xE3, 0xE0, 0x03, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00,
  0x02, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x40, 0x00, 0x01, 0x40, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x02, 0x0C, 0x00, 0x06, 0x07, 0x00, 0x0C, 0x01, 0xC0,
  0x78, 0x00, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F,
  0x0C, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x0C, 0x1F, 0x3C, 0x30, 0xC0,
  0x1C, 0xC6, 0x00, 0x1B, 0x30, 0x00, 0x3C, 0x80, 0x00, 0x76, 0x00, 0x01,
  0xD0, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0D, 0x00, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0xF0, 0xC0, 0x0E, 0xC1, 0x80, 0xE3, 0x03, 0xFF,
  0x0C, 0x00, 0x80, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60,
  0x03, 0x00, 0xE0, 0x38, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x0F, 0xE0, 0x41, 0xE1, 0xC2, 0x18,
  0x03, 0x91, 0x80, 0x0C, 0x90, 0x00, 0x35, 0x00, 0x00, 0xB8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x02,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x38, 0x00, 0x60,
  0xFF, 0xC0, 0x08, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x1A, 0x00, 0x01, 0xC8, 0x00, 0x0C, 0x20, 0x00, 0x60,
  0x80, 0x03, 0x02, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x20, 0x06, 0x00, 0x80,
  0x70, 0x02, 0x03, 0x00, 0x08, 0x18, 0x00, 0x20, 0xC0, 0x00, 0x86, 0x00,
  0x02, 0x3C, 0x00, 0x09, 0x98, 0x00, 0x38, 0x60, 0x00, 0xC0, 0xC0, 0x02,
  0x01, 0x80, 0x08, 0x03, 0x00, 0x20, 0x06, 0x00, 0x80, 0x0C, 0x02, 0x00,
  0x18, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0x80, 0x00, 0xC2, 0x00, 0x01,
  0x08, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x1C, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40,
  0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xFC, 0xC7, 0xE0, 0x1F, 0x8C, 0xE3, 0x87, 0x1C, 0xD8, 0x0C, 0xC0,
  0x6F, 0x00, 0x58, 0x02, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x01, 0xC0,
  0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00,
  0x20, 0x01, 0xC0, 0x02, 0x00, 0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00,
  0x1C, 0x00, 0x20, 0x01, 0xC0, 0x02, 0x00, 0x10, 0x80, 0xFE, 0x04, 0x1E,
  0x1C, 0x21, 0x80, 0x31, 0x38, 0x00, 0xC9, 0x00, 0x03, 0x50, 0x00, 0x0B,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x07, 0x01, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x04, 0x40, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x28, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x24, 0x00, 0x00, 0x33, 0x00, 0x00, 0x11, 0x80, 0x00,
  0x18, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x03, 0x80,
  0x0C, 0x00, 0xF0, 0x1C, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x81,
  0xFC, 0x02, 0x1E, 0x3C, 0x08, 0xC0, 0x18, 0x2C, 0x00, 0x30, 0xA0, 0x00,
  0x63, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x20, 0x00, 0x04, 0x80, 0x00, 0x1A,
  0x00, 0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68,
  0x00, 0x01, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x22, 0x80, 0x01, 0x89, 0x80,
  0x0C, 0x23, 0x80, 0xE0, 0x83, 0xFE, 0x02, 0x01, 0x80, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xFC, 0x0C, 0x1F, 0x3C, 0x30, 0xC0, 0x1C, 0xC6, 0x00, 0x1B,
  0x30, 0x00, 0x3C, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x30, 0x00, 0x1C, 0x60, 0x00,
  0xF0, 0xC0, 0x0E, 0xC1, 0x80, 0xE3, 0x03, 0xFF, 0x0C, 0x00, 0x80, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x7E, 0x1C, 0x30, 0x03, 0x38, 0x00,
  0xD8, 0x00, 0x34, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0x8F, 0xC0, 0x30, 0x01, 0xC0, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x98, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x60, 0x00, 0x04, 0x60, 0x00, 0x18,
  0x60, 0x00, 0x60, 0x70, 0x07, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x60, 0x00, 0x3B,
  0x00, 0x02, 0xCC, 0x00, 0x76, 0x38, 0x0E, 0x30, 0x7F, 0xE1, 0x80, 0x20,
  0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x36, 0x00, 0x00, 0x09, 0x80,
  0x00, 0x06, 0x20, 0x00, 0x01, 0x0C, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x08, 0x08, 0x00, 0x06, 0x03, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0xC0, 0x10, 0x00, 0x20, 0x06, 0x00, 0x18, 0x00, 0x80, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x80, 0x20, 0x00, 0x60, 0x18, 0x00,
  0x0C, 0x04, 0x00, 0x03, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0x02, 0x18, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x02, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xF0, 0x01, 0xC0, 0x04, 0x80,
  0x0A, 0x00, 0x24, 0x00, 0x50, 0x03, 0x30, 0x06, 0x80, 0x19, 0x80, 0x36,
  0x00, 0x84, 0x01, 0x30, 0x04, 0x20, 0x08, 0x80, 0x61, 0x80, 0xC4, 0x03,
  0x0C, 0x06, 0x30, 0x18, 0x20, 0x21, 0x80, 0x81, 0x01, 0x04, 0x04, 0x0C,
  0x18, 0x20, 0x60, 0x60, 0xC1, 0x83, 0x03, 0x04, 0x0C, 0x10, 0x08, 0x20,
  0x20, 0x80, 0x43, 0x01, 0x0C, 0x03, 0x18, 0x0C, 0x60, 0x18, 0x80, 0x62,
  0x00, 0x44, 0x01, 0x10, 0x02, 0x60, 0x08, 0x80, 0x1B, 0x00, 0x6C, 0x00,
  0xD0, 0x01, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x1C, 0x00, 0x50, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x01, 0xB0, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x20, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x10, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x10, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0x30, 0x08, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x41, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x00,
  0x80, 0x00, 0x80, 0x18, 0x00, 0x0C, 0x01, 0x00, 0x00, 0x40, 0x30, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x20, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x10,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x08, 0x80, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x19, 0xC3, 0x80, 0x00, 0x98, 0x07, 0x00,
  0x04, 0x80, 0x0C, 0x00, 0x6C, 0x00, 0x30, 0x02, 0x60, 0x00, 0xC0, 0x32,
  0x00, 0x03, 0x83, 0x10, 0x00, 0x07, 0xF0,
};

const GFXglyph RobotoMono_Thin54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 3, 38, 32, 14, -38 },
  { 16, 8, 11, 32, 12, -41 },
  { 27, 29, 38, 32, 2, -38 },
  { 165, 23, 49, 32, 5, -44 },
  { 306, 30, 40, 32, 1, -39 },
  { 456, 27, 40, 32, 4, -39 },
  { 591, 2, 11, 32, 14, -41 },
  { 594, 11, 55, 32, 11, -43 },
  { 670, 11, 55, 32, 10, -43 },
  { 746, 23, 21, 32, 5, -38 },
  { 807, 26, 28, 32, 3, -32 },
  { 898, 4, 11, 32, 11, -4 },
  { 904, 19, 1, 32, 7, -18 },
  { 907, 3, 3, 32, 16, -3 },
  { 909, 18, 41, 32, 8, -38 },
  { 1002, 23, 40, 32, 5, -39 },
  { 1117, 13, 38, 32, 6, -38 },
  { 1179, 24, 39, 32, 3, -39 },
  { 1296, 23, 40, 32, 3, -39 },
  { 1411, 27, 38, 32, 2, -38 },
  { 1540, 22, 39, 32, 6, -38 },
  { 1648, 24, 40, 32, 4, -39 },
  { 1768, 24, 38, 32, 4, -38 },
  { 1882, 24, 40, 32, 5, -39 },
  { 2002, 24, 40, 32, 4, -39 },
  { 2122, 3, 26, 32, 17, -26 },
  { 2132, 5, 33, 32, 15, -26 },
  { 2153, 23, 21, 32, 4, -28 },
  { 2214, 23, 13, 32, 5, -24 },
  { 2252, 23, 21, 32, 5, -28 },
  { 2313, 19, 39, 32, 7, -39 },
  { 2406, 30, 39, 32, 1, -39 },
  { 2553, 27, 38, 32, 3, -38 },
  { 2682, 23, 38, 32, 6, -38 },
  { 2792, 25, 40, 32, 4, -39 },
  { 2917, 24, 38, 32, 5, -38 },
  { 3031, 22, 38, 32, 6, -38 },
  { 3136, 22, 38, 32, 6, -38 },
  { 3241, 24, 40, 32, 4, -39 },
  { 3361, 23, 38, 32, 5, -38 },
  { 3471, 21, 38, 32, 6, -38 },
  { 3571, 23, 39, 32, 3, -38 },
  { 3684, 25, 38, 32, 6, -38 },
  { 3803, 22, 38, 32, 6, -38 },
  { 3908, 23, 38, 32, 5, -38 },
  { 4018, 23, 38, 32, 5, -38 },
  { 4128, 25, 40, 32, 4, -39 },
  { 4253, 24, 38, 32, 6, -38 },
  { 4367, 27, 46, 32, 3, -39 },
  { 4523, 23, 38, 32, 6, -38 },
  { 4633, 25, 40, 32, 4, -39 },
  { 4758, 27, 38, 32, 3, -38 },
  { 4887, 23, 39, 32, 5, -38 },
  { 5000, 26, 38, 32, 3, -38 },
  { 5124, 28, 38, 32, 3, -38 },
  { 5257, 27, 38, 32, 3, -38 },
  { 5386, 27, 38, 32, 2, -38 },
  { 5515, 23, 38, 32, 4, -38 },
  { 5625, 7, 52, 32, 13, -44 },
  { 5671, 18, 41, 32, 7, -38 },
  { 5764, 8, 52, 32, 12, -44 },
  { 5816, 19, 21, 32, 7, -38 },
  { 5866, 22, 1, 32, 5, 0 },
  { 5869, 6, 7, 32, 13, -40 },
  { 5875, 23, 30, 32, 5, -29 },
  { 5962, 22, 42, 32, 6, -41 },
  { 6078, 22, 30, 32, 5, -29 },
  { 6161, 22, 42, 32, 5, -41 },
  { 6277, 24, 30, 32, 4, -29 },
  { 6367, 23, 41, 32, 6, -41 },
  { 6485, 22, 41, 32, 5, -29 },
  { 6598, 21, 41, 32, 6, -41 },
  { 6706, 22, 39, 32, 6, -39 },
  { 6814, 16, 51, 32, 5, -39 },
  { 6916, 22, 41, 32, 7, -41 },
  { 7029, 22, 41, 32, 6, -41 },
  { 7142, 28, 29, 32, 2, -29 },
  { 7244, 21, 29, 32, 6, -29 },
  { 7321, 25, 30, 32, 4, -29 },
  { 7415, 22, 40, 32, 6, -29 },
  { 7525, 22, 40, 32, 5, -29 },
  { 7635, 18, 29, 32, 10, -29 },
  { 7701, 23, 30, 32, 5, -29 },
  { 7788, 22, 37, 32, 5, -36 },
  { 7890, 21, 30, 32, 6, -29 },
  { 7969, 26, 29, 32, 3, -29 },
  { 8064, 29, 29, 32, 2, -29 },
  { 8170, 25, 29, 32, 4, -29 },
  { 8261, 28, 41, 32, 2, -29 },
  { 8405, 25, 29, 32, 4, -29 },
  { 8496, 17, 54, 32, 9, -42 },
  { 8611, 2, 45, 32, 15, -38 },
  { 8623, 17, 54, 32, 9, -42 },
  { 8738, 29, 8, 32, 2, -20 },
};

const GFXfont RobotoMono_Thin54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin54pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_THIN54PT7B_H_
