#ifndef _ROBOTOMONO_THIN36PT7B_H_
#define _ROBOTOMONO_THIN36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x00, 0xB0, 0x8C, 0x63, 0x18, 0xC6,
  0x20, 0x00, 0x80, 0x80, 0x08, 0x10, 0x00, 0x81, 0x00, 0x08, 0x10, 0x01,
  0x01, 0x00, 0x10, 0x10, 0x01, 0x02, 0x00, 0x10, 0x20, 0x7F, 0xFF, 0xF0,
  0x10, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40,
  0x02, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00, 0x40, 0x80, 0xFF, 0xFF,
  0xC0, 0x40, 0x80, 0x04, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x81,
  0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x03, 0xE0, 0x0C, 0x18, 0x10, 0x04, 0x20, 0x06, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x01, 0x40, 0x01, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x06,
  0x18, 0x0C, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x3C, 0x00, 0x04, 0x20, 0x00, 0xC3, 0x00, 0x08, 0x10, 0x20, 0x81, 0x02,
  0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x10, 0x80, 0x81, 0x08, 0x0C, 0x31,
  0x00, 0x42, 0x10, 0x03, 0xC2, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x41, 0x00, 0x08, 0x6C, 0x01, 0x88, 0x20, 0x10, 0x82, 0x02, 0x10, 0x10,
  0x21, 0x01, 0x04, 0x10, 0x10, 0x41, 0x01, 0x08, 0x10, 0x10, 0x80, 0x82,
  0x00, 0x08, 0x20, 0x00, 0x7C, 0x07, 0x80, 0x02, 0x18, 0x01, 0x02, 0x00,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0xC0, 0x80, 0x10,
  0x40, 0x04, 0x20, 0x00, 0x90, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x04, 0x80,
  0x02, 0x10, 0x01, 0x82, 0x02, 0x40, 0x40, 0xA0, 0x18, 0x48, 0x03, 0x12,
  0x00, 0x44, 0x80, 0x0B, 0x20, 0x01, 0x8C, 0x00, 0x61, 0x00, 0x2C, 0x30,
  0x11, 0x07, 0xF8, 0x30, 0x55, 0x68, 0x01, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x40, 0x20,
  0x20, 0x10, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x80, 0x40, 0x20, 0x10, 0x18,
  0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x10, 0x20, 0xDE, 0x4E, 0x03, 0xE0, 0x03,
  0x00, 0x0D, 0x00, 0x11, 0x00, 0x41, 0x01, 0x01, 0x06, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xF0, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x24, 0x92, 0xB0, 0xFF, 0xF8, 0x70, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x07, 0xC0, 0x18, 0x30, 0x30, 0x08, 0x20, 0x04,
  0x40, 0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x06, 0x80, 0x09, 0x80, 0x11,
  0x80, 0x21, 0x80, 0x41, 0x80, 0x81, 0x81, 0x01, 0x82, 0x01, 0x84, 0x01,
  0x88, 0x01, 0x90, 0x01, 0xA0, 0x02, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x20, 0x04, 0x20, 0x0C, 0x18, 0x18, 0x0F, 0xE0, 0x00, 0x81, 0xC7, 0x2E,
  0x18, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x07, 0xC0, 0x18, 0x30, 0x20, 0x08, 0x40, 0x04, 0x40, 0x04,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x0C,
  0x60, 0x04, 0x40, 0x02, 0x80, 0x02, 0x80, 0x02, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x18, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x40, 0x02, 0x60, 0x04, 0x30, 0x08, 0x0F, 0xF0, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x04, 0x80, 0x06, 0x40, 0x02,
  0x20, 0x02, 0x10, 0x03, 0x08, 0x01, 0x04, 0x01, 0x02, 0x01, 0x81, 0x00,
  0x80, 0x80, 0x80, 0x40, 0xC0, 0x20, 0x40, 0x10, 0x40, 0x08, 0x60, 0x04,
  0x3F, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x3F, 0xFE, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x3F, 0x03, 0x81, 0x84, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0x90,
  0x01, 0x10, 0x04, 0x10, 0x18, 0x1F, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x10,
  0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01,
  0x07, 0x82, 0x70, 0xC5, 0x00, 0x4C, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x50, 0x01, 0x10, 0x06, 0x10, 0x18, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x00,
  0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x04, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x1C, 0x18, 0x30, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x60, 0x02,
  0x20, 0x04, 0x18, 0x08, 0x07, 0xF0, 0x0E, 0x70, 0x30, 0x04, 0x60, 0x02,
  0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x01, 0x60, 0x02, 0x30, 0x0C, 0x0F, 0xF0, 0x07, 0xC0, 0x18, 0x30,
  0x30, 0x08, 0x60, 0x04, 0x40, 0x04, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x40, 0x05,
  0x60, 0x06, 0x30, 0x1A, 0x18, 0x72, 0x07, 0x82, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x1F, 0x80,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x2C, 0x00, 0x00, 0x00, 0x00, 0x09, 0x29,
  0x28, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x60, 0x82, 0x01, 0x10, 0x02, 0x40, 0x0A, 0x00, 0x20, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x00, 0xFC,
  0x00, 0x38, 0x30, 0x06, 0x01, 0x80, 0x80, 0x0C, 0x10, 0x00, 0x42, 0x02,
  0x02, 0x20, 0xF8, 0x24, 0x10, 0x42, 0x42, 0x04, 0x24, 0x20, 0x41, 0x82,
  0x04, 0x18, 0x40, 0x41, 0x84, 0x04, 0x18, 0x40, 0x81, 0x84, 0x08, 0x28,
  0x40, 0x82, 0x84, 0x08, 0x28, 0x41, 0x82, 0x84, 0x18, 0x4C, 0x22, 0x44,
  0x41, 0xC3, 0x84, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x02,
  0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x80,
  0x01, 0x20, 0x00, 0x48, 0x00, 0x11, 0x00, 0x08, 0x40, 0x02, 0x10, 0x00,
  0x82, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x10, 0x02, 0x07, 0xFF, 0x81, 0x00, 0x10, 0x80, 0x04,
  0x20, 0x01, 0x08, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x60,
  0x00, 0x10, 0xFE, 0x01, 0x03, 0xC2, 0x00, 0x44, 0x00, 0x48, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x01,
  0x8F, 0xFC, 0x10, 0x0E, 0x20, 0x02, 0x40, 0x02, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x40, 0x06, 0x80,
  0x39, 0xFF, 0xC0, 0x07, 0xE0, 0x18, 0x30, 0x30, 0x0C, 0x20, 0x04, 0x40,
  0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x40, 0x02, 0x60,
  0x06, 0x20, 0x04, 0x18, 0x18, 0x0F, 0xF0, 0xFE, 0x00, 0x81, 0xC0, 0x80,
  0x30, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x04, 0x80, 0x0C, 0x80, 0x08, 0x80, 0x10, 0x80, 0x60, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF, 0xFA, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0x90, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x03, 0xF0,
  0x06, 0x06, 0x06, 0x01, 0x82, 0x00, 0x62, 0x00, 0x13, 0x00, 0x09, 0x00,
  0x02, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00,
  0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x09, 0x00, 0x04, 0xC0, 0x02, 0x20,
  0x03, 0x0C, 0x03, 0x01, 0xFE, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFC,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x10, 0x18, 0x0F, 0xE0,
  0x80, 0x03, 0x40, 0x01, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01,
  0x02, 0x01, 0x01, 0x01, 0x00, 0x81, 0x00, 0x41, 0x80, 0x21, 0x80, 0x11,
  0x80, 0x09, 0xC0, 0x05, 0xB0, 0x02, 0x88, 0x01, 0x82, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x20, 0x18, 0x10, 0x04, 0x08, 0x01, 0x04, 0x00, 0x42, 0x00,
  0x11, 0x00, 0x0C, 0x80, 0x02, 0x40, 0x00, 0xC0, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xA0, 0x05, 0xA0, 0x05, 0x90, 0x09, 0x90, 0x09, 0x90,
  0x11, 0x88, 0x11, 0x88, 0x11, 0x84, 0x21, 0x84, 0x21, 0x84, 0x41, 0x82,
  0x41, 0x82, 0x41, 0x82, 0x81, 0x81, 0x81, 0x81, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x1A, 0x00, 0x32, 0x00,
  0x62, 0x00, 0xC4, 0x01, 0x84, 0x03, 0x08, 0x06, 0x08, 0x0C, 0x10, 0x18,
  0x10, 0x30, 0x20, 0x60, 0x20, 0xC0, 0x21, 0x80, 0x43, 0x00, 0x46, 0x00,
  0x8C, 0x00, 0x98, 0x01, 0x30, 0x01, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x04, 0x03, 0xE0, 0x06, 0x0C, 0x06, 0x01, 0x02, 0x00, 0x42, 0x00,
  0x31, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x11, 0x00,
  0x08, 0xC0, 0x08, 0x20, 0x0C, 0x0C, 0x0C, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x80, 0x70, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04,
  0x80, 0x18, 0xFF, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x03, 0xF0, 0x03, 0x06, 0x01, 0x80, 0x60, 0xC0, 0x08, 0x20,
  0x01, 0x10, 0x00, 0x44, 0x00, 0x09, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x09, 0x00, 0x02, 0x40,
  0x00, 0x88, 0x00, 0x42, 0x00, 0x10, 0x40, 0x08, 0x08, 0x0C, 0x01, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08,
  0xFF, 0x00, 0x80, 0xE0, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x08, 0x80, 0x30, 0xFF, 0xC0, 0x80, 0x40, 0x80, 0x40, 0x80, 0x20,
  0x80, 0x20, 0x80, 0x10, 0x80, 0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04,
  0x80, 0x02, 0x80, 0x03, 0x07, 0xE0, 0x18, 0x18, 0x20, 0x04, 0x40, 0x02,
  0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x40, 0x01, 0x60, 0x02, 0x30, 0x0C, 0x0F, 0xF8, 0xFF, 0xFF, 0xC0, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80,
  0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x0C, 0x10, 0x18, 0x0F, 0xE0, 0x80,
  0x00, 0x60, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x18, 0x00,
  0x42, 0x00, 0x10, 0x80, 0x08, 0x20, 0x02, 0x04, 0x00, 0x81, 0x00, 0x40,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x00, 0x80, 0x80, 0x10, 0x20, 0x04,
  0x10, 0x01, 0x04, 0x00, 0x21, 0x00, 0x08, 0x80, 0x02, 0x20, 0x00, 0x48,
  0x00, 0x14, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x03, 0x01, 0x40, 0x60, 0x28, 0x0C, 0x05, 0x01, 0x40,
  0x90, 0x28, 0x12, 0x09, 0x02, 0x41, 0x20, 0x88, 0x24, 0x11, 0x04, 0x42,
  0x20, 0x88, 0x42, 0x21, 0x08, 0x44, 0x21, 0x08, 0x84, 0x41, 0x10, 0x48,
  0x22, 0x09, 0x04, 0x81, 0x20, 0x50, 0x24, 0x0A, 0x04, 0x81, 0x40, 0x60,
  0x28, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40,
  0x40, 0x00, 0x50, 0x00, 0x22, 0x00, 0x10, 0x40, 0x04, 0x10, 0x02, 0x02,
  0x01, 0x00, 0xC0, 0x40, 0x10, 0x20, 0x02, 0x18, 0x00, 0x84, 0x00, 0x12,
  0x00, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0A, 0x00, 0x04, 0x80,
  0x02, 0x10, 0x00, 0x82, 0x00, 0x40, 0x80, 0x20, 0x10, 0x08, 0x06, 0x04,
  0x00, 0x83, 0x00, 0x10, 0x80, 0x04, 0x40, 0x00, 0xB0, 0x00, 0x10, 0x80,
  0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x22, 0x00, 0x21, 0x00, 0x10,
  0x40, 0x10, 0x20, 0x08, 0x08, 0x08, 0x04, 0x04, 0x01, 0x04, 0x00, 0xC2,
  0x00, 0x22, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0xFF, 0xFE, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0xFF, 0xFC, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x0F, 0xC0, 0x04, 0x00, 0x60, 0x0A, 0x00, 0x90, 0x09, 0x01, 0x10, 0x10,
  0x82, 0x08, 0x20, 0x42, 0x04, 0x40, 0x44, 0x02, 0x80, 0x28, 0x01, 0xFF,
  0xFE, 0x8C, 0x42, 0x10, 0x0F, 0xF0, 0x10, 0x08, 0x20, 0x04, 0x40, 0x02,
  0x40, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFE, 0x1F, 0x02,
  0x30, 0x02, 0x40, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06,
  0x40, 0x0A, 0x20, 0x32, 0x1F, 0xC3, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x8F, 0xC1, 0x60,
  0x63, 0x80, 0x66, 0x00, 0x48, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x40, 0x02,
  0x80, 0x05, 0x00, 0x06, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xA0,
  0x01, 0x40, 0x04, 0xC0, 0x19, 0x60, 0x62, 0x3F, 0x00, 0x0F, 0xF0, 0x30,
  0x30, 0x80, 0x13, 0x00, 0x34, 0x00, 0x28, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x08, 0x00, 0x50,
  0x00, 0x90, 0x01, 0x20, 0x04, 0x30, 0x10, 0x3F, 0xC0, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x0F, 0xE2, 0x20, 0x24, 0x80, 0x2A, 0x00, 0x34, 0x00, 0x68, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x03, 0x20, 0x0A, 0x20, 0x34, 0x3F, 0x88,
  0x07, 0xF0, 0x18, 0x18, 0x20, 0x04, 0x60, 0x02, 0x40, 0x02, 0x40, 0x02,
  0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x02, 0x18, 0x0C,
  0x07, 0xF0, 0x00, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xFC, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0F, 0xE2, 0x20, 0x24,
  0x80, 0x2A, 0x00, 0x34, 0x00, 0x68, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00, 0x50, 0x00,
  0xB0, 0x03, 0x20, 0x0E, 0x20, 0x34, 0x3F, 0x88, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x80, 0x01, 0x30, 0x04, 0x30, 0x18, 0x38, 0xE0, 0x0E, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x8F, 0xE2, 0x60, 0x6A, 0x00, 0xB0, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x30, 0x04, 0x07, 0x1F, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x01, 0x80, 0x0A, 0x00, 0xC8, 0x06, 0x20, 0x20, 0x81, 0x02, 0x08, 0x08,
  0x40, 0x26, 0x00, 0xB8, 0x03, 0xB0, 0x08, 0x40, 0x20, 0x80, 0x81, 0x02,
  0x02, 0x08, 0x04, 0x20, 0x08, 0x80, 0x12, 0x00, 0x68, 0x00, 0xC0, 0xFF,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x03,
  0xFF, 0xF8, 0xBF, 0x1F, 0xB0, 0x68, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20,
  0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06,
  0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x04, 0x8F, 0xE2, 0x40,
  0x4A, 0x00, 0xB0, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x07, 0xF0, 0x04, 0x06, 0x04,
  0x00, 0x84, 0x00, 0x66, 0x00, 0x12, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00,
  0x0D, 0x80, 0x04, 0x40, 0x06, 0x10, 0x02, 0x04, 0x06, 0x01, 0xFC, 0x00,
  0x8F, 0xC2, 0xC0, 0xCC, 0x01, 0xB0, 0x02, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x02, 0xC0, 0x1A, 0xC0, 0xC9, 0xFC, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xE2,
  0x20, 0x24, 0x80, 0x2A, 0x00, 0x34, 0x00, 0x68, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xA0, 0x03, 0x20, 0x0E, 0x20, 0x34, 0x3F, 0x88, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x87,
  0xF9, 0x80, 0xA0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x40, 0x31, 0x00, 0x34, 0x00, 0x28,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x40, 0x00, 0x60, 0x00, 0xC0, 0x02, 0xC0, 0x04,
  0xC0, 0x30, 0x7F, 0xC0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x1F, 0xFF, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x7F, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x40, 0x14, 0x80, 0xD1, 0xFC, 0x40, 0x80,
  0x00, 0xA0, 0x00, 0x50, 0x00, 0x44, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10,
  0x40, 0x08, 0x20, 0x08, 0x08, 0x04, 0x04, 0x04, 0x01, 0x02, 0x00, 0x82,
  0x00, 0x61, 0x00, 0x10, 0x80, 0x08, 0x80, 0x02, 0x40, 0x01, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x80, 0x60, 0x34, 0x06, 0x02, 0x40, 0x60, 0x24,
  0x06, 0x02, 0x40, 0x90, 0x22, 0x09, 0x04, 0x20, 0x90, 0x42, 0x09, 0x04,
  0x21, 0x08, 0x41, 0x10, 0x88, 0x11, 0x08, 0x81, 0x10, 0x88, 0x12, 0x04,
  0x81, 0x20, 0x50, 0x0A, 0x05, 0x00, 0xA0, 0x50, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x02, 0x00, 0xC0, 0x03, 0x60, 0x02, 0x20, 0x04, 0x10, 0x08,
  0x08, 0x10, 0x0C, 0x30, 0x06, 0x20, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x03, 0xC0, 0x02, 0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x08, 0x30, 0x0C,
  0x20, 0x04, 0x40, 0x02, 0x80, 0x01, 0xC0, 0x00, 0x28, 0x00, 0x08, 0x80,
  0x01, 0x10, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x02, 0x00, 0x40, 0x40,
  0x08, 0x0C, 0x02, 0x00, 0x80, 0x40, 0x18, 0x10, 0x01, 0x02, 0x00, 0x30,
  0x80, 0x02, 0x10, 0x00, 0x46, 0x00, 0x04, 0x80, 0x00, 0xB0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x20, 0x18, 0x04, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x1C, 0x03, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x10, 0x01, 0x80,
  0x0C, 0x03, 0x80, 0x80, 0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x00, 0x0C, 0x00, 0x06, 0x60, 0x05, 0x03, 0x00, 0xA0, 0x30, 0x18,
  0x03, 0x05, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoMono_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 2, 26, 22, 10, -26 },
  { 8, 5, 7, 22, 8, -27 },
  { 13, 20, 26, 22, 1, -26 },
  { 78, 16, 33, 22, 3, -29 },
  { 144, 20, 26, 22, 1, -26 },
  { 209, 18, 26, 22, 3, -26 },
  { 268, 2, 7, 22, 9, -27 },
  { 270, 8, 37, 22, 7, -29 },
  { 307, 8, 37, 22, 6, -29 },
  { 344, 15, 14, 22, 4, -26 },
  { 371, 18, 18, 22, 2, -21 },
  { 412, 3, 7, 22, 7, -3 },
  { 415, 13, 1, 22, 4, -12 },
  { 417, 2, 2, 22, 10, -2 },
  { 418, 12, 28, 22, 5, -26 },
  { 460, 16, 26, 22, 3, -26 },
  { 512, 9, 26, 22, 4, -26 },
  { 542, 16, 26, 22, 2, -26 },
  { 594, 16, 26, 22, 2, -26 },
  { 646, 17, 26, 22, 2, -26 },
  { 702, 15, 26, 22, 4, -26 },
  { 751, 15, 26, 22, 3, -26 },
  { 800, 17, 26, 22, 2, -26 },
  { 856, 16, 26, 22, 3, -26 },
  { 908, 16, 26, 22, 3, -26 },
  { 960, 2, 17, 22, 11, -17 },
  { 965, 3, 21, 22, 10, -17 },
  { 973, 15, 14, 22, 3, -19 },
  { 1000, 16, 8, 22, 3, -16 },
  { 1016, 16, 14, 22, 3, -19 },
  { 1044, 14, 26, 22, 4, -26 },
  { 1090, 20, 26, 22, 1, -26 },
  { 1155, 18, 26, 22, 2, -26 },
  { 1214, 15, 26, 22, 4, -26 },
  { 1263, 16, 26, 22, 3, -26 },
  { 1315, 16, 26, 22, 4, -26 },
  { 1367, 14, 26, 22, 4, -26 },
  { 1413, 15, 26, 22, 4, -26 },
  { 1462, 17, 26, 22, 2, -26 },
  { 1518, 16, 26, 22, 3, -26 },
  { 1570, 14, 26, 22, 4, -26 },
  { 1616, 16, 26, 22, 2, -26 },
  { 1668, 17, 26, 22, 4, -26 },
  { 1724, 15, 26, 22, 4, -26 },
  { 1773, 16, 26, 22, 3, -26 },
  { 1825, 15, 26, 22, 3, -26 },
  { 1874, 17, 26, 22, 2, -26 },
  { 1930, 16, 26, 22, 4, -26 },
  { 1982, 18, 31, 22, 2, -26 },
  { 2052, 16, 26, 22, 4, -26 },
  { 2104, 16, 26, 22, 3, -26 },
  { 2156, 18, 26, 22, 2, -26 },
  { 2215, 16, 26, 22, 3, -26 },
  { 2267, 18, 26, 22, 2, -26 },
  { 2326, 19, 26, 22, 2, -26 },
  { 2388, 18, 26, 22, 2, -26 },
  { 2447, 17, 26, 22, 2, -26 },
  { 2503, 15, 26, 22, 3, -26 },
  { 2552, 6, 34, 22, 8, -29 },
  { 2578, 12, 28, 22, 5, -26 },
  { 2620, 5, 34, 22, 8, -29 },
  { 2642, 12, 14, 22, 5, -26 },
  { 2663, 15, 1, 22, 3, 0 },
  { 2665, 4, 5, 22, 9, -27 },
  { 2668, 16, 19, 22, 3, -19 },
  { 2706, 15, 27, 22, 4, -27 },
  { 2757, 15, 19, 22, 3, -19 },
  { 2793, 15, 27, 22, 3, -27 },
  { 2844, 16, 19, 22, 3, -19 },
  { 2882, 16, 27, 22, 4, -27 },
  { 2936, 15, 27, 22, 3, -19 },
  { 2987, 14, 27, 22, 4, -27 },
  { 3035, 15, 26, 22, 4, -26 },
  { 3084, 11, 34, 22, 3, -26 },
  { 3131, 14, 27, 22, 5, -27 },
  { 3179, 15, 27, 22, 4, -27 },
  { 3230, 18, 19, 22, 2, -19 },
  { 3273, 14, 19, 22, 4, -19 },
  { 3307, 17, 19, 22, 2, -19 },
  { 3348, 14, 26, 22, 4, -19 },
  { 3394, 15, 26, 22, 3, -19 },
  { 3443, 12, 19, 22, 7, -19 },
  { 3472, 15, 19, 22, 4, -19 },
  { 3508, 15, 24, 22, 3, -24 },
  { 3553, 14, 19, 22, 4, -19 },
  { 3587, 17, 19, 22, 2, -19 },
  { 3628, 20, 19, 22, 1, -19 },
  { 3676, 16, 19, 22, 3, -19 },
  { 3714, 19, 27, 22, 1, -19 },
  { 3779, 18, 19, 22, 2, -19 },
  { 3822, 11, 36, 22, 6, -28 },
  { 3872, 1, 31, 22, 10, -26 },
  { 3876, 11, 36, 22, 6, -28 },
  { 3926, 19, 6, 22, 1, -14 },
};

const GFXfont RobotoMono_Thin36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin36pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_THIN36PT7B_H_
