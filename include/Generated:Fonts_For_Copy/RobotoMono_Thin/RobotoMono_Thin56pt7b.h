#ifndef _ROBOTOMONO_THIN56PT7B_H_
#define _ROBOTOMONO_THIN56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C,
  0x00, 0x00, 0x00, 0xBF, 0xC1, 0xE0, 0xD0, 0x68, 0x34, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x02,
  0x00, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x10, 0x00, 0x04, 0x00, 0xC0, 0x00,
  0x10, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00,
  0x60, 0x00, 0x08, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x10,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00,
  0x03, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x08, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0xC0, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x00,
  0x08, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0xE0, 0x06, 0x00, 0x38, 0x0C,
  0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x06, 0x20,
  0x00, 0x02, 0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x03, 0x20, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x07, 0x80, 0x70, 0x01,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x04,
  0x01, 0x80, 0x10, 0x18, 0x03, 0x00, 0x30, 0x30, 0x02, 0x00, 0xC0, 0x60,
  0x04, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x01, 0x80, 0x10, 0x08, 0x03, 0x00,
  0x20, 0x30, 0x06, 0x00, 0x40, 0x40, 0x04, 0x01, 0x81, 0x80, 0x08, 0x03,
  0x02, 0x00, 0x18, 0x04, 0x0C, 0x00, 0x18, 0x18, 0x30, 0x00, 0x1C, 0xE0,
  0x60, 0x00, 0x1F, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0xF8, 0x00, 0x03, 0x03, 0xFC, 0x00, 0x04, 0x0C, 0x18, 0x00, 0x18, 0x30,
  0x18, 0x00, 0x60, 0x40, 0x18, 0x00, 0xC0, 0x80, 0x30, 0x03, 0x03, 0x00,
  0x20, 0x04, 0x06, 0x00, 0x40, 0x18, 0x0C, 0x00, 0x80, 0x20, 0x18, 0x01,
  0x00, 0xC0, 0x30, 0x02, 0x01, 0x00, 0x60, 0x04, 0x06, 0x00, 0xC0, 0x08,
  0x18, 0x00, 0x80, 0x30, 0x00, 0x01, 0x80, 0x40, 0x00, 0x01, 0x01, 0x80,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x04, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x40, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x06, 0x30,
  0x02, 0x00, 0x62, 0x00, 0x30, 0x06, 0x60, 0x01, 0x80, 0x44, 0x00, 0x0C,
  0x0C, 0x40, 0x00, 0x60, 0xC4, 0x00, 0x03, 0x0C, 0xC0, 0x00, 0x31, 0x84,
  0x00, 0x01, 0x98, 0x40, 0x00, 0x0F, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x07, 0x03, 0x00, 0x00, 0xD0, 0x38, 0x00, 0x19, 0x81, 0xC0, 0x03, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x3F, 0xF8, 0x03, 0x00, 0x10, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x03, 0x00, 0x10, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x80, 0x18, 0x02, 0xF0, 0x18, 0x1F, 0x3E, 0x10, 0xF8, 0x07,
  0xD3, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x46, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x06,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x08, 0x00, 0x10, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x11, 0x11, 0x11, 0x33, 0x66, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x60, 0x1C, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x33, 0x80, 0x00, 0x63, 0x80, 0x00,
  0xC1, 0x80, 0x01, 0x81, 0x80, 0x03, 0x01, 0x80, 0x06, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x01, 0x80, 0x60, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x86, 0x00, 0x03, 0x8C, 0x00,
  0x03, 0xD8, 0x00, 0x03, 0xF0, 0x00, 0x02, 0x60, 0x00, 0x02, 0x40, 0x00,
  0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x10, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3A, 0x07, 0x11, 0xE0,
  0xBC, 0x07, 0x80, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x01, 0xFF, 0x00,
  0x03, 0xC1, 0xE0, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x03, 0x00, 0x01,
  0x81, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0x81, 0xE0, 0x0E, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x30,
  0x00, 0x06, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x07, 0x80, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x10, 0x80, 0x00, 0x06, 0x10, 0x00,
  0x01, 0x82, 0x00, 0x00, 0x20, 0x40, 0x00, 0x0C, 0x08, 0x00, 0x03, 0x01,
  0x00, 0x00, 0x40, 0x20, 0x00, 0x18, 0x04, 0x00, 0x06, 0x00, 0x80, 0x00,
  0x80, 0x10, 0x00, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0x04, 0x00, 0xC0,
  0x00, 0x80, 0x30, 0x00, 0x10, 0x0C, 0x00, 0x02, 0x01, 0x80, 0x00, 0x40,
  0x60, 0x00, 0x08, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x7F, 0x00, 0x27, 0xEF, 0xC0, 0x78, 0x01, 0xC0,
  0xC0, 0x00, 0xC1, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xA0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x08, 0x80, 0x00,
  0x31, 0x80, 0x00, 0x41, 0x80, 0x01, 0x81, 0x80, 0x06, 0x01, 0xC0, 0x38,
  0x00, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x81, 0xFE, 0x00, 0x87, 0xC3, 0xC0, 0x47, 0x00, 0x30, 0x26,
  0x00, 0x0C, 0x36, 0x00, 0x03, 0x1E, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0x60, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x09, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0xC0,
  0x01, 0x80, 0x30, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xE0, 0xF0, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x03, 0x81, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x08, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x90, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x20, 0x00, 0x08, 0x18, 0x00,
  0x0C, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x70, 0x01, 0xC0, 0x60, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x60,
  0x00, 0x03, 0x20, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x43, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0xF0, 0x01,
  0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20,
  0xC0, 0x00, 0x18, 0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x06, 0x80, 0x00, 0x03, 0x40, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x2C, 0x60, 0x00, 0x36, 0x18, 0x00, 0x33, 0x06, 0x00, 0x71, 0x01,
  0xE1, 0xE0, 0x80, 0x3F, 0xC0, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x31, 0x88, 0x42, 0x11, 0x88, 0xC4, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0xF0, 0x70, 0x18, 0x01, 0xC3, 0x00, 0x04,
  0x60, 0x00, 0x64, 0x00, 0x02, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x01, 0xF0, 0x0C, 0x30, 0x0F, 0xF0, 0x18, 0x40, 0x30, 0x30,
  0x11, 0x80, 0xC0, 0x20, 0x33, 0x01, 0x00, 0x40, 0x64, 0x06, 0x00, 0x80,
  0xD8, 0x08, 0x01, 0x01, 0xB0, 0x30, 0x02, 0x03, 0x40, 0x60, 0x0C, 0x02,
  0x80, 0x80, 0x18, 0x05, 0x01, 0x00, 0x30, 0x0A, 0x06, 0x00, 0x60, 0x14,
  0x0C, 0x00, 0x80, 0x78, 0x18, 0x01, 0x00, 0xF0, 0x30, 0x02, 0x01, 0xE0,
  0x60, 0x0C, 0x03, 0x40, 0xC0, 0x18, 0x04, 0x81, 0x80, 0x30, 0x09, 0x01,
  0x00, 0xE0, 0x32, 0x02, 0x01, 0x40, 0x66, 0x04, 0x06, 0x80, 0x8C, 0x0C,
  0x19, 0x83, 0x18, 0x0C, 0x61, 0x8C, 0x10, 0x0F, 0x81, 0xF0, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x03, 0x04, 0x00, 0x00, 0x30, 0x40, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x60, 0x20, 0x00, 0x06, 0x02, 0x00, 0x00, 0x40, 0x30, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0xC0, 0x10, 0x00, 0x08, 0x01, 0x80, 0x01, 0x80, 0x08, 0x00,
  0x18, 0x00, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x60, 0x06, 0x00, 0x02, 0x00, 0x60, 0x00, 0x20,
  0x04, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x01, 0x00, 0x80,
  0x00, 0x18, 0x18, 0x00, 0x01, 0x81, 0x80, 0x00, 0x08, 0x10, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x42, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x01, 0xC0, 0x80, 0x00,
  0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00,
  0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x08, 0x80, 0x00,
  0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0xE0, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0x00, 0x80, 0x03, 0xE0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x70, 0x80, 0x0F, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x04, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x20, 0x00, 0x01,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x0C, 0x01, 0xC0, 0x06, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x30, 0x00, 0x70,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x04, 0xC0, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x06, 0x00,
  0x0E, 0x03, 0x00, 0x7E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x88, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x8C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x30, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0x80, 0x00, 0x06,
  0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x81, 0xC0,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x07, 0x80, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0C,
  0x0C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x1B, 0x00, 0x00, 0xCC, 0x60,
  0x00, 0x36, 0x18, 0x00, 0x0F, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0xC0,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x05, 0xF0, 0x00, 0x0D, 0xD0, 0x00, 0x09, 0xD8,
  0x00, 0x19, 0xD8, 0x00, 0x19, 0xC8, 0x00, 0x11, 0xCC, 0x00, 0x31, 0xC4,
  0x00, 0x21, 0xC6, 0x00, 0x61, 0xC6, 0x00, 0x61, 0xC2, 0x00, 0x41, 0xC3,
  0x00, 0xC1, 0xC1, 0x00, 0x81, 0xC1, 0x01, 0x81, 0xC1, 0x81, 0x01, 0xC0,
  0x83, 0x01, 0xC0, 0xC3, 0x01, 0xC0, 0xC2, 0x01, 0xC0, 0x46, 0x01, 0xC0,
  0x64, 0x01, 0xC0, 0x2C, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x18, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xA0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x90, 0x00, 0x03, 0x98,
  0x00, 0x03, 0x88, 0x00, 0x03, 0x84, 0x00, 0x03, 0x86, 0x00, 0x03, 0x82,
  0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x00, 0x03, 0x81, 0x80, 0x03, 0x80,
  0x80, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x20, 0x03, 0x80,
  0x30, 0x03, 0x80, 0x10, 0x03, 0x80, 0x18, 0x03, 0x80, 0x08, 0x03, 0x80,
  0x0C, 0x03, 0x80, 0x06, 0x03, 0x80, 0x02, 0x03, 0x80, 0x03, 0x03, 0x80,
  0x01, 0x03, 0x80, 0x01, 0x83, 0x80, 0x00, 0x83, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0x43, 0x80, 0x00, 0x23, 0x80, 0x00, 0x33, 0x80, 0x00, 0x13, 0x80,
  0x00, 0x1B, 0x80, 0x00, 0x0B, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0xFF, 0x80, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x18, 0x00,
  0x00, 0x44, 0x00, 0x00, 0x19, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x90, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x04, 0x20, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x81, 0x80, 0x00, 0x60, 0x60,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0xE0, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00,
  0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x70, 0x80, 0x03,
  0xC0, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x10, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x30,
  0x00, 0x00, 0xC2, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x64, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x02, 0x40, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x42, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xC0, 0x78, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x01,
  0xC0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xC0, 0x00,
  0x18, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xC0, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01,
  0x80, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0, 0x00,
  0x20, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x10, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x60,
  0x01, 0xC0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC2,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x33, 0x00, 0x00, 0x08, 0xC0, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x05,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x01, 0x88, 0x00, 0x00, 0x21, 0x80, 0x00, 0x04, 0x10, 0x00, 0x01, 0x82,
  0x00, 0x00, 0x20, 0x60, 0x00, 0x04, 0x04, 0x00, 0x01, 0x80, 0x80, 0x00,
  0x20, 0x18, 0x00, 0x04, 0x01, 0x00, 0x01, 0x80, 0x20, 0x00, 0x20, 0x06,
  0x00, 0x04, 0x00, 0x40, 0x01, 0x80, 0x08, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x02, 0x00, 0x30, 0x00, 0x60, 0x04, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0x80, 0x30, 0x00, 0x18, 0x04, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x20, 0x30, 0x00, 0x06, 0x04, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08,
  0x30, 0x00, 0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x30, 0x00,
  0x00, 0x64, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0x60, 0x02, 0x80, 0x09, 0x00, 0x34, 0x00, 0x48, 0x01, 0xB0,
  0x02, 0x40, 0x0D, 0x80, 0x33, 0x00, 0x4C, 0x01, 0x98, 0x02, 0x20, 0x08,
  0xC0, 0x31, 0x00, 0x42, 0x01, 0x8C, 0x02, 0x10, 0x0C, 0x60, 0x10, 0x80,
  0x43, 0x01, 0x86, 0x02, 0x08, 0x0C, 0x30, 0x30, 0x40, 0x41, 0x81, 0x83,
  0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x02, 0x04,
  0x08, 0x30, 0x10, 0x60, 0x61, 0x80, 0xC3, 0x03, 0x0C, 0x06, 0x10, 0x08,
  0x40, 0x30, 0x80, 0x42, 0x00, 0x84, 0x02, 0x30, 0x04, 0x20, 0x11, 0x80,
  0x33, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x40, 0x0C, 0x80, 0x32, 0x00, 0x24,
  0x00, 0xB0, 0x01, 0x20, 0x05, 0x80, 0x09, 0x00, 0x2C, 0x00, 0x78, 0x01,
  0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x40, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x20, 0x00,
  0x60, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x80, 0x18, 0x00,
  0x0C, 0x01, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x09, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30, 0x40,
  0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x01, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x06, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x08, 0x10, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x08, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x10, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x20, 0x03, 0x00, 0x06, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x0C, 0x00, 0x08, 0x00, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x04, 0x01,
  0x00, 0x00, 0x60, 0x30, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x01, 0x0C, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0xFF, 0xFF, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFF, 0xFE, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0B, 0x00, 0x01, 0x90, 0x00,
  0x11, 0x80, 0x03, 0x08, 0x00, 0x30, 0xC0, 0x02, 0x0C, 0x00, 0x60, 0x40,
  0x04, 0x06, 0x00, 0xC0, 0x20, 0x0C, 0x03, 0x00, 0x80, 0x30, 0x18, 0x01,
  0x01, 0x00, 0x18, 0x30, 0x00, 0x83, 0x00, 0x0C, 0x20, 0x00, 0xC6, 0x00,
  0x06, 0x40, 0x00, 0x6C, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xE0, 0x60, 0x40,
  0xC0, 0xC0, 0x81, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xE7, 0xE0, 0x0E, 0x00,
  0x70, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x06, 0x40, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0xFE, 0x0F, 0x80, 0x06, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0x40, 0x00, 0x1E, 0x60, 0x00,
  0x32, 0x30, 0x00, 0xE2, 0x1C, 0x03, 0x83, 0x07, 0xFE, 0x03, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x0F, 0xE0, 0x18, 0xF8, 0xF0, 0x33, 0x80, 0x30, 0x6C, 0x00, 0x30, 0xF0,
  0x00, 0x31, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x05,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x4C, 0x00, 0x01, 0x9C,
  0x00, 0x06, 0x3C, 0x00, 0x0C, 0x6C, 0x00, 0x70, 0xCF, 0x01, 0xC1, 0x87,
  0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xC7, 0x80, 0x18,
  0x01, 0xC0, 0x60, 0x00, 0xC1, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x88, 0x00,
  0x01, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0,
  0x00, 0x03, 0x30, 0x00, 0x04, 0x20, 0x00, 0x18, 0x60, 0x00, 0x60, 0x70,
  0x01, 0x80, 0x38, 0x0E, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0xFE, 0x04, 0x0F,
  0x3E, 0x10, 0xE0, 0x0C, 0x46, 0x00, 0x0D, 0x10, 0x00, 0x14, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x01, 0x40, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x16, 0x00, 0x00, 0x58,
  0x00, 0x01, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x71, 0x80, 0x03, 0x43, 0x00,
  0x19, 0x07, 0x01, 0xC4, 0x07, 0xFC, 0x10, 0x01, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x0C, 0x60, 0x00, 0x02, 0x20,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x68, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x0B, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x81, 0x80, 0x00, 0xC0, 0x60,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x5C, 0x00, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x06, 0x07,
  0x8F, 0x0C, 0x38, 0x03, 0x98, 0xE0, 0x01, 0xB1, 0x80, 0x01, 0x66, 0x00,
  0x03, 0xC8, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x06, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x60,
  0x00, 0xD8, 0x60, 0x03, 0x30, 0x70, 0x1C, 0x60, 0x3F, 0xE0, 0xC0, 0x04,
  0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x42, 0x00, 0x01, 0x86, 0x00, 0x06, 0x06, 0x00, 0x18,
  0x07, 0x00, 0x60, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x7F, 0x02, 0x0F, 0x8F, 0x08,
  0x70, 0x06, 0x23, 0x00, 0x0C, 0x98, 0x00, 0x1A, 0xC0, 0x00, 0x2A, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x30, 0x00, 0x18, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80,
  0x06, 0x03, 0x00, 0x18, 0x06, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x18, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00,
  0x03, 0x76, 0x00, 0x07, 0x86, 0x00, 0x0E, 0x0E, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x0C, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xF0, 0xC7, 0xF0, 0x1F, 0xC6, 0x71,
  0xC1, 0xC7, 0x36, 0x03, 0x30, 0x0D, 0xE0, 0x0D, 0x00, 0x3E, 0x00, 0x38,
  0x01, 0xF0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x02, 0x00, 0x0E, 0x00, 0x10, 0x00, 0x70, 0x00, 0x80, 0x03, 0x80,
  0x04, 0x00, 0x1C, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x00, 0x07, 0x00, 0x08,
  0x00, 0x38, 0x00, 0x40, 0x01, 0xC0, 0x02, 0x00, 0x0E, 0x00, 0x10, 0x00,
  0x70, 0x00, 0x80, 0x03, 0x80, 0x04, 0x00, 0x1C, 0x00, 0x20, 0x00, 0xE0,
  0x01, 0x00, 0x07, 0x00, 0x08, 0x00, 0x38, 0x00, 0x40, 0x01, 0xC0, 0x02,
  0x00, 0x0E, 0x00, 0x10, 0x00, 0x70, 0x00, 0x80, 0x03, 0x80, 0x04, 0x00,
  0x1C, 0x00, 0x20, 0x00, 0xE0, 0x01, 0x00, 0x04, 0x80, 0x7F, 0x02, 0x0F,
  0x8F, 0x08, 0x70, 0x06, 0x23, 0x00, 0x0C, 0x98, 0x00, 0x1A, 0xC0, 0x00,
  0x2A, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x00, 0x78,
  0xF8, 0x00, 0x70, 0x03, 0x00, 0x30, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x0C,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x04, 0x60, 0x00, 0x01,
  0x90, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x02, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x66, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x02, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0xC1, 0xFE, 0x01, 0x8F, 0x1F, 0x03, 0x30, 0x03, 0x06, 0xC0, 0x03, 0x0F,
  0x00, 0x03, 0x1C, 0x00, 0x02, 0x30, 0x00, 0x06, 0x60, 0x00, 0x04, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x16, 0x00, 0x00, 0x2C, 0x00, 0x00,
  0x58, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x60, 0x00, 0x04, 0xC0, 0x00, 0x19,
  0xC0, 0x00, 0x63, 0xC0, 0x01, 0x86, 0xC0, 0x07, 0x0C, 0xF0, 0x38, 0x18,
  0x7F, 0xE0, 0x30, 0x04, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x06, 0x0F, 0x8F, 0x0C, 0x38, 0x03, 0x98, 0xE0, 0x01, 0xB1, 0x80, 0x01,
  0x66, 0x00, 0x03, 0xC8, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x40, 0x00, 0x06,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x30, 0x00, 0x0E, 0x60, 0x00,
  0x1C, 0x60, 0x00, 0xD8, 0x60, 0x03, 0x30, 0x70, 0x1C, 0x60, 0x3F, 0xE0,
  0xC0, 0x04, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x80, 0x7F, 0xE0, 0x7C,
  0x18, 0x70, 0x02, 0x30, 0x00, 0x98, 0x00, 0x2C, 0x00, 0x0A, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0x8F, 0xC0, 0x70, 0x01,
  0xC1, 0x80, 0x00, 0xC6, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x90, 0x00, 0x01,
  0xA0, 0x00, 0x03, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x09, 0x80, 0x00, 0x31, 0xC0, 0x01,
  0xC1, 0xE0, 0x0F, 0x00, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x1D,
  0x80, 0x00, 0xF3, 0x00, 0x06, 0xC6, 0x00, 0x33, 0x0E, 0x03, 0x8C, 0x1F,
  0xF8, 0x30, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0x10, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x03, 0x04, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x08, 0x08, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x18, 0x03, 0x00, 0x02, 0x00, 0x60, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0xC0, 0x01,
  0x80, 0x10, 0x00, 0x10, 0x06, 0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x06, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01,
  0x84, 0x00, 0x00, 0x11, 0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x34, 0x00, 0x30, 0x00, 0x90, 0x00,
  0xE0, 0x02, 0x60, 0x07, 0x80, 0x19, 0x80, 0x1A, 0x00, 0x66, 0x00, 0x48,
  0x01, 0x88, 0x01, 0x30, 0x04, 0x30, 0x0C, 0xC0, 0x10, 0xC0, 0x33, 0x00,
  0xC3, 0x00, 0x84, 0x03, 0x04, 0x02, 0x18, 0x08, 0x10, 0x18, 0x60, 0x20,
  0x60, 0x61, 0x81, 0x81, 0x81, 0x02, 0x06, 0x02, 0x04, 0x0C, 0x10, 0x08,
  0x30, 0x30, 0x40, 0x30, 0x80, 0x41, 0x00, 0xC2, 0x01, 0x0C, 0x03, 0x08,
  0x06, 0x30, 0x04, 0x60, 0x18, 0x80, 0x19, 0x00, 0x22, 0x00, 0x64, 0x00,
  0x98, 0x01, 0x90, 0x03, 0x60, 0x02, 0xC0, 0x0D, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x28, 0x00, 0x50, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x30, 0x30,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x33, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x00, 0x63, 0x00, 0x00, 0x02,
  0x08, 0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x01, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0xC0, 0x20, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x04, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x30, 0x01, 0x80, 0x01, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x40,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x71, 0xC0, 0x00,
  0x33, 0x01, 0xC0, 0x00, 0x98, 0x01, 0x80, 0x02, 0x40, 0x03, 0x00, 0x1B,
  0x00, 0x06, 0x00, 0xCC, 0x00, 0x0E, 0x07, 0x30, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 3, 40, 34, 15, -40 },
  { 16, 9, 11, 34, 12, -42 },
  { 29, 30, 40, 34, 2, -40 },
  { 179, 24, 51, 34, 5, -45 },
  { 332, 31, 41, 34, 1, -40 },
  { 491, 28, 41, 34, 4, -40 },
  { 635, 1, 11, 34, 15, -42 },
  { 637, 12, 57, 34, 11, -44 },
  { 723, 12, 57, 34, 10, -44 },
  { 809, 24, 22, 34, 6, -40 },
  { 875, 28, 29, 34, 3, -33 },
  { 977, 4, 11, 34, 11, -4 },
  { 983, 20, 2, 34, 7, -19 },
  { 988, 3, 3, 34, 16, -3 },
  { 990, 19, 43, 34, 8, -40 },
  { 1093, 24, 41, 34, 5, -40 },
  { 1216, 13, 40, 34, 6, -40 },
  { 1281, 25, 40, 34, 3, -40 },
  { 1406, 24, 41, 34, 3, -40 },
  { 1529, 27, 40, 34, 3, -40 },
  { 1664, 23, 41, 34, 6, -40 },
  { 1782, 25, 41, 34, 4, -40 },
  { 1911, 25, 40, 34, 4, -40 },
  { 2036, 25, 41, 34, 5, -40 },
  { 2165, 25, 41, 34, 4, -40 },
  { 2294, 3, 27, 34, 18, -27 },
  { 2305, 5, 34, 34, 16, -27 },
  { 2327, 24, 22, 34, 4, -29 },
  { 2393, 24, 13, 34, 5, -25 },
  { 2432, 24, 22, 34, 5, -29 },
  { 2498, 20, 40, 34, 7, -40 },
  { 2598, 31, 40, 34, 1, -40 },
  { 2753, 28, 40, 34, 3, -40 },
  { 2893, 24, 40, 34, 6, -40 },
  { 3013, 26, 41, 34, 4, -40 },
  { 3147, 25, 40, 34, 5, -40 },
  { 3272, 23, 40, 34, 6, -40 },
  { 3387, 23, 40, 34, 6, -40 },
  { 3502, 26, 41, 34, 4, -40 },
  { 3636, 24, 40, 34, 5, -40 },
  { 3756, 22, 40, 34, 6, -40 },
  { 3866, 24, 41, 34, 3, -40 },
  { 3989, 26, 40, 34, 6, -40 },
  { 4119, 22, 40, 34, 7, -40 },
  { 4229, 24, 40, 34, 5, -40 },
  { 4349, 24, 40, 34, 5, -40 },
  { 4469, 26, 41, 34, 4, -40 },
  { 4603, 24, 40, 34, 7, -40 },
  { 4723, 28, 47, 34, 3, -40 },
  { 4888, 24, 40, 34, 6, -40 },
  { 5008, 26, 41, 34, 4, -40 },
  { 5142, 28, 40, 34, 3, -40 },
  { 5282, 24, 41, 34, 5, -40 },
  { 5405, 27, 40, 34, 3, -40 },
  { 5540, 29, 40, 34, 3, -40 },
  { 5685, 28, 40, 34, 3, -40 },
  { 5825, 28, 40, 34, 2, -40 },
  { 5965, 24, 40, 34, 4, -40 },
  { 6085, 8, 55, 34, 13, -46 },
  { 6140, 18, 43, 34, 8, -40 },
  { 6237, 9, 55, 34, 12, -46 },
  { 6299, 20, 22, 34, 7, -40 },
  { 6354, 23, 1, 34, 5, 0 },
  { 6357, 7, 7, 34, 13, -41 },
  { 6364, 24, 31, 34, 5, -30 },
  { 6457, 23, 43, 34, 6, -42 },
  { 6581, 23, 31, 34, 5, -30 },
  { 6671, 22, 43, 34, 5, -42 },
  { 6790, 25, 31, 34, 4, -30 },
  { 6887, 24, 43, 34, 6, -43 },
  { 7016, 23, 42, 34, 5, -30 },
  { 7137, 22, 42, 34, 6, -42 },
  { 7253, 22, 40, 34, 7, -40 },
  { 7363, 17, 52, 34, 5, -40 },
  { 7474, 23, 42, 34, 7, -42 },
  { 7595, 22, 42, 34, 7, -42 },
  { 7711, 29, 30, 34, 2, -30 },
  { 7820, 22, 30, 34, 6, -30 },
  { 7903, 26, 31, 34, 4, -30 },
  { 8004, 23, 41, 34, 6, -30 },
  { 8122, 23, 41, 34, 5, -30 },
  { 8240, 18, 30, 34, 11, -30 },
  { 8308, 23, 31, 34, 6, -30 },
  { 8398, 23, 39, 34, 5, -38 },
  { 8511, 22, 31, 34, 6, -30 },
  { 8597, 27, 30, 34, 3, -30 },
  { 8699, 30, 30, 34, 2, -30 },
  { 8812, 26, 30, 34, 4, -30 },
  { 8910, 29, 42, 34, 2, -30 },
  { 9063, 26, 30, 34, 4, -30 },
  { 9161, 18, 56, 34, 9, -44 },
  { 9287, 2, 47, 34, 16, -40 },
  { 9299, 18, 56, 34, 9, -44 },
  { 9425, 30, 9, 34, 2, -21 },
};

const GFXfont RobotoMono_Thin56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin56pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_THIN56PT7B_H_
