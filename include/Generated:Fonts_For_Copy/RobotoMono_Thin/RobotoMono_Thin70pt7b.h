#ifndef _ROBOTOMONO_THIN70PT7B_H_
#define _ROBOTOMONO_THIN70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin70pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x60, 0x00, 0x00, 0x00, 0x17, 0xFC, 0x60, 0x6C, 0x0D, 0x81,
  0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1A, 0x03, 0x40, 0x68, 0x0D, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x30, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x01, 0x80, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x03, 0x00, 0x00, 0x70,
  0x18, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x40, 0x01, 0x80, 0x0C, 0x01, 0x80,
  0x03, 0x00, 0x38, 0x03, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x00, 0x80, 0x60, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x00,
  0xC0, 0x70, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x60, 0x00, 0x00, 0xFF, 0x00,
  0xC0, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x06, 0x00, 0xFE,
  0x00, 0x00, 0x0C, 0x07, 0xDE, 0x00, 0x00, 0x30, 0x1C, 0x0E, 0x00, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x06, 0x01, 0x80,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x01, 0x00, 0x38, 0x01, 0x80, 0x02, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x08, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x00,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x06, 0x00, 0x00,
  0x60, 0x03, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x06, 0x00, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x00, 0x31,
  0x80, 0x01, 0x80, 0x0C, 0x60, 0x00, 0x70, 0x03, 0x30, 0x00, 0x0E, 0x00,
  0xCC, 0x00, 0x01, 0x80, 0x33, 0x00, 0x00, 0x30, 0x18, 0xC0, 0x00, 0x06,
  0x06, 0x20, 0x00, 0x00, 0xC1, 0x88, 0x00, 0x00, 0x38, 0xC3, 0x00, 0x00,
  0x07, 0x30, 0xC0, 0x00, 0x00, 0xD8, 0x30, 0x00, 0x00, 0x1E, 0x0C, 0x00,
  0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xFC, 0x0E,
  0x00, 0x00, 0x63, 0x01, 0xC0, 0x00, 0x30, 0x60, 0x38, 0x00, 0x38, 0x0C,
  0x07, 0xC0, 0xF8, 0x01, 0x80, 0x7F, 0xF8, 0x00, 0x30, 0x01, 0xF0, 0x00,
  0x00, 0x6D, 0xB6, 0xDB, 0x49, 0x2D, 0xB0, 0x00, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x6F, 0x80, 0x30, 0x07, 0xCF, 0xC0, 0xC0, 0xFC, 0x07, 0xE3, 0x1F, 0x80,
  0x03, 0xFD, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x8C, 0xCC, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6F, 0xF7, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x06, 0xF0, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x01, 0x8F, 0x00,
  0x00, 0x0C, 0x3C, 0x00, 0x00, 0x60, 0xF0, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0x18, 0x0F, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x30,
  0x03, 0xC0, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x60, 0x00,
  0xF0, 0x03, 0x00, 0x03, 0xC0, 0x18, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x3C,
  0x06, 0x00, 0x00, 0xF0, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0F, 0x0C,
  0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x03, 0x58, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0xFB, 0x03, 0xC3, 0x0F, 0x03, 0x3C, 0x03, 0xF0, 0x03, 0xC0,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x31, 0x00, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x18, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x01, 0x83, 0x00, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x0C, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xC0, 0x03, 0x3F,
  0xFF, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x70, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x07, 0x80,
  0x01, 0x80, 0xFF, 0xF0, 0x03, 0x07, 0xC0, 0xF8, 0x06, 0x3C, 0x00, 0x38,
  0x0C, 0xE0, 0x00, 0x38, 0x13, 0x80, 0x00, 0x18, 0x2C, 0x00, 0x00, 0x18,
  0x50, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00,
  0x70, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x03, 0x03, 0x80, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x06, 0xCE, 0x00,
  0x00, 0x1B, 0x1C, 0x00, 0x00, 0xCC, 0x38, 0x00, 0x0E, 0x30, 0x70, 0x00,
  0x70, 0xC0, 0xF0, 0x0F, 0x82, 0x00, 0xFF, 0xF8, 0x18, 0x00, 0xFF, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF7, 0x0C, 0x3C,
  0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x02, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x61, 0xC1, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xF1, 0xF8, 0x03, 0x80, 0x0E,
  0x03, 0x80, 0x03, 0x83, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x31, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0xC0, 0x01, 0xF0, 0x03, 0x87, 0x00, 0x3F, 0xE0,
  0x06, 0x18, 0x01, 0xC1, 0xE0, 0x18, 0xE0, 0x0E, 0x01, 0x80, 0x63, 0x00,
  0x70, 0x06, 0x00, 0xCC, 0x01, 0x80, 0x18, 0x03, 0x60, 0x0C, 0x00, 0x60,
  0x0D, 0x80, 0x30, 0x01, 0x80, 0x36, 0x01, 0x80, 0x06, 0x00, 0xD8, 0x06,
  0x00, 0x18, 0x03, 0x40, 0x18, 0x00, 0x60, 0x0F, 0x00, 0xC0, 0x01, 0x00,
  0x3C, 0x03, 0x00, 0x04, 0x00, 0xF0, 0x0C, 0x00, 0x30, 0x03, 0xC0, 0x30,
  0x00, 0xC0, 0x0F, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x02, 0x00, 0x0C, 0x00,
  0xF0, 0x08, 0x00, 0x30, 0x03, 0xC0, 0x20, 0x00, 0xC0, 0x0F, 0x00, 0x80,
  0x07, 0x00, 0x2C, 0x02, 0x00, 0x1C, 0x01, 0xB0, 0x08, 0x00, 0x60, 0x06,
  0xC0, 0x30, 0x03, 0xC0, 0x1B, 0x00, 0xC0, 0x0F, 0x00, 0x6C, 0x03, 0x00,
  0x6C, 0x03, 0x30, 0x0C, 0x01, 0xB0, 0x0C, 0x60, 0x18, 0x0C, 0xC0, 0x61,
  0x80, 0x60, 0x61, 0x83, 0x86, 0x00, 0xE7, 0x07, 0xBC, 0x1C, 0x01, 0xF8,
  0x0F, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x18, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x30, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x40, 0x00, 0x06, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x40, 0x00, 0x00, 0x40, 0x18, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x04, 0x18, 0x00,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x07, 0xC0, 0x30, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0x00, 0x01, 0xF8, 0x0C, 0x00, 0x00, 0x78, 0x30, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x3C, 0x30, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x07, 0xE0,
  0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x1C, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0xC1, 0xE0, 0x00, 0x00, 0xC3, 0x70, 0x00, 0x00,
  0xC6, 0x38, 0x00, 0x00, 0xCC, 0x18, 0x00, 0x00, 0xD8, 0x0C, 0x00, 0x00,
  0xF0, 0x06, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x00,
  0xC0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0D, 0xD8, 0x00, 0x00, 0x37, 0x60, 0x00, 0x01, 0xDD, 0x80, 0x00,
  0x06, 0x73, 0x00, 0x00, 0x19, 0xCC, 0x00, 0x00, 0xC7, 0x18, 0x00, 0x03,
  0x1C, 0x60, 0x00, 0x18, 0x71, 0x80, 0x00, 0x61, 0xC3, 0x00, 0x01, 0x87,
  0x0C, 0x00, 0x0C, 0x1C, 0x18, 0x00, 0x30, 0x70, 0x60, 0x01, 0x81, 0xC1,
  0x80, 0x06, 0x07, 0x03, 0x00, 0x18, 0x1C, 0x0C, 0x00, 0xC0, 0x70, 0x30,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x07, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x01,
  0x80, 0x70, 0x0C, 0x0C, 0x01, 0xC0, 0x30, 0x30, 0x07, 0x00, 0x61, 0x80,
  0x1C, 0x01, 0x86, 0x00, 0x70, 0x02, 0x10, 0x01, 0xC0, 0x0C, 0xC0, 0x07,
  0x00, 0x33, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x60, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x00, 0xF3, 0x00, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x0F, 0x18, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x0F, 0x02, 0x00, 0x00, 0x3C,
  0x0C, 0x00, 0x00, 0xF0, 0x18, 0x00, 0x03, 0xC0, 0x60, 0x00, 0x0F, 0x00,
  0xC0, 0x00, 0x3C, 0x03, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x03, 0xC0, 0x08,
  0x00, 0x0F, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x40, 0x00, 0xF0, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x18, 0x00,
  0xF0, 0x00, 0x60, 0x03, 0xC0, 0x00, 0xC0, 0x0F, 0x00, 0x01, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0xF0, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x30, 0x0F, 0x00,
  0x00, 0x60, 0x3C, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0x04, 0x0F, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x00,
  0xC3, 0xC0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x06, 0x3C, 0x00, 0x00, 0x0C,
  0xF0, 0x00, 0x00, 0x13, 0xC0, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x01, 0xF0, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x0F, 0x0C, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x0C, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x0F, 0x80, 0x30, 0x00, 0x07,
  0x80, 0xC0, 0x00, 0x07, 0x03, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x0C,
  0x00, 0x07, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x07, 0x0C,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x18, 0x01, 0x80,
  0x00, 0x04, 0x00, 0x20, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x18, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1A,
  0x00, 0x01, 0x80, 0x00, 0xD0, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00, 0xE0,
  0x00, 0x36, 0x00, 0x07, 0x00, 0x01, 0x30, 0x00, 0x3C, 0x00, 0x09, 0x80,
  0x01, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0x20, 0x00, 0xD8, 0x00,
  0x31, 0x80, 0x06, 0x40, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x08, 0x60, 0x01,
  0x98, 0x00, 0x43, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x30,
  0x40, 0x06, 0x10, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x01, 0x86,
  0x00, 0x60, 0xC0, 0x18, 0x30, 0x02, 0x06, 0x00, 0xC1, 0x80, 0x10, 0x30,
  0x06, 0x04, 0x01, 0x80, 0x80, 0x30, 0x30, 0x0C, 0x04, 0x01, 0x81, 0x80,
  0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x0C, 0x01, 0x01, 0x80, 0x60, 0x60,
  0x08, 0x18, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00,
  0xC0, 0x80, 0x18, 0x30, 0x03, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x06,
  0x18, 0x00, 0xC3, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x00, 0xC6, 0x00, 0x30,
  0xC0, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x31, 0x80, 0x06, 0x20, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x26, 0x00, 0x0C, 0xC0,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x68, 0x00,
  0x0D, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x06,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x01,
  0x83, 0x80, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x03, 0x80, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x18, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x00, 0x06, 0x07, 0x00, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30,
  0x04, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x00, 0x43, 0x00, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x43, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xC3, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x06, 0x07, 0x80, 0x00, 0x18, 0x78, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x03, 0x98,
  0x00, 0x00, 0x1E, 0x60, 0x00, 0x00, 0xD8, 0xC0, 0x00, 0x06, 0x63, 0x80,
  0x00, 0x71, 0x87, 0x80, 0x07, 0x87, 0x0F, 0x80, 0xF8, 0x1C, 0x0F, 0xFF,
  0x80, 0x30, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x01,
  0xF0, 0x00, 0xC0, 0xFF, 0xE0, 0x0C, 0x3E, 0x0F, 0x80, 0xC7, 0x00, 0x1C,
  0x0C, 0xC0, 0x00, 0xE0, 0xD8, 0x00, 0x03, 0x0F, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x01, 0x8F, 0x00, 0x00, 0x38, 0xF8, 0x00, 0x03, 0x0D, 0xC0, 0x00,
  0x60, 0xCF, 0x00, 0x1C, 0x0C, 0x3E, 0x0F, 0x80, 0xC0, 0xFF, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x02,
  0x20, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x70, 0x03, 0x00, 0x7F, 0xF0, 0x30, 0x1F, 0x07, 0xC3, 0x03, 0x80, 0x0E,
  0x30, 0x70, 0x00, 0x33, 0x0C, 0x00, 0x01, 0xB1, 0xC0, 0x00, 0x0F, 0x18,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xF0, 0x70, 0x00,
  0x3B, 0x03, 0x80, 0x0F, 0x30, 0x1F, 0x07, 0xC3, 0x00, 0x7F, 0xF0, 0x30,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0x01, 0x01, 0xF0, 0x7C, 0x10, 0x38, 0x00, 0xE1, 0x07, 0x00,
  0x03, 0x10, 0xE0, 0x00, 0x19, 0x1C, 0x00, 0x00, 0xD1, 0x80, 0x00, 0x07,
  0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0D, 0x07, 0x00, 0x03, 0x90, 0x38,
  0x00, 0xF1, 0x01, 0xF0, 0x7C, 0x10, 0x07, 0xFF, 0x01, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x3F,
  0xFC, 0x0C, 0x0F, 0x81, 0xE0, 0xC1, 0xC0, 0x03, 0x8C, 0x38, 0x00, 0x1C,
  0xC6, 0x00, 0x00, 0xCC, 0xC0, 0x00, 0x06, 0xD8, 0x00, 0x00, 0x6D, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x0C, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0,
  0x38, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0xC7, 0xC0, 0x00, 0x0C, 0xEE, 0x00, 0x00, 0xDC, 0x60, 0x00, 0x0F,
  0x03, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x06,
  0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x18, 0x0C, 0x3F, 0xE0, 0x1F,
  0xF0, 0xCF, 0x07, 0x07, 0x83, 0xCD, 0xC0, 0x18, 0xE0, 0x0C, 0xF8, 0x00,
  0xD8, 0x00, 0x6F, 0x00, 0x0D, 0x80, 0x06, 0xE0, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00,
  0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x0C, 0x03,
  0xFF, 0xC0, 0xC0, 0xF8, 0x1E, 0x0C, 0x1C, 0x00, 0x38, 0xC3, 0x80, 0x01,
  0x8C, 0x60, 0x00, 0x0C, 0xCC, 0x00, 0x00, 0x6D, 0x80, 0x00, 0x06, 0xD8,
  0x00, 0x00, 0x6F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x08,
  0x0F, 0xFE, 0x00, 0x83, 0xE0, 0xF8, 0x08, 0x70, 0x01, 0xC0, 0x9C, 0x00,
  0x0E, 0x09, 0x80, 0x00, 0x70, 0xB0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xC8, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x68,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x06, 0x80, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x03, 0x8B, 0x00, 0x00, 0x70, 0x9C, 0x00, 0x0E, 0x08, 0xE0,
  0x01, 0xC0, 0x83, 0xC0, 0xF8, 0x08, 0x0F, 0xFE, 0x00, 0x80, 0x0E, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xFF, 0x01, 0x01, 0xF0, 0x7C, 0x10, 0x38, 0x00, 0xE1,
  0x07, 0x00, 0x03, 0x10, 0xE0, 0x00, 0x19, 0x1C, 0x00, 0x00, 0xD1, 0x80,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x73, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x13, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x0D, 0x07, 0x00, 0x03,
  0x90, 0x38, 0x00, 0xF1, 0x01, 0xF0, 0x7C, 0x10, 0x07, 0xFF, 0x01, 0x00,
  0x07, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xFC, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x01, 0xC1, 0xE0, 0x00,
  0xC3, 0x80, 0x00, 0xC7, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFD, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0x30, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x1B, 0x18, 0x00, 0x03, 0xB1,
  0xC0, 0x00, 0x73, 0x0E, 0x00, 0x1E, 0x30, 0x7C, 0x0F, 0x83, 0x01, 0xFF,
  0xE0, 0x30, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x07, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x06, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x06, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x00, 0xE0,
  0x00, 0x66, 0x00, 0x0D, 0x00, 0x03, 0x30, 0x00, 0x6C, 0x00, 0x19, 0x80,
  0x03, 0x60, 0x00, 0x8C, 0x00, 0x13, 0x00, 0x0C, 0x30, 0x01, 0x98, 0x00,
  0x61, 0x80, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x60, 0x02,
  0x18, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60,
  0x60, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x40, 0xC0, 0x30, 0x18, 0x06, 0x06,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x08, 0x06, 0x02, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x00, 0x30, 0x60, 0x06, 0x18,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x31, 0x80,
  0x06, 0x20, 0x01, 0x8C, 0x00, 0x33, 0x00, 0x04, 0x40, 0x01, 0x98, 0x00,
  0x36, 0x00, 0x04, 0x80, 0x01, 0xB0, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x01,
  0xE0, 0x00, 0x28, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x03, 0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x00, 0x71, 0x80, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x18, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0C, 0x3E, 0xFC, 0x00,
  0x00, 0x21, 0xC0, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x70, 0x00, 0x06, 0x30,
  0x00, 0x70, 0x00, 0x19, 0x80, 0x00, 0xE0, 0x00, 0xC6, 0x00, 0x01, 0xC0,
  0x03, 0x18, 0x00, 0x03, 0x80, 0x18, 0x40, 0x00, 0x03, 0x81, 0xC3, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph RobotoMono_Thin70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 3, 50, 42, 19, -50 },
  { 20, 11, 15, 42, 15, -53 },
  { 41, 38, 50, 42, 2, -50 },
  { 279, 30, 64, 42, 7, -57 },
  { 519, 39, 51, 42, 1, -50 },
  { 768, 34, 51, 42, 6, -50 },
  { 985, 3, 15, 42, 18, -53 },
  { 991, 15, 71, 42, 14, -55 },
  { 1125, 15, 71, 42, 12, -55 },
  { 1259, 30, 27, 42, 7, -50 },
  { 1361, 34, 36, 42, 4, -41 },
  { 1514, 5, 14, 42, 14, -5 },
  { 1523, 24, 2, 42, 9, -24 },
  { 1529, 4, 4, 42, 20, -4 },
  { 1531, 23, 54, 42, 10, -50 },
  { 1687, 30, 51, 42, 6, -50 },
  { 1879, 16, 50, 42, 8, -50 },
  { 1979, 31, 50, 42, 4, -50 },
  { 2173, 31, 51, 42, 3, -50 },
  { 2371, 35, 50, 42, 3, -50 },
  { 2590, 29, 51, 42, 8, -50 },
  { 2775, 31, 51, 42, 5, -50 },
  { 2973, 32, 50, 42, 5, -50 },
  { 3173, 32, 51, 42, 6, -50 },
  { 3377, 30, 51, 42, 6, -50 },
  { 3569, 4, 34, 42, 22, -34 },
  { 3586, 7, 43, 42, 19, -34 },
  { 3624, 29, 28, 42, 6, -37 },
  { 3726, 30, 16, 42, 6, -31 },
  { 3786, 30, 28, 42, 6, -37 },
  { 3891, 25, 50, 42, 9, -50 },
  { 4048, 38, 50, 42, 2, -50 },
  { 4286, 35, 50, 42, 4, -50 },
  { 4505, 30, 50, 42, 7, -50 },
  { 4693, 32, 51, 42, 5, -50 },
  { 4897, 31, 50, 42, 7, -50 },
  { 5091, 28, 50, 42, 8, -50 },
  { 5266, 28, 50, 42, 8, -50 },
  { 5441, 32, 51, 42, 5, -50 },
  { 5645, 30, 50, 42, 6, -50 },
  { 5833, 28, 50, 42, 7, -50 },
  { 6008, 30, 51, 42, 4, -50 },
  { 6200, 32, 50, 42, 8, -50 },
  { 6400, 28, 50, 42, 8, -50 },
  { 6575, 30, 50, 42, 6, -50 },
  { 6763, 30, 50, 42, 6, -50 },
  { 6951, 32, 51, 42, 5, -50 },
  { 7155, 30, 50, 42, 8, -50 },
  { 7343, 34, 59, 42, 4, -50 },
  { 7594, 30, 50, 42, 8, -50 },
  { 7782, 33, 51, 42, 5, -50 },
  { 7993, 34, 50, 42, 4, -50 },
  { 8206, 30, 51, 42, 6, -50 },
  { 8398, 34, 50, 42, 4, -50 },
  { 8611, 37, 50, 42, 3, -50 },
  { 8843, 35, 50, 42, 4, -50 },
  { 9062, 35, 50, 42, 3, -50 },
  { 9281, 31, 50, 42, 5, -50 },
  { 9475, 10, 68, 42, 16, -57 },
  { 9560, 22, 54, 42, 10, -50 },
  { 9709, 10, 68, 42, 16, -57 },
  { 9794, 24, 27, 42, 9, -50 },
  { 9875, 28, 2, 42, 7, 0 },
  { 9882, 8, 9, 42, 17, -52 },
  { 9891, 30, 39, 42, 6, -38 },
  { 10038, 28, 54, 42, 8, -53 },
  { 10227, 30, 39, 42, 6, -38 },
  { 10374, 28, 54, 42, 6, -53 },
  { 10563, 30, 39, 42, 6, -38 },
  { 10710, 31, 53, 42, 7, -53 },
  { 10916, 28, 53, 42, 6, -38 },
  { 11102, 28, 53, 42, 7, -53 },
  { 11288, 29, 50, 42, 8, -50 },
  { 11470, 22, 65, 42, 6, -50 },
  { 11649, 28, 53, 42, 9, -53 },
  { 11835, 29, 53, 42, 8, -53 },
  { 12028, 36, 38, 42, 3, -38 },
  { 12199, 28, 38, 42, 7, -38 },
  { 12332, 32, 39, 42, 5, -38 },
  { 12488, 28, 52, 42, 8, -38 },
  { 12670, 28, 52, 42, 6, -38 },
  { 12852, 24, 38, 42, 13, -38 },
  { 12966, 29, 39, 42, 7, -38 },
  { 13108, 28, 48, 42, 7, -47 },
  { 13276, 28, 38, 42, 7, -37 },
  { 13409, 34, 37, 42, 4, -37 },
  { 13567, 37, 37, 42, 3, -37 },
  { 13739, 33, 37, 42, 5, -37 },
  { 13892, 36, 52, 42, 3, -37 },
  { 14126, 33, 37, 42, 5, -37 },
  { 14279, 22, 70, 42, 12, -55 },
  { 14472, 2, 59, 42, 20, -50 },
  { 14487, 22, 70, 42, 12, -55 },
  { 14680, 38, 11, 42, 2, -26 },
};

const GFXfont RobotoMono_Thin70pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin70pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin70pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _ROBOTOMONO_THIN70PT7B_H_
