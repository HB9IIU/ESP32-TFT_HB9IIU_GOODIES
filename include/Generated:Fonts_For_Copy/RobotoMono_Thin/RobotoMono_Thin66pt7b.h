#ifndef _ROBOTOMONO_THIN66PT7B_H_
#define _ROBOTOMONO_THIN66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin66pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x70, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1A, 0x02,
  0x40, 0x48, 0x09, 0x01, 0x20, 0x24, 0x05, 0x80, 0x80, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x18, 0x00, 0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x00, 0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x06, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x01, 0x80, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x01, 0x80, 0x00, 0x06, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x08, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x60, 0x00, 0x01, 0x80, 0x04, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x38, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x02, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x16, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x0C,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x01, 0x80, 0x18, 0x00, 0x20, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x40, 0x03, 0x00, 0x10, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x60, 0x01, 0x00, 0x0C, 0x06, 0x00,
  0x0C, 0x00, 0x40, 0x30, 0x00, 0x60, 0x06, 0x03, 0x00, 0x03, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x03, 0x01, 0x80, 0x00, 0x30, 0x38, 0x08, 0x00, 0x00,
  0xFF, 0x80, 0xC0, 0x00, 0x03, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0x80, 0x7E,
  0x00, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x60, 0x70, 0x00, 0x0C,
  0x06, 0x01, 0x80, 0x00, 0x60, 0x30, 0x06, 0x00, 0x06, 0x03, 0x00, 0x10,
  0x00, 0x30, 0x18, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x20, 0x01, 0x80, 0x0C, 0x01, 0x00, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x60, 0x06, 0x00, 0x40, 0x03, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x80,
  0x02, 0x00, 0x60, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x18,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x06, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x01, 0x80, 0x00, 0x60, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0x18, 0xC0, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x01, 0x80, 0x60, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x80, 0x18, 0xC0, 0x00,
  0xC0, 0x0C, 0x60, 0x00, 0x30, 0x06, 0x30, 0x00, 0x0C, 0x06, 0x30, 0x00,
  0x03, 0x03, 0x18, 0x00, 0x01, 0xC1, 0x8C, 0x00, 0x00, 0x61, 0xC6, 0x00,
  0x00, 0x18, 0xC3, 0x00, 0x00, 0x06, 0xE0, 0x80, 0x00, 0x01, 0xE0, 0x60,
  0x00, 0x00, 0x70, 0x30, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x00, 0x3C, 0x07,
  0x00, 0x00, 0x33, 0x01, 0xC0, 0x00, 0x70, 0xC0, 0x70, 0x00, 0x70, 0x30,
  0x1F, 0x01, 0xE0, 0x0C, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x55, 0x55, 0x5F, 0xF0, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x40, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x08, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x80, 0x06, 0x00, 0x2E, 0x00, 0x60, 0x0F,
  0x7C, 0x06, 0x07, 0xC0, 0xF8, 0x63, 0xE0, 0x01, 0xF6, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x31, 0x88, 0xCC, 0x00, 0xFF, 0xFF, 0xFE,
  0x4F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x38, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x01, 0x80,
  0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0C, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x38, 0x30, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x3C,
  0xC0, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x04,
  0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0xF3, 0x07, 0xC3, 0x1E, 0x03, 0x78, 0x03, 0xE0, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xF0, 0x3E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x30, 0x60,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x11, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x07,
  0xC0, 0x78, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xA0, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x00, 0xC4, 0x00, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x00, 0x61, 0x00, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x00, 0x60, 0x40, 0x00, 0x00, 0x30, 0x20, 0x00,
  0x00, 0x30, 0x10, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x04, 0x00,
  0x00, 0x18, 0x02, 0x00, 0x00, 0x18, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x06, 0x00, 0x10,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x06, 0x00, 0x04, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x00, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x00,
  0x40, 0x01, 0x80, 0x00, 0x20, 0x01, 0x80, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x08, 0x00, 0xC0, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x02, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x40, 0x00, 0x30, 0xFF, 0xE0, 0x03, 0x3E, 0x0F, 0x80, 0x3E, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x70, 0x30, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x18, 0x1C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x30, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x03, 0x00, 0x7E, 0x00, 0x18, 0x1F, 0xFE, 0x00, 0x83, 0xC0, 0x3C,
  0x04, 0x70, 0x00, 0x70, 0x67, 0x00, 0x01, 0xC3, 0x60, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x03, 0x00, 0x70, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x03, 0x10, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x06, 0x40, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x70, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03,
  0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x20, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x07, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x03, 0xC6, 0x00, 0x00,
  0x36, 0x38, 0x00, 0x03, 0x30, 0xE0, 0x00, 0x31, 0x83, 0x80, 0x07, 0x0C,
  0x0F, 0x00, 0xF0, 0x40, 0x1F, 0xFE, 0x06, 0x00, 0x3F, 0xC0, 0x30, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x4E, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4E,
  0xFE, 0x08, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xC1, 0xE0, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x00, 0xC0,
  0xC0, 0x01, 0x80, 0x0C, 0x18, 0x00, 0xFE, 0x00, 0x61, 0x80, 0x3C, 0x38,
  0x06, 0x30, 0x07, 0x01, 0xC0, 0x63, 0x00, 0xE0, 0x08, 0x06, 0x20, 0x0C,
  0x00, 0x80, 0x26, 0x01, 0x80, 0x08, 0x02, 0x60, 0x18, 0x00, 0x80, 0x36,
  0x03, 0x00, 0x18, 0x03, 0x40, 0x30, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x18,
  0x03, 0xC0, 0x20, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x18, 0x03, 0xC0, 0x60,
  0x01, 0x80, 0x3C, 0x06, 0x00, 0x10, 0x03, 0xC0, 0x60, 0x01, 0x00, 0x38,
  0x06, 0x00, 0x10, 0x02, 0x80, 0x60, 0x03, 0x00, 0x28, 0x06, 0x00, 0x30,
  0x02, 0xC0, 0x60, 0x03, 0x00, 0x6C, 0x06, 0x00, 0x70, 0x06, 0xC0, 0x60,
  0x07, 0x00, 0x6C, 0x06, 0x00, 0xF0, 0x04, 0xC0, 0x60, 0x0F, 0x00, 0xCC,
  0x03, 0x01, 0x90, 0x0C, 0x40, 0x30, 0x39, 0x81, 0x86, 0x01, 0x87, 0x1C,
  0x30, 0x60, 0x1F, 0xE0, 0xFE, 0x07, 0x00, 0x78, 0x07, 0xC0, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x02,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0x06, 0x08, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x01, 0x03, 0x00, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x00, 0x40, 0x30, 0x00, 0x00, 0x60, 0x08, 0x00, 0x00, 0x30, 0x06,
  0x00, 0x00, 0x10, 0x03, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x30, 0x00, 0x06, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x30, 0x00, 0x60, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x10, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x18, 0x03,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xC0, 0x00, 0x78, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x1E, 0x0C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0xC0, 0x00, 0x0E, 0x06, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x62, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x30, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x0F, 0x80, 0x30, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00,
  0x23, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x01, 0x83, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x30,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x4C,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0xC4, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x08, 0x00, 0x00, 0x06,
  0x18, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0x70, 0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60,
  0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x38,
  0x00, 0x00, 0x30, 0xF8, 0x00, 0x00, 0x63, 0x98, 0x00, 0x00, 0xC6, 0x18,
  0x00, 0x01, 0x98, 0x38, 0x00, 0x03, 0x60, 0x30, 0x00, 0x07, 0x80, 0x30,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x01, 0x83, 0x00, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0D, 0xF0, 0x00, 0x00, 0xDD, 0x80, 0x00, 0x19, 0xD8, 0x00,
  0x01, 0x9C, 0x80, 0x00, 0x19, 0xCC, 0x00, 0x03, 0x1C, 0xC0, 0x00, 0x31,
  0xC6, 0x00, 0x06, 0x1C, 0x60, 0x00, 0x61, 0xC6, 0x00, 0x06, 0x1C, 0x30,
  0x00, 0xC1, 0xC3, 0x00, 0x0C, 0x1C, 0x10, 0x01, 0x81, 0xC1, 0x80, 0x18,
  0x1C, 0x18, 0x01, 0x01, 0xC0, 0xC0, 0x30, 0x1C, 0x0C, 0x03, 0x01, 0xC0,
  0x40, 0x60, 0x1C, 0x06, 0x06, 0x01, 0xC0, 0x60, 0x40, 0x1C, 0x02, 0x0C,
  0x01, 0xC0, 0x30, 0xC0, 0x1C, 0x03, 0x18, 0x01, 0xC0, 0x19, 0x80, 0x1C,
  0x01, 0x90, 0x01, 0xC0, 0x0B, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x0E,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x39, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0x60, 0x00, 0x03, 0x82, 0x00, 0x00,
  0x38, 0x30, 0x00, 0x03, 0x81, 0x00, 0x00, 0x38, 0x18, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x02, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x38, 0x01, 0x00, 0x03, 0x80, 0x18, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x02,
  0x00, 0x38, 0x00, 0x30, 0x03, 0x80, 0x01, 0x00, 0x38, 0x00, 0x18, 0x03,
  0x80, 0x00, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x30, 0x38, 0x00, 0x01, 0x03, 0x80, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x83, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x06, 0x38, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0x38, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x19, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x42, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x60, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x1E, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x20, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x60, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x30,
  0x00, 0x1E, 0x01, 0x80, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0xC3,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x0C, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0x60, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x80, 0x00, 0x01,
  0x87, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x1E, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x18, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x06,
  0x03, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x20, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x20, 0x0C, 0x00, 0x00, 0x18, 0x04, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x81, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x18, 0x40, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0x20, 0x00,
  0x70, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x04, 0xC0, 0x01, 0x40, 0x01, 0x98,
  0x00, 0x6C, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00,
  0x84, 0x00, 0x36, 0x00, 0x10, 0x80, 0x04, 0x40, 0x02, 0x18, 0x01, 0x8C,
  0x00, 0xC3, 0x00, 0x31, 0x80, 0x18, 0x60, 0x06, 0x30, 0x03, 0x0C, 0x00,
  0xC6, 0x00, 0x60, 0x80, 0x10, 0x40, 0x08, 0x10, 0x06, 0x0C, 0x01, 0x03,
  0x00, 0xC1, 0x80, 0x60, 0x60, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x06, 0x01,
  0x81, 0x80, 0x40, 0x40, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0x60, 0x60, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x81,
  0x00, 0x40, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x82, 0x00,
  0x41, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x06, 0x08, 0x01, 0x84, 0x00, 0x43,
  0x00, 0x31, 0x80, 0x0C, 0x60, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x31, 0x00, 0x08, 0xC0, 0x06, 0x20, 0x01, 0x10, 0x00, 0xC4, 0x00, 0x36,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xD0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x01, 0x80, 0x60, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x18,
  0x00, 0x00, 0x70, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x18,
  0x06, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x03, 0x00, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x80, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x03, 0x30, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x61, 0x80, 0x01, 0x83,
  0x00, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0x00, 0x01, 0x86,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x07, 0x80,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x60, 0xF0, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x1E, 0xC0, 0x00, 0x03, 0x66, 0x00, 0x00, 0x76, 0x30, 0x00,
  0x0E, 0x61, 0xC0, 0x03, 0x86, 0x0F, 0x01, 0xF0, 0x30, 0x7F, 0xFC, 0x03,
  0x00, 0x74, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x03, 0x00, 0x06, 0x07, 0xFE, 0x00, 0xC3, 0xE0,
  0xF0, 0x18, 0xE0, 0x07, 0x83, 0x30, 0x00, 0x38, 0x6C, 0x00, 0x03, 0x0F,
  0x00, 0x00, 0x31, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCF, 0x00, 0x00, 0x31,
  0xF0, 0x00, 0x0C, 0x37, 0x00, 0x03, 0x86, 0x70, 0x00, 0xE0, 0xC3, 0xC0,
  0xF0, 0x18, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x60,
  0x00, 0x70, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0x71, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x0E, 0x00, 0x03,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x40, 0x04, 0x03, 0xFF, 0x01, 0x03, 0xE0, 0xF0, 0x41, 0xC0, 0x07,
  0x10, 0xE0, 0x00, 0xE4, 0x70, 0x00, 0x1D, 0x18, 0x00, 0x03, 0x4C, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x58, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x18, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xD0, 0xE0, 0x00, 0x64, 0x1C,
  0x00, 0x71, 0x03, 0xC0, 0xF8, 0x40, 0x3F, 0xF8, 0x10, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0x38, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF0, 0x10,
  0x1E, 0x0F, 0x04, 0x1C, 0x00, 0x71, 0x0E, 0x00, 0x0E, 0x47, 0x00, 0x01,
  0xD1, 0x80, 0x00, 0x34, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x50, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x0D, 0x0C, 0x00, 0x06, 0x41, 0xC0, 0x07, 0x10, 0x3C, 0x0F, 0x84, 0x03,
  0xFF, 0x81, 0x00, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x18, 0x40, 0x00, 0x06, 0x30, 0x00, 0x03, 0x07, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0xC0, 0x1E, 0x00, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x20,
  0x03, 0x00, 0xFF, 0xC0, 0xC0, 0xF0, 0x3C, 0x30, 0xE0, 0x03, 0x8C, 0x70,
  0x00, 0x73, 0x30, 0x00, 0x0C, 0xD8, 0x00, 0x01, 0xB4, 0x00, 0x00, 0x6F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x70, 0x60,
  0x00, 0x1C, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x03, 0x80, 0x03, 0x00,
  0xE0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x06, 0x36, 0x00, 0x00, 0xDC, 0x60, 0x00, 0x1F, 0x06,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x00, 0xE0, 0x01,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC6, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x1C, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x00,
  0x60, 0x21, 0xFF, 0x01, 0xFF, 0x08, 0xE0, 0xE0, 0xF0, 0xF2, 0x60, 0x0C,
  0x60, 0x0C, 0xB0, 0x01, 0xB0, 0x01, 0xA8, 0x00, 0x78, 0x00, 0x6E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x30, 0x1F, 0xFC,
  0x0C, 0x1F, 0x07, 0xC3, 0x0E, 0x00, 0x38, 0xC7, 0x00, 0x07, 0x33, 0x00,
  0x00, 0xCD, 0x80, 0x00, 0x1B, 0x40, 0x00, 0x06, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x03,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0x1F, 0xF8, 0x03, 0x0F, 0x83, 0xC0, 0x63, 0x80, 0x1C, 0x0C,
  0xC0, 0x00, 0xC1, 0xB0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x18, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0xB0, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x30, 0xDC, 0x00,
  0x0C, 0x19, 0xC0, 0x03, 0x03, 0x0F, 0x03, 0xC0, 0x60, 0x7F, 0xF0, 0x0C,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x3F, 0xF0, 0x10, 0x3E, 0x0F, 0x04, 0x1C, 0x00, 0x71, 0x0E, 0x00, 0x0E,
  0x47, 0x00, 0x01, 0xD1, 0x80, 0x00, 0x34, 0xC0, 0x00, 0x07, 0x30, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x50, 0x00, 0x00, 0x16, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x0D, 0x0E, 0x00, 0x06, 0x41, 0xC0, 0x07, 0x10, 0x3C,
  0x0F, 0x84, 0x03, 0xFF, 0x81, 0x00, 0x0E, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0xC2, 0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0xE0, 0xF0, 0x00, 0x87,
  0x00, 0x02, 0x30, 0x00, 0x09, 0x80, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x83,
  0xF0, 0x07, 0x00, 0x07, 0x81, 0x80, 0x00, 0x38, 0x60, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0x3F, 0x01,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFA, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60,
  0x00, 0x03, 0xD8, 0x00, 0x00, 0xF3, 0x00, 0x00, 0x6C, 0x60, 0x00, 0x33,
  0x1C, 0x00, 0x38, 0xC1, 0xE0, 0x7C, 0x30, 0x3F, 0xFC, 0x0C, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x06,
  0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30, 0x0C,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x36, 0x00, 0x06, 0x00, 0x02, 0x60, 0x00, 0x60, 0x00, 0x66, 0x00,
  0x0F, 0x00, 0x06, 0x60, 0x00, 0xF0, 0x00, 0x63, 0x00, 0x0D, 0x00, 0x04,
  0x30, 0x00, 0x90, 0x00, 0xC3, 0x00, 0x19, 0x80, 0x0C, 0x30, 0x01, 0x98,
  0x00, 0xC1, 0x00, 0x19, 0x80, 0x0C, 0x18, 0x01, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0xC0, 0x18, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x80, 0x30, 0xC0, 0x18,
  0x0C, 0x02, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x60, 0x30, 0x0C, 0x06, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x60, 0x30, 0x06, 0x04, 0x03, 0x02, 0x00, 0x60,
  0xC0, 0x30, 0x60, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x10, 0x60,
  0x02, 0x08, 0x01, 0x86, 0x00, 0x31, 0x80, 0x18, 0x40, 0x03, 0x18, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x01, 0x10, 0x00, 0xCC, 0x00, 0x1B,
  0x00, 0x0C, 0x80, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x1A, 0x00, 0x05, 0x80,
  0x01, 0xA0, 0x00, 0x58, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x03, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x60, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x07, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03,
  0x0C, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x06, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x60, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xC0, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x70, 0x3C, 0x00,
  0x01, 0x98, 0x01, 0xC0, 0x00, 0x33, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00,
  0xC0, 0x01, 0x98, 0x00, 0x0C, 0x00, 0x32, 0x00, 0x00, 0xE0, 0x0C, 0xC0,
  0x00, 0x0F, 0x07, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00,
};

const GFXglyph RobotoMono_Thin66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 4, 47, 40, 17, -47 },
  { 25, 11, 14, 40, 14, -50 },
  { 45, 36, 47, 40, 2, -47 },
  { 257, 28, 61, 40, 6, -54 },
  { 471, 37, 49, 40, 1, -48 },
  { 698, 33, 49, 40, 5, -48 },
  { 901, 2, 14, 40, 17, -50 },
  { 905, 14, 67, 40, 13, -52 },
  { 1023, 14, 67, 40, 12, -52 },
  { 1141, 28, 26, 40, 7, -47 },
  { 1232, 32, 34, 40, 4, -39 },
  { 1368, 5, 13, 40, 13, -5 },
  { 1377, 23, 1, 40, 8, -22 },
  { 1380, 4, 4, 40, 19, -4 },
  { 1382, 21, 51, 40, 10, -47 },
  { 1516, 28, 49, 40, 6, -48 },
  { 1688, 16, 47, 40, 7, -47 },
  { 1782, 29, 48, 40, 4, -48 },
  { 1956, 29, 49, 40, 3, -48 },
  { 2134, 33, 47, 40, 3, -47 },
  { 2328, 28, 48, 40, 7, -47 },
  { 2496, 29, 49, 40, 5, -48 },
  { 2674, 30, 47, 40, 4, -47 },
  { 2851, 30, 49, 40, 6, -48 },
  { 3035, 29, 49, 40, 5, -48 },
  { 3213, 4, 32, 40, 21, -32 },
  { 3229, 7, 40, 40, 18, -32 },
  { 3264, 28, 26, 40, 5, -34 },
  { 3355, 28, 15, 40, 6, -29 },
  { 3408, 28, 26, 40, 6, -35 },
  { 3499, 24, 48, 40, 8, -48 },
  { 3643, 36, 47, 40, 2, -47 },
  { 3855, 33, 47, 40, 4, -47 },
  { 4049, 28, 47, 40, 7, -47 },
  { 4214, 30, 49, 40, 5, -48 },
  { 4398, 30, 47, 40, 6, -47 },
  { 4575, 27, 47, 40, 7, -47 },
  { 4734, 27, 47, 40, 7, -47 },
  { 4893, 31, 49, 40, 4, -48 },
  { 5083, 28, 47, 40, 6, -47 },
  { 5248, 26, 47, 40, 7, -47 },
  { 5401, 28, 48, 40, 4, -47 },
  { 5569, 31, 47, 40, 7, -47 },
  { 5752, 26, 47, 40, 8, -47 },
  { 5905, 28, 47, 40, 6, -47 },
  { 6070, 28, 47, 40, 6, -47 },
  { 6235, 30, 49, 40, 5, -48 },
  { 6419, 28, 47, 40, 8, -47 },
  { 6584, 32, 56, 40, 4, -48 },
  { 6808, 29, 47, 40, 7, -47 },
  { 6979, 30, 49, 40, 5, -48 },
  { 7163, 32, 47, 40, 4, -47 },
  { 7351, 28, 48, 40, 6, -47 },
  { 7519, 33, 47, 40, 3, -47 },
  { 7713, 35, 47, 40, 3, -47 },
  { 7919, 33, 47, 40, 4, -47 },
  { 8113, 33, 47, 40, 3, -47 },
  { 8307, 29, 47, 40, 5, -47 },
  { 8478, 10, 64, 40, 15, -54 },
  { 8558, 22, 51, 40, 9, -47 },
  { 8699, 9, 64, 40, 15, -54 },
  { 8771, 23, 26, 40, 8, -47 },
  { 8846, 27, 2, 40, 6, 0 },
  { 8853, 8, 9, 40, 16, -49 },
  { 8862, 28, 37, 40, 6, -36 },
  { 8992, 27, 51, 40, 7, -50 },
  { 9165, 27, 37, 40, 6, -36 },
  { 9290, 26, 51, 40, 6, -50 },
  { 9456, 29, 37, 40, 5, -36 },
  { 9591, 29, 50, 40, 7, -50 },
  { 9773, 26, 50, 40, 6, -36 },
  { 9936, 26, 50, 40, 7, -50 },
  { 10099, 27, 47, 40, 8, -47 },
  { 10258, 20, 61, 40, 6, -47 },
  { 10411, 27, 50, 40, 8, -50 },
  { 10580, 27, 50, 40, 8, -50 },
  { 10749, 34, 36, 40, 3, -36 },
  { 10902, 26, 36, 40, 7, -36 },
  { 11019, 30, 37, 40, 5, -36 },
  { 11158, 27, 49, 40, 7, -36 },
  { 11324, 26, 49, 40, 6, -36 },
  { 11484, 22, 36, 40, 13, -36 },
  { 11583, 27, 37, 40, 7, -36 },
  { 11708, 27, 45, 40, 6, -44 },
  { 11860, 26, 36, 40, 7, -35 },
  { 11977, 32, 35, 40, 4, -35 },
  { 12117, 36, 35, 40, 2, -35 },
  { 12275, 31, 35, 40, 5, -35 },
  { 12411, 34, 49, 40, 3, -35 },
  { 12620, 32, 35, 40, 4, -35 },
  { 12760, 21, 65, 40, 11, -51 },
  { 12931, 2, 56, 40, 19, -47 },
  { 12945, 21, 65, 40, 11, -51 },
  { 13116, 35, 11, 40, 2, -25 },
};

const GFXfont RobotoMono_Thin66pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin66pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin66pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _ROBOTOMONO_THIN66PT7B_H_
