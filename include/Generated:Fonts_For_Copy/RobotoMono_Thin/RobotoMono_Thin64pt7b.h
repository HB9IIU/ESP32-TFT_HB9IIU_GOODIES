#ifndef _ROBOTOMONO_THIN64PT7B_H_
#define _ROBOTOMONO_THIN64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin64pt7bBitmaps[] PROGMEM = {
  0x00, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x44, 0x44, 0x44, 0x44, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFE,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00,
  0x20, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0x80, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x40, 0x02, 0x00, 0x00, 0x18, 0x00, 0x40, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0x00, 0x20, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x04, 0x00, 0x00, 0x30, 0x00, 0x80, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x18,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x01,
  0x00, 0x08, 0x00, 0x00, 0x60, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x00, 0x80, 0x04, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xC0, 0x00,
  0xE0, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x60,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x11, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x60,
  0x01, 0x00, 0x40, 0x06, 0x00, 0x30, 0x04, 0x00, 0x60, 0x03, 0x00, 0xC0,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x02, 0x00, 0xC0,
  0x0C, 0x00, 0x20, 0x0C, 0x00, 0xC0, 0x02, 0x01, 0x80, 0x04, 0x00, 0x60,
  0x10, 0x00, 0x60, 0x06, 0x03, 0x00, 0x06, 0x00, 0x60, 0x60, 0x00, 0x60,
  0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x18, 0x0C, 0x00,
  0x00, 0xFF, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x01, 0x80, 0x7F,
  0x00, 0x00, 0x18, 0x0E, 0x38, 0x00, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x30, 0x06, 0x00, 0x06, 0x03, 0x00, 0x60, 0x00, 0x60, 0x60, 0x02, 0x00,
  0x0C, 0x06, 0x00, 0x30, 0x00, 0x80, 0x60, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0x20, 0x08, 0x00, 0x30, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x18, 0x00, 0x04, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x04, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x03,
  0x03, 0x80, 0x00, 0x01, 0x86, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x18, 0x03, 0x80, 0x0C, 0x30,
  0x01, 0x80, 0x0C, 0x20, 0x00, 0xC0, 0x0C, 0x60, 0x00, 0x60, 0x0C, 0x40,
  0x00, 0x30, 0x08, 0xC0, 0x00, 0x18, 0x18, 0xC0, 0x00, 0x18, 0x18, 0xC0,
  0x00, 0x0C, 0x18, 0xC0, 0x00, 0x06, 0x30, 0xC0, 0x00, 0x03, 0x30, 0xC0,
  0x00, 0x01, 0xE0, 0x40, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x01, 0xE0, 0x30, 0x00, 0x03, 0x30, 0x18, 0x00, 0x06, 0x18, 0x0E,
  0x00, 0x1C, 0x0C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xFF, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x08, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x40, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x27, 0x00,
  0x60, 0x0F, 0xFE, 0x06, 0x07, 0xC0, 0xFC, 0x61, 0xF0, 0x01, 0xFE, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x03,
  0x00, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x06, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x11, 0x11, 0x11, 0x13, 0x36, 0x6C, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xF7, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B,
  0x40, 0x00, 0x03, 0x34, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x0C, 0x3C, 0x00,
  0x01, 0x83, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0,
  0x1C, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0,
  0x0C, 0x00, 0x1C, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x3C, 0x18, 0x00, 0x03, 0x43, 0x80, 0x00, 0x34,
  0x70, 0x00, 0x03, 0x6E, 0x00, 0x00, 0x37, 0xC0, 0x00, 0x03, 0x78, 0x00,
  0x00, 0x27, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0,
  0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xB0, 0x3C, 0x61, 0xE0, 0xDE, 0x01, 0xF0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x10, 0x80, 0x00, 0x00, 0x84, 0x00, 0x00, 0x04, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x70,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x61, 0xC0, 0x00,
  0x0C, 0x0E, 0x00, 0x01, 0x80, 0x70, 0x00, 0x70, 0x01, 0xE0, 0x3E, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x06, 0x03, 0x00, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xC7, 0xFF, 0x80, 0x1B, 0xC0, 0x7C, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x1C, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x21, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x30, 0x00, 0x18,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x1F,
  0xC0, 0x04, 0x0F, 0xFF, 0x00, 0x43, 0xC0, 0x3C, 0x0C, 0x70, 0x00, 0xE0,
  0xCC, 0x00, 0x03, 0x0D, 0x80, 0x00, 0x18, 0xF0, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xE0, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x04,
  0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x06, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x13, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x14, 0x00, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x01,
  0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0x60,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0x38, 0x18, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x0F, 0x30, 0x00, 0x00, 0xB1, 0x80, 0x00, 0x1B, 0x1C, 0x00, 0x03, 0x30,
  0xE0, 0x00, 0xE3, 0x07, 0x00, 0x1C, 0x20, 0x1F, 0x1F, 0x02, 0x00, 0x7F,
  0xC0, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x2F, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0xFF, 0x60, 0x08, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x04, 0x10,
  0x41, 0x04, 0x30, 0xC3, 0x18, 0x63, 0x08, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x38, 0x03, 0x80, 0xC0,
  0x01, 0x83, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x60, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x30, 0x60,
  0x07, 0xF8, 0x02, 0x0C, 0x01, 0xC3, 0x80, 0x63, 0x00, 0x60, 0x38, 0x0C,
  0x60, 0x18, 0x03, 0x01, 0x98, 0x06, 0x00, 0x60, 0x33, 0x00, 0xC0, 0x08,
  0x02, 0x60, 0x30, 0x01, 0x00, 0x48, 0x06, 0x00, 0x20, 0x0F, 0x00, 0x80,
  0x04, 0x01, 0xE0, 0x30, 0x01, 0x80, 0x3C, 0x06, 0x00, 0x30, 0x07, 0x80,
  0xC0, 0x06, 0x00, 0xF0, 0x18, 0x00, 0xC0, 0x1C, 0x02, 0x00, 0x18, 0x03,
  0x80, 0x40, 0x03, 0x00, 0x50, 0x08, 0x00, 0x40, 0x0A, 0x01, 0x00, 0x08,
  0x03, 0x40, 0x20, 0x03, 0x00, 0x68, 0x04, 0x00, 0x60, 0x0D, 0x80, 0x80,
  0x1C, 0x01, 0xB0, 0x18, 0x03, 0x80, 0x26, 0x03, 0x00, 0xD0, 0x0C, 0xC0,
  0x60, 0x1B, 0x01, 0x98, 0x04, 0x06, 0x60, 0x61, 0x00, 0xC1, 0x8C, 0x1C,
  0x30, 0x0E, 0xE0, 0xEF, 0x06, 0x00, 0xF8, 0x0F, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x06, 0x40,
  0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x0C, 0x20,
  0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x10,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x06,
  0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x03, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01,
  0x80, 0x03, 0x00, 0x00, 0xC0, 0x02, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x60, 0x07, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00,
  0x60, 0x0C, 0x00, 0x00, 0x20, 0x08, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0x10, 0x10, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x08, 0x20, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0x04, 0x40, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x02,
  0x00, 0x0F, 0xC0, 0x40, 0x00, 0x1C, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00,
  0x0C, 0x20, 0x00, 0x00, 0xC4, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00,
  0x19, 0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x03, 0x10, 0x00, 0x00, 0x62, 0x00, 0x00, 0x18, 0x40, 0x00, 0x06,
  0x08, 0x00, 0x03, 0x81, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x10, 0x00, 0x00, 0xE2, 0x00, 0x00, 0x0E,
  0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0x90,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x38, 0x40, 0x00, 0x1E, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x32, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x00, 0x41, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xF8,
  0x01, 0x80, 0x00, 0xF0, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0x03,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x0E, 0x01, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE3, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x60, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x60, 0x70, 0x00, 0x18, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x30, 0x03, 0x80,
  0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x30, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x0C,
  0x36, 0x00, 0x00, 0x31, 0x8C, 0x00, 0x00, 0xCC, 0x30, 0x00, 0x03, 0x60,
  0x60, 0x00, 0x0F, 0x00, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80,
  0x30, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x00, 0x70, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xD0, 0x00, 0x00, 0x5B, 0x00, 0x00, 0x1B, 0x60,
  0x00, 0x03, 0x66, 0x00, 0x00, 0xCC, 0xC0, 0x00, 0x19, 0x88, 0x00, 0x06,
  0x31, 0x80, 0x00, 0xC6, 0x30, 0x00, 0x18, 0xC3, 0x00, 0x06, 0x18, 0x60,
  0x00, 0xC3, 0x8C, 0x00, 0x30, 0x70, 0xC0, 0x06, 0x0E, 0x18, 0x00, 0x81,
  0xC1, 0x00, 0x30, 0x38, 0x30, 0x06, 0x07, 0x06, 0x01, 0x80, 0xE0, 0x60,
  0x30, 0x1C, 0x0C, 0x04, 0x03, 0x80, 0x81, 0x80, 0x70, 0x18, 0x30, 0x0E,
  0x03, 0x0C, 0x01, 0xC0, 0x21, 0x80, 0x38, 0x06, 0x20, 0x07, 0x00, 0xCC,
  0x00, 0xE0, 0x0D, 0x80, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3A, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x70, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC1, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x07, 0x03, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x80, 0x40, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x00, 0x80, 0x01, 0xC0, 0x18,
  0x00, 0x38, 0x01, 0x80, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x20, 0x03, 0x80, 0x06, 0x00, 0x70, 0x00, 0x40, 0x0E, 0x00, 0x0C,
  0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x10, 0x1C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x20, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x13, 0x80, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x04, 0x06, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x01, 0x08,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00,
  0x30, 0x40, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x02, 0x00, 0x03,
  0xE0, 0x40, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x71, 0x00, 0x00, 0x06, 0x20,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x68, 0x00,
  0x00, 0x19, 0x00, 0x00, 0x07, 0x20, 0x00, 0x01, 0xC4, 0x00, 0x00, 0x70,
  0x80, 0x00, 0x78, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x40, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x00, 0x10, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x01, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x04, 0x80,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x42, 0x00,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0xF0, 0x0C, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0xC0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF0, 0x03,
  0xC0, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x02, 0x30, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x40, 0x00, 0x00, 0x34, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x43, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38,
  0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x20, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x10, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x04, 0x00,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x20, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x40, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x06, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0x10, 0x08, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x04, 0x20, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0B, 0x00,
  0x03, 0x00, 0x02, 0x40, 0x01, 0xE0, 0x00, 0x90, 0x00, 0x78, 0x00, 0x66,
  0x00, 0x1E, 0x00, 0x19, 0x80, 0x05, 0x80, 0x06, 0x60, 0x01, 0x20, 0x01,
  0x18, 0x00, 0xC8, 0x00, 0x42, 0x00, 0x33, 0x00, 0x10, 0x80, 0x0C, 0xC0,
  0x0C, 0x30, 0x02, 0x30, 0x03, 0x0C, 0x00, 0x84, 0x00, 0xC3, 0x00, 0x61,
  0x00, 0x20, 0xC0, 0x18, 0x60, 0x08, 0x10, 0x06, 0x18, 0x02, 0x04, 0x01,
  0x06, 0x01, 0x81, 0x80, 0x41, 0x80, 0x60, 0x60, 0x30, 0x20, 0x18, 0x18,
  0x0C, 0x0C, 0x04, 0x06, 0x03, 0x03, 0x01, 0x00, 0x80, 0x80, 0xC0, 0x40,
  0x20, 0x20, 0x30, 0x30, 0x08, 0x18, 0x04, 0x0C, 0x03, 0x06, 0x01, 0x83,
  0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x40, 0x18, 0x20, 0x0C, 0x10, 0x06,
  0x08, 0x01, 0x0C, 0x00, 0x86, 0x00, 0x43, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x88, 0x00, 0xC4, 0x00, 0x66,
  0x00, 0x11, 0x00, 0x09, 0x80, 0x06, 0x40, 0x02, 0x60, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x34, 0x00, 0x1B, 0x00, 0x0F, 0x00, 0x02, 0x80,
  0x03, 0xC0, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60,
  0x0C, 0x00, 0x00, 0x30, 0x08, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x30, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30,
  0x18, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0x60, 0x04, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x30,
  0x08, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x08,
  0x30, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x04, 0x60, 0x00, 0x00, 0x06,
  0x40, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0F, 0xFF, 0xFC, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x1F, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x21, 0x80, 0x01, 0x86, 0x00, 0x04, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0x60, 0x06, 0x01, 0x80, 0x18, 0x02, 0x00, 0x40, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x02, 0x04, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x03, 0xC0,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x30, 0x30,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x18, 0x70, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x0D, 0x9C, 0x00,
  0x07, 0x31, 0xC0, 0x01, 0xC6, 0x1E, 0x01, 0xE0, 0x60, 0xFF, 0xF0, 0x0C,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x0F, 0xF8, 0x03, 0x0F, 0x07, 0x80, 0xC6, 0x00, 0x38, 0x33,
  0x00, 0x07, 0x0D, 0x80, 0x00, 0xC3, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x63,
  0xC0, 0x00, 0x38, 0xD8, 0x00, 0x1C, 0x33, 0x80, 0x0E, 0x0C, 0x78, 0x0F,
  0x03, 0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x58, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0x86, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x10,
  0x07, 0xFE, 0x04, 0x07, 0xC3, 0xC1, 0x03, 0x80, 0x1C, 0x41, 0x80, 0x01,
  0x90, 0xC0, 0x00, 0x34, 0x60, 0x00, 0x05, 0x18, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x60, 0x00, 0x00, 0x58,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00,
  0x50, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x16, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01,
  0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x31, 0x80, 0x00, 0x1C, 0x30, 0x00,
  0x0D, 0x06, 0x00, 0x07, 0x40, 0xC0, 0x03, 0x10, 0x1E, 0x07, 0x84, 0x03,
  0xFF, 0x81, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20,
  0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0xC0, 0x3C, 0x00, 0x38, 0x00, 0xF0,
  0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x10, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x81, 0xF0, 0xF0, 0x41, 0xC0, 0x0E, 0x21, 0x80,
  0x01, 0x91, 0x80, 0x00, 0x69, 0x80, 0x00, 0x14, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x33, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x34, 0x30,
  0x00, 0x3A, 0x0C, 0x00, 0x39, 0x03, 0xC0, 0xF0, 0x80, 0xFF, 0xE0, 0x40,
  0x03, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0x10, 0x00, 0x01,
  0x8C, 0x00, 0x01, 0x83, 0x80, 0x01, 0x80, 0xE0, 0x03, 0x80, 0x3C, 0x07,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x01, 0xFF, 0x81, 0x03, 0xE0, 0xF0, 0x83, 0x80, 0x1C,
  0x43, 0x00, 0x03, 0x23, 0x00, 0x01, 0x93, 0x00, 0x00, 0x6B, 0x00, 0x00,
  0x15, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x3B, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x1C, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0xE0,
  0x00, 0x0C, 0xCC, 0x00, 0x03, 0x61, 0x80, 0x00, 0xF0, 0x30, 0x00, 0x30,
  0x06, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x30, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x47, 0x0F,
  0x0F, 0x0E, 0x26, 0x01, 0xCC, 0x01, 0x96, 0x00, 0x6C, 0x00, 0x6E, 0x00,
  0x14, 0x00, 0x36, 0x00, 0x0E, 0x00, 0x0B, 0x00, 0x06, 0x00, 0x07, 0x80,
  0x03, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x80, 0x7F, 0xE0, 0x40, 0xF8, 0x3C, 0x20, 0xE0, 0x07,
  0x10, 0xC0, 0x01, 0xC8, 0xC0, 0x00, 0x64, 0xC0, 0x00, 0x1A, 0xC0, 0x00,
  0x0D, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x02, 0x60,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x18, 0x0C,
  0x00, 0x00, 0x60, 0x38, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0xFF, 0x80, 0x30, 0xF0, 0x78, 0x0C, 0xE0, 0x03, 0x83,
  0x70, 0x00, 0x70, 0xF8, 0x00, 0x0C, 0x3C, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x06,
  0x3C, 0x00, 0x03, 0x0D, 0x80, 0x01, 0xC3, 0x38, 0x00, 0xE0, 0xC7, 0x80,
  0xE0, 0x30, 0x7F, 0xF0, 0x0C, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x81, 0xF0, 0xF8, 0x41, 0xC0, 0x0E, 0x21, 0x80, 0x03, 0x91,
  0x80, 0x00, 0x69, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x40, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x34, 0x30, 0x00, 0x3A,
  0x0C, 0x00, 0x39, 0x03, 0xC0, 0xF0, 0x80, 0xFF, 0xE0, 0x40, 0x03, 0x00,
  0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x02, 0xC0, 0x1F, 0xFF, 0x03, 0xF0, 0x2C, 0x1C, 0x00, 0x31, 0xC0,
  0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x11,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x60, 0x70, 0x00, 0x38,
  0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xEC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x79, 0x80, 0x00, 0x6C, 0xE0, 0x00, 0x66, 0x38,
  0x00, 0xE3, 0x0F, 0x01, 0xE1, 0x81, 0xFF, 0xC0, 0xC0, 0x0D, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x10, 0x18, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x20, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x30,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0xA0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x68, 0x00, 0x1C, 0x00, 0x19, 0x80, 0x03, 0x80,
  0x03, 0x30, 0x00, 0x50, 0x00, 0x66, 0x00, 0x0A, 0x00, 0x0C, 0x40, 0x03,
  0x60, 0x01, 0x0C, 0x00, 0x6C, 0x00, 0x61, 0x80, 0x0D, 0x80, 0x0C, 0x30,
  0x01, 0x10, 0x01, 0x82, 0x00, 0x63, 0x00, 0x20, 0x60, 0x0C, 0x60, 0x0C,
  0x0C, 0x01, 0x8C, 0x01, 0x81, 0x80, 0x20, 0x80, 0x30, 0x30, 0x0C, 0x18,
  0x04, 0x02, 0x01, 0x83, 0x01, 0x80, 0x60, 0x20, 0x60, 0x30, 0x0C, 0x04,
  0x04, 0x06, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x10, 0x30, 0x18, 0x10, 0x03,
  0x04, 0x03, 0x06, 0x00, 0x60, 0x80, 0x20, 0xC0, 0x0C, 0x30, 0x06, 0x18,
  0x00, 0x86, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x18, 0xC0, 0x03, 0x10, 0x01,
  0x18, 0x00, 0x66, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x40, 0x00, 0x90,
  0x00, 0xC8, 0x00, 0x1A, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x03, 0x80, 0x00, 0x1C,
  0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00, 0x01,
  0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x01, 0x80,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x03, 0x03, 0x80, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x00, 0x60, 0x60, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x30, 0x18, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x06, 0x0C, 0x00,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xC3, 0xFF, 0x00,
  0x00, 0x31, 0x80, 0xF0, 0x00, 0x0C, 0xC0, 0x0E, 0x00, 0x03, 0x60, 0x01,
  0xC0, 0x00, 0x98, 0x00, 0x38, 0x00, 0x64, 0x00, 0x03, 0x00, 0x33, 0x00,
  0x00, 0x70, 0x1C, 0xC0, 0x00, 0x0F, 0xFE, 0x30, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph RobotoMono_Thin64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 4, 46, 38, 17, -46 },
  { 24, 10, 13, 38, 14, -48 },
  { 41, 35, 46, 38, 2, -46 },
  { 243, 27, 59, 38, 6, -52 },
  { 443, 36, 47, 38, 1, -46 },
  { 655, 32, 47, 38, 5, -46 },
  { 843, 2, 13, 38, 17, -48 },
  { 847, 13, 66, 38, 13, -51 },
  { 955, 14, 66, 38, 11, -51 },
  { 1071, 28, 25, 38, 6, -46 },
  { 1159, 31, 33, 38, 4, -38 },
  { 1287, 4, 13, 38, 13, -5 },
  { 1294, 22, 2, 38, 8, -22 },
  { 1300, 4, 4, 38, 18, -4 },
  { 1302, 20, 50, 38, 10, -46 },
  { 1427, 28, 47, 38, 5, -46 },
  { 1592, 15, 46, 38, 7, -46 },
  { 1679, 29, 46, 38, 3, -46 },
  { 1846, 28, 47, 38, 3, -46 },
  { 2011, 32, 46, 38, 3, -46 },
  { 2195, 27, 47, 38, 7, -46 },
  { 2354, 28, 47, 38, 5, -46 },
  { 2519, 29, 46, 38, 4, -46 },
  { 2686, 29, 47, 38, 6, -46 },
  { 2857, 28, 47, 38, 5, -46 },
  { 3022, 4, 31, 38, 20, -31 },
  { 3038, 6, 39, 38, 18, -31 },
  { 3068, 27, 25, 38, 5, -33 },
  { 3153, 28, 14, 38, 5, -28 },
  { 3202, 27, 26, 38, 6, -34 },
  { 3290, 23, 46, 38, 8, -46 },
  { 3423, 35, 46, 38, 2, -46 },
  { 3625, 32, 46, 38, 4, -46 },
  { 3809, 27, 46, 38, 7, -46 },
  { 3965, 30, 47, 38, 4, -46 },
  { 4142, 29, 46, 38, 6, -46 },
  { 4309, 26, 46, 38, 7, -46 },
  { 4459, 26, 46, 38, 7, -46 },
  { 4609, 30, 47, 38, 4, -46 },
  { 4786, 27, 46, 38, 6, -46 },
  { 4942, 25, 46, 38, 7, -46 },
  { 5086, 27, 47, 38, 4, -46 },
  { 5245, 30, 46, 38, 7, -46 },
  { 5418, 25, 46, 38, 8, -46 },
  { 5562, 27, 46, 38, 6, -46 },
  { 5718, 27, 46, 38, 6, -46 },
  { 5874, 30, 47, 38, 4, -46 },
  { 6051, 27, 46, 38, 8, -46 },
  { 6207, 31, 54, 38, 4, -46 },
  { 6417, 28, 46, 38, 7, -46 },
  { 6578, 29, 47, 38, 5, -46 },
  { 6749, 32, 46, 38, 3, -46 },
  { 6933, 28, 47, 38, 5, -46 },
  { 7098, 32, 46, 38, 3, -46 },
  { 7282, 34, 46, 38, 3, -46 },
  { 7478, 32, 46, 38, 4, -46 },
  { 7662, 32, 46, 38, 3, -46 },
  { 7846, 29, 46, 38, 4, -46 },
  { 8013, 9, 62, 38, 15, -52 },
  { 8083, 21, 50, 38, 9, -46 },
  { 8215, 9, 62, 38, 14, -52 },
  { 8285, 22, 25, 38, 8, -46 },
  { 8354, 26, 2, 38, 6, 0 },
  { 8361, 8, 8, 38, 15, -47 },
  { 8369, 27, 35, 38, 6, -34 },
  { 8488, 26, 49, 38, 7, -48 },
  { 8648, 26, 35, 38, 6, -34 },
  { 8762, 26, 49, 38, 5, -48 },
  { 8922, 28, 35, 38, 5, -34 },
  { 9045, 28, 49, 38, 7, -49 },
  { 9217, 25, 48, 38, 6, -34 },
  { 9367, 25, 48, 38, 7, -48 },
  { 9517, 27, 46, 38, 7, -46 },
  { 9673, 19, 60, 38, 6, -46 },
  { 9816, 26, 48, 38, 8, -48 },
  { 9972, 27, 48, 38, 7, -48 },
  { 10134, 33, 34, 38, 3, -34 },
  { 10275, 25, 34, 38, 7, -34 },
  { 10382, 30, 35, 38, 4, -34 },
  { 10514, 26, 47, 38, 7, -34 },
  { 10667, 25, 47, 38, 6, -34 },
  { 10814, 22, 34, 38, 12, -34 },
  { 10908, 27, 35, 38, 6, -34 },
  { 11027, 26, 44, 38, 6, -43 },
  { 11170, 25, 35, 38, 7, -34 },
  { 11280, 31, 34, 38, 4, -34 },
  { 11412, 35, 34, 38, 2, -34 },
  { 11561, 30, 34, 38, 5, -34 },
  { 11689, 33, 48, 38, 3, -34 },
  { 11887, 31, 34, 38, 4, -34 },
  { 12019, 20, 64, 38, 11, -50 },
  { 12179, 2, 54, 38, 18, -46 },
  { 12193, 20, 64, 38, 11, -50 },
  { 12353, 34, 10, 38, 2, -24 },
};

const GFXfont RobotoMono_Thin64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin64pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_THIN64PT7B_H_
