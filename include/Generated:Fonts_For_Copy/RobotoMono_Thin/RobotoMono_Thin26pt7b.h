#ifndef _ROBOTOMONO_THIN26PT7B_H_
#define _ROBOTOMONO_THIN26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF8, 0x40, 0x99, 0x99, 0x99, 0x04, 0x10, 0x10, 0x80, 0x42,
  0x01, 0x08, 0x04, 0x21, 0xEF, 0xF0, 0x82, 0x02, 0x10, 0x08, 0x40, 0x21,
  0x01, 0x04, 0x04, 0x10, 0xFF, 0xF8, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20,
  0x80, 0x82, 0x00, 0x02, 0x00, 0x20, 0x0F, 0x01, 0x0C, 0x20, 0x24, 0x02,
  0x40, 0x24, 0x01, 0x40, 0x02, 0x00, 0x10, 0x00, 0xE0, 0x01, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x80, 0x14, 0x01, 0x40, 0x22, 0x06, 0x1D, 0x80, 0x20,
  0x02, 0x00, 0x20, 0x70, 0x02, 0x20, 0x08, 0x82, 0x21, 0x08, 0x84, 0x42,
  0x11, 0x08, 0x48, 0x22, 0x20, 0x71, 0x00, 0x08, 0x00, 0x20, 0x01, 0x1E,
  0x04, 0x84, 0x22, 0x10, 0x88, 0x44, 0x21, 0x30, 0x84, 0x02, 0x10, 0x07,
  0x80, 0x0E, 0x00, 0x88, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10, 0x80, 0x88,
  0x02, 0x80, 0x18, 0x00, 0xC0, 0x09, 0x00, 0x84, 0x28, 0x11, 0x40, 0x8A,
  0x02, 0x50, 0x0C, 0x80, 0x22, 0x04, 0x8F, 0xC2, 0xFC, 0x04, 0x21, 0x08,
  0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10,
  0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x84, 0x10, 0x42, 0x08, 0x42, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0x08, 0x44, 0x42, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x62, 0x73, 0xF0, 0x18, 0x04, 0x80, 0x88, 0x20, 0x88,
  0x10, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0xFF, 0xF0,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x55, 0x80, 0xFF,
  0x80, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x0F, 0x03,
  0x08, 0x20, 0x44, 0x02, 0x40, 0x28, 0x02, 0x80, 0x58, 0x09, 0x81, 0x18,
  0x21, 0x84, 0x18, 0x81, 0x90, 0x1A, 0x02, 0x40, 0x24, 0x02, 0x40, 0x42,
  0x04, 0x1F, 0x80, 0x1D, 0x98, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x07, 0x03, 0x08, 0x40, 0x44, 0x02, 0x80,
  0x28, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x7F, 0xF0, 0x06, 0x03,
  0x0C, 0x20, 0x24, 0x02, 0x40, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0xC0,
  0xF0, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x40, 0x22,
  0x06, 0x1F, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x04, 0x80, 0x24, 0x02,
  0x20, 0x21, 0x01, 0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x80, 0x8F, 0xFF,
  0x80, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x7F, 0xC8, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x17, 0x83, 0x0C, 0x40, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x12, 0x02, 0x40, 0x87, 0xE0, 0x03, 0x81,
  0x80, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x04, 0xFC, 0xA0, 0x58, 0x0A,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x44, 0x08, 0x7E,
  0x00, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x07, 0x03, 0x0C, 0x40, 0x24, 0x02, 0x40, 0x14,
  0x01, 0x40, 0x24, 0x02, 0x30, 0x40, 0xF8, 0x30, 0xC4, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x12, 0x02, 0x1F, 0xC0, 0x0F, 0x06, 0x11,
  0x01, 0x20, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05, 0x01,
  0x90, 0x51, 0xF2, 0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x78, 0x00,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0x01, 0x24, 0xA0, 0x00, 0x20, 0x18,
  0x0C, 0x06, 0x07, 0x01, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0x80, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x40, 0x30, 0x18, 0x1C, 0x0C, 0x02, 0x00,
  0x00, 0x0C, 0x08, 0x44, 0x0A, 0x01, 0x80, 0x40, 0x10, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x03, 0xC0, 0x30, 0xC1, 0x01, 0x08, 0x02, 0x43, 0x89, 0x11, 0x18,
  0x84, 0x62, 0x11, 0x90, 0x46, 0x41, 0x19, 0x04, 0x64, 0x21, 0x90, 0x86,
  0x45, 0x28, 0xB5, 0x21, 0x08, 0x40, 0x00, 0x80, 0x81, 0xFC, 0x00, 0x06,
  0x00, 0x60, 0x09, 0x00, 0x90, 0x09, 0x01, 0x08, 0x10, 0x81, 0x08, 0x10,
  0x82, 0x04, 0x20, 0x42, 0x04, 0x5F, 0xA4, 0x02, 0x40, 0x28, 0x01, 0x80,
  0x18, 0x01, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x0C, 0xFF, 0x10, 0x12, 0x01, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x02,
  0x80, 0x9F, 0xE0, 0x07, 0x03, 0x08, 0x40, 0x44, 0x02, 0x80, 0x28, 0x01,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0xFF, 0x10, 0x12, 0x01,
  0x40, 0x28, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x81, 0x1F, 0xC0, 0xFF, 0xE0, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xA0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x07, 0x03, 0x0C, 0x40, 0x44,
  0x02, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x83, 0xE8,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x02, 0x1F, 0xC0,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x14, 0x02, 0x40, 0x87,
  0xE0, 0x80, 0x68, 0x04, 0x80, 0x88, 0x10, 0x82, 0x08, 0x40, 0x88, 0x09,
  0x00, 0xB0, 0x0C, 0x80, 0x84, 0x08, 0x20, 0x81, 0x08, 0x10, 0x80, 0x88,
  0x04, 0x80, 0x28, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x3C, 0x03, 0xA0, 0x5A, 0x05, 0xA0,
  0x99, 0x09, 0x90, 0x98, 0x91, 0x89, 0x18, 0xA1, 0x86, 0x18, 0x41, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x06, 0x80,
  0xD0, 0x19, 0x03, 0x20, 0x62, 0x0C, 0x21, 0x84, 0x30, 0x46, 0x08, 0xC0,
  0x98, 0x13, 0x01, 0x60, 0x1C, 0x03, 0x80, 0x30, 0x04, 0x0F, 0x03, 0x08,
  0x40, 0x44, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x40, 0x42, 0x04,
  0x1F, 0x80, 0xFF, 0x90, 0x0A, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x5F, 0xF2, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x00, 0x07, 0x03, 0x08, 0x40, 0x44, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x04, 0x00, 0x40, 0x03,
  0xFF, 0x10, 0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0x60, 0x14, 0x02, 0x80,
  0x9F, 0xE2, 0x08, 0x40, 0x88, 0x11, 0x01, 0x20, 0x24, 0x02, 0x80, 0x50,
  0x04, 0x0F, 0x03, 0x0C, 0x40, 0x24, 0x02, 0x80, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x80, 0x18,
  0x01, 0x40, 0x16, 0x02, 0x1F, 0xC0, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x50, 0x0A, 0x01, 0x20, 0x43,
  0xF0, 0xC0, 0x0A, 0x00, 0x50, 0x04, 0x80, 0x22, 0x01, 0x10, 0x10, 0x80,
  0x82, 0x04, 0x10, 0x40, 0x82, 0x02, 0x10, 0x11, 0x00, 0x88, 0x02, 0x40,
  0x14, 0x00, 0xA0, 0x03, 0x00, 0x10, 0x00, 0x81, 0x06, 0x0C, 0x14, 0x30,
  0x50, 0xC2, 0x42, 0x89, 0x12, 0x24, 0x48, 0x91, 0x22, 0x44, 0x88, 0x91,
  0x42, 0x85, 0x0A, 0x14, 0x28, 0x50, 0xA1, 0x42, 0x85, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x80, 0x14, 0x02, 0x20, 0x42, 0x04, 0x10, 0x80, 0x88,
  0x09, 0x00, 0x60, 0x02, 0x00, 0x60, 0x09, 0x00, 0x90, 0x10, 0x82, 0x04,
  0x20, 0x44, 0x02, 0x80, 0x18, 0x01, 0xC0, 0x0A, 0x00, 0x88, 0x04, 0x40,
  0x41, 0x02, 0x08, 0x20, 0x22, 0x01, 0x10, 0x05, 0x00, 0x28, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0xFF, 0xE0, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x1F,
  0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0xF0, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10,
  0x08, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0x01, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x0C,
  0x06, 0x04, 0x82, 0x42, 0x21, 0x09, 0x04, 0x81, 0x40, 0xC0, 0x40, 0xFF,
  0xE0, 0xC8, 0x80, 0x1F, 0x84, 0x09, 0x00, 0xA0, 0x10, 0x02, 0x00, 0x43,
  0xF9, 0x81, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x34, 0x0A, 0x7E, 0x40, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE3, 0x86, 0x80, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x2C, 0x0A, 0xFC,
  0x1F, 0x84, 0x09, 0x00, 0xA0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x01, 0x00, 0xA0, 0x12, 0x04, 0x3F, 0x00, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x47, 0xC9, 0x05, 0x40, 0x68, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x28, 0x04, 0x81, 0x8F, 0xD0,
  0x0F, 0x83, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x21, 0xFC, 0x03, 0xE0, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x3F, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x00, 0x1F, 0x24, 0x15, 0x01, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x05, 0x00, 0xA0, 0x12, 0x06, 0x3F, 0x40, 0x08, 0x01, 0x00,
  0x48, 0x08, 0xC6, 0x07, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x09, 0xF2, 0x82, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x04, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x83, 0xFF, 0x80, 0x01, 0x03, 0x00,
  0x00, 0x00, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0x0C, 0xE0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x14, 0x04, 0x81, 0x10, 0x42,
  0x30, 0x48, 0x0B, 0x01, 0x90, 0x21, 0x04, 0x10, 0x81, 0x10, 0x12, 0x02,
  0x40, 0x30, 0xFC, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x7F, 0xF0, 0xBC, 0x73, 0x0C, 0x28, 0x20, 0x60,
  0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18,
  0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x10, 0x9F, 0x28, 0x2C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x10, 0x0F, 0x02, 0x0C, 0x40, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x24, 0x02, 0x20, 0x41, 0xF8, 0x9E, 0x38,
  0x48, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x02, 0xC0, 0xAF, 0xC8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x1F, 0x24,
  0x15, 0x01, 0xA0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x05,
  0x00, 0xA0, 0x12, 0x06, 0x3F, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x8F, 0xD8, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x3F, 0x10, 0x28, 0x06, 0x01, 0x80, 0x10,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x10, 0x06, 0x01, 0xC0, 0x4F, 0xE0, 0x08,
  0x01, 0x00, 0x20, 0x7F, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x03, 0xE0, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x40, 0xCF, 0xD0, 0x80, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x22,
  0x02, 0x08, 0x10, 0x41, 0x02, 0x08, 0x08, 0x40, 0x44, 0x01, 0x20, 0x0A,
  0x00, 0x30, 0x01, 0x00, 0x82, 0x06, 0x0C, 0x18, 0x30, 0x90, 0xC2, 0x45,
  0x09, 0x12, 0x24, 0x48, 0x91, 0x24, 0x28, 0x90, 0xA1, 0x42, 0x85, 0x0A,
  0x18, 0x10, 0x20, 0x40, 0x80, 0x80, 0x14, 0x02, 0x20, 0x41, 0x08, 0x09,
  0x00, 0x90, 0x06, 0x00, 0x60, 0x09, 0x01, 0x10, 0x10, 0x82, 0x04, 0x40,
  0x28, 0x01, 0x80, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x22, 0x01, 0x10, 0x10,
  0x40, 0x82, 0x08, 0x08, 0x40, 0x44, 0x01, 0x20, 0x09, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x06, 0x00, 0x80, 0x00, 0xFF,
  0xE0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x03, 0x82, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x06, 0x0C, 0x01, 0x00,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x03,
  0x00, 0x40, 0xFF, 0xFF, 0xF8, 0xC0, 0x18, 0x04, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x38, 0x10, 0x10, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x20, 0x60, 0x40, 0x00, 0x38,
  0x05, 0x10, 0x18, 0x30, 0xA0, 0x3C,
};

const GFXglyph RobotoMono_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 1, 18, 16, 7, -18 },
  { 4, 4, 6, 16, 6, -20 },
  { 7, 14, 18, 16, 1, -18 },
  { 39, 12, 24, 16, 2, -21 },
  { 75, 14, 19, 16, 1, -19 },
  { 109, 13, 19, 16, 2, -19 },
  { 140, 1, 6, 16, 7, -20 },
  { 141, 6, 27, 16, 5, -21 },
  { 162, 5, 27, 16, 5, -21 },
  { 179, 11, 10, 16, 3, -18 },
  { 193, 12, 13, 16, 2, -15 },
  { 213, 2, 5, 16, 5, -2 },
  { 215, 9, 1, 16, 3, -9 },
  { 217, 2, 1, 16, 7, -1 },
  { 218, 8, 20, 16, 4, -18 },
  { 238, 12, 19, 16, 2, -19 },
  { 267, 6, 18, 16, 3, -18 },
  { 281, 12, 19, 16, 1, -19 },
  { 310, 12, 19, 16, 1, -19 },
  { 339, 13, 18, 16, 1, -18 },
  { 369, 11, 18, 16, 3, -18 },
  { 394, 11, 19, 16, 2, -19 },
  { 421, 12, 18, 16, 2, -18 },
  { 448, 12, 19, 16, 2, -19 },
  { 477, 11, 19, 16, 2, -19 },
  { 504, 2, 12, 16, 8, -12 },
  { 507, 3, 15, 16, 7, -12 },
  { 513, 11, 11, 16, 2, -14 },
  { 529, 12, 5, 16, 2, -11 },
  { 537, 11, 11, 16, 2, -14 },
  { 553, 10, 19, 16, 3, -19 },
  { 577, 14, 19, 16, 1, -19 },
  { 611, 12, 18, 16, 2, -18 },
  { 638, 11, 18, 16, 3, -18 },
  { 663, 12, 19, 16, 2, -19 },
  { 692, 11, 18, 16, 3, -18 },
  { 717, 10, 18, 16, 3, -18 },
  { 740, 10, 18, 16, 3, -18 },
  { 763, 12, 19, 16, 2, -19 },
  { 792, 11, 18, 16, 2, -18 },
  { 817, 10, 18, 16, 3, -18 },
  { 840, 11, 18, 16, 2, -18 },
  { 865, 12, 18, 16, 3, -18 },
  { 892, 11, 18, 16, 3, -18 },
  { 917, 12, 18, 16, 2, -18 },
  { 944, 11, 18, 16, 2, -18 },
  { 969, 12, 19, 16, 2, -19 },
  { 998, 11, 18, 16, 3, -18 },
  { 1023, 12, 22, 16, 2, -19 },
  { 1056, 11, 18, 16, 3, -18 },
  { 1081, 12, 19, 16, 2, -19 },
  { 1110, 13, 18, 16, 1, -18 },
  { 1140, 11, 18, 16, 2, -18 },
  { 1165, 13, 18, 16, 1, -18 },
  { 1195, 14, 18, 16, 1, -18 },
  { 1227, 12, 18, 16, 2, -18 },
  { 1254, 13, 18, 16, 1, -18 },
  { 1284, 11, 18, 16, 2, -18 },
  { 1309, 4, 25, 16, 6, -21 },
  { 1322, 8, 20, 16, 4, -18 },
  { 1342, 4, 25, 16, 6, -21 },
  { 1355, 9, 10, 16, 3, -18 },
  { 1367, 11, 1, 16, 2, 0 },
  { 1369, 3, 3, 16, 6, -19 },
  { 1371, 11, 14, 16, 2, -14 },
  { 1391, 10, 20, 16, 3, -20 },
  { 1416, 11, 14, 16, 2, -14 },
  { 1436, 11, 20, 16, 2, -20 },
  { 1464, 12, 14, 16, 2, -14 },
  { 1485, 11, 20, 16, 3, -20 },
  { 1513, 11, 20, 16, 2, -14 },
  { 1541, 10, 20, 16, 3, -20 },
  { 1566, 11, 19, 16, 3, -19 },
  { 1593, 8, 25, 16, 2, -19 },
  { 1618, 11, 20, 16, 3, -20 },
  { 1646, 11, 20, 16, 3, -20 },
  { 1674, 14, 14, 16, 1, -14 },
  { 1699, 10, 14, 16, 3, -14 },
  { 1717, 12, 14, 16, 2, -14 },
  { 1738, 10, 19, 16, 3, -14 },
  { 1762, 11, 19, 16, 2, -14 },
  { 1789, 9, 14, 16, 5, -14 },
  { 1805, 10, 14, 16, 3, -14 },
  { 1823, 11, 17, 16, 2, -17 },
  { 1847, 10, 14, 16, 3, -14 },
  { 1865, 13, 14, 16, 1, -14 },
  { 1888, 14, 14, 16, 1, -14 },
  { 1913, 12, 14, 16, 2, -14 },
  { 1934, 13, 20, 16, 1, -14 },
  { 1967, 12, 14, 16, 2, -14 },
  { 1988, 9, 26, 16, 4, -20 },
  { 2018, 1, 21, 16, 7, -18 },
  { 2021, 9, 26, 16, 4, -20 },
  { 2051, 14, 4, 16, 1, -10 },
};

const GFXfont RobotoMono_Thin26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin26pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_THIN26PT7B_H_
