#ifndef _ROBOTOMONO_THIN31PT7B_H_
#define _ROBOTOMONO_THIN31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin31pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x70, 0x8C, 0x63, 0x18, 0xC4, 0x01,
  0x04, 0x00, 0x82, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x80, 0x10, 0x41,
  0xFF, 0xFE, 0x08, 0x10, 0x04, 0x08, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82,
  0x00, 0x41, 0x00, 0x40, 0x80, 0x20, 0x41, 0xFF, 0xFE, 0x08, 0x20, 0x04,
  0x10, 0x04, 0x08, 0x02, 0x04, 0x01, 0x04, 0x00, 0x82, 0x00, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x3B, 0x82, 0x02, 0x20, 0x09, 0x00, 0x28, 0x01, 0x40,
  0x0A, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x05, 0x00, 0x44,
  0x06, 0x1F, 0xC0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x78, 0x00, 0x42, 0x00,
  0x20, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04, 0x10, 0x82, 0x08, 0x81, 0x04,
  0x40, 0x44, 0x40, 0x1C, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0xE0,
  0x10, 0x88, 0x08, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08,
  0x22, 0x04, 0x10, 0x02, 0x10, 0x00, 0xF0, 0x0F, 0x80, 0x10, 0x40, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x40, 0x10, 0x40, 0x10, 0x80, 0x0B,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x12, 0x00, 0x21, 0x02, 0x40, 0x82, 0x40,
  0x42, 0x40, 0x42, 0x80, 0x24, 0x80, 0x14, 0x40, 0x08, 0x40, 0x14, 0x20,
  0x22, 0x1F, 0xC3, 0xFC, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x81, 0x01, 0x01, 0x01, 0x01, 0x82, 0x04, 0x08, 0x20,
  0x41, 0x02, 0x08, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x84, 0x20, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x0C, 0x21, 0x9D, 0x70, 0x1C, 0x00, 0xA0, 0x04, 0x80, 0x42,
  0x04, 0x08, 0x40, 0x20, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x7F, 0xFF, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x55, 0x60,
  0xFF, 0xE0, 0xB0, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x1F, 0xC1, 0x01,
  0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0E, 0x00, 0xB0, 0x09, 0x80, 0x8C,
  0x0C, 0x60, 0xC3, 0x0C, 0x18, 0xC0, 0xCC, 0x06, 0xC0, 0x3C, 0x01, 0xC0,
  0x0C, 0x00, 0x90, 0x04, 0x80, 0x42, 0x06, 0x0F, 0xC0, 0x03, 0x0D, 0x31,
  0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x81, 0x03, 0x10, 0x09,
  0x00, 0x28, 0x01, 0x40, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x7F, 0xFC, 0x1F, 0xC1, 0x01, 0x10, 0x05,
  0x00, 0x28, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x03, 0x03,
  0xE0, 0x01, 0xC0, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x80, 0x22, 0x02, 0x0F, 0xE0, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x50, 0x00, 0x50, 0x00, 0x90, 0x01, 0x10, 0x03, 0x10, 0x02, 0x10, 0x04,
  0x10, 0x08, 0x10, 0x08, 0x10, 0x10, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40,
  0x10, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x7F, 0xF4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x08, 0x00, 0x9F, 0x0E, 0x0C, 0x80, 0x20, 0x02, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x60, 0x41, 0xF8,
  0x01, 0xE0, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x00,
  0x10, 0xC0, 0x4C, 0xE2, 0xC0, 0x4C, 0x00, 0xB0, 0x02, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x24, 0x00, 0x88, 0x04, 0x10,
  0x30, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x80, 0x84, 0x01, 0x10,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x90, 0x02, 0x40, 0x10, 0xC0, 0x80,
  0xFC, 0x0C, 0x18, 0x40, 0x12, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x90, 0x02, 0x60, 0x30, 0x7F, 0x00, 0x0F, 0xC0, 0x40,
  0xC2, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x50, 0x03, 0x20, 0x14, 0x41, 0x90, 0xF8, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x7C, 0x00,
  0xB0, 0x00, 0x00, 0x2C, 0x4C, 0x00, 0x00, 0x00, 0x00, 0x92, 0x52, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x01, 0x00, 0x00, 0x3F, 0x88, 0x0A, 0x01, 0x40, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x18, 0x00,
  0x03, 0xF8, 0x06, 0x02, 0x04, 0x00, 0x84, 0x00, 0x22, 0x0C, 0x12, 0x19,
  0x89, 0x08, 0x43, 0x08, 0x21, 0x84, 0x10, 0xC4, 0x08, 0x62, 0x04, 0x31,
  0x04, 0x18, 0x82, 0x0C, 0x41, 0x0A, 0x20, 0x85, 0x10, 0xC2, 0x84, 0x92,
  0x21, 0x86, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x80, 0x7F, 0x80, 0x01,
  0x00, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x44, 0x00, 0x88, 0x01, 0x10,
  0x02, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20, 0x40, 0x80, 0x81, 0x01, 0x02,
  0x01, 0x08, 0x02, 0x1F, 0xFC, 0x20, 0x08, 0x80, 0x09, 0x00, 0x12, 0x00,
  0x28, 0x00, 0x30, 0x00, 0x40, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20, 0x04,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x12, 0x01, 0x8F, 0xF8,
  0x20, 0x18, 0x80, 0x12, 0x00, 0x28, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00,
  0x28, 0x00, 0xA0, 0x04, 0x80, 0x23, 0xFF, 0x00, 0x0F, 0xE0, 0x40, 0x42,
  0x00, 0x90, 0x02, 0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01,
  0x40, 0x05, 0x00, 0x14, 0x00, 0x88, 0x02, 0x10, 0x10, 0x3F, 0x80, 0xFF,
  0x02, 0x03, 0x08, 0x02, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0xC3,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xF9, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x3F, 0xFD, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x00, 0x0F, 0xE0, 0x40, 0x42, 0x00, 0x90, 0x01, 0x40, 0x06, 0x00,
  0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x12, 0x00, 0x48,
  0x01, 0x10, 0x08, 0x3F, 0xC0, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x0F, 0xFF, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x22, 0x02,
  0x0F, 0xE0, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x44, 0x01, 0x08, 0x04, 0x10,
  0x10, 0x20, 0x40, 0x41, 0x00, 0x84, 0x01, 0x10, 0x02, 0x50, 0x05, 0x20,
  0x0C, 0x20, 0x10, 0x20, 0x20, 0x20, 0x40, 0x20, 0x80, 0x41, 0x00, 0x42,
  0x00, 0x44, 0x00, 0x48, 0x00, 0x50, 0x00, 0xC0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x5A,
  0x02, 0xD0, 0x16, 0x41, 0x32, 0x09, 0x90, 0x8C, 0x44, 0x62, 0x23, 0x0A,
  0x18, 0x50, 0xC3, 0x06, 0x08, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x40, 0x1A,
  0x00, 0xC8, 0x06, 0x40, 0x31, 0x01, 0x88, 0x0C, 0x20, 0x60, 0x83, 0x04,
  0x18, 0x10, 0xC0, 0x86, 0x02, 0x30, 0x11, 0x80, 0x4C, 0x01, 0x60, 0x0B,
  0x00, 0x38, 0x01, 0xC0, 0x04, 0x0F, 0xC0, 0x40, 0xC2, 0x00, 0x90, 0x02,
  0x40, 0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x05, 0x00,
  0x14, 0x00, 0x88, 0x06, 0x10, 0x30, 0x3F, 0x00, 0xFF, 0x84, 0x03, 0x20,
  0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xA0, 0x0D, 0x01, 0x8F, 0xE0, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x0F, 0xE0, 0x20, 0x20,
  0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x04, 0x80, 0x09, 0x00, 0x11, 0x00, 0x41, 0x01, 0x01,
  0xFC, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0x82, 0x01,
  0x88, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x0A, 0x00, 0x48, 0x02, 0x20, 0x30, 0xFF, 0x82, 0x02, 0x08, 0x04, 0x20,
  0x10, 0x80, 0x22, 0x00, 0x88, 0x01, 0x20, 0x02, 0x80, 0x0A, 0x00, 0x10,
  0x0F, 0xE0, 0x20, 0x30, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x80, 0x03, 0x00, 0x05, 0x00, 0x11,
  0x00, 0x23, 0x00, 0x81, 0xFE, 0x00, 0xFF, 0xFE, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x04, 0x80, 0x22, 0x06, 0x0F, 0xC0,
  0x80, 0x03, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x24, 0x00, 0x88, 0x01, 0x08,
  0x02, 0x10, 0x08, 0x20, 0x10, 0x20, 0x20, 0x40, 0x40, 0x81, 0x00, 0x82,
  0x01, 0x04, 0x02, 0x10, 0x02, 0x20, 0x04, 0x40, 0x09, 0x00, 0x0A, 0x00,
  0x14, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x80, 0xA0, 0x40, 0x50, 0x30,
  0x48, 0x28, 0x24, 0x14, 0x12, 0x0A, 0x09, 0x05, 0x04, 0x42, 0x42, 0x22,
  0x21, 0x11, 0x11, 0x08, 0x88, 0x84, 0x44, 0x42, 0x21, 0x20, 0xA0, 0x90,
  0x50, 0x48, 0x28, 0x28, 0x14, 0x14, 0x0A, 0x06, 0x05, 0x03, 0x01, 0x01,
  0x80, 0x80, 0x80, 0x40, 0x40, 0xC0, 0x02, 0x80, 0x08, 0x80, 0x21, 0x00,
  0x41, 0x01, 0x01, 0x04, 0x02, 0x08, 0x02, 0x20, 0x02, 0x40, 0x05, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x88, 0x01, 0x08, 0x04, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0x40, 0xC0,
  0x03, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x10, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x08, 0x10, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02, 0x40, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0xF8, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0xFF, 0xF0, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x7C, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x1F, 0x04, 0x01, 0x80, 0x28, 0x09, 0x01, 0x10, 0x22, 0x08, 0x41,
  0x04, 0x40, 0x88, 0x09, 0x01, 0x40, 0x10, 0xFF, 0xF8, 0xC4, 0x21, 0x07,
  0x01, 0xC7, 0x10, 0x0C, 0x80, 0x28, 0x01, 0x00, 0x04, 0x00, 0x20, 0x01,
  0x1F, 0xF3, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0xA8,
  0x09, 0x3F, 0x88, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x1C, 0x13, 0x18, 0xA0, 0x26, 0x00, 0xA0, 0x05, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x2C,
  0x01, 0x50, 0x12, 0x7F, 0x00, 0x07, 0x00, 0xC6, 0x08, 0x08, 0x80, 0x28,
  0x01, 0x40, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0xA0, 0x09, 0x00, 0x44, 0x04, 0x1F, 0xC0, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0E, 0x13, 0x0D, 0x60, 0x34, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x12, 0x07, 0x1F, 0x90, 0x03, 0x80, 0x31, 0x81,
  0x01, 0x08, 0x02, 0x40, 0x05, 0x00, 0x14, 0x00, 0x5F, 0xFF, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x46, 0x02,
  0x07, 0xF0, 0x00, 0x78, 0x06, 0x10, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0F, 0x01, 0x0D, 0x20,
  0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x07, 0x1F, 0x90, 0x01, 0x00,
  0x10, 0x01, 0x40, 0x24, 0x02, 0x31, 0xC0, 0xE0, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x1C, 0x13, 0x0C, 0xA0, 0x15, 0x00,
  0xB0, 0x05, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0x01, 0x80, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x80, 0x81, 0x8E, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x18, 0x02, 0x80, 0x48, 0x18, 0x83, 0x08, 0x40, 0x88, 0x09,
  0x00, 0xA8, 0x0C, 0x40, 0x86, 0x08, 0x20, 0x81, 0x08, 0x08, 0x80, 0x48,
  0x02, 0x80, 0x10, 0xFE, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0xFF, 0xF0, 0x1C, 0x18, 0xA3, 0x62, 0xC1, 0x41, 0xC0, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81,
  0x07, 0x04, 0xC3, 0x28, 0x05, 0x40, 0x2C, 0x01, 0x40, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x07, 0x80, 0x61, 0x83, 0x01, 0x08, 0x02, 0x40,
  0x05, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x40, 0x05, 0x00, 0x22, 0x00, 0x84, 0x04, 0x0F, 0xE0, 0x07, 0x04,
  0xC6, 0x28, 0x09, 0x80, 0x28, 0x01, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x40, 0x0B, 0x00, 0x94, 0x0C,
  0x9F, 0x84, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x0E, 0x03, 0x0D, 0x60, 0x34, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x12, 0x07,
  0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0xE7, 0x0A, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0F, 0x81, 0x83,
  0x10, 0x04, 0x80, 0x14, 0x00, 0xA0, 0x01, 0x00, 0x06, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x05, 0x00, 0x2C, 0x02, 0x1F,
  0xE0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0xF0, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x40, 0x14, 0x03, 0x20, 0x71, 0xF9, 0x80, 0x06, 0x80,
  0x09, 0x00, 0x12, 0x00, 0x42, 0x00, 0x84, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x22, 0x00, 0x48, 0x00, 0x50, 0x00,
  0xC0, 0x00, 0x80, 0x80, 0x80, 0xA0, 0xC0, 0x90, 0x50, 0x48, 0x28, 0x24,
  0x14, 0x12, 0x12, 0x10, 0x88, 0x88, 0x44, 0x44, 0x22, 0x22, 0x12, 0x12,
  0x05, 0x05, 0x02, 0x82, 0x81, 0x41, 0x40, 0xC0, 0xA0, 0x20, 0x20, 0x10,
  0x10, 0x40, 0x04, 0x40, 0x10, 0x40, 0x40, 0x41, 0x00, 0xC4, 0x00, 0x88,
  0x00, 0xA0, 0x00, 0x80, 0x02, 0x80, 0x0D, 0x80, 0x11, 0x00, 0x41, 0x01,
  0x01, 0x04, 0x01, 0x18, 0x03, 0x60, 0x03, 0xC0, 0x01, 0x40, 0x02, 0x20,
  0x02, 0x20, 0x02, 0x10, 0x04, 0x10, 0x04, 0x10, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x04, 0x10, 0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01,
  0x40, 0x00, 0x80, 0x00, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x60, 0x00, 0x7F, 0xFC, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0x00,
  0xC0, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x04, 0x02, 0x03, 0x00, 0x30, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x60, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80,
  0x18, 0x03, 0x03, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x18, 0x08, 0x00, 0x1C, 0x00, 0xB1,
  0x00, 0x90, 0x60, 0x50, 0x18, 0x28, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Thin31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 2, 22, 19, 8, -22 },
  { 7, 5, 6, 19, 7, -23 },
  { 11, 17, 22, 19, 1, -22 },
  { 58, 13, 28, 19, 3, -25 },
  { 104, 17, 22, 19, 1, -22 },
  { 151, 16, 22, 19, 2, -22 },
  { 195, 1, 6, 19, 8, -23 },
  { 196, 7, 32, 19, 6, -25 },
  { 224, 6, 32, 19, 6, -25 },
  { 248, 13, 12, 19, 3, -22 },
  { 268, 15, 16, 19, 2, -18 },
  { 298, 2, 6, 19, 6, -2 },
  { 300, 11, 1, 19, 4, -11 },
  { 302, 2, 2, 19, 9, -2 },
  { 303, 10, 24, 19, 5, -22 },
  { 333, 13, 22, 19, 3, -22 },
  { 369, 8, 22, 19, 3, -22 },
  { 391, 13, 22, 19, 2, -22 },
  { 427, 13, 22, 19, 2, -22 },
  { 463, 16, 22, 19, 1, -22 },
  { 507, 12, 22, 19, 4, -22 },
  { 540, 14, 22, 19, 2, -22 },
  { 579, 14, 22, 19, 2, -22 },
  { 618, 14, 22, 19, 3, -22 },
  { 657, 14, 22, 19, 2, -22 },
  { 696, 2, 15, 19, 10, -15 },
  { 700, 3, 19, 19, 9, -15 },
  { 708, 14, 12, 19, 2, -16 },
  { 729, 13, 7, 19, 3, -14 },
  { 741, 13, 12, 19, 3, -16 },
  { 761, 11, 22, 19, 4, -22 },
  { 792, 17, 22, 19, 1, -22 },
  { 839, 15, 22, 19, 2, -22 },
  { 881, 14, 22, 19, 3, -22 },
  { 920, 14, 22, 19, 2, -22 },
  { 959, 14, 22, 19, 3, -22 },
  { 998, 13, 22, 19, 3, -22 },
  { 1034, 13, 22, 19, 3, -22 },
  { 1070, 14, 22, 19, 2, -22 },
  { 1109, 13, 22, 19, 3, -22 },
  { 1145, 12, 22, 19, 3, -22 },
  { 1178, 13, 22, 19, 2, -22 },
  { 1214, 15, 22, 19, 3, -22 },
  { 1256, 12, 22, 19, 4, -22 },
  { 1289, 13, 22, 19, 3, -22 },
  { 1325, 13, 22, 19, 3, -22 },
  { 1361, 14, 22, 19, 2, -22 },
  { 1400, 13, 22, 19, 4, -22 },
  { 1436, 15, 26, 19, 2, -22 },
  { 1485, 14, 22, 19, 3, -22 },
  { 1524, 15, 22, 19, 2, -22 },
  { 1566, 15, 22, 19, 2, -22 },
  { 1608, 13, 22, 19, 3, -22 },
  { 1644, 15, 22, 19, 2, -22 },
  { 1686, 17, 22, 19, 1, -22 },
  { 1733, 15, 22, 19, 2, -22 },
  { 1775, 16, 22, 19, 1, -22 },
  { 1819, 14, 22, 19, 2, -22 },
  { 1858, 5, 30, 19, 7, -25 },
  { 1877, 10, 24, 19, 4, -22 },
  { 1907, 4, 30, 19, 7, -25 },
  { 1922, 11, 12, 19, 4, -22 },
  { 1939, 13, 1, 19, 3, 0 },
  { 1941, 4, 4, 19, 7, -23 },
  { 1943, 13, 17, 19, 3, -17 },
  { 1971, 13, 23, 19, 3, -23 },
  { 2009, 13, 17, 19, 3, -17 },
  { 2037, 12, 23, 19, 3, -23 },
  { 2072, 14, 17, 19, 2, -17 },
  { 2102, 14, 24, 19, 3, -24 },
  { 2144, 12, 24, 19, 3, -17 },
  { 2180, 13, 23, 19, 3, -23 },
  { 2218, 12, 22, 19, 4, -22 },
  { 2251, 9, 29, 19, 3, -22 },
  { 2284, 12, 23, 19, 4, -23 },
  { 2319, 12, 23, 19, 4, -23 },
  { 2354, 16, 17, 19, 1, -17 },
  { 2388, 13, 17, 19, 3, -17 },
  { 2416, 14, 17, 19, 2, -17 },
  { 2446, 13, 23, 19, 3, -17 },
  { 2484, 12, 23, 19, 3, -17 },
  { 2519, 10, 17, 19, 6, -17 },
  { 2541, 13, 17, 19, 3, -17 },
  { 2569, 12, 21, 19, 3, -21 },
  { 2601, 12, 16, 19, 3, -16 },
  { 2625, 15, 16, 19, 2, -16 },
  { 2655, 17, 16, 19, 1, -16 },
  { 2689, 15, 16, 19, 2, -16 },
  { 2719, 16, 23, 19, 1, -16 },
  { 2765, 15, 16, 19, 2, -16 },
  { 2795, 10, 31, 19, 5, -24 },
  { 2834, 1, 26, 19, 9, -22 },
  { 2838, 10, 31, 19, 5, -24 },
  { 2877, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_Thin31pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin31pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOMONO_THIN31PT7B_H_
