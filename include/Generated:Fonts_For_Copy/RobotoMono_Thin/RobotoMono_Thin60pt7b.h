#ifndef _ROBOTOMONO_THIN60PT7B_H_
#define _ROBOTOMONO_THIN60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin60pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x90, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x30, 0x00, 0x06, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x06, 0x00, 0x60, 0x00, 0x04, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x00, 0x08, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x01, 0x80, 0x00, 0x10, 0x01, 0x00,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00,
  0x00, 0x20, 0x03, 0x00, 0x00, 0x20, 0x03, 0x00, 0x00, 0x60, 0x02, 0x00,
  0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0x40, 0x06, 0x00, 0x00, 0x40, 0x04, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x08, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x10, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xC3,
  0xE0, 0x07, 0x00, 0x38, 0x06, 0x00, 0x06, 0x06, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x30,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x00, 0x80, 0x60, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x10, 0x03, 0x00, 0x10, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x10,
  0x03, 0x00, 0xC0, 0x04, 0x01, 0x80, 0x30, 0x01, 0x00, 0x40, 0x0C, 0x00,
  0x40, 0x30, 0x03, 0x00, 0x10, 0x08, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x10,
  0x03, 0x01, 0x00, 0x06, 0x00, 0xC0, 0xC0, 0x01, 0x80, 0x60, 0x60, 0x00,
  0x30, 0x18, 0x18, 0x00, 0x06, 0x1C, 0x0C, 0x00, 0x00, 0xFE, 0x03, 0x00,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0x00, 0xFC, 0x00, 0x00, 0xC0, 0xE3, 0x80, 0x00, 0x60, 0x60, 0x30, 0x00,
  0x18, 0x18, 0x04, 0x00, 0x0C, 0x0C, 0x01, 0x80, 0x03, 0x03, 0x00, 0x20,
  0x01, 0x80, 0x80, 0x08, 0x00, 0x40, 0x20, 0x03, 0x00, 0x30, 0x08, 0x00,
  0xC0, 0x08, 0x02, 0x00, 0x30, 0x06, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x20,
  0x03, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x60, 0x03, 0x00, 0x20, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00, 0x10, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x02, 0x00,
  0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x83,
  0x00, 0x00, 0x18, 0x0C, 0x00, 0x31, 0x80, 0x30, 0x01, 0x8C, 0x00, 0xC0,
  0x0C, 0xC0, 0x03, 0x00, 0x64, 0x00, 0x0C, 0x03, 0x60, 0x00, 0x60, 0x13,
  0x00, 0x01, 0x81, 0x90, 0x00, 0x06, 0x0C, 0x80, 0x00, 0x18, 0x44, 0x00,
  0x00, 0x66, 0x30, 0x00, 0x03, 0x31, 0x80, 0x00, 0x0F, 0x0C, 0x00, 0x00,
  0x30, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x3B, 0x06, 0x00, 0x03, 0x8C,
  0x1C, 0x00, 0x30, 0x60, 0x78, 0x0F, 0x01, 0x80, 0xFF, 0xE0, 0x06, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFF, 0xAA, 0x00, 0x08, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x08, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x01, 0xBE, 0x03, 0x03, 0xF1, 0xF0, 0xC3, 0xC0, 0x0F, 0xB7, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0x30, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0xC0, 0x03, 0x00, 0x38, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x10,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x11,
  0x11, 0x11, 0x13, 0x36, 0x6C, 0xFF, 0xFF, 0xFC, 0x6F, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7C, 0x78, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0C, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x20, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x00, 0x00, 0x0E, 0x40,
  0x00, 0x06, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x07,
  0x06, 0x00, 0x03, 0xC3, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x3C, 0xC0, 0x00,
  0x0D, 0x60, 0x00, 0x03, 0x70, 0x00, 0x00, 0x98, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x81,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x07, 0x00, 0x18, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x70, 0x0F,
  0xC0, 0xF3, 0x0F, 0x0C, 0xF0, 0x3E, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x01, 0x08, 0x00, 0x00, 0x23, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0x38, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x98, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x09, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x8C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x06,
  0x00, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x01, 0x0C, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x08, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x40, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x01, 0x80, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x18, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x20, 0x7E, 0x00, 0x27, 0xFF, 0xC0, 0x6E, 0x00, 0xE0, 0x78, 0x00, 0x38,
  0x60, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x0E, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x01, 0x01, 0xFE, 0x00, 0xC1, 0xFF, 0xE0, 0x31, 0xC0, 0x0E, 0x0C, 0xC0,
  0x01, 0xC2, 0x60, 0x00, 0x38, 0xB0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x13, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0xB0,
  0x00, 0x00, 0x64, 0x00, 0x00, 0x19, 0x80, 0x00, 0x04, 0x20, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x61, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x01, 0x30, 0x00, 0x00, 0x26, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x60, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xA0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x04, 0x40, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x70, 0x03, 0x80, 0x30, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x0C, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x10,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0xA0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0x72, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x1B,
  0x18, 0x00, 0x0C, 0xC3, 0x00, 0x06, 0x30, 0x60, 0x07, 0x08, 0x0F, 0x0F,
  0x82, 0x00, 0xFF, 0x81, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x18, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0x8C, 0x63, 0x18, 0xC4,
  0x63, 0x31, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0x0F, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x18,
  0x80, 0x00, 0x66, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0F, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x03, 0x06, 0x00,
  0x7E, 0x01, 0x86, 0x00, 0xF7, 0x80, 0x43, 0x00, 0xC0, 0x60, 0x31, 0x00,
  0xC0, 0x10, 0x19, 0x80, 0x40, 0x18, 0x0C, 0xC0, 0x60, 0x0C, 0x06, 0x40,
  0x20, 0x06, 0x01, 0x60, 0x30, 0x03, 0x00, 0xB0, 0x18, 0x01, 0x00, 0x58,
  0x08, 0x00, 0x80, 0x28, 0x0C, 0x00, 0x40, 0x14, 0x06, 0x00, 0x20, 0x0A,
  0x03, 0x00, 0x10, 0x05, 0x01, 0x80, 0x18, 0x02, 0x80, 0x80, 0x0C, 0x03,
  0x40, 0x40, 0x06, 0x01, 0xA0, 0x20, 0x03, 0x00, 0xD0, 0x18, 0x03, 0x80,
  0x68, 0x0C, 0x01, 0xC0, 0x24, 0x06, 0x00, 0xE0, 0x13, 0x03, 0x00, 0xF0,
  0x19, 0x80, 0x80, 0xD8, 0x08, 0xC0, 0x60, 0x64, 0x0C, 0x20, 0x10, 0x63,
  0x0C, 0x18, 0x0F, 0xE0, 0xFC, 0x0C, 0x01, 0xC0, 0x3C, 0x03, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x22, 0x00, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x10, 0xC0, 0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x02, 0x02, 0x00, 0x00, 0x30, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x08, 0x02, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x20, 0x02, 0x00, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x02, 0x00,
  0x02, 0x00, 0x30, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x08, 0x00, 0x02,
  0x00, 0xC0, 0x00, 0x18, 0x07, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x02, 0x03,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x02, 0x0C, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x02, 0x30, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x0C, 0x00, 0x1E, 0x03, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x1C, 0x30,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x13, 0x00, 0x00, 0x04, 0xC0, 0x00,
  0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x08, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0x83, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x38, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x02, 0x40, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x22, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x02, 0x00, 0x0F, 0x00, 0x40,
  0x00, 0x38, 0x08, 0x00, 0x03, 0x81, 0x00, 0x00, 0x38, 0x20, 0x00, 0x03,
  0x04, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x10, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x06, 0x40, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01,
  0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x0A, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x40, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x04, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x22, 0x00, 0x00, 0x0C, 0x40,
  0x00, 0x03, 0x08, 0x00, 0x00, 0x61, 0x00, 0x00, 0x18, 0x20, 0x00, 0x06,
  0x04, 0x00, 0x03, 0x80, 0x80, 0x01, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18,
  0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x24, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0x0E, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x38, 0x0C,
  0x00, 0x38, 0x03, 0xC0, 0x78, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x03, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x30, 0x20, 0x00, 0x0C, 0x04,
  0x00, 0x03, 0x80, 0x80, 0x00, 0xE0, 0x10, 0x00, 0x18, 0x02, 0x00, 0x06,
  0x00, 0x40, 0x01, 0x80, 0x08, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x20,
  0x06, 0x00, 0x04, 0x01, 0x80, 0x00, 0x80, 0x60, 0x00, 0x10, 0x18, 0x00,
  0x02, 0x07, 0x00, 0x00, 0x41, 0xC0, 0x00, 0x08, 0x78, 0x00, 0x01, 0x1D,
  0x80, 0x00, 0x23, 0x18, 0x00, 0x04, 0xC1, 0x80, 0x00, 0xB0, 0x18, 0x00,
  0x1C, 0x03, 0x00, 0x03, 0x00, 0x30, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00,
  0x30, 0x01, 0x00, 0x03, 0x00, 0x20, 0x00, 0x60, 0x04, 0x00, 0x06, 0x00,
  0x80, 0x00, 0x60, 0x10, 0x00, 0x06, 0x02, 0x00, 0x00, 0x60, 0x40, 0x00,
  0x0C, 0x08, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0xC4,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x1A, 0x00, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x05,
  0xD0, 0x00, 0x03, 0x76, 0x00, 0x00, 0x9D, 0x80, 0x00, 0x67, 0x30, 0x00,
  0x19, 0xCC, 0x00, 0x04, 0x71, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x87, 0x18,
  0x00, 0x61, 0xC2, 0x00, 0x18, 0x70, 0xC0, 0x0C, 0x1C, 0x10, 0x03, 0x07,
  0x06, 0x00, 0x81, 0xC1, 0x80, 0x60, 0x70, 0x20, 0x18, 0x1C, 0x0C, 0x0C,
  0x07, 0x03, 0x03, 0x01, 0xC0, 0x40, 0x80, 0x70, 0x18, 0x60, 0x1C, 0x02,
  0x10, 0x07, 0x00, 0xCC, 0x01, 0xC0, 0x33, 0x00, 0x70, 0x04, 0x80, 0x1C,
  0x01, 0xE0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xD0, 0x00, 0x00, 0xF6,
  0x00, 0x00, 0x3C, 0x80, 0x00, 0x0F, 0x30, 0x00, 0x03, 0xC4, 0x00, 0x00,
  0xF1, 0x80, 0x00, 0x3C, 0x30, 0x00, 0x0F, 0x0C, 0x00, 0x03, 0xC1, 0x80,
  0x00, 0xF0, 0x20, 0x00, 0x3C, 0x0C, 0x00, 0x0F, 0x01, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0xF0, 0x08, 0x00, 0x3C, 0x03, 0x00, 0x0F, 0x00, 0x60, 0x03,
  0xC0, 0x08, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0x40, 0x0F, 0x00, 0x18,
  0x03, 0xC0, 0x02, 0x00, 0xF0, 0x00, 0xC0, 0x3C, 0x00, 0x18, 0x0F, 0x00,
  0x02, 0x03, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x10, 0x3C, 0x00, 0x06, 0x0F,
  0x00, 0x00, 0x83, 0xC0, 0x00, 0x30, 0xF0, 0x00, 0x06, 0x3C, 0x00, 0x00,
  0x8F, 0x00, 0x00, 0x33, 0xC0, 0x00, 0x04, 0xF0, 0x00, 0x01, 0xBC, 0x00,
  0x00, 0x2F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30,
  0x18, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x04, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x24, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x24, 0x00, 0x00, 0x02,
  0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x04, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x80, 0x80, 0x00, 0x10, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x07, 0x83, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x00, 0x90, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x06, 0x20, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x43, 0x00, 0x00, 0x03, 0x06, 0x00, 0x00, 0x08,
  0x18, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x08, 0x00, 0x1E, 0x02, 0x00, 0x01, 0xC0, 0x80, 0x00,
  0x18, 0x20, 0x00, 0x03, 0x08, 0x00, 0x00, 0x42, 0x00, 0x00, 0x18, 0x80,
  0x00, 0x02, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x0C, 0x80, 0x00, 0x02, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x62, 0x00,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x20, 0x00, 0x0C, 0x08, 0x00, 0x0E, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x20, 0x00, 0xC0, 0x08, 0x00, 0x10,
  0x02, 0x00, 0x06, 0x00, 0x80, 0x00, 0xC0, 0x20, 0x00, 0x30, 0x08, 0x00,
  0x06, 0x02, 0x00, 0x00, 0x80, 0x80, 0x00, 0x30, 0x20, 0x00, 0x04, 0x08,
  0x00, 0x01, 0x82, 0x00, 0x00, 0x30, 0x80, 0x00, 0x0C, 0x20, 0x00, 0x01,
  0x88, 0x00, 0x00, 0x62, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x68, 0x00, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x1F, 0x00,
  0x1C, 0x00, 0x70, 0x06, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60, 0x00,
  0x03, 0x08, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x26, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x06, 0x00, 0x18, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x10, 0x80, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x08, 0x10, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x01, 0x81, 0x80, 0x00, 0x04, 0x02, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x02, 0x00, 0x40, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x40, 0x00, 0x20, 0x03, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x04, 0x00, 0x80, 0x00, 0x18, 0x06, 0x00,
  0x00, 0x60, 0x10, 0x00, 0x00, 0x80, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x0C, 0x00, 0x00, 0x10, 0x20, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x02, 0x10, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x68, 0x00, 0x50, 0x00, 0xD0, 0x00, 0xB0, 0x01,
  0x20, 0x01, 0x60, 0x02, 0x60, 0x06, 0xC0, 0x04, 0xC0, 0x0C, 0x80, 0x19,
  0x80, 0x11, 0x00, 0x31, 0x00, 0x23, 0x00, 0x62, 0x00, 0x46, 0x00, 0x84,
  0x01, 0x8C, 0x01, 0x0C, 0x03, 0x08, 0x02, 0x18, 0x06, 0x10, 0x04, 0x30,
  0x08, 0x30, 0x18, 0x20, 0x10, 0x60, 0x30, 0x40, 0x60, 0xC0, 0x40, 0x80,
  0xC0, 0x80, 0x81, 0x81, 0x81, 0x01, 0x03, 0x02, 0x03, 0x02, 0x06, 0x04,
  0x06, 0x0C, 0x04, 0x18, 0x0C, 0x18, 0x08, 0x30, 0x08, 0x30, 0x10, 0x60,
  0x10, 0x40, 0x30, 0x80, 0x30, 0x80, 0x61, 0x00, 0x61, 0x00, 0xC6, 0x00,
  0xC6, 0x00, 0x8C, 0x01, 0x8C, 0x01, 0x18, 0x01, 0x18, 0x02, 0x20, 0x03,
  0x20, 0x06, 0x40, 0x06, 0x40, 0x0D, 0x80, 0x0C, 0x80, 0x1B, 0x00, 0x1B,
  0x00, 0x36, 0x00, 0x16, 0x00, 0x28, 0x00, 0x2C, 0x00, 0x50, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x03, 0x00, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0x0C, 0x04, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x20, 0x08, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0x10, 0x60, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x40,
  0x60, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x02, 0x00, 0x20,
  0x00, 0x30, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x10, 0x01,
  0x80, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x18, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x04, 0x00, 0x04, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x06,
  0x00, 0x30, 0x00, 0x10, 0x01, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x02, 0x00,
  0x80, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x40, 0x40, 0x00, 0x03, 0x06, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x7F, 0xC0, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x98, 0x00, 0x19, 0x80, 0x01,
  0x08, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00,
  0x40, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x01, 0x81, 0x80, 0x18,
  0x10, 0x00, 0x83, 0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x06, 0x60, 0x00,
  0x64, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x30, 0x30, 0x18, 0x0C, 0x04, 0x07, 0x00, 0x7F, 0xC0,
  0x00, 0xFC, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x18, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x11, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xFE, 0x07, 0xC0, 0x01, 0x87, 0x80, 0x00, 0x63, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x06, 0x60, 0x00, 0x01, 0x90, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xE4, 0x00, 0x00,
  0x79, 0x80, 0x00, 0x36, 0x30, 0x00, 0x19, 0x8E, 0x00, 0x1C, 0x20, 0xE0,
  0x1E, 0x0C, 0x1F, 0xFE, 0x03, 0x00, 0x68, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x81, 0xFF, 0x00, 0x87, 0x87, 0xC0, 0x8E, 0x00, 0xE0, 0x98, 0x00, 0x30,
  0xB0, 0x00, 0x18, 0xE0, 0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x04,
  0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x02, 0x80, 0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06,
  0x80, 0x00, 0x04, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x08, 0xE0, 0x00, 0x18,
  0xB0, 0x00, 0x30, 0x9C, 0x00, 0x60, 0x8F, 0x01, 0xC0, 0x83, 0xFF, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x78, 0x01, 0xC0, 0x06,
  0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x18, 0xC0, 0x00,
  0x04, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x50, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x20, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x60, 0x38, 0x00,
  0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x00, 0xFF, 0x81, 0x03, 0xE1, 0xE1, 0x07, 0x00, 0x31, 0x0C,
  0x00, 0x19, 0x18, 0x00, 0x0D, 0x18, 0x00, 0x07, 0x30, 0x00, 0x03, 0x20,
  0x00, 0x03, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x60,
  0x00, 0x01, 0x20, 0x00, 0x01, 0x30, 0x00, 0x03, 0x10, 0x00, 0x03, 0x18,
  0x00, 0x07, 0x0C, 0x00, 0x0D, 0x06, 0x00, 0x39, 0x03, 0x80, 0xF1, 0x00,
  0xFF, 0xC1, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x3C, 0x00,
  0x38, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0x98, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x1E, 0x03, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x81, 0xF0, 0xF0, 0xC1,
  0xC0, 0x1C, 0x61, 0x80, 0x03, 0x31, 0x80, 0x00, 0xD8, 0xC0, 0x00, 0x3C,
  0xC0, 0x00, 0x0E, 0x40, 0x00, 0x07, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x1A, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x20, 0x00, 0x01, 0x98,
  0x00, 0x01, 0xC4, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xF0, 0xC0, 0x00, 0xD8,
  0x30, 0x01, 0xCC, 0x0E, 0x03, 0xC6, 0x01, 0xFF, 0x83, 0x00, 0x08, 0x01,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x40, 0x00, 0x18, 0x60, 0x00, 0x18, 0x18, 0x00,
  0x0C, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x3C, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0xC0, 0xC1, 0xF0, 0xF0, 0xC3,
  0x80, 0x18, 0xC6, 0x00, 0x0C, 0xCC, 0x00, 0x06, 0xD8, 0x00, 0x06, 0xD0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x3F, 0xFC,
  0x03, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x0E, 0x80, 0x00, 0x18,
  0x80, 0x00, 0x30, 0x80, 0x00, 0x60, 0x80, 0x00, 0xC0, 0x80, 0x03, 0x80,
  0x80, 0x07, 0x00, 0x80, 0x0E, 0x00, 0x80, 0x18, 0x00, 0x80, 0x30, 0x00,
  0x80, 0x60, 0x00, 0x80, 0xC0, 0x00, 0x83, 0x80, 0x00, 0x87, 0x00, 0x00,
  0x8F, 0x00, 0x00, 0x99, 0x80, 0x00, 0xB0, 0xC0, 0x00, 0xE0, 0x60, 0x00,
  0xC0, 0x70, 0x00, 0x80, 0x38, 0x00, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x80, 0x06, 0x00, 0x80, 0x03, 0x00, 0x80, 0x01, 0x80, 0x80, 0x00, 0xC0,
  0x80, 0x00, 0x60, 0x80, 0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x1C,
  0x80, 0x00, 0x0C, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x0F,
  0xE1, 0x3C, 0x78, 0x70, 0xE2, 0xC0, 0x31, 0x80, 0x67, 0x00, 0x36, 0x00,
  0x6E, 0x00, 0x38, 0x00, 0xD8, 0x00, 0x60, 0x00, 0xB0, 0x00, 0xC0, 0x01,
  0x40, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x18, 0x00, 0x28, 0x00, 0x30,
  0x00, 0x50, 0x00, 0x60, 0x00, 0xA0, 0x00, 0xC0, 0x01, 0x40, 0x01, 0x80,
  0x02, 0xC0, 0x7F, 0xC0, 0xC1, 0xF0, 0xF0, 0xC3, 0x80, 0x18, 0xC6, 0x00,
  0x0C, 0xCC, 0x00, 0x06, 0xD8, 0x00, 0x06, 0xD0, 0x00, 0x02, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x0C, 0x20, 0x00, 0x00, 0x46, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x64, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x24, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0xFF, 0x80,
  0x61, 0xE1, 0xF0, 0x31, 0x80, 0x1C, 0x19, 0x80, 0x03, 0x0D, 0x80, 0x00,
  0xC7, 0x80, 0x00, 0x63, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x02, 0x60, 0x00, 0x03, 0x38, 0x00, 0x01, 0x1E, 0x00, 0x01,
  0x8D, 0x80, 0x01, 0x86, 0x60, 0x01, 0x83, 0x1E, 0x03, 0x81, 0x83, 0xFF,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x03, 0xE1, 0xE1, 0x07, 0x00, 0x71,
  0x0C, 0x00, 0x19, 0x18, 0x00, 0x0D, 0x18, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x20, 0x00, 0x03, 0x60, 0x00, 0x01, 0x60, 0x00, 0x01, 0x40, 0x00, 0x01,
  0x40, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01,
  0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x07, 0x0C, 0x00, 0x0D, 0x06, 0x00, 0x39, 0x03, 0x80, 0xF1,
  0x00, 0xFF, 0xC1, 0x00, 0x08, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xC0, 0x1F, 0xFE, 0x07, 0xC0, 0xB0, 0xF0, 0x01, 0x8E,
  0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x40, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xF1, 0xF8, 0x03, 0x80, 0x07,
  0x03, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x73, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x3C, 0x01, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3C, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30,
  0x00, 0x0F, 0x18, 0x00, 0x1B, 0x1C, 0x00, 0x73, 0x0F, 0x01, 0xE3, 0x03,
  0xFF, 0x83, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x63, 0x00, 0x00, 0x03, 0x08,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x01, 0x81, 0x00, 0x00, 0x08, 0x0C, 0x00,
  0x00, 0xC0, 0x60, 0x00, 0x04, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0x20, 0x00, 0x30, 0x01, 0x80, 0x01, 0x80, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x06, 0x00, 0x60, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x10, 0x18,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x06, 0x04, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x40, 0x01, 0x80, 0x03, 0x40, 0x01, 0xC0,
  0x03, 0x60, 0x01, 0xC0, 0x03, 0x60, 0x03, 0x40, 0x02, 0x60, 0x03, 0x40,
  0x06, 0x20, 0x03, 0x60, 0x06, 0x30, 0x02, 0x60, 0x06, 0x30, 0x06, 0x60,
  0x04, 0x30, 0x06, 0x20, 0x0C, 0x10, 0x06, 0x30, 0x0C, 0x10, 0x04, 0x30,
  0x0C, 0x18, 0x0C, 0x30, 0x08, 0x18, 0x0C, 0x10, 0x08, 0x08, 0x0C, 0x18,
  0x18, 0x08, 0x08, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x08,
  0x10, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x10, 0x0C, 0x30, 0x06, 0x30, 0x0C,
  0x30, 0x06, 0x30, 0x04, 0x20, 0x06, 0x20, 0x06, 0x60, 0x02, 0x20, 0x06,
  0x60, 0x02, 0x60, 0x02, 0x60, 0x03, 0x60, 0x02, 0x40, 0x03, 0x40, 0x03,
  0x40, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x06, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x18,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x11, 0x80, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x10, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x80, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x06, 0x02, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x18,
  0x1C, 0x00, 0x03, 0x30, 0x06, 0x00, 0x03, 0x60, 0x03, 0x00, 0x02, 0x40,
  0x01, 0xC0, 0x06, 0xC0, 0x00, 0xE0, 0x0C, 0xC0, 0x00, 0x30, 0x1C, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoMono_Thin60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 3, 43, 36, 16, -43 },
  { 18, 9, 12, 36, 13, -45 },
  { 32, 32, 43, 36, 2, -43 },
  { 204, 25, 55, 36, 6, -49 },
  { 376, 34, 44, 36, 1, -43 },
  { 563, 29, 44, 36, 5, -43 },
  { 723, 2, 12, 36, 16, -45 },
  { 726, 13, 62, 36, 12, -48 },
  { 827, 12, 62, 36, 11, -48 },
  { 920, 26, 24, 36, 6, -43 },
  { 998, 30, 31, 36, 3, -35 },
  { 1115, 4, 12, 36, 12, -5 },
  { 1121, 22, 1, 36, 7, -20 },
  { 1124, 4, 3, 36, 17, -3 },
  { 1126, 20, 47, 36, 9, -43 },
  { 1244, 26, 44, 36, 5, -43 },
  { 1387, 14, 43, 36, 7, -43 },
  { 1463, 27, 43, 36, 3, -43 },
  { 1609, 26, 44, 36, 3, -43 },
  { 1752, 29, 43, 36, 3, -43 },
  { 1908, 24, 44, 36, 7, -43 },
  { 2040, 26, 44, 36, 5, -43 },
  { 2183, 27, 43, 36, 4, -43 },
  { 2329, 27, 44, 36, 5, -43 },
  { 2478, 26, 44, 36, 5, -43 },
  { 2621, 3, 29, 36, 19, -29 },
  { 2632, 5, 36, 36, 17, -29 },
  { 2655, 25, 23, 36, 5, -31 },
  { 2727, 26, 13, 36, 5, -26 },
  { 2770, 25, 23, 36, 6, -31 },
  { 2842, 22, 43, 36, 7, -43 },
  { 2961, 33, 43, 36, 1, -43 },
  { 3139, 29, 43, 36, 4, -43 },
  { 3295, 26, 43, 36, 6, -43 },
  { 3435, 28, 44, 36, 4, -43 },
  { 3589, 27, 43, 36, 6, -43 },
  { 3735, 25, 43, 36, 6, -43 },
  { 3870, 24, 43, 36, 7, -43 },
  { 3999, 28, 44, 36, 4, -43 },
  { 4153, 26, 43, 36, 5, -43 },
  { 4293, 24, 43, 36, 6, -43 },
  { 4422, 25, 44, 36, 4, -43 },
  { 4560, 27, 43, 36, 7, -43 },
  { 4706, 24, 43, 36, 7, -43 },
  { 4835, 26, 43, 36, 5, -43 },
  { 4975, 26, 43, 36, 5, -43 },
  { 5115, 28, 44, 36, 4, -43 },
  { 5269, 26, 43, 36, 7, -43 },
  { 5409, 30, 51, 36, 3, -43 },
  { 5601, 26, 43, 36, 7, -43 },
  { 5741, 27, 44, 36, 5, -43 },
  { 5890, 30, 43, 36, 3, -43 },
  { 6052, 26, 44, 36, 5, -43 },
  { 6195, 30, 43, 36, 3, -43 },
  { 6357, 31, 43, 36, 3, -43 },
  { 6524, 29, 43, 36, 4, -43 },
  { 6680, 29, 43, 36, 3, -43 },
  { 6836, 27, 43, 36, 4, -43 },
  { 6982, 9, 58, 36, 14, -49 },
  { 7048, 20, 47, 36, 8, -43 },
  { 7166, 9, 58, 36, 13, -49 },
  { 7232, 20, 24, 36, 8, -43 },
  { 7292, 24, 2, 36, 6, 0 },
  { 7298, 8, 7, 36, 14, -44 },
  { 7305, 26, 33, 36, 5, -32 },
  { 7413, 24, 46, 36, 7, -45 },
  { 7551, 25, 33, 36, 5, -32 },
  { 7655, 24, 46, 36, 5, -45 },
  { 7793, 26, 33, 36, 5, -32 },
  { 7901, 27, 46, 36, 6, -46 },
  { 8057, 25, 45, 36, 5, -32 },
  { 8198, 24, 45, 36, 6, -45 },
  { 8333, 24, 43, 36, 7, -43 },
  { 8462, 19, 56, 36, 5, -43 },
  { 8595, 24, 45, 36, 8, -45 },
  { 8730, 24, 45, 36, 7, -45 },
  { 8865, 31, 32, 36, 3, -32 },
  { 8989, 24, 32, 36, 6, -32 },
  { 9085, 28, 33, 36, 4, -32 },
  { 9201, 25, 44, 36, 6, -32 },
  { 9339, 24, 44, 36, 5, -32 },
  { 9471, 21, 32, 36, 11, -32 },
  { 9555, 25, 33, 36, 6, -32 },
  { 9659, 24, 41, 36, 6, -40 },
  { 9782, 24, 33, 36, 6, -32 },
  { 9881, 29, 32, 36, 3, -32 },
  { 9997, 32, 32, 36, 2, -32 },
  { 10125, 28, 32, 36, 4, -32 },
  { 10237, 31, 45, 36, 2, -32 },
  { 10412, 29, 32, 36, 4, -32 },
  { 10528, 19, 60, 36, 10, -47 },
  { 10671, 2, 51, 36, 17, -43 },
  { 10684, 19, 60, 36, 10, -47 },
  { 10827, 32, 10, 36, 2, -23 },
};

const GFXfont RobotoMono_Thin60pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin60pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOMONO_THIN60PT7B_H_
