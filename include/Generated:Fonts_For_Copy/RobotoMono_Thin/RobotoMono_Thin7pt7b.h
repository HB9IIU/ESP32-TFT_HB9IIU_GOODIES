#ifndef _ROBOTOMONO_THIN7PT7B_H_
#define _ROBOTOMONO_THIN7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x5F, 0x6F, 0x60, 0x56, 0x23, 0x50, 0xCE, 0x27, 0x70,
  0xDA, 0x7E, 0x80, 0x5A, 0xA9, 0x95, 0x56, 0x5E, 0x80, 0x2F, 0x22, 0xC0,
  0xC0, 0x00, 0x56, 0x80, 0xF7, 0xDE, 0xF8, 0xE4, 0xAE, 0xE5, 0x9E, 0x26,
  0x6F, 0x20, 0xF8, 0x9E, 0xDA, 0xDE, 0xF2, 0x22, 0x40, 0xF5, 0x5E, 0xF6,
  0xBC, 0xA0, 0xB0, 0x71, 0x80, 0xFC, 0x8F, 0x00, 0xD5, 0x00, 0x7F, 0xBB,
  0xE0, 0x46, 0x66, 0x90, 0xF7, 0x5E, 0x79, 0x89, 0x70, 0xD6, 0xDC, 0xF3,
  0x4E, 0xF3, 0x48, 0x78, 0xA9, 0x70, 0xB7, 0xDA, 0xD5, 0xC0, 0x24, 0x9E,
  0xBA, 0x6A, 0x92, 0x4E, 0xB7, 0xDA, 0xB6, 0xFA, 0x79, 0x99, 0x70, 0xF7,
  0xC8, 0x79, 0x99, 0x71, 0xF6, 0xEA, 0xF1, 0x1E, 0xF2, 0x22, 0x20, 0xB6,
  0xDE, 0x99, 0x66, 0x40, 0xBB, 0xD6, 0x50, 0x96, 0x26, 0x90, 0x96, 0x42,
  0x20, 0x72, 0x44, 0xF0, 0xFE, 0xA5, 0x40, 0xFE, 0xBC, 0xE0, 0x80, 0xC7,
  0xF0, 0x9A, 0xDE, 0xD6, 0x70, 0x7F, 0xC0, 0xDE, 0x70, 0xFA, 0x48, 0xFF,
  0xC0, 0x9A, 0xDA, 0x59, 0x2E, 0x75, 0x58, 0x97, 0x6A, 0xC9, 0x2E, 0xFB,
  0xBB, 0xD6, 0xD0, 0x69, 0x97, 0xD6, 0xF8, 0xFF, 0x40, 0xF2, 0x40, 0xD5,
  0xF0, 0xBA, 0xC0, 0xFF, 0x95, 0x64, 0xBB, 0x66, 0xA9, 0x50, 0x99, 0x64,
  0x48, 0x72, 0x4F, 0x57, 0x54, 0xFC, 0xD5, 0x58, 0xF0,
};

const GFXglyph RobotoMono_Thin7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 1, 1, 4, 2, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 1, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 3, 5, 4, 1, -5 },
  { 14, 1, 1, 4, 1, -5 },
  { 15, 2, 8, 4, 1, -6 },
  { 17, 2, 8, 4, 1, -6 },
  { 19, 3, 3, 4, 1, -5 },
  { 21, 4, 4, 4, 0, -4 },
  { 23, 1, 2, 4, 1, -1 },
  { 24, 2, 1, 4, 1, -3 },
  { 25, 1, 1, 4, 2, -1 },
  { 26, 2, 5, 4, 1, -5 },
  { 28, 3, 5, 4, 1, -5 },
  { 30, 1, 5, 4, 1, -5 },
  { 31, 3, 5, 4, 0, -5 },
  { 33, 3, 5, 4, 0, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 1, -5 },
  { 40, 3, 5, 4, 1, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 1, -5 },
  { 47, 3, 5, 4, 1, -5 },
  { 49, 1, 3, 4, 2, -3 },
  { 50, 1, 4, 4, 2, -3 },
  { 51, 3, 3, 4, 1, -4 },
  { 53, 3, 2, 4, 1, -3 },
  { 54, 3, 3, 4, 1, -4 },
  { 56, 2, 5, 4, 1, -5 },
  { 58, 4, 5, 4, 0, -5 },
  { 61, 4, 5, 4, 0, -5 },
  { 64, 3, 5, 4, 1, -5 },
  { 66, 4, 5, 4, 0, -5 },
  { 69, 3, 5, 4, 1, -5 },
  { 71, 3, 5, 4, 1, -5 },
  { 73, 3, 5, 4, 1, -5 },
  { 75, 4, 5, 4, 0, -5 },
  { 78, 3, 5, 4, 1, -5 },
  { 80, 2, 5, 4, 1, -5 },
  { 82, 3, 5, 4, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 3, 5, 4, 1, -5 },
  { 88, 3, 5, 4, 1, -5 },
  { 90, 3, 5, 4, 1, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 3, 5, 4, 1, -5 },
  { 97, 4, 6, 4, 0, -5 },
  { 100, 3, 5, 4, 1, -5 },
  { 102, 3, 5, 4, 1, -5 },
  { 104, 4, 5, 4, 0, -5 },
  { 107, 3, 5, 4, 1, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 5, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 1, 7, 4, 2, -6 },
  { 125, 2, 5, 4, 1, -5 },
  { 127, 1, 7, 4, 2, -6 },
  { 128, 2, 3, 4, 1, -5 },
  { 129, 3, 1, 4, 1, 0 },
  { 130, 1, 1, 4, 2, -5 },
  { 131, 3, 4, 4, 1, -4 },
  { 133, 3, 5, 4, 1, -5 },
  { 135, 3, 4, 4, 1, -4 },
  { 137, 2, 5, 4, 1, -5 },
  { 139, 3, 4, 4, 1, -4 },
  { 141, 3, 5, 4, 1, -5 },
  { 143, 2, 5, 4, 1, -4 },
  { 145, 3, 5, 4, 1, -5 },
  { 147, 3, 5, 4, 1, -5 },
  { 149, 2, 7, 4, 1, -5 },
  { 151, 3, 5, 4, 1, -5 },
  { 153, 3, 5, 4, 1, -5 },
  { 155, 4, 4, 4, 0, -4 },
  { 157, 3, 4, 4, 1, -4 },
  { 159, 4, 4, 4, 0, -4 },
  { 161, 3, 5, 4, 1, -4 },
  { 163, 2, 5, 4, 1, -4 },
  { 165, 3, 4, 4, 1, -4 },
  { 167, 3, 4, 4, 1, -4 },
  { 169, 2, 5, 4, 1, -5 },
  { 171, 2, 4, 4, 1, -4 },
  { 172, 4, 4, 4, 0, -4 },
  { 174, 4, 4, 4, 0, -4 },
  { 176, 3, 4, 4, 1, -4 },
  { 178, 4, 6, 4, 0, -4 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 2, 7, 4, 1, -5 },
  { 185, 1, 6, 4, 2, -5 },
  { 186, 2, 7, 4, 1, -5 },
  { 188, 4, 1, 4, 0, -3 },
};

const GFXfont RobotoMono_Thin7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin7pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_THIN7PT7B_H_
