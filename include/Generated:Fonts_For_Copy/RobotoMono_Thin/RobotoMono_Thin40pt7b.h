#ifndef _ROBOTOMONO_THIN40PT7B_H_
#define _ROBOTOMONO_THIN40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0x0F, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x00, 0x40, 0x60, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30,
  0x10, 0x00, 0x80, 0x40, 0x02, 0x02, 0x00, 0x08, 0x08, 0x00, 0x20, 0x20,
  0x3F, 0xFF, 0xFC, 0x04, 0x02, 0x00, 0x10, 0x10, 0x00, 0x40, 0x40, 0x01,
  0x01, 0x00, 0x04, 0x04, 0x00, 0x30, 0x10, 0x00, 0x80, 0xC0, 0x02, 0x02,
  0x00, 0x08, 0x08, 0x00, 0x20, 0x20, 0x3F, 0xFF, 0xFE, 0x04, 0x02, 0x00,
  0x10, 0x18, 0x00, 0x40, 0x40, 0x01, 0x01, 0x00, 0x04, 0x04, 0x00, 0x30,
  0x10, 0x00, 0x80, 0xC0, 0x02, 0x02, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x7C, 0x00, 0xE1, 0x80, 0x80, 0x30, 0x80, 0x08, 0x80, 0x02,
  0x40, 0x01, 0x20, 0x00, 0x90, 0x00, 0x28, 0x00, 0x14, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x34, 0x00, 0x11, 0x00, 0x10, 0x60,
  0x38, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x00, 0xCC, 0x00, 0x04, 0x10, 0x00, 0x20, 0x20, 0x00, 0x80,
  0x80, 0x82, 0x02, 0x06, 0x08, 0x08, 0x10, 0x20, 0x20, 0xC0, 0x80, 0x82,
  0x02, 0x02, 0x10, 0x0C, 0x18, 0x40, 0x10, 0x42, 0x00, 0x3E, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0xE0, 0x01,
  0x0C, 0xC0, 0x0C, 0x20, 0x80, 0x21, 0x01, 0x01, 0x04, 0x04, 0x04, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x81, 0x01, 0x04, 0x04, 0x04, 0x30, 0x10, 0x10,
  0x00, 0x60, 0x80, 0x00, 0x82, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x63,
  0x00, 0x08, 0x18, 0x01, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10,
  0x08, 0x01, 0x00, 0x80, 0x10, 0x10, 0x01, 0x83, 0x00, 0x08, 0x60, 0x00,
  0x48, 0x00, 0x05, 0x00, 0x00, 0x20, 0x00, 0x0D, 0x00, 0x01, 0x88, 0x00,
  0x10, 0xC0, 0x02, 0x06, 0x02, 0x40, 0x20, 0x24, 0x01, 0x06, 0x80, 0x08,
  0x48, 0x00, 0xC4, 0x80, 0x06, 0xC8, 0x00, 0x28, 0x40, 0x01, 0x84, 0x00,
  0x38, 0x20, 0x06, 0x41, 0x80, 0xC6, 0x0F, 0xF0, 0x30, 0xFF, 0x01, 0x03,
  0x02, 0x04, 0x08, 0x18, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x08, 0x0C,
  0x04, 0x02, 0x01, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x30, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0xC0,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x0F, 0x04, 0x1C, 0x72, 0x70, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xB0, 0x00,
  0x8C, 0x00, 0x82, 0x00, 0xC0, 0x80, 0xC0, 0x20, 0x40, 0x18, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x24, 0x92, 0x94, 0xFF, 0xFF, 0xFF, 0xF0, 0xEC, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x04, 0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x40, 0x00,
  0x01, 0xE0, 0x01, 0x87, 0x01, 0x80, 0x60, 0x40, 0x08, 0x20, 0x01, 0x08,
  0x00, 0x64, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x90, 0x00, 0xB8, 0x00,
  0x46, 0x00, 0x21, 0x80, 0x10, 0x60, 0x08, 0x18, 0x04, 0x06, 0x02, 0x01,
  0x81, 0x00, 0x60, 0x80, 0x18, 0x40, 0x07, 0x20, 0x01, 0x50, 0x00, 0xD8,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x02, 0x20, 0x01, 0x0C, 0x00, 0x41, 0x00,
  0x20, 0x30, 0x30, 0x07, 0xF8, 0x00, 0x01, 0xC1, 0xD1, 0x85, 0x81, 0x80,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x03, 0xE0, 0x03, 0x0E, 0x01, 0x00, 0x40,
  0x80, 0x08, 0x40, 0x03, 0x10, 0x00, 0x4C, 0x00, 0x12, 0x00, 0x04, 0x80,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xE0, 0x03, 0x87, 0x01, 0x80, 0x60, 0x80, 0x0C, 0x60, 0x01, 0x10, 0x00,
  0x24, 0x00, 0x09, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x04, 0x00, 0x06, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x02, 0x40, 0x00, 0x98, 0x00, 0x63, 0x00, 0x30,
  0x60, 0x18, 0x07, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x1A,
  0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x06, 0x20, 0x00, 0x42, 0x00, 0x08,
  0x20, 0x01, 0x82, 0x00, 0x10, 0x20, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x02, 0x01, 0x00, 0x20, 0x20, 0x02, 0x06,
  0x00, 0x20, 0x40, 0x02, 0x0F, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x3F, 0xFF, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x47,
  0xC0, 0x78, 0x30, 0x60, 0x0C, 0x80, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x02, 0x40, 0x06, 0x60, 0x04, 0x30, 0x18, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x38, 0x09, 0xE7,
  0x09, 0x80, 0x65, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x05, 0x00, 0x02,
  0x80, 0x01, 0x60, 0x01, 0x10, 0x00, 0x84, 0x00, 0x81, 0x81, 0x80, 0x7F,
  0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x00, 0xE3, 0x80, 0x60, 0x0C, 0x18,
  0x00, 0x82, 0x00, 0x08, 0x40, 0x01, 0x10, 0x00, 0x12, 0x00, 0x02, 0x40,
  0x00, 0x4C, 0x00, 0x18, 0x80, 0x02, 0x18, 0x00, 0xC1, 0x80, 0x30, 0x0C,
  0x18, 0x00, 0xFE, 0x00, 0x60, 0x30, 0x10, 0x01, 0x04, 0x00, 0x11, 0x00,
  0x01, 0x20, 0x00, 0x24, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00,
  0x02, 0x40, 0x00, 0x4C, 0x00, 0x18, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0x7F,
  0xC0, 0x03, 0xE0, 0x03, 0x86, 0x01, 0x80, 0x60, 0xC0, 0x08, 0x20, 0x01,
  0x10, 0x00, 0x44, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x0D, 0x80,
  0x06, 0x20, 0x02, 0x84, 0x01, 0x20, 0xC3, 0x88, 0x0F, 0x82, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x33, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x22, 0x22, 0x24, 0x48,
  0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x71, 0xC2, 0x01, 0x90, 0x02,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xDE, 0x00, 0x30, 0x06, 0x01, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x40, 0x00,
  0x63, 0x01, 0xC0, 0x88, 0x19, 0x82, 0x60, 0x81, 0x0D, 0x04, 0x04, 0x14,
  0x10, 0x20, 0x50, 0x80, 0x81, 0x82, 0x02, 0x06, 0x08, 0x08, 0x18, 0x20,
  0x20, 0x60, 0x80, 0x81, 0x82, 0x02, 0x06, 0x08, 0x18, 0x38, 0x20, 0x60,
  0xA0, 0x81, 0x82, 0x82, 0x0A, 0x09, 0x0C, 0x68, 0x44, 0x1F, 0x1E, 0x10,
  0x10, 0x10, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x60, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x50, 0x00,
  0x09, 0x00, 0x00, 0x98, 0x00, 0x08, 0x80, 0x01, 0x88, 0x00, 0x10, 0xC0,
  0x01, 0x04, 0x00, 0x30, 0x40, 0x02, 0x06, 0x00, 0x20, 0x20, 0x06, 0x02,
  0x00, 0x40, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x10, 0x08, 0x01, 0x00, 0x80,
  0x08, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x10, 0x00, 0x41, 0x00, 0x04, 0x20,
  0x00, 0x42, 0x00, 0x02, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xF0, 0x40, 0x06, 0x20, 0x01, 0x90, 0x00, 0x48, 0x00,
  0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0,
  0x00, 0x90, 0x00, 0x88, 0x03, 0x87, 0xFF, 0x82, 0x00, 0x31, 0x00, 0x04,
  0x80, 0x01, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x40, 0x01, 0x20, 0x03, 0x1F,
  0xFE, 0x00, 0x01, 0xF0, 0x01, 0x87, 0x01, 0x80, 0x60, 0x40, 0x04, 0x20,
  0x01, 0x98, 0x00, 0x24, 0x00, 0x0D, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x14, 0x00, 0x05, 0x00, 0x02, 0x20, 0x00, 0x88, 0x00,
  0x41, 0x00, 0x30, 0x30, 0x18, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x20, 0x06,
  0x08, 0x00, 0xC2, 0x00, 0x18, 0x80, 0x03, 0x20, 0x00, 0x48, 0x00, 0x1A,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x08, 0x80, 0x04, 0x20, 0x02, 0x08, 0x03, 0x03, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xF3, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xC7, 0x01,
  0x80, 0x60, 0xC0, 0x04, 0x20, 0x01, 0x90, 0x00, 0x24, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x05, 0x00,
  0x01, 0x20, 0x00, 0x4C, 0x00, 0x11, 0x80, 0x0C, 0x30, 0x0C, 0x03, 0xFE,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x90,
  0x00, 0x24, 0x00, 0x09, 0x00, 0x06, 0x20, 0x01, 0x0C, 0x00, 0x81, 0x80,
  0xC0, 0x1F, 0xE0, 0x80, 0x00, 0xD0, 0x00, 0x22, 0x00, 0x08, 0x40, 0x02,
  0x08, 0x00, 0xC1, 0x00, 0x30, 0x20, 0x0C, 0x04, 0x03, 0x00, 0x80, 0xC0,
  0x10, 0x10, 0x02, 0x04, 0x00, 0x41, 0x00, 0x08, 0x60, 0x01, 0x14, 0x00,
  0x24, 0x40, 0x05, 0x04, 0x00, 0xC0, 0xC0, 0x10, 0x0C, 0x02, 0x00, 0x80,
  0x40, 0x08, 0x08, 0x00, 0x81, 0x00, 0x18, 0x20, 0x01, 0x84, 0x00, 0x10,
  0x80, 0x01, 0x10, 0x00, 0x12, 0x00, 0x03, 0x40, 0x00, 0x30, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xB4, 0x00, 0x5A, 0x00, 0x4D, 0x00, 0x26, 0x40, 0x33, 0x20, 0x11, 0x98,
  0x08, 0xC4, 0x08, 0x62, 0x04, 0x30, 0x84, 0x18, 0x42, 0x0C, 0x31, 0x06,
  0x09, 0x03, 0x04, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x34, 0x00, 0x1A, 0x00, 0x0C, 0x80, 0x06, 0x40, 0x03, 0x10, 0x01, 0x8C,
  0x00, 0xC2, 0x00, 0x60, 0x80, 0x30, 0x40, 0x18, 0x10, 0x0C, 0x08, 0x06,
  0x02, 0x03, 0x01, 0x81, 0x80, 0x40, 0xC0, 0x10, 0x60, 0x08, 0x30, 0x02,
  0x18, 0x01, 0x0C, 0x00, 0x46, 0x00, 0x33, 0x00, 0x09, 0x80, 0x02, 0xC0,
  0x01, 0x60, 0x00, 0x70, 0x00, 0x30, 0x01, 0xE0, 0x01, 0x86, 0x01, 0x80,
  0x60, 0xC0, 0x08, 0x20, 0x01, 0x10, 0x00, 0x24, 0x00, 0x09, 0x00, 0x02,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x09, 0x00, 0x02,
  0x20, 0x01, 0x08, 0x00, 0x41, 0x00, 0x20, 0x30, 0x30, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x40, 0x06, 0x20, 0x00, 0x90, 0x00, 0x68, 0x00, 0x14, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x28, 0x00, 0x34, 0x00, 0x32, 0x00, 0x71, 0xFF, 0xE0, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x70, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x08, 0x10, 0x00,
  0xC2, 0x00, 0x04, 0x20, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00,
  0x03, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x22, 0x00, 0x04,
  0x20, 0x00, 0x41, 0x00, 0x08, 0x08, 0x01, 0x80, 0x60, 0x30, 0x03, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0xFF, 0xF0, 0x20, 0x03, 0x08, 0x00, 0x62, 0x00, 0x0C, 0x80, 0x01,
  0x20, 0x00, 0x48, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x68,
  0x00, 0x12, 0x00, 0x04, 0x80, 0x02, 0x20, 0x01, 0x08, 0x01, 0x83, 0xFF,
  0x80, 0x80, 0x20, 0x20, 0x04, 0x08, 0x01, 0x82, 0x00, 0x20, 0x80, 0x0C,
  0x20, 0x01, 0x08, 0x00, 0x22, 0x00, 0x08, 0x80, 0x01, 0x20, 0x00, 0x68,
  0x00, 0x0A, 0x00, 0x03, 0x01, 0xF0, 0x03, 0x83, 0x01, 0x80, 0x30, 0x80,
  0x06, 0x60, 0x00, 0x90, 0x00, 0x34, 0x00, 0x05, 0x00, 0x01, 0x40, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00,
  0x58, 0x00, 0x33, 0x00, 0x18, 0x60, 0x0C, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x09,
  0x80, 0x06, 0x20, 0x01, 0x04, 0x00, 0x80, 0xC0, 0xC0, 0x1F, 0xE0, 0x80,
  0x00, 0x34, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x04, 0x20, 0x00, 0x42,
  0x00, 0x04, 0x20, 0x00, 0xC1, 0x00, 0x08, 0x10, 0x00, 0x81, 0x00, 0x18,
  0x08, 0x01, 0x00, 0x80, 0x10, 0x08, 0x03, 0x00, 0x40, 0x20, 0x04, 0x02,
  0x00, 0x40, 0x20, 0x02, 0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x10,
  0x80, 0x01, 0x08, 0x00, 0x10, 0x80, 0x00, 0x90, 0x00, 0x09, 0x00, 0x00,
  0x90, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x20, 0x0C,
  0x01, 0x00, 0x60, 0x1C, 0x04, 0x80, 0xA0, 0x24, 0x05, 0x01, 0x20, 0x28,
  0x09, 0x01, 0x40, 0x48, 0x13, 0x02, 0x40, 0x88, 0x13, 0x04, 0x41, 0x08,
  0x22, 0x08, 0x41, 0x10, 0x42, 0x10, 0xC2, 0x10, 0x82, 0x10, 0x84, 0x10,
  0x84, 0x20, 0x88, 0x11, 0x04, 0x40, 0x90, 0x22, 0x04, 0x80, 0x90, 0x24,
  0x04, 0x81, 0x20, 0x24, 0x09, 0x01, 0x40, 0x30, 0x0A, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0x60,
  0x00, 0x32, 0x00, 0x06, 0x10, 0x00, 0x41, 0x80, 0x08, 0x08, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x03, 0x00, 0x20, 0x20, 0x01, 0x04, 0x00, 0x10, 0xC0,
  0x00, 0x88, 0x00, 0x0D, 0x00, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x70,
  0x00, 0x0D, 0x00, 0x00, 0x88, 0x00, 0x10, 0xC0, 0x01, 0x04, 0x00, 0x20,
  0x20, 0x04, 0x03, 0x00, 0x40, 0x10, 0x08, 0x00, 0x81, 0x80, 0x08, 0x10,
  0x00, 0x42, 0x00, 0x06, 0x60, 0x00, 0x2C, 0x00, 0x01, 0xC0, 0x00, 0x34,
  0x00, 0x06, 0x60, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x00, 0x10,
  0x18, 0x01, 0x00, 0x80, 0x20, 0x04, 0x02, 0x00, 0x40, 0x40, 0x02, 0x04,
  0x00, 0x20, 0x80, 0x01, 0x08, 0x00, 0x11, 0x00, 0x00, 0x90, 0x00, 0x0A,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00,
  0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xF8, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0x80, 0x04, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x0C, 0xFF, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x48, 0x01, 0x20, 0x0C, 0xC0, 0x21, 0x00, 0x84, 0x04, 0x08, 0x10, 0x20,
  0xC0, 0xC2, 0x01, 0x08, 0x04, 0x40, 0x09, 0x00, 0x28, 0x00, 0xC0, 0xFF,
  0xFF, 0x8C, 0x42, 0x31, 0x01, 0x80, 0x07, 0xFC, 0x0C, 0x03, 0x0C, 0x00,
  0x44, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0xFF, 0xC3, 0xC0, 0x26, 0x00, 0x12, 0x00, 0x0A, 0x00, 0x05,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x01, 0xA0, 0x01, 0xD8, 0x01, 0xA6, 0x01,
  0x90, 0xFF, 0x0C, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x80, 0x47, 0xF8,
  0x26, 0x02, 0x14, 0x00, 0x8E, 0x00, 0x26, 0x00, 0x12, 0x00, 0x05, 0x00,
  0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x60, 0x01, 0x30, 0x00,
  0x94, 0x00, 0x89, 0x80, 0x84, 0x7F, 0x80, 0x00, 0xC0, 0x03, 0xFC, 0x03,
  0x01, 0x82, 0x00, 0x62, 0x00, 0x11, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x90, 0x00, 0x4C, 0x00, 0x42,
  0x00, 0x60, 0xC0, 0x60, 0x3F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x80, 0x83, 0xFC, 0x46, 0x03, 0x22, 0x00, 0x52, 0x00, 0x19, 0x00, 0x0D,
  0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x90,
  0x00, 0xC8, 0x00, 0x62, 0x00, 0x50, 0x80, 0xC8, 0x3F, 0xC4, 0x00, 0x40,
  0x01, 0xFE, 0x00, 0xC0, 0x60, 0x40, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x24,
  0x00, 0x09, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x03, 0x00, 0x08, 0x60, 0x06, 0x0C, 0x03, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x30, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xC0, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x03, 0xFC,
  0x42, 0x03, 0x22, 0x00, 0x52, 0x00, 0x39, 0x00, 0x0D, 0x00, 0x02, 0x80,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A,
  0x00, 0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x90, 0x00, 0xC8, 0x00,
  0x62, 0x00, 0x50, 0x80, 0xC8, 0x3F, 0xC4, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x00, 0x88, 0x00, 0xC6, 0x00, 0x41, 0x80, 0xC0, 0x3F, 0xC0,
  0x03, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x40, 0x87, 0xF8, 0x8C, 0x04,
  0x90, 0x02, 0xA0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x01, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x00, 0x10, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0x87, 0xF8,
  0x4C, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x06, 0x80, 0x0C,
  0x80, 0x18, 0x80, 0x20, 0x80, 0x40, 0x81, 0x80, 0x83, 0x00, 0x86, 0x00,
  0x8C, 0x00, 0x9C, 0x00, 0xA6, 0x00, 0xC3, 0x00, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x80, 0x20, 0x80, 0x10, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0x04, 0x01, 0x0B, 0xF8, 0xFE, 0xE0, 0xD0, 0x3C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40,
  0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04,
  0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x00, 0x40, 0x87,
  0xF8, 0x8C, 0x04, 0x90, 0x02, 0xA0, 0x02, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x80, 0x01, 0xFE, 0x01, 0x80, 0x60,
  0xC0, 0x0C, 0x20, 0x01, 0x10, 0x00, 0x24, 0x00, 0x0A, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x40, 0x00, 0x90, 0x00, 0x22, 0x00, 0x10,
  0xC0, 0x0C, 0x0C, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x8F, 0xF0, 0x98,
  0x08, 0xA0, 0x04, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x02, 0xC0, 0x02, 0xA0, 0x04, 0x98,
  0x18, 0x8F, 0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x80, 0x03, 0xFC, 0x46,
  0x03, 0x22, 0x00, 0x52, 0x00, 0x39, 0x00, 0x0D, 0x00, 0x02, 0x80, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00,
  0x05, 0x00, 0x02, 0x80, 0x01, 0x40, 0x00, 0x90, 0x00, 0xC8, 0x00, 0x62,
  0x00, 0x50, 0x80, 0xC8, 0x3F, 0xC4, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x24, 0x3F, 0xE6, 0x01, 0x60, 0x0A, 0x00, 0x60, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00,
  0x80, 0x07, 0xFC, 0x0C, 0x01, 0x8C, 0x00, 0x64, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x02, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x60, 0x7F, 0xC0, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0xFF, 0xFE,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01,
  0x40, 0x03, 0x40, 0x03, 0x20, 0x05, 0x30, 0x19, 0x0F, 0xF1, 0xC0, 0x00,
  0x34, 0x00, 0x02, 0x60, 0x00, 0x62, 0x00, 0x04, 0x20, 0x00, 0xC1, 0x00,
  0x08, 0x10, 0x00, 0x80, 0x80, 0x10, 0x08, 0x01, 0x00, 0xC0, 0x20, 0x04,
  0x02, 0x00, 0x60, 0x60, 0x02, 0x04, 0x00, 0x20, 0x40, 0x01, 0x08, 0x00,
  0x10, 0x80, 0x01, 0x90, 0x00, 0x09, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x10, 0x05, 0x00, 0xC0, 0x24, 0x03, 0x00, 0x90,
  0x0A, 0x02, 0x20, 0x28, 0x08, 0x81, 0x20, 0x62, 0x04, 0x81, 0x08, 0x13,
  0x04, 0x30, 0x44, 0x10, 0x42, 0x10, 0x41, 0x08, 0x42, 0x04, 0x20, 0x88,
  0x18, 0x82, 0x20, 0x24, 0x08, 0x80, 0x90, 0x24, 0x02, 0x40, 0x50, 0x0A,
  0x01, 0x40, 0x18, 0x05, 0x00, 0x60, 0x14, 0x01, 0x80, 0x20, 0x04, 0x00,
  0x80, 0xC0, 0x00, 0xC4, 0x00, 0x30, 0xC0, 0x04, 0x0C, 0x01, 0x00, 0x80,
  0x40, 0x08, 0x18, 0x00, 0x86, 0x00, 0x18, 0x80, 0x01, 0xA0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xD0, 0x00, 0x13, 0x00, 0x04, 0x30, 0x01, 0x82,
  0x00, 0x60, 0x20, 0x08, 0x02, 0x02, 0x00, 0x60, 0x80, 0x06, 0x30, 0x00,
  0x4C, 0x00, 0x06, 0x80, 0x00, 0x1C, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00,
  0x06, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x00, 0x81, 0x00, 0x08, 0x08,
  0x01, 0x00, 0x80, 0x10, 0x04, 0x02, 0x00, 0x40, 0x20, 0x02, 0x06, 0x00,
  0x20, 0x40, 0x01, 0x0C, 0x00, 0x10, 0x80, 0x01, 0x88, 0x00, 0x09, 0x00,
  0x00, 0xD0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x30, 0x04, 0x01,
  0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x30,
  0x0C, 0x00, 0xE0, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x08, 0x00, 0x1F, 0x00, 0x0C, 0xC3, 0x00, 0x24, 0x06,
  0x00, 0x90, 0x04, 0x02, 0x40, 0x0C, 0x12, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoMono_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 2, 28, 24, 11, -28 },
  { 8, 6, 8, 24, 9, -30 },
  { 14, 22, 28, 24, 1, -28 },
  { 91, 17, 36, 24, 4, -32 },
  { 168, 22, 29, 24, 1, -29 },
  { 248, 20, 29, 24, 3, -29 },
  { 321, 1, 8, 24, 11, -30 },
  { 322, 8, 41, 24, 8, -32 },
  { 363, 9, 41, 24, 7, -32 },
  { 410, 17, 15, 24, 4, -28 },
  { 442, 20, 21, 24, 2, -24 },
  { 495, 3, 8, 24, 8, -3 },
  { 498, 14, 2, 24, 5, -14 },
  { 502, 3, 2, 24, 11, -2 },
  { 503, 13, 30, 24, 6, -28 },
  { 552, 18, 29, 24, 3, -29 },
  { 618, 10, 28, 24, 4, -28 },
  { 653, 18, 29, 24, 2, -29 },
  { 719, 18, 29, 24, 2, -29 },
  { 785, 20, 28, 24, 2, -28 },
  { 855, 16, 28, 24, 5, -28 },
  { 911, 17, 29, 24, 3, -29 },
  { 973, 18, 28, 24, 3, -28 },
  { 1036, 19, 29, 24, 3, -29 },
  { 1105, 18, 29, 24, 3, -29 },
  { 1171, 2, 19, 24, 13, -19 },
  { 1176, 4, 24, 24, 11, -19 },
  { 1188, 17, 16, 24, 3, -21 },
  { 1222, 18, 9, 24, 3, -18 },
  { 1243, 17, 16, 24, 4, -21 },
  { 1277, 14, 29, 24, 5, -29 },
  { 1328, 22, 29, 24, 1, -29 },
  { 1408, 20, 28, 24, 2, -28 },
  { 1478, 17, 28, 24, 4, -28 },
  { 1538, 18, 29, 24, 3, -29 },
  { 1604, 18, 28, 24, 4, -28 },
  { 1667, 16, 28, 24, 4, -28 },
  { 1723, 17, 28, 24, 4, -28 },
  { 1783, 18, 29, 24, 3, -29 },
  { 1849, 18, 28, 24, 3, -28 },
  { 1912, 16, 28, 24, 4, -28 },
  { 1968, 18, 28, 24, 2, -28 },
  { 2031, 19, 28, 24, 4, -28 },
  { 2098, 16, 28, 24, 5, -28 },
  { 2154, 17, 28, 24, 4, -28 },
  { 2214, 17, 28, 24, 4, -28 },
  { 2274, 18, 29, 24, 3, -29 },
  { 2340, 17, 28, 24, 5, -28 },
  { 2400, 20, 34, 24, 2, -29 },
  { 2485, 18, 28, 24, 4, -28 },
  { 2548, 18, 29, 24, 3, -29 },
  { 2614, 20, 28, 24, 2, -28 },
  { 2684, 18, 28, 24, 3, -28 },
  { 2747, 20, 28, 24, 2, -28 },
  { 2817, 21, 28, 24, 2, -28 },
  { 2891, 20, 28, 24, 2, -28 },
  { 2961, 20, 28, 24, 2, -28 },
  { 3031, 17, 28, 24, 3, -28 },
  { 3091, 6, 39, 24, 9, -33 },
  { 3121, 13, 30, 24, 6, -28 },
  { 3170, 6, 39, 24, 9, -33 },
  { 3200, 14, 15, 24, 5, -28 },
  { 3227, 16, 1, 24, 4, 0 },
  { 3229, 4, 6, 24, 10, -30 },
  { 3232, 17, 22, 24, 4, -22 },
  { 3279, 17, 30, 24, 4, -30 },
  { 3343, 17, 22, 24, 3, -22 },
  { 3390, 17, 30, 24, 3, -30 },
  { 3454, 18, 22, 24, 3, -22 },
  { 3504, 18, 30, 24, 4, -30 },
  { 3572, 17, 31, 24, 3, -22 },
  { 3638, 16, 30, 24, 4, -30 },
  { 3698, 16, 29, 24, 5, -29 },
  { 3756, 13, 38, 24, 3, -29 },
  { 3818, 16, 30, 24, 5, -30 },
  { 3878, 16, 30, 24, 5, -30 },
  { 3938, 20, 22, 24, 2, -22 },
  { 3993, 16, 22, 24, 4, -22 },
  { 4037, 18, 22, 24, 3, -22 },
  { 4087, 16, 30, 24, 4, -22 },
  { 4147, 17, 30, 24, 3, -22 },
  { 4211, 13, 22, 24, 8, -22 },
  { 4247, 17, 22, 24, 4, -22 },
  { 4294, 16, 27, 24, 4, -27 },
  { 4348, 16, 21, 24, 4, -21 },
  { 4390, 20, 21, 24, 2, -21 },
  { 4443, 22, 21, 24, 1, -21 },
  { 4501, 19, 21, 24, 3, -21 },
  { 4551, 20, 30, 24, 2, -21 },
  { 4626, 19, 21, 24, 3, -21 },
  { 4676, 12, 40, 24, 7, -31 },
  { 4736, 2, 33, 24, 11, -28 },
  { 4745, 12, 40, 24, 7, -31 },
  { 4805, 22, 6, 24, 1, -15 },
};

const GFXfont RobotoMono_Thin40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin40pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_THIN40PT7B_H_
