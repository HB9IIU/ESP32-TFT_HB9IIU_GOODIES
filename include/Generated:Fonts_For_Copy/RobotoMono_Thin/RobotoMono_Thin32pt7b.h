#ifndef _ROBOTOMONO_THIN32PT7B_H_
#define _ROBOTOMONO_THIN32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin32pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0x1C, 0x8C, 0x63, 0x18, 0xC4, 0x01,
  0x02, 0x00, 0x82, 0x00, 0x41, 0x00, 0x20, 0x80, 0x20, 0x40, 0x10, 0x20,
  0x08, 0x10, 0xFF, 0xFF, 0x02, 0x08, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81,
  0x00, 0x41, 0x00, 0x20, 0x80, 0x10, 0x40, 0x10, 0x20, 0xFF, 0xFF, 0x04,
  0x08, 0x02, 0x08, 0x01, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x03, 0xF0, 0x10, 0x30, 0x80, 0x44, 0x00,
  0x90, 0x02, 0x40, 0x05, 0x00, 0x14, 0x00, 0x08, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x14, 0x00, 0x90, 0x02, 0x20, 0x10, 0x7F, 0x80, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x38, 0x00, 0x22, 0x00, 0x20, 0x80, 0x10, 0x40, 0x88,
  0x20, 0x84, 0x10, 0x82, 0x08, 0x41, 0x04, 0x40, 0x82, 0x20, 0x36, 0x20,
  0x04, 0x10, 0x00, 0x10, 0x00, 0x08, 0x00, 0x08, 0x78, 0x08, 0x42, 0x04,
  0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x11, 0x02, 0x08,
  0x00, 0x84, 0x00, 0x3C, 0x0F, 0x00, 0x21, 0x00, 0x81, 0x01, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x20, 0x10, 0xC0, 0x13, 0x00, 0x28, 0x00, 0x20,
  0x00, 0xA0, 0x02, 0x20, 0x08, 0x60, 0x60, 0x41, 0x40, 0x42, 0x80, 0x45,
  0x00, 0x4A, 0x00, 0x64, 0x00, 0xC8, 0x01, 0x8C, 0x0C, 0x8F, 0xE0, 0x80,
  0xFC, 0x02, 0x08, 0x20, 0x81, 0x04, 0x08, 0x20, 0x40, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x10, 0x20, 0x40, 0x40,
  0x80, 0x81, 0x01, 0x01, 0x01, 0x81, 0x02, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x84, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x81, 0x05, 0xC4, 0xE0, 0xFC, 0x00, 0xC0, 0x04, 0x80, 0x31, 0x00, 0x82,
  0x04, 0x0C, 0x20, 0x10, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFE, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x24, 0x95, 0x00, 0xFF, 0xE0, 0x70, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x00, 0x0F, 0x80, 0xC1, 0x82, 0x01, 0x10, 0x04, 0x80, 0x0A, 0x00,
  0x28, 0x01, 0xA0, 0x09, 0x80, 0x46, 0x02, 0x18, 0x10, 0x60, 0x81, 0x84,
  0x06, 0x20, 0x19, 0x80, 0x6C, 0x01, 0xE0, 0x0B, 0x00, 0x28, 0x00, 0x90,
  0x04, 0x40, 0x10, 0xC0, 0x81, 0xFC, 0x00, 0x02, 0x1C, 0xCE, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x0F, 0x80, 0xC1, 0x84, 0x01, 0x10, 0x04, 0x80,
  0x0A, 0x00, 0x28, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0xC0,
  0x84, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x06, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x80,
  0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x02, 0x40, 0x08, 0x80, 0xC1,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x50, 0x00, 0x90,
  0x00, 0x90, 0x01, 0x10, 0x02, 0x10, 0x02, 0x10, 0x04, 0x10, 0x08, 0x10,
  0x08, 0x10, 0x10, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x7F, 0xFA, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x05, 0xFC, 0x30, 0x18, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00,
  0x20, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x05, 0x00, 0x24, 0x01, 0x10, 0x10,
  0x7F, 0x00, 0x00, 0xF0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x47, 0xC1, 0x60, 0xCA, 0x00, 0xB0, 0x02, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x50,
  0x02, 0x20, 0x08, 0x40, 0x40, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0xC6, 0x01, 0x10, 0x02, 0x80, 0x0A,
  0x00, 0x18, 0x00, 0x50, 0x02, 0x40, 0x08, 0x80, 0x41, 0x86, 0x03, 0xF0,
  0x30, 0x31, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x40, 0x08, 0x80, 0x41, 0xFE, 0x00, 0x0F, 0x81, 0x83, 0x10,
  0x0C, 0x80, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x14, 0x01, 0xB0, 0x14, 0x43, 0x21, 0xC1, 0x00, 0x08,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x7C, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x12, 0x49, 0x40, 0x00, 0x08,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x80, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x20, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x1F, 0x82, 0x04, 0x40, 0x28,
  0x02, 0x80, 0x18, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x01, 0xF8, 0x03, 0x02, 0x02, 0x00,
  0x82, 0x00, 0x22, 0x00, 0x12, 0x0F, 0x85, 0x08, 0x42, 0x84, 0x21, 0x84,
  0x10, 0xC2, 0x08, 0x62, 0x04, 0x31, 0x02, 0x18, 0x81, 0x0C, 0x40, 0x86,
  0x20, 0xC3, 0x10, 0x61, 0x84, 0x51, 0x42, 0x4D, 0x90, 0xC3, 0x08, 0x00,
  0x02, 0x00, 0x00, 0xC0, 0x40, 0x1F, 0xC0, 0x01, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x02, 0x80, 0x02, 0x40, 0x02, 0x40, 0x04, 0x40, 0x04, 0x20, 0x04,
  0x20, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x10, 0x10, 0x10, 0x08, 0x10,
  0x08, 0x3F, 0xF8, 0x20, 0x04, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x40,
  0x02, 0x80, 0x02, 0x80, 0x01, 0xFF, 0x02, 0x03, 0x88, 0x01, 0x20, 0x02,
  0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x48, 0x06,
  0x3F, 0xF0, 0x80, 0x32, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x02, 0x80, 0x0A, 0x00, 0xCF, 0xFC, 0x00, 0x07, 0xE0,
  0x30, 0x20, 0x40, 0x21, 0x00, 0x24, 0x00, 0x48, 0x00, 0x50, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x40, 0x02, 0x80, 0x05, 0x00, 0x11, 0x00, 0x22,
  0x00, 0x82, 0x02, 0x03, 0xF8, 0x00, 0xFE, 0x02, 0x03, 0x08, 0x02, 0x20,
  0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x28, 0x00, 0xA0, 0x04, 0x80, 0x22, 0x01, 0x0F, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xE8, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0xFF, 0xC8, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x20, 0xC0, 0x21, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x1F, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x80,
  0x05, 0x00, 0x09, 0x00, 0x12, 0x00, 0x23, 0x01, 0x81, 0xFC, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x20, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x03, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x90, 0x02, 0x40, 0x10, 0x80, 0x81, 0xFC, 0x00, 0x80, 0x0E, 0x00, 0x68,
  0x03, 0x20, 0x18, 0x80, 0x42, 0x02, 0x08, 0x10, 0x20, 0x80, 0x84, 0x02,
  0x20, 0x09, 0x00, 0x2A, 0x00, 0xC4, 0x02, 0x08, 0x08, 0x30, 0x20, 0x40,
  0x80, 0x82, 0x01, 0x08, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00, 0x28, 0x00,
  0x40, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x03, 0xFF, 0xE0, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0x70, 0x05, 0xA0, 0x16,
  0x80, 0x99, 0x02, 0x64, 0x11, 0x90, 0x46, 0x21, 0x18, 0x88, 0x61, 0x21,
  0x85, 0x06, 0x14, 0x18, 0x20, 0x60, 0x81, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x40, 0x1A, 0x00, 0xC8, 0x06, 0x40, 0x31, 0x01, 0x88, 0x0C, 0x20,
  0x61, 0x03, 0x04, 0x18, 0x10, 0xC0, 0x86, 0x02, 0x30, 0x11, 0x80, 0x4C,
  0x02, 0x60, 0x0B, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x20, 0x07, 0xC0,
  0x30, 0x60, 0xC0, 0x21, 0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x40, 0x02, 0x80, 0x09, 0x00, 0x11, 0x00, 0x22,
  0x00, 0x82, 0x02, 0x03, 0xF8, 0x00, 0xFF, 0x82, 0x01, 0x88, 0x01, 0x20,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x0A, 0x00, 0x28,
  0x01, 0xA0, 0x0C, 0xFF, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xC0, 0x18, 0x30, 0x20, 0x08, 0x20, 0x04, 0x40, 0x04, 0x40, 0x02, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x40,
  0x04, 0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x0F, 0xE0, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0xFF, 0x04, 0x06, 0x20, 0x09, 0x00, 0x28,
  0x01, 0x40, 0x0A, 0x00, 0x30, 0x01, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x00,
  0x8F, 0xF8, 0x40, 0x82, 0x02, 0x10, 0x10, 0x80, 0x44, 0x02, 0x20, 0x09,
  0x00, 0x28, 0x01, 0x40, 0x06, 0x00, 0x20, 0x07, 0xE0, 0x30, 0x30, 0x80,
  0x32, 0x00, 0x24, 0x00, 0x28, 0x00, 0x50, 0x00, 0x20, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x12, 0x00, 0x42, 0x01,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x80, 0x14, 0x01, 0x10,
  0x10, 0x7F, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x24, 0x00,
  0x48, 0x00, 0x88, 0x02, 0x10, 0x04, 0x20, 0x08, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x80, 0x82, 0x01, 0x04, 0x02, 0x08, 0x02, 0x10, 0x04, 0x40, 0x08,
  0x80, 0x09, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0x40, 0x00, 0x81,
  0x01, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x81, 0x82,
  0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x44, 0x42, 0x44, 0x22, 0x44,
  0x24, 0x24, 0x24, 0x24, 0x24, 0x28, 0x24, 0x28, 0x14, 0x28, 0x14, 0x28,
  0x14, 0x28, 0x18, 0x10, 0x18, 0x10, 0x08, 0x10, 0x08, 0x80, 0x03, 0x40,
  0x02, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08, 0x10, 0x04,
  0x20, 0x02, 0x40, 0x02, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x40, 0x04, 0x40, 0x04, 0x20, 0x08, 0x10, 0x10, 0x10, 0x10, 0x08, 0x20,
  0x04, 0x20, 0x04, 0x40, 0x02, 0x80, 0x03, 0xC0, 0x01, 0x40, 0x01, 0x20,
  0x02, 0x20, 0x02, 0x10, 0x04, 0x10, 0x04, 0x08, 0x08, 0x08, 0x10, 0x04,
  0x10, 0x04, 0x20, 0x02, 0x20, 0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0x80, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x10,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0F, 0xFF, 0xC0, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x20, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87,
  0xE0, 0x04, 0x00, 0xC0, 0x28, 0x05, 0x01, 0x10, 0x22, 0x04, 0x21, 0x04,
  0x20, 0x88, 0x09, 0x01, 0x20, 0x18, 0x02, 0xFF, 0xF8, 0x8C, 0x43, 0x1F,
  0xC1, 0x01, 0x90, 0x05, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x1F,
  0x1F, 0x0B, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x68,
  0x0D, 0x3F, 0x88, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x11, 0xF8, 0x90, 0x25, 0x00, 0xB0, 0x05, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x01, 0x60, 0x0A, 0xC0, 0x91, 0xF8, 0x0F, 0xC1, 0x81, 0x18, 0x04, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0xA0, 0x05, 0x00, 0x46, 0x06, 0x0F, 0xC0, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x23, 0xF1, 0x20,
  0x6A, 0x00, 0xD0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x14, 0x00, 0xA0, 0x0C, 0x80, 0xA3,
  0xF9, 0x0F, 0xC0, 0xC0, 0x86, 0x01, 0x10, 0x02, 0x80, 0x0A, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01,
  0x00, 0x06, 0x00, 0x8C, 0x04, 0x0F, 0xE0, 0x01, 0xFC, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x3F, 0xFE, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x1F, 0x89, 0x03, 0x50, 0x06, 0x80, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x05,
  0x00, 0x64, 0x05, 0x1F, 0xC8, 0x00, 0x40, 0x02, 0x00, 0x24, 0x01, 0x20,
  0x10, 0xC1, 0x01, 0xF0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x11, 0xFC, 0x90, 0x35, 0x00, 0xB0, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x06, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x06, 0x3E, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x02,
  0x80, 0x24, 0x06, 0x20, 0x61, 0x04, 0x08, 0x40, 0x44, 0x02, 0x40, 0x15,
  0x00, 0xC4, 0x04, 0x10, 0x20, 0x41, 0x01, 0x08, 0x04, 0x40, 0x12, 0x00,
  0xD0, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x1F, 0xFF, 0x9F, 0x3E, 0x50, 0xA0, 0xB0, 0x30, 0x30,
  0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x80, 0x80, 0x8F, 0xC4, 0x81, 0xA8, 0x05, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x0F, 0xE0,
  0x20, 0x20, 0x80, 0x22, 0x00, 0x24, 0x00, 0x48, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x14, 0x00, 0x48, 0x00,
  0x88, 0x02, 0x08, 0x08, 0x0F, 0xE0, 0x8F, 0xC5, 0x81, 0x28, 0x05, 0x80,
  0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x0B, 0x00, 0x54, 0x04, 0x9F, 0xC4, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x1F, 0x89, 0x03,
  0x50, 0x06, 0x80, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x05, 0x00, 0x64, 0x05, 0x1F,
  0xC8, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x87, 0xF3, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x00,
  0x1F, 0xE0, 0x80, 0x44, 0x00, 0x90, 0x02, 0x40, 0x05, 0x00, 0x02, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x02, 0x00, 0x06, 0x00,
  0x34, 0x00, 0x98, 0x04, 0x1F, 0xE0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x0F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x04, 0x00, 0x1F, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xA0, 0x0D, 0x00, 0x64, 0x05, 0x1F, 0xC8, 0x80, 0x03, 0x00,
  0x05, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01, 0x04, 0x02, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00,
  0xA0, 0x01, 0x40, 0x01, 0x00, 0x80, 0x80, 0xC0, 0x40, 0x50, 0x30, 0x28,
  0x28, 0x14, 0x14, 0x12, 0x09, 0x08, 0x84, 0x84, 0x44, 0x42, 0x22, 0x22,
  0x11, 0x09, 0x04, 0x84, 0x82, 0x82, 0x41, 0x41, 0x40, 0xA0, 0x60, 0x50,
  0x30, 0x10, 0x18, 0x08, 0x08, 0x00, 0x40, 0x06, 0x40, 0x08, 0x40, 0x20,
  0xC0, 0x80, 0x82, 0x00, 0x8C, 0x00, 0x90, 0x00, 0xC0, 0x01, 0x00, 0x05,
  0x00, 0x09, 0x00, 0x21, 0x00, 0x81, 0x02, 0x02, 0x08, 0x02, 0x10, 0x02,
  0xC0, 0x02, 0xC0, 0x00, 0xA0, 0x00, 0x90, 0x00, 0x44, 0x00, 0x42, 0x00,
  0x20, 0x80, 0x20, 0x40, 0x10, 0x10, 0x10, 0x08, 0x08, 0x02, 0x04, 0x01,
  0x04, 0x00, 0x42, 0x00, 0x22, 0x00, 0x09, 0x00, 0x05, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFF,
  0xFE, 0x00, 0x40, 0x60, 0x20, 0x08, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x01, 0x03, 0x80, 0xE0, 0x04, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x02, 0x00, 0xC0, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x80, 0x30, 0x03, 0x00, 0xC0, 0xC0, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x04, 0x02, 0x03,
  0x00, 0x3E, 0x00, 0xA0, 0x80, 0x50, 0x20, 0x30, 0x0C, 0x28, 0x01, 0xE0,
};

const GFXglyph RobotoMono_Thin32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 2, 23, 19, 8, -23 },
  { 7, 5, 6, 19, 7, -24 },
  { 11, 17, 23, 19, 1, -23 },
  { 60, 14, 29, 19, 3, -26 },
  { 111, 17, 23, 19, 1, -23 },
  { 160, 15, 23, 19, 3, -23 },
  { 204, 1, 6, 19, 8, -24 },
  { 205, 7, 32, 19, 6, -25 },
  { 233, 6, 32, 19, 6, -25 },
  { 257, 14, 13, 19, 3, -23 },
  { 280, 15, 17, 19, 2, -19 },
  { 312, 3, 6, 19, 6, -2 },
  { 315, 11, 1, 19, 4, -11 },
  { 317, 2, 2, 19, 9, -2 },
  { 318, 10, 25, 19, 5, -23 },
  { 350, 14, 23, 19, 3, -23 },
  { 391, 7, 23, 19, 4, -23 },
  { 412, 14, 23, 19, 2, -23 },
  { 453, 14, 23, 19, 2, -23 },
  { 494, 16, 23, 19, 1, -23 },
  { 540, 13, 23, 19, 4, -23 },
  { 578, 14, 23, 19, 2, -23 },
  { 619, 15, 23, 19, 2, -23 },
  { 663, 14, 23, 19, 3, -23 },
  { 704, 13, 23, 19, 3, -23 },
  { 742, 2, 16, 19, 10, -16 },
  { 746, 3, 20, 19, 9, -16 },
  { 754, 13, 13, 19, 3, -17 },
  { 776, 14, 7, 19, 3, -14 },
  { 789, 13, 13, 19, 3, -17 },
  { 811, 12, 23, 19, 4, -23 },
  { 846, 17, 23, 19, 1, -23 },
  { 895, 16, 23, 19, 2, -23 },
  { 941, 14, 23, 19, 3, -23 },
  { 982, 15, 23, 19, 2, -23 },
  { 1026, 14, 23, 19, 3, -23 },
  { 1067, 13, 23, 19, 3, -23 },
  { 1105, 13, 23, 19, 4, -23 },
  { 1143, 15, 23, 19, 2, -23 },
  { 1187, 13, 23, 19, 3, -23 },
  { 1225, 13, 23, 19, 3, -23 },
  { 1263, 14, 23, 19, 2, -23 },
  { 1304, 14, 23, 19, 4, -23 },
  { 1345, 13, 23, 19, 4, -23 },
  { 1383, 14, 23, 19, 3, -23 },
  { 1424, 13, 23, 19, 3, -23 },
  { 1462, 15, 23, 19, 2, -23 },
  { 1506, 14, 23, 19, 4, -23 },
  { 1547, 16, 27, 19, 2, -23 },
  { 1601, 13, 23, 19, 4, -23 },
  { 1639, 15, 23, 19, 2, -23 },
  { 1683, 16, 23, 19, 2, -23 },
  { 1729, 13, 23, 19, 3, -23 },
  { 1767, 15, 23, 19, 2, -23 },
  { 1811, 16, 23, 19, 2, -23 },
  { 1857, 16, 23, 19, 2, -23 },
  { 1903, 16, 23, 19, 1, -23 },
  { 1949, 14, 23, 19, 2, -23 },
  { 1990, 5, 31, 19, 7, -26 },
  { 2010, 11, 25, 19, 4, -23 },
  { 2045, 5, 31, 19, 7, -26 },
  { 2065, 11, 13, 19, 4, -23 },
  { 2083, 13, 1, 19, 3, 0 },
  { 2085, 4, 4, 19, 8, -24 },
  { 2087, 13, 17, 19, 3, -17 },
  { 2115, 13, 24, 19, 3, -24 },
  { 2154, 13, 17, 19, 3, -17 },
  { 2182, 13, 24, 19, 3, -24 },
  { 2221, 14, 17, 19, 3, -17 },
  { 2251, 14, 24, 19, 3, -24 },
  { 2293, 13, 24, 19, 3, -17 },
  { 2332, 13, 24, 19, 3, -24 },
  { 2371, 13, 23, 19, 4, -23 },
  { 2409, 10, 30, 19, 3, -23 },
  { 2447, 13, 24, 19, 4, -24 },
  { 2486, 13, 24, 19, 4, -24 },
  { 2525, 17, 17, 19, 1, -17 },
  { 2562, 13, 17, 19, 3, -17 },
  { 2590, 15, 17, 19, 2, -17 },
  { 2622, 13, 24, 19, 3, -17 },
  { 2661, 13, 24, 19, 3, -17 },
  { 2700, 11, 17, 19, 6, -17 },
  { 2724, 14, 17, 19, 3, -17 },
  { 2754, 13, 21, 19, 3, -21 },
  { 2789, 13, 17, 19, 3, -17 },
  { 2817, 15, 17, 19, 2, -17 },
  { 2849, 17, 17, 19, 1, -17 },
  { 2886, 15, 17, 19, 2, -17 },
  { 2918, 17, 24, 19, 1, -17 },
  { 2969, 15, 17, 19, 2, -17 },
  { 3001, 10, 32, 19, 5, -25 },
  { 3041, 1, 27, 19, 9, -23 },
  { 3045, 10, 32, 19, 5, -25 },
  { 3085, 17, 5, 19, 1, -12 },
};

const GFXfont RobotoMono_Thin32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin32pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_THIN32PT7B_H_
