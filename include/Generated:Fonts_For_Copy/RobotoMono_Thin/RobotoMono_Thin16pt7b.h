#ifndef _ROBOTOMONO_THIN16PT7B_H_
#define _ROBOTOMONO_THIN16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xFC, 0x09, 0x08, 0x84, 0x4F, 0xD1, 0x20, 0x90, 0x49,
  0xFF, 0x24, 0x12, 0x09, 0x00, 0x10, 0xEC, 0x61, 0x86, 0x04, 0x0E, 0x04,
  0x18, 0x61, 0x68, 0x41, 0x00, 0x60, 0x48, 0x24, 0x92, 0x49, 0x43, 0x20,
  0x20, 0x17, 0x14, 0x8A, 0x49, 0x20, 0x70, 0x38, 0x44, 0x44, 0x44, 0x48,
  0x30, 0x50, 0x49, 0x85, 0x86, 0x82, 0x7D, 0xE0, 0x12, 0x44, 0x88, 0x88,
  0x88, 0x88, 0x84, 0x42, 0x10, 0x89, 0x12, 0x49, 0x24, 0x92, 0x52, 0x80,
  0x10, 0x4D, 0xCC, 0x4A, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0xE0, 0xFC, 0x80, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41, 0x04,
  0x20, 0x38, 0x89, 0x0C, 0x18, 0x71, 0x64, 0xD1, 0xC3, 0x05, 0x09, 0xE0,
  0x79, 0x11, 0x11, 0x11, 0x11, 0x10, 0x38, 0x8A, 0x14, 0x10, 0x40, 0x82,
  0x08, 0x10, 0x41, 0x07, 0xF0, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x8F, 0x01,
  0x03, 0x06, 0x0B, 0xE0, 0x04, 0x0C, 0x14, 0x24, 0x24, 0x44, 0x84, 0xFF,
  0x04, 0x04, 0x04, 0xFE, 0x08, 0x20, 0xF8, 0x10, 0x41, 0x86, 0x17, 0x80,
  0x0C, 0x61, 0x02, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0xFE,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x80, 0x18, 0x66, 0x42,
  0x81, 0x42, 0x42, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x7E, 0x38, 0x8A, 0x0C,
  0x18, 0x30, 0x60, 0xB3, 0x1A, 0x04, 0x11, 0xC0, 0x81, 0x40, 0x01, 0x60,
  0x0E, 0x63, 0x03, 0x01, 0x80, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0xE0, 0x30,
  0x18, 0x63, 0x18, 0x00, 0x33, 0x28, 0x41, 0x04, 0x21, 0x08, 0x20, 0x00,
  0x08, 0x3F, 0x20, 0x53, 0xB2, 0x59, 0x2D, 0x16, 0x8B, 0x49, 0x5B, 0x20,
  0x0F, 0x80, 0x10, 0x18, 0x28, 0x24, 0x24, 0x44, 0x42, 0x7E, 0x82, 0x81,
  0x81, 0xF9, 0x0A, 0x14, 0x28, 0x9F, 0x21, 0x41, 0x83, 0x0B, 0xE0, 0x38,
  0x8D, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x05, 0x09, 0xE0, 0xF9, 0x0A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0B, 0xE0, 0xFE, 0x08, 0x20, 0x83,
  0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82,
  0x08, 0x00, 0x38, 0x8E, 0x0C, 0x18, 0x10, 0x20, 0x47, 0x83, 0x05, 0x09,
  0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xFC,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8F, 0xC0, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x83, 0x05, 0xF0, 0x87, 0x12, 0x45, 0x0A, 0x1C, 0x24,
  0x44, 0x89, 0x0A, 0x08, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0x83, 0x87, 0x1D, 0x3A, 0xB3, 0x64, 0xC1, 0x83, 0x06, 0x08, 0x83,
  0x86, 0x8D, 0x19, 0x32, 0x62, 0xC3, 0x87, 0x06, 0x08, 0x38, 0x89, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0xFD, 0x06, 0x0C, 0x18,
  0x3F, 0xA0, 0x40, 0x81, 0x02, 0x00, 0x38, 0x46, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x04, 0x02, 0xF9, 0x0A, 0x0C, 0x18,
  0x5D, 0x24, 0x44, 0x85, 0x0A, 0x08, 0x30, 0x46, 0x82, 0x81, 0x40, 0x20,
  0x1C, 0x02, 0x01, 0x81, 0x81, 0x7E, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x84, 0xF0, 0x81, 0x82, 0x82, 0x42, 0x44, 0x44, 0x24, 0x28, 0x28,
  0x18, 0x10, 0x91, 0x99, 0x99, 0x99, 0x99, 0xA5, 0x66, 0x66, 0x46, 0x42,
  0x42, 0x83, 0x42, 0x24, 0x24, 0x18, 0x10, 0x18, 0x24, 0x42, 0x42, 0x81,
  0x83, 0x82, 0x44, 0x44, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE,
  0x08, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40, 0x83, 0xF8, 0xEA, 0xAA, 0xAA,
  0xAC, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0x10, 0xD5, 0x55, 0x55,
  0x5C, 0x20, 0xC5, 0x12, 0x8A, 0x10, 0xFE, 0x90, 0x3C, 0x86, 0x08, 0x13,
  0xE8, 0x60, 0xC1, 0x7E, 0x82, 0x08, 0x3C, 0x8A, 0x18, 0x61, 0x86, 0x18,
  0x7E, 0x38, 0x8D, 0x0C, 0x08, 0x10, 0x20, 0xA1, 0x3C, 0x02, 0x04, 0x09,
  0xD4, 0x70, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xF0, 0x38, 0x8D, 0x0C, 0x1F,
  0xD0, 0x20, 0x20, 0x3E, 0x1E, 0x40, 0x87, 0xE2, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x00, 0x38, 0x8D, 0x0C, 0x18, 0x30, 0x60, 0xA1, 0x3E, 0x04,
  0x0B, 0xE0, 0x82, 0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x18, 0x61, 0x10,
  0x0E, 0x04, 0x10, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x08, 0x1C, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0xF8, 0x82, 0x08, 0x21, 0x8A, 0x4A, 0x38, 0x92,
  0x48, 0xA1, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x66,
  0x99, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x3B, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x84, 0x38, 0x46, 0x82, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C,
  0x72, 0x28, 0x61, 0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x38, 0x8E, 0x0C,
  0x18, 0x30, 0x60, 0xA1, 0x3E, 0x04, 0x08, 0x10, 0x3E, 0x21, 0x08, 0x42,
  0x10, 0x80, 0x7A, 0x18, 0x60, 0x70, 0x30, 0x61, 0x78, 0x20, 0x8F, 0xC8,
  0x20, 0x82, 0x08, 0x20, 0x83, 0xC0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5F,
  0x81, 0x82, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x91, 0x99, 0x99, 0xAA,
  0xA6, 0x66, 0x46, 0x44, 0xC2, 0x24, 0x28, 0x10, 0x18, 0x24, 0x42, 0x83,
  0x81, 0x82, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0xE0, 0xFE,
  0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0xFF, 0x19, 0x08, 0x42, 0x11, 0x10,
  0x42, 0x08, 0x42, 0x10, 0x60, 0xFF, 0xF8, 0xC2, 0x08, 0x42, 0x10, 0x83,
  0x21, 0x08, 0x42, 0x23, 0x00, 0xF1, 0x89, 0x06,
};

const GFXglyph RobotoMono_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 1, 11, 10, 4, -11 },
  { 3, 2, 3, 10, 4, -12 },
  { 4, 9, 11, 10, 0, -11 },
  { 17, 6, 15, 10, 2, -13 },
  { 29, 9, 12, 10, 0, -12 },
  { 43, 8, 12, 10, 1, -12 },
  { 55, 1, 3, 10, 4, -12 },
  { 56, 4, 17, 10, 3, -13 },
  { 65, 3, 17, 10, 3, -13 },
  { 72, 6, 6, 10, 2, -11 },
  { 77, 8, 8, 10, 1, -9 },
  { 85, 1, 3, 10, 3, -1 },
  { 86, 6, 1, 10, 2, -6 },
  { 87, 1, 1, 10, 5, -1 },
  { 88, 6, 12, 10, 2, -11 },
  { 97, 7, 12, 10, 1, -12 },
  { 108, 4, 11, 10, 2, -11 },
  { 114, 7, 12, 10, 1, -12 },
  { 125, 7, 12, 10, 1, -12 },
  { 136, 8, 11, 10, 1, -11 },
  { 147, 6, 11, 10, 2, -11 },
  { 156, 7, 12, 10, 1, -12 },
  { 167, 7, 11, 10, 1, -11 },
  { 177, 8, 12, 10, 1, -12 },
  { 189, 7, 12, 10, 1, -12 },
  { 200, 1, 8, 10, 5, -8 },
  { 201, 2, 10, 10, 4, -8 },
  { 204, 7, 6, 10, 1, -8 },
  { 210, 7, 4, 10, 1, -7 },
  { 214, 7, 6, 10, 1, -8 },
  { 220, 6, 12, 10, 2, -12 },
  { 229, 9, 11, 10, 0, -11 },
  { 242, 8, 11, 10, 1, -11 },
  { 253, 7, 11, 10, 2, -11 },
  { 263, 7, 12, 10, 1, -12 },
  { 274, 7, 11, 10, 2, -11 },
  { 284, 6, 11, 10, 2, -11 },
  { 293, 6, 11, 10, 2, -11 },
  { 302, 7, 12, 10, 1, -12 },
  { 313, 7, 11, 10, 1, -11 },
  { 323, 6, 11, 10, 2, -11 },
  { 332, 7, 11, 10, 1, -11 },
  { 342, 7, 11, 10, 2, -11 },
  { 352, 6, 11, 10, 2, -11 },
  { 361, 7, 11, 10, 1, -11 },
  { 371, 7, 11, 10, 1, -11 },
  { 381, 7, 12, 10, 1, -12 },
  { 392, 7, 11, 10, 2, -11 },
  { 402, 8, 14, 10, 1, -12 },
  { 416, 7, 11, 10, 2, -11 },
  { 426, 8, 12, 10, 1, -12 },
  { 438, 8, 11, 10, 1, -11 },
  { 449, 7, 11, 10, 1, -11 },
  { 459, 8, 11, 10, 1, -11 },
  { 470, 8, 11, 10, 1, -11 },
  { 481, 8, 11, 10, 1, -11 },
  { 492, 8, 11, 10, 1, -11 },
  { 503, 7, 11, 10, 1, -11 },
  { 513, 2, 15, 10, 4, -13 },
  { 517, 5, 12, 10, 2, -11 },
  { 525, 2, 15, 10, 4, -13 },
  { 529, 6, 6, 10, 2, -11 },
  { 534, 7, 1, 10, 1, 0 },
  { 535, 2, 2, 10, 4, -12 },
  { 536, 7, 9, 10, 1, -9 },
  { 544, 6, 12, 10, 2, -12 },
  { 553, 7, 9, 10, 1, -9 },
  { 561, 7, 12, 10, 1, -12 },
  { 572, 7, 9, 10, 1, -9 },
  { 580, 7, 12, 10, 2, -12 },
  { 591, 7, 12, 10, 1, -9 },
  { 602, 6, 12, 10, 2, -12 },
  { 611, 6, 11, 10, 2, -11 },
  { 620, 5, 14, 10, 1, -11 },
  { 629, 6, 12, 10, 2, -12 },
  { 638, 6, 12, 10, 2, -12 },
  { 647, 8, 9, 10, 1, -9 },
  { 656, 6, 9, 10, 2, -9 },
  { 663, 8, 9, 10, 1, -9 },
  { 672, 6, 12, 10, 2, -9 },
  { 681, 7, 12, 10, 1, -9 },
  { 692, 5, 9, 10, 3, -9 },
  { 698, 6, 9, 10, 2, -9 },
  { 705, 6, 11, 10, 2, -11 },
  { 714, 6, 8, 10, 2, -8 },
  { 720, 8, 8, 10, 1, -8 },
  { 728, 8, 8, 10, 1, -8 },
  { 736, 8, 8, 10, 1, -8 },
  { 744, 8, 11, 10, 1, -8 },
  { 755, 8, 8, 10, 1, -8 },
  { 763, 5, 15, 10, 3, -12 },
  { 773, 1, 13, 10, 4, -11 },
  { 775, 5, 15, 10, 3, -12 },
  { 785, 8, 3, 10, 1, -6 },
};

const GFXfont RobotoMono_Thin16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Thin16pt7bBitmaps,
  (GFXglyph *)RobotoMono_Thin16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_THIN16PT7B_H_
