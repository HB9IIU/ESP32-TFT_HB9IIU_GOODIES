#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC19PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x63, 0x00, 0x8E, 0x70, 0x6F, 0x3C,
  0xF6, 0xD8, 0x04, 0xC3, 0x20, 0xD8, 0x26, 0x3F, 0xDF, 0xF1, 0x30, 0x48,
  0x32, 0x3F, 0xE2, 0x61, 0x90, 0x6C, 0x13, 0x00, 0x02, 0x07, 0x8F, 0xE6,
  0xA3, 0x41, 0xA0, 0xF0, 0x3C, 0x0F, 0x05, 0xA5, 0xDF, 0xCF, 0xC0, 0x80,
  0x40, 0x38, 0x67, 0x84, 0x6C, 0xCC, 0x98, 0xC9, 0x0D, 0xB0, 0xDA, 0xFF,
  0x6B, 0x6D, 0xB0, 0x93, 0x19, 0x31, 0x12, 0x31, 0x66, 0x1C, 0x06, 0x07,
  0xC1, 0xB8, 0x6C, 0x1B, 0x07, 0x81, 0xC0, 0xF3, 0x6C, 0xF9, 0xEC, 0x7B,
  0x1C, 0xFF, 0x1E, 0x60, 0x7F, 0x6C, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x18,
  0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x18, 0x60, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0x10, 0x32,
  0x47, 0xF3, 0xEF, 0x36, 0x26, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x36, 0x6C, 0xC0, 0x7F, 0xC0, 0x5F, 0x80, 0x01, 0xC0, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x00, 0x0C, 0x3E, 0x36, 0x67, 0x67, 0xC7, 0xC6, 0xC6, 0xC6,
  0xC6, 0xCC, 0xCC, 0xF8, 0xF0, 0x0C, 0x77, 0xBE, 0xD8, 0x61, 0x8C, 0x30,
  0xC3, 0x1C, 0x61, 0x80, 0x07, 0x07, 0xE1, 0x9C, 0x07, 0x01, 0x80, 0x60,
  0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x7F, 0x3F, 0xC0, 0x0E, 0x1F,
  0x84, 0xE0, 0x70, 0x30, 0x18, 0x78, 0x7C, 0x06, 0x03, 0x81, 0xD0, 0xCF,
  0xE7, 0xC0, 0x03, 0x81, 0x81, 0xC1, 0xE0, 0xB0, 0xD8, 0xD8, 0xCC, 0x66,
  0x7F, 0xBF, 0xC1, 0x80, 0xC0, 0x60, 0x1F, 0x8F, 0xC6, 0x06, 0x03, 0x01,
  0x81, 0xF8, 0x4E, 0x07, 0x03, 0x81, 0xD0, 0xCF, 0xE7, 0xC0, 0x07, 0x1F,
  0x38, 0x70, 0x60, 0xEC, 0xFE, 0xE6, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78,
  0x7F, 0xBF, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x0E, 0x06, 0x00, 0x0E, 0x0F, 0x8C, 0x66, 0x33, 0x39, 0xD8, 0x78,
  0x7C, 0x66, 0x71, 0xB0, 0xD8, 0xEF, 0xE3, 0xE0, 0x0E, 0x0F, 0x8C, 0xC6,
  0x76, 0x3B, 0x19, 0x8C, 0xFE, 0x3B, 0x03, 0x81, 0x81, 0xCF, 0xC7, 0xC0,
  0x33, 0x00, 0x00, 0x04, 0xEC, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x33, 0x19,
  0x8C, 0x00, 0x03, 0x0F, 0x3C, 0xF0, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x1E, 0x70, 0xC0,
  0x80, 0x38, 0xF9, 0x38, 0x60, 0xC3, 0x8E, 0x38, 0x60, 0xC0, 0x02, 0x0C,
  0x18, 0x00, 0x03, 0x80, 0xFE, 0x18, 0x23, 0x03, 0x67, 0xB4, 0xDB, 0xD9,
  0xB9, 0x93, 0x93, 0x29, 0x32, 0x9D, 0x49, 0xD8, 0xC0, 0x0C, 0x10, 0x7F,
  0x01, 0xC0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x66, 0x33, 0x3F,
  0x9F, 0xDC, 0x6C, 0x36, 0x1E, 0x0C, 0x1E, 0x07, 0xE1, 0x9C, 0xE7, 0x31,
  0x8C, 0x63, 0xF0, 0xFC, 0x63, 0x18, 0xE6, 0x39, 0x8C, 0xFF, 0x3F, 0x00,
  0x07, 0x0F, 0xCE, 0x4E, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0F, 0xC3, 0xE0, 0x1E, 0x07, 0xE1, 0xBC, 0xE3, 0x30, 0xCC, 0x33,
  0x0C, 0xC3, 0x71, 0xD8, 0x66, 0x39, 0x9C, 0xFE, 0x3F, 0x00, 0x1F, 0x8F,
  0xC6, 0x07, 0x03, 0x01, 0x80, 0xFC, 0x7C, 0x70, 0x30, 0x18, 0x0C, 0x0F,
  0xE7, 0xE0, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x01, 0x80, 0xF8, 0x7C, 0x70,
  0x30, 0x18, 0x0C, 0x0E, 0x06, 0x00, 0x07, 0x87, 0xF3, 0x89, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x1E, 0xC3, 0xB0, 0xCC, 0x33, 0x8C, 0x7F, 0x1F, 0xC0,
  0x18, 0x63, 0x0C, 0x61, 0x9C, 0x73, 0x0C, 0x61, 0x8F, 0xF1, 0xFE, 0x71,
  0x8C, 0x31, 0x86, 0x30, 0xCE, 0x39, 0x86, 0x00, 0x1F, 0x1F, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30, 0x78, 0xFC, 0x03, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0xF0, 0xE0, 0x18, 0xE3, 0x18, 0x66, 0x1D, 0xC3, 0x70, 0x6C,
  0x0F, 0x01, 0xE0, 0x7E, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x71, 0x86, 0x00,
  0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0F, 0xFF,
  0x80, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE3,
  0xCD, 0x8F, 0x36, 0x65, 0x99, 0x96, 0xC6, 0x53, 0x19, 0xCC, 0xE6, 0x33,
  0x19, 0xC0, 0x18, 0x31, 0xC3, 0x1C, 0x63, 0xC6, 0x3C, 0x63, 0x66, 0x36,
  0x63, 0x6C, 0x66, 0xC6, 0x3C, 0x63, 0xC6, 0x38, 0xE3, 0x8C, 0x38, 0x0F,
  0x07, 0xE3, 0x9D, 0xC7, 0x60, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xB0, 0x6C,
  0x3B, 0x9C, 0xFE, 0x1F, 0x00, 0x1E, 0x07, 0xE1, 0x98, 0xE7, 0x31, 0xCC,
  0x63, 0x38, 0xFC, 0x7E, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x0F,
  0x07, 0xE3, 0x9D, 0xC7, 0x60, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xB0, 0x6C,
  0x3B, 0x9C, 0xFE, 0x1F, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0x1E, 0x0F, 0xC6,
  0xE7, 0x33, 0x19, 0x8C, 0xCE, 0x7E, 0x7E, 0x33, 0x19, 0x8C, 0xCE, 0x76,
  0x18, 0x0F, 0x0F, 0xCE, 0x46, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x01, 0x90, 0xCF, 0xC7, 0xC0, 0xFF, 0xFC, 0xC1, 0x83, 0x0E, 0x1C, 0x30,
  0x60, 0xC3, 0x86, 0x0C, 0x18, 0x00, 0x30, 0xCC, 0x37, 0x1D, 0xC6, 0x61,
  0x98, 0x66, 0x1B, 0x8E, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0xFE, 0x1F, 0x00,
  0xC3, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB8, 0xD8, 0x6C, 0x3C,
  0x1E, 0x0E, 0x07, 0x00, 0xC3, 0x0F, 0x1C, 0x6C, 0x71, 0xB3, 0xCC, 0xCF,
  0x33, 0x2C, 0xCD, 0xB6, 0x36, 0xD8, 0xF3, 0xC3, 0xCF, 0x0E, 0x2C, 0x38,
  0xE0, 0xE3, 0x83, 0x0C, 0x00, 0x18, 0x63, 0x1C, 0x73, 0x06, 0xC0, 0xF8,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xCC, 0x19, 0x86, 0x31, 0xC7,
  0x00, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0x78, 0x78, 0x70, 0x60, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0x1F, 0xC7, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0,
  0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x7F, 0x3F, 0x80, 0x0F, 0x0F, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x78, 0xF0, 0xCC, 0xCC, 0xC6, 0x66, 0x66, 0x66, 0x33, 0x1E, 0x3C, 0x18,
  0x20, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x78, 0xF0,
  0x04, 0x07, 0x03, 0x83, 0xC1, 0x21, 0x99, 0x8C, 0xC6, 0xC1, 0x80, 0xFE,
  0xD9, 0x80, 0x3F, 0x77, 0xE7, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0xFC,
  0x18, 0x0C, 0x0E, 0x06, 0x03, 0xF1, 0xDC, 0xC6, 0xE3, 0x63, 0xB1, 0x98,
  0xCC, 0xEF, 0xE6, 0xE0, 0x3E, 0xEB, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xF8,
  0xF0, 0x01, 0x80, 0xC0, 0xC0, 0x63, 0xF3, 0xBB, 0x9D, 0x8C, 0xC6, 0x63,
  0x31, 0x99, 0xCF, 0xC7, 0xE0, 0x3E, 0xCF, 0x9E, 0x7F, 0xDC, 0x30, 0x60,
  0xFC, 0xF8, 0x01, 0x00, 0xF0, 0x68, 0x18, 0x06, 0x07, 0xC0, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x0E, 0x03, 0x00, 0x1F, 0x9D, 0xDC, 0xEC, 0x66, 0x33, 0x19, 0x9C, 0xCE,
  0x7E, 0x3F, 0x01, 0x81, 0xC8, 0xC7, 0xE0, 0x80, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0xF1, 0xDC, 0xCE, 0xE6, 0x63, 0x31, 0x98, 0xCC, 0xEE, 0x66, 0x30,
  0x18, 0xC0, 0x03, 0x18, 0xCE, 0x63, 0x18, 0xCE, 0x60, 0x06, 0x0C, 0x00,
  0x00, 0xC1, 0x83, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C, 0x18, 0x71,
  0xC3, 0x00, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x39, 0x98, 0xD8, 0xD8, 0x7C,
  0x3E, 0x1B, 0x0D, 0xCC, 0x66, 0x30, 0x18, 0xC6, 0x63, 0x18, 0xCE, 0x63,
  0x18, 0xCE, 0x60, 0x3F, 0x79, 0xDE, 0xCC, 0xE6, 0xE6, 0x36, 0x31, 0xB1,
  0x99, 0x8C, 0xCC, 0xC6, 0xC6, 0x36, 0x33, 0x80, 0x3F, 0x1D, 0xCC, 0xEE,
  0x66, 0x33, 0x19, 0x8C, 0xCE, 0xE6, 0x63, 0x00, 0x3E, 0xEF, 0x9E, 0x3C,
  0x78, 0xF1, 0xE7, 0xFC, 0xF0, 0x1F, 0x87, 0x71, 0x8C, 0xE3, 0x31, 0xCC,
  0x63, 0x18, 0xCE, 0x7F, 0x1B, 0x86, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00,
  0x3F, 0x77, 0x67, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0xEC, 0x0C, 0x0C,
  0x1C, 0x18, 0x18, 0x3E, 0x7C, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0x80,
  0x3E, 0xE5, 0x83, 0x83, 0x83, 0x83, 0x06, 0xFD, 0xF0, 0x31, 0x8D, 0xF6,
  0x31, 0x98, 0xC6, 0x31, 0xEF, 0x00, 0x63, 0x63, 0x67, 0xC6, 0xC6, 0xC6,
  0xCE, 0xCC, 0xFC, 0xFC, 0xC7, 0xC6, 0xCC, 0xCC, 0xDC, 0xD8, 0xD8, 0xF0,
  0x70, 0x60, 0xC6, 0x3C, 0xE6, 0xCA, 0x6D, 0xAC, 0xDE, 0xCD, 0x6C, 0xF7,
  0x8E, 0x78, 0xE7, 0x0E, 0x70, 0x39, 0xC6, 0xE1, 0xB0, 0x78, 0x0C, 0x07,
  0x01, 0xE0, 0xD8, 0x66, 0x39, 0xC0, 0x18, 0xE3, 0x18, 0x67, 0x0C, 0xC1,
  0x98, 0x16, 0x02, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x80,
  0xE0, 0x30, 0x00, 0x1F, 0x23, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x70, 0x7E,
  0xFC, 0x03, 0x0E, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0, 0xF0, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x70, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10,
  0x38, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06, 0x3C, 0x61, 0xC3, 0x06, 0x0C,
  0x78, 0xE0, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 9, 15, 9, 0, -14 },
  { 49, 12, 14, 14, 1, -14 },
  { 70, 10, 14, 10, 0, -14 },
  { 88, 3, 5, 4, 2, -14 },
  { 90, 7, 17, 5, 0, -14 },
  { 105, 6, 17, 5, -1, -14 },
  { 118, 7, 8, 8, 2, -15 },
  { 125, 8, 9, 9, 1, -11 },
  { 134, 4, 5, 5, -1, -2 },
  { 137, 5, 2, 6, 0, -6 },
  { 139, 3, 3, 5, 0, -3 },
  { 141, 10, 14, 7, -1, -14 },
  { 159, 8, 14, 9, 1, -14 },
  { 173, 6, 14, 9, 2, -14 },
  { 184, 10, 14, 9, -1, -14 },
  { 202, 9, 14, 9, 0, -14 },
  { 218, 9, 14, 9, 0, -14 },
  { 234, 9, 14, 9, 0, -14 },
  { 250, 8, 14, 9, 1, -14 },
  { 264, 9, 14, 9, 1, -14 },
  { 280, 9, 14, 9, 0, -14 },
  { 296, 9, 14, 9, 0, -14 },
  { 312, 4, 10, 5, 0, -10 },
  { 317, 5, 13, 5, -1, -10 },
  { 326, 8, 9, 9, 1, -11 },
  { 335, 8, 5, 9, 1, -9 },
  { 340, 8, 9, 9, 1, -11 },
  { 349, 7, 14, 7, 1, -14 },
  { 362, 12, 16, 13, 1, -14 },
  { 386, 9, 14, 9, -1, -14 },
  { 402, 10, 14, 10, 0, -14 },
  { 420, 9, 14, 9, 1, -14 },
  { 436, 10, 14, 10, 0, -14 },
  { 454, 9, 14, 8, 0, -14 },
  { 470, 9, 14, 8, 0, -14 },
  { 486, 10, 14, 11, 1, -14 },
  { 504, 11, 14, 11, 0, -14 },
  { 524, 8, 14, 6, -1, -14 },
  { 538, 8, 18, 5, -3, -14 },
  { 556, 11, 14, 9, 0, -14 },
  { 576, 7, 14, 8, 0, -14 },
  { 589, 14, 14, 14, 0, -14 },
  { 614, 12, 14, 11, 0, -14 },
  { 635, 10, 14, 11, 1, -14 },
  { 653, 10, 14, 9, 0, -14 },
  { 671, 10, 17, 11, 1, -14 },
  { 693, 9, 14, 9, 0, -14 },
  { 709, 9, 14, 8, 0, -14 },
  { 725, 7, 14, 8, 2, -14 },
  { 738, 10, 14, 11, 1, -14 },
  { 756, 9, 14, 9, 2, -14 },
  { 772, 14, 14, 14, 2, -14 },
  { 797, 11, 14, 9, -1, -14 },
  { 817, 8, 14, 8, 2, -14 },
  { 831, 10, 14, 8, -1, -14 },
  { 849, 8, 17, 6, -1, -14 },
  { 866, 4, 14, 7, 2, -14 },
  { 873, 7, 17, 6, -1, -14 },
  { 888, 9, 9, 9, 0, -14 },
  { 899, 7, 1, 6, -2, 2 },
  { 900, 3, 3, 5, 3, -15 },
  { 902, 8, 10, 9, 1, -10 },
  { 912, 9, 14, 9, 0, -14 },
  { 928, 7, 10, 7, 1, -10 },
  { 937, 9, 14, 9, 1, -14 },
  { 953, 7, 10, 8, 1, -10 },
  { 962, 10, 20, 5, -2, -15 },
  { 987, 9, 15, 9, 0, -10 },
  { 1004, 9, 14, 9, 0, -14 },
  { 1020, 5, 14, 4, 0, -14 },
  { 1029, 7, 19, 4, -2, -14 },
  { 1046, 9, 14, 8, 0, -14 },
  { 1062, 5, 14, 4, 0, -14 },
  { 1071, 13, 10, 14, 0, -10 },
  { 1088, 9, 10, 9, 0, -10 },
  { 1100, 7, 10, 9, 1, -10 },
  { 1109, 10, 15, 9, -1, -10 },
  { 1128, 8, 15, 9, 1, -10 },
  { 1143, 7, 10, 6, 0, -10 },
  { 1152, 7, 10, 7, 0, -10 },
  { 1161, 5, 13, 6, 1, -13 },
  { 1170, 8, 10, 9, 1, -10 },
  { 1180, 8, 10, 8, 1, -10 },
  { 1190, 12, 10, 12, 1, -10 },
  { 1205, 10, 10, 8, -1, -10 },
  { 1218, 11, 15, 8, -2, -10 },
  { 1239, 8, 10, 7, -1, -10 },
  { 1249, 8, 17, 6, 0, -14 },
  { 1266, 2, 19, 8, 3, -15 },
  { 1271, 7, 17, 6, -1, -14 },
  { 1286, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC19PT7B_H_
