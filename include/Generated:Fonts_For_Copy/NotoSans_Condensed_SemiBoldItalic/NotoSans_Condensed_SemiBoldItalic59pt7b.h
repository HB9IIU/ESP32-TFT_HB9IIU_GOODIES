#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x06, 0x00, 0x00, 0x3F, 0x8F, 0xE7,
  0xE1, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7C, 0x7E,
  0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xC1, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFC,
  0xE3, 0x80, 0x7F, 0x38, 0x10, 0x0F, 0xC7, 0x00, 0x01, 0xF8, 0xE0, 0x00,
  0x3F, 0x1C, 0x00, 0x07, 0xE3, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x1F, 0xDC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xDF, 0xE0, 0x00,
  0x39, 0xFC, 0x00, 0x07, 0x3F, 0x80, 0x01, 0xC7, 0xF0, 0x00, 0x38, 0xFE,
  0x10, 0x07, 0x1F, 0xC3, 0x00, 0xE3, 0xF0, 0x78, 0x18, 0xFE, 0x0F, 0xE7,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0xFF, 0xF8,
  0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x7C, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x07, 0xC0,
  0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x1F, 0x00,
  0x1F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x1F, 0x80, 0x07, 0xC1, 0xF8,
  0xF8, 0x3C, 0x3E, 0x0F, 0x8F, 0x87, 0xF9, 0xF0, 0x7C, 0x7C, 0x7F, 0xEF,
  0x87, 0xC7, 0xC7, 0xFF, 0xFE, 0x7E, 0x7E, 0x7F, 0xFD, 0xFF, 0xE3, 0xE3,
  0xE3, 0xEF, 0xFF, 0x3E, 0x3E, 0x1F, 0x3F, 0xF1, 0xF1, 0xF0, 0xF8, 0xFE,
  0x1F, 0x1F, 0x07, 0xC1, 0xC1, 0xF8, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC1,
  0xF0, 0x00, 0xFC, 0x7E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x7C,
  0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xC1, 0xF0,
  0x03, 0xF0, 0x7E, 0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x1F,
  0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xF0, 0x0F,
  0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xFF,
  0x80, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0x03, 0xFF, 0xC0, 0x7E, 0x07,
  0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x1F, 0xE7, 0xF0, 0xFC, 0x1F,
  0xC7, 0xF1, 0xFC, 0x3F, 0x83, 0xF9, 0xF8, 0x3F, 0x03, 0xFB, 0xF8, 0x7F,
  0x01, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0xE0, 0xFE,
  0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x80, 0x7F, 0x87, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xCF, 0xE0, 0x1F,
  0xFF, 0x8F, 0xF0, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x06, 0x07, 0xC0, 0x0F, 0x0F, 0x80,
  0x3F, 0x1F, 0x00, 0x7F, 0xBC, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x3F, 0xBF, 0x01, 0xFE, 0x3E, 0x01, 0xF8,
  0x7E, 0x01, 0xF0, 0xFE, 0x01, 0xC0, 0xFC, 0x01, 0x01, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0x80, 0x1F, 0x1F, 0xDF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFC, 0x18,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFB,
  0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F,
  0xC0, 0x0F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xFB,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x03,
  0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xF7, 0xF3, 0xFC, 0xFC, 0x3F,
  0x1F, 0x83, 0xC7, 0xF0, 0x60, 0xFE, 0x04, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFC, 0x7F, 0xC0, 0x0F, 0x80, 0xFF, 0x00, 0x78, 0x07, 0xF8, 0x01, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0x0F,
  0xF8, 0x07, 0x00, 0xFF, 0x00, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x40,
  0x01, 0xFE, 0x0C, 0x00, 0x7F, 0xC1, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xFC,
  0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x80, 0x03,
  0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x3F,
  0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF0, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x9F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC2, 0x00, 0x0F, 0xF0, 0x70, 0x03, 0xFE, 0x0F, 0xE3,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x08, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xE7, 0xFC, 0x03, 0xF3, 0xFF,
  0x80, 0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFC,
  0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F,
  0xE7, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE0,
  0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0x87, 0xF8, 0x7F, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0x80,
  0x7F, 0xE7, 0xE0, 0x07, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x38,
  0x3F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x58, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3E, 0x1F, 0xE1, 0x80, 0x7F, 0x08, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x07, 0xF8,
  0x1F, 0x0F, 0xC0, 0x7F, 0xF8, 0x7C, 0x3E, 0x03, 0xFF, 0xE0, 0xF1, 0xF0,
  0x1F, 0xFF, 0x83, 0xC7, 0xC0, 0xFC, 0x3E, 0x0F, 0x1F, 0x07, 0xC1, 0xF0,
  0x3C, 0xF8, 0x3F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x1F, 0x07, 0xDF, 0x07,
  0xC0, 0x7C, 0x1F, 0x7C, 0x1F, 0x03, 0xE0, 0x7D, 0xF0, 0x7C, 0x0F, 0x81,
  0xF7, 0xC3, 0xE0, 0x3E, 0x07, 0x9E, 0x0F, 0x80, 0xF8, 0x3E, 0xF8, 0x3E,
  0x07, 0xC0, 0xFB, 0xE0, 0xF8, 0x1F, 0x03, 0xCF, 0x83, 0xE0, 0x7C, 0x1F,
  0x3E, 0x1F, 0x03, 0xF0, 0x7C, 0xF8, 0x7C, 0x0F, 0x83, 0xE3, 0xE1, 0xF8,
  0x7E, 0x0F, 0x8F, 0x83, 0xE3, 0xFC, 0x7C, 0x3E, 0x0F, 0xFE, 0xFF, 0xE0,
  0xF8, 0x3F, 0xF3, 0xFF, 0x03, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0x80, 0xFC,
  0x1F, 0xC0, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x40, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00,
  0xFF, 0xC3, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x9F,
  0x00, 0x7F, 0xC0, 0x18, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x03,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0x7E, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x07,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xE0, 0x7F,
  0x00, 0xFF, 0x80, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0xFE, 0x01, 0xFF, 0x80, 0x1C, 0x03,
  0xFE, 0x00, 0x08, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xFF, 0x1F, 0xE0, 0x1F, 0xFE, 0x3F, 0x80, 0x7F, 0xFC, 0x7F, 0x00, 0xFF,
  0xF8, 0xFE, 0x01, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFC, 0x07,
  0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x01, 0x0F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xF0,
  0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xF7,
  0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC,
  0x00, 0xFB, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0x7C, 0x01,
  0xF3, 0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x03, 0xF7,
  0xF0, 0x0F, 0xE7, 0xC0, 0x7E, 0x7F, 0x00, 0xFE, 0x7C, 0x07, 0xE7, 0xE0,
  0x0F, 0xC7, 0xC0, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x0F, 0xCF, 0xE0, 0x0F,
  0xC7, 0xE1, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x1F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xE3, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE7,
  0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xE7, 0xC1,
  0xFC, 0x03, 0xF0, 0x7E, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xEF, 0x81, 0xF8,
  0x03, 0xF0, 0x7F, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xFF, 0x03, 0xF8, 0x07,
  0xF0, 0x7F, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x1F,
  0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xBF, 0x00,
  0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x00, 0x7E,
  0x7F, 0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0xFC,
  0x01, 0xFC, 0x7E, 0x0F, 0xE0, 0x0F, 0xE3, 0xF0, 0x7F, 0x00, 0x7E, 0x1F,
  0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0xFC, 0x01,
  0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xC0, 0xFE, 0x7F, 0x00, 0x7E, 0x03, 0xF3,
  0xF0, 0x03, 0xF0, 0x1F, 0x9F, 0x80, 0x1F, 0x80, 0xFC, 0xFC, 0x01, 0xFC,
  0x07, 0xE7, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x80,
  0xFF, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF1,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE3, 0xFE,
  0x01, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xBF, 0xC0,
  0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x1F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7E,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x38, 0x01, 0xFE, 0x00, 0x40, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x10, 0x00, 0x3F, 0x80, 0xC0, 0x03, 0xFC,
  0x07, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF,
  0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xCF,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x8F, 0xE0,
  0x0F, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0x0F, 0xE0, 0x1F,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x7D, 0xF8, 0x1F, 0x80,
  0xFE, 0x0F, 0xDF, 0x83, 0xF8, 0x0F, 0xE0, 0xFD, 0xF8, 0x3F, 0x80, 0xFE,
  0x1F, 0x9F, 0x83, 0xF0, 0x0F, 0xC1, 0xF9, 0xF8, 0x7F, 0x00, 0xFC, 0x1F,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF1, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x1F, 0x9F,
  0xC0, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x1F, 0xBF, 0x80,
  0x0F, 0xCF, 0x81, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x81, 0xF7, 0xF0, 0x00, 0xFD, 0xF0, 0x1F, 0x7E, 0x00, 0x0F, 0xFF,
  0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0x3E, 0xFE, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x0F,
  0xF0, 0xFC, 0x03, 0xFF, 0x1F, 0x01, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x3F, 0xE0, 0x7F, 0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xF0,
  0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xE3, 0xF0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0x80, 0x03, 0xF1,
  0xFE, 0x00, 0x7E, 0x7F, 0xE0, 0x1F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x80,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0x83, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xF3, 0xFF, 0xC0, 0x7E, 0x3F, 0xF0, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x87, 0x03, 0xFC, 0x04,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x18, 0x3F, 0xE1, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x40, 0xFE, 0x00,
  0x3F, 0xC7, 0xF0, 0x03, 0xFF, 0x3F, 0x00, 0x3F, 0xFD, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F,
  0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE3, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xC0, 0x1F, 0xFE, 0x7C, 0x00,
  0x7F, 0xE3, 0xE0, 0x01, 0xFE, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0,
  0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x1F,
  0xCF, 0xE0, 0x7F, 0x9F, 0x9F, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x87, 0xF8, 0x07, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x01, 0xFF,
  0x8F, 0x80, 0x1F, 0xFF, 0x7E, 0x00, 0x7F, 0xFD, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x03, 0xFE, 0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xE0, 0x01, 0xFF,
  0x9F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x20, 0x00, 0xFE, 0x00, 0xE0, 0x07, 0xF8, 0x03,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0x80, 0x03, 0xF1, 0xFE, 0x00, 0x7E,
  0x7F, 0xE0, 0x1F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFC, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F,
  0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFC,
  0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x60,
  0x00, 0xF8, 0x7F, 0x81, 0xFE, 0x00, 0x7C, 0xFF, 0xE1, 0xFF, 0x80, 0x7E,
  0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0x7F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0xF1, 0xFE, 0x07, 0xF8, 0x3F, 0xF0, 0x7F,
  0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x83,
  0xF0, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x3E, 0x1F, 0xE0, 0x07, 0xC7, 0xFE, 0x01, 0xF9, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7, 0xF8, 0x1F, 0xE0, 0x7F,
  0x07, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x01,
  0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x8F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xF8, 0x7F, 0x80, 0x03, 0xE3, 0xFF, 0x00, 0x1F, 0x9F, 0xFE, 0x00, 0x7E,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF0,
  0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xFC, 0x00,
  0xFD, 0xFF, 0xE0, 0x03, 0xF3, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F,
  0x02, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xF0, 0xFC, 0x03,
  0xFF, 0x1F, 0x00, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F,
  0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC,
  0x01, 0xFF, 0x9F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0x60, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1A, 0x03, 0xE1,
  0xF8, 0x07, 0xC7, 0xF0, 0x1F, 0x9F, 0xE0, 0x3F, 0x7F, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xC4, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFC, 0x1E, 0x07, 0xF0, 0x08, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC2, 0x00, 0x7F, 0x07,
  0x81, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x84,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x08, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F,
  0x83, 0xFE, 0x0F, 0xF1, 0xFF, 0x83, 0xFF, 0xF7, 0xC0, 0xFF, 0xFD, 0xF0,
  0x1F, 0xFE, 0x7C, 0x07, 0xFF, 0x3F, 0x00, 0x7F, 0x8F, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7E,
  0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xBF,
  0x01, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0xC0,
  0xFE, 0x7E, 0x07, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xF0, 0x7F, 0x1F, 0x83,
  0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0xF8, 0x1F, 0x87, 0xE0, 0xFF, 0xC1, 0xFC,
  0x3F, 0x0F, 0xBE, 0x0F, 0xC1, 0xF8, 0x7D, 0xF0, 0xFE, 0x0F, 0xC7, 0xEF,
  0x87, 0xE0, 0x7E, 0x3E, 0x7C, 0x3F, 0x03, 0xF1, 0xF3, 0xE3, 0xF8, 0x1F,
  0x9F, 0x1F, 0x1F, 0x80, 0xFC, 0xF8, 0xF8, 0xFC, 0x07, 0xEF, 0xC7, 0xCF,
  0xC0, 0x3F, 0x7C, 0x3E, 0x7E, 0x01, 0xF3, 0xE1, 0xF7, 0xE0, 0x0F, 0xBE,
  0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x7D, 0xF8, 0x03, 0xEF, 0x83, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x10, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x7F, 0xFD, 0x00, 0x0F, 0xF8, 0x80, 0x00,
  0xF0, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 17, 43, 15, 0, -42 },
  { 93, 19, 15, 23, 6, -42 },
  { 129, 32, 42, 30, 0, -42 },
  { 297, 27, 48, 27, 1, -45 },
  { 459, 37, 44, 42, 3, -43 },
  { 663, 32, 44, 32, 0, -43 },
  { 839, 9, 15, 13, 6, -42 },
  { 856, 20, 51, 17, 1, -42 },
  { 984, 19, 52, 17, -4, -43 },
  { 1108, 23, 24, 26, 5, -45 },
  { 1177, 24, 28, 29, 3, -35 },
  { 1261, 13, 15, 14, -3, -7 },
  { 1286, 15, 6, 17, 1, -19 },
  { 1298, 9, 9, 14, 0, -8 },
  { 1309, 30, 42, 22, -3, -42 },
  { 1467, 25, 44, 27, 2, -43 },
  { 1605, 19, 42, 27, 6, -42 },
  { 1705, 29, 43, 27, -2, -43 },
  { 1861, 27, 44, 27, 0, -43 },
  { 2010, 28, 42, 27, -1, -42 },
  { 2157, 27, 43, 27, 0, -42 },
  { 2303, 26, 44, 27, 2, -43 },
  { 2446, 28, 42, 27, 2, -42 },
  { 2593, 28, 44, 27, 0, -43 },
  { 2747, 26, 44, 27, 1, -43 },
  { 2890, 14, 33, 14, 0, -32 },
  { 2948, 17, 40, 14, -3, -32 },
  { 3033, 25, 28, 29, 3, -35 },
  { 3121, 24, 17, 29, 3, -29 },
  { 3172, 25, 28, 29, 3, -35 },
  { 3260, 21, 44, 21, 2, -43 },
  { 3376, 38, 47, 41, 2, -42 },
  { 3600, 29, 42, 29, -4, -42 },
  { 3753, 30, 42, 30, 0, -42 },
  { 3911, 29, 44, 28, 3, -43 },
  { 4071, 31, 42, 32, 0, -42 },
  { 4234, 28, 42, 25, 0, -42 },
  { 4381, 28, 42, 24, 0, -42 },
  { 4528, 31, 44, 33, 3, -43 },
  { 4699, 35, 42, 33, 0, -42 },
  { 4883, 25, 42, 19, -2, -42 },
  { 5015, 26, 54, 15, -9, -42 },
  { 5191, 33, 42, 29, 1, -42 },
  { 5365, 20, 42, 24, 0, -42 },
  { 5470, 44, 42, 43, 1, -42 },
  { 5701, 37, 42, 36, 0, -42 },
  { 5896, 31, 44, 35, 3, -43 },
  { 6067, 30, 42, 29, 0, -42 },
  { 6225, 31, 53, 35, 3, -43 },
  { 6431, 28, 42, 29, 1, -42 },
  { 6578, 29, 44, 26, -1, -43 },
  { 6738, 24, 42, 25, 5, -42 },
  { 6864, 31, 43, 33, 3, -42 },
  { 7031, 29, 42, 28, 5, -42 },
  { 7184, 44, 42, 44, 5, -42 },
  { 7415, 35, 42, 27, -3, -42 },
  { 7599, 26, 42, 26, 5, -42 },
  { 7736, 30, 42, 25, -2, -42 },
  { 7894, 23, 51, 17, -2, -42 },
  { 8041, 12, 42, 22, 6, -42 },
  { 8104, 23, 51, 17, -4, -42 },
  { 8251, 27, 25, 27, 0, -42 },
  { 8336, 21, 4, 20, -5, 5 },
  { 8347, 10, 9, 17, 9, -45 },
  { 8359, 27, 34, 29, 2, -33 },
  { 8474, 27, 46, 29, 0, -45 },
  { 8630, 22, 34, 23, 2, -33 },
  { 8724, 29, 46, 29, 2, -45 },
  { 8891, 23, 34, 26, 2, -33 },
  { 8989, 31, 59, 17, -7, -45 },
  { 9218, 30, 47, 29, -1, -33 },
  { 9395, 27, 45, 29, 0, -45 },
  { 9547, 16, 44, 14, 0, -44 },
  { 9635, 24, 58, 14, -8, -44 },
  { 9809, 29, 45, 26, 0, -45 },
  { 9973, 16, 45, 14, 0, -45 },
  { 10063, 41, 33, 43, 0, -33 },
  { 10233, 27, 33, 29, 0, -33 },
  { 10345, 24, 34, 28, 2, -33 },
  { 10447, 30, 47, 29, -3, -33 },
  { 10624, 27, 47, 29, 2, -33 },
  { 10783, 23, 33, 20, 0, -33 },
  { 10878, 23, 34, 22, 0, -33 },
  { 10976, 18, 40, 18, 2, -39 },
  { 11066, 26, 33, 29, 2, -32 },
  { 11174, 24, 32, 24, 3, -32 },
  { 11270, 37, 32, 38, 4, -32 },
  { 11418, 30, 32, 25, -3, -32 },
  { 11538, 33, 46, 24, -5, -32 },
  { 11728, 25, 32, 21, -2, -32 },
  { 11828, 23, 51, 20, 1, -42 },
  { 11975, 5, 59, 25, 10, -45 },
  { 12012, 22, 51, 20, -3, -42 },
  { 12153, 25, 9, 29, 3, -25 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC59PT7B_H_
