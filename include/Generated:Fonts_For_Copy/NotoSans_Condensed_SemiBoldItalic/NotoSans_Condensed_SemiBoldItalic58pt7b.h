#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC58PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x18,
  0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x8F, 0xE7, 0xE1,
  0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83,
  0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0x99, 0xF0, 0x1F, 0xCE, 0x1C, 0x07, 0xE3, 0x80, 0x01, 0xF8,
  0xE0, 0x00, 0xFE, 0x30, 0x00, 0x3F, 0x9C, 0x00, 0x0F, 0xE7, 0x00, 0x01,
  0xFD, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x77, 0xF0, 0x00,
  0x1D, 0xFC, 0x00, 0x06, 0x3F, 0x00, 0x03, 0x8F, 0xC0, 0x00, 0xE3, 0xF0,
  0x00, 0x38, 0xFC, 0x30, 0x0C, 0x7F, 0x0F, 0x07, 0x1F, 0xC3, 0xF1, 0xDF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xE0,
  0x0F, 0xC7, 0xC0, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x07, 0xC1, 0xF0,
  0x1F, 0x00, 0x3E, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x87, 0xE0, 0x03, 0xF0, 0x7C, 0x3E, 0x00, 0x1F, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0x3F, 0x1F, 0x00, 0x07, 0xC1, 0xF1, 0xF0, 0xFE,
  0x3E, 0x0F, 0x9F, 0x8F, 0xF9, 0xF0, 0xF8, 0xF8, 0xFF, 0xEF, 0xCF, 0xCF,
  0x8F, 0xFF, 0x3F, 0xFC, 0x7C, 0xFC, 0xFD, 0xFF, 0xE7, 0xC7, 0xC3, 0xEF,
  0xFE, 0x7E, 0x7E, 0x1F, 0x3F, 0xE3, 0xE3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x07, 0xC0, 0x01, 0xF1, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x83, 0xF0, 0x01,
  0xF8, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x1F, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0x80, 0x3F,
  0xFE, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xC1, 0xFF, 0xF0,
  0x3F, 0x87, 0xFF, 0xF0, 0x7E, 0x0F, 0xEF, 0xE1, 0xFC, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0x1F, 0xDF, 0x87, 0xF0, 0x3F, 0xFF,
  0x0F, 0xE0, 0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0xF8, 0x3F, 0x00, 0x7F, 0xE0,
  0xFE, 0x00, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x03,
  0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0x0F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x20, 0x3E, 0x00,
  0xC0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0xCF, 0x01, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF, 0x00, 0xFE, 0x7E, 0x07,
  0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0E, 0x0F, 0xE0, 0x10, 0x1E, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00,
  0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80,
  0x1E, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xF9, 0xFC, 0xFC, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x7F,
  0xFF, 0x3F, 0xEF, 0xC7, 0xE7, 0xF1, 0xF1, 0xFC, 0x38, 0x7E, 0x04, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x00, 0x30, 0x07, 0xF0, 0x02, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3C, 0x0F, 0xF0, 0x06, 0x00, 0xFF, 0x00, 0x80, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x08,
  0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x82,
  0x00, 0x0F, 0xF0, 0x60, 0x03, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7D,
  0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xF8,
  0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x04, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x10, 0x00, 0x7F, 0x83, 0x80, 0x1F, 0xE0, 0x7E, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x0E, 0x00,
  0x3F, 0x9F, 0xE0, 0x0F, 0xCF, 0xFC, 0x03, 0xF7, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0x07, 0xF8, 0x1F, 0xC3, 0xFC,
  0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x9F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF1, 0xFC, 0x03,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07,
  0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE,
  0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F,
  0xE7, 0xF0, 0x1F, 0xE1, 0xFC, 0x1F, 0xF0, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0C, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x05, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80,
  0x10, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x38, 0x0F,
  0xE1, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0x80, 0x1E, 0x07, 0xC0, 0x7F, 0xF0,
  0x78, 0x3E, 0x03, 0xFF, 0xE1, 0xF0, 0xF8, 0x1F, 0xFF, 0x07, 0xC7, 0xC0,
  0xFE, 0xFC, 0x1F, 0x1F, 0x07, 0xE1, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0xC1,
  0xF3, 0xE0, 0xF8, 0x3E, 0x07, 0x8F, 0x07, 0xC0, 0xF8, 0x1E, 0x7C, 0x1F,
  0x03, 0xE0, 0xF9, 0xF0, 0x78, 0x0F, 0x83, 0xE7, 0x83, 0xE0, 0x7C, 0x0F,
  0x9E, 0x0F, 0x81, 0xF0, 0x3C, 0xF8, 0x3E, 0x07, 0xC0, 0xF3, 0xE1, 0xF0,
  0x1F, 0x07, 0xCF, 0x87, 0xC0, 0xF8, 0x1E, 0x3E, 0x1F, 0x03, 0xE0, 0xF8,
  0xF8, 0x7C, 0x1F, 0x83, 0xE3, 0xE1, 0xF0, 0x7E, 0x1F, 0x0F, 0x87, 0xE3,
  0xF8, 0x78, 0x3E, 0x0F, 0xFF, 0xFF, 0xE0, 0xF8, 0x3F, 0xF7, 0xFF, 0x03,
  0xE0, 0xFF, 0x8F, 0xF8, 0x0F, 0x81, 0xFC, 0x1F, 0xC0, 0x3E, 0x01, 0xC0,
  0x10, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x80, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0x07, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xC0, 0x3F, 0xE0,
  0x08, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x03, 0x00, 0x7F, 0xE7, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x7E, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0,
  0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3E,
  0x01, 0xFF, 0x00, 0x18, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x07, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0x1F, 0xC0, 0x3F, 0xFC, 0x3F, 0x80,
  0x7F, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE,
  0x03, 0xFC, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xEF, 0xF0, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x7E, 0x7E, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x1F, 0x03, 0xF3,
  0xF8, 0x07, 0xE3, 0xE0, 0x7E, 0x7F, 0x00, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0,
  0x1F, 0x8F, 0x83, 0xF1, 0xF8, 0x07, 0xF1, 0xF0, 0x7C, 0x3F, 0x00, 0xFC,
  0x3E, 0x1F, 0x8F, 0xE0, 0x1F, 0x87, 0xC3, 0xE1, 0xFC, 0x03, 0xF0, 0xF8,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x1F, 0x07, 0xE0, 0x1F, 0xC3, 0xE7, 0xE1,
  0xFC, 0x03, 0xF0, 0x7E, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xFF, 0x07, 0xE0,
  0x0F, 0xC1, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFE, 0x01, 0xF8, 0x1F,
  0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x0F,
  0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x3F,
  0x3F, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x3F, 0x3F, 0x01, 0xF8,
  0x03, 0xF3, 0xF8, 0x3F, 0x80, 0x7F, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8,
  0x3F, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x7F, 0x00, 0x7E,
  0x0F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFC, 0x7E, 0x00, 0xFC, 0x0F, 0xC7, 0xE0,
  0x0F, 0xC0, 0xFC, 0x7E, 0x00, 0xFC, 0x0F, 0xE7, 0xE0, 0x0F, 0xC0, 0x7E,
  0xFC, 0x01, 0xFC, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x7E, 0xFC, 0x01, 0xF8,
  0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x3F,
  0xF8, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80,
  0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFE, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xEF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0xFC, 0x03, 0xF8, 0x1F,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xEF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xC3, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x87, 0xC0, 0x1F, 0xE0, 0x0C, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x60, 0x01, 0xFC, 0x07, 0x80, 0x7F,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFB, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x07,
  0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xFF, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x7E,
  0x01, 0xFF, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xBE, 0x03, 0xF0, 0x3F, 0x01, 0xF7, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x1F, 0x83, 0xF3, 0xE0, 0xFE,
  0x03, 0xF0, 0x7E, 0x7C, 0x1F, 0x80, 0x7E, 0x1F, 0x8F, 0x87, 0xF0, 0x0F,
  0xC3, 0xF1, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0x3F, 0x1F,
  0x87, 0xC7, 0xF0, 0x07, 0xE3, 0xE0, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x1F,
  0x3F, 0x80, 0x1F, 0x9F, 0x83, 0xE7, 0xE0, 0x03, 0xF3, 0xE0, 0x7C, 0xFC,
  0x00, 0x7E, 0xFC, 0x0F, 0xBF, 0x80, 0x0F, 0xDF, 0x01, 0xF7, 0xE0, 0x01,
  0xFF, 0xE0, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xF1, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xE3, 0xF0, 0x1F, 0xFC, 0xFC, 0x0F, 0xFF, 0xBF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x1F,
  0xC0, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE3, 0xF8, 0x01,
  0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0xC3,
  0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x0F, 0xF1, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF3, 0xFE, 0x00, 0xFE, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0,
  0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0x9F, 0xFE, 0x03, 0xF3, 0xFF, 0x80, 0x7C, 0x3F,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x03,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x04, 0x0F, 0xF8, 0x70, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0xC7, 0xE0, 0x07, 0xFF, 0x7F, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFD, 0xF0, 0x03, 0xFF, 0xCF, 0x80, 0x0F, 0xFC, 0xFC, 0x00,
  0x3F, 0xC7, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xC1, 0xFF,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x43, 0xFC,
  0x03, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x40, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0xFE, 0x7E, 0x00, 0xFF, 0xFB, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0x00, 0x1F, 0xFB,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x40, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x02, 0x00, 0x1F, 0xE0, 0x1C, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x7F, 0xC0, 0x3F, 0xBF, 0xF8, 0x0F, 0xDF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFC, 0x1F, 0xF0,
  0x7F, 0x07, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x07,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFE,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF1, 0xFF, 0x07, 0xFC, 0x03, 0xF3,
  0xFF, 0x8F, 0xFE, 0x03, 0xF7, 0xFF, 0x9F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x07,
  0xF0, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0xFE,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x7F, 0xC0, 0x3F,
  0x3F, 0xF8, 0x0F, 0xDF, 0xFF, 0x03, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xE1, 0xFC, 0x1F, 0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFF, 0x80, 0x07,
  0xE7, 0xFF, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xDF, 0xFF, 0x00, 0x3F, 0x7F, 0xF8, 0x00, 0xFC, 0xFF, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC1, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xE3, 0xF0, 0x1F, 0xFC, 0xFC, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xF1, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x02, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC7, 0xF0, 0x3F, 0x3F, 0xC0, 0xFD,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xC3, 0xE0, 0xFE,
  0x03, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC2, 0x00, 0x7F, 0x0F, 0x03, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x05, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x10, 0x7F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x08, 0x00,
  0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0,
  0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0xE0, 0xFE, 0x0F, 0xF8, 0x3F, 0x87, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB, 0xF0, 0x1F, 0xFC,
  0xF8, 0x03, 0xFC, 0x3E, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0x80, 0x7E, 0xFC, 0x07, 0xF8, 0x0F, 0xEF, 0xC0, 0xFF, 0x80, 0xFC, 0xFC,
  0x0F, 0xF8, 0x0F, 0xCF, 0xC0, 0xFF, 0x81, 0xF8, 0xFC, 0x1F, 0xF8, 0x1F,
  0x8F, 0xC1, 0xFF, 0x83, 0xF8, 0xFC, 0x3F, 0xF8, 0x3F, 0x0F, 0xC3, 0xEF,
  0x83, 0xF0, 0xFC, 0x3E, 0xF8, 0x7E, 0x0F, 0xC7, 0xCF, 0x87, 0xE0, 0xFC,
  0x7C, 0xF8, 0xFE, 0x0F, 0xCF, 0xCF, 0x8F, 0xC0, 0xFC, 0xF8, 0xF8, 0xFC,
  0x0F, 0x8F, 0x8F, 0x9F, 0x80, 0xF9, 0xF0, 0xF9, 0xF8, 0x0F, 0x9F, 0x0F,
  0xBF, 0x00, 0xFB, 0xF0, 0xFB, 0xF0, 0x0F, 0xBE, 0x0F, 0xBF, 0x00, 0xFB,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x9F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x3F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0x7F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 16, 42, 15, 0, -41 },
  { 85, 19, 15, 23, 6, -41 },
  { 121, 31, 41, 30, 0, -41 },
  { 280, 26, 47, 26, 1, -44 },
  { 433, 37, 43, 42, 3, -42 },
  { 632, 31, 43, 32, 0, -42 },
  { 799, 9, 15, 13, 6, -41 },
  { 816, 20, 51, 16, 1, -42 },
  { 944, 19, 51, 16, -4, -42 },
  { 1066, 22, 24, 25, 5, -44 },
  { 1132, 24, 27, 28, 3, -34 },
  { 1213, 12, 15, 14, -3, -7 },
  { 1236, 15, 6, 17, 1, -19 },
  { 1248, 9, 9, 14, 0, -8 },
  { 1259, 29, 42, 21, -3, -42 },
  { 1412, 24, 43, 26, 2, -42 },
  { 1541, 18, 41, 27, 6, -41 },
  { 1634, 28, 42, 26, -2, -42 },
  { 1781, 27, 43, 26, 0, -42 },
  { 1927, 28, 42, 27, -1, -42 },
  { 2074, 27, 42, 26, 0, -41 },
  { 2216, 26, 43, 26, 2, -42 },
  { 2356, 27, 41, 26, 2, -41 },
  { 2495, 27, 43, 26, 0, -42 },
  { 2641, 25, 43, 26, 1, -42 },
  { 2776, 14, 33, 14, 0, -32 },
  { 2834, 17, 40, 14, -3, -32 },
  { 2919, 24, 28, 28, 3, -35 },
  { 3003, 24, 17, 28, 3, -29 },
  { 3054, 24, 28, 28, 3, -35 },
  { 3138, 21, 43, 21, 2, -42 },
  { 3251, 38, 47, 40, 2, -42 },
  { 3475, 29, 42, 29, -4, -42 },
  { 3628, 29, 41, 29, 0, -41 },
  { 3777, 28, 43, 27, 3, -42 },
  { 3928, 31, 41, 32, 0, -41 },
  { 4087, 27, 41, 25, 0, -41 },
  { 4226, 27, 41, 24, 0, -41 },
  { 4365, 31, 43, 33, 3, -42 },
  { 4532, 34, 41, 33, 0, -41 },
  { 4707, 24, 41, 18, -2, -41 },
  { 4830, 25, 53, 15, -9, -41 },
  { 4996, 32, 41, 28, 1, -41 },
  { 5160, 20, 41, 24, 0, -41 },
  { 5263, 43, 41, 43, 1, -41 },
  { 5484, 36, 41, 35, 0, -41 },
  { 5669, 30, 43, 34, 3, -42 },
  { 5831, 29, 41, 28, 0, -41 },
  { 5980, 30, 52, 34, 3, -42 },
  { 6175, 28, 41, 29, 1, -41 },
  { 6319, 28, 43, 25, -1, -42 },
  { 6470, 24, 41, 24, 5, -41 },
  { 6593, 31, 42, 32, 3, -41 },
  { 6756, 28, 41, 28, 5, -41 },
  { 6900, 43, 41, 43, 5, -41 },
  { 7121, 34, 41, 27, -3, -41 },
  { 7296, 26, 41, 26, 5, -41 },
  { 7430, 30, 41, 24, -2, -41 },
  { 7584, 23, 51, 17, -2, -42 },
  { 7731, 11, 42, 22, 6, -42 },
  { 7789, 23, 51, 17, -4, -42 },
  { 7936, 26, 24, 27, 0, -41 },
  { 8014, 20, 4, 20, -5, 5 },
  { 8024, 11, 9, 17, 8, -44 },
  { 8037, 26, 33, 28, 2, -32 },
  { 8145, 27, 45, 28, 0, -44 },
  { 8297, 22, 33, 22, 2, -32 },
  { 8388, 29, 45, 28, 2, -44 },
  { 8552, 23, 33, 26, 2, -32 },
  { 8647, 30, 58, 17, -7, -44 },
  { 8865, 29, 46, 28, -1, -32 },
  { 9032, 26, 44, 28, 0, -44 },
  { 9175, 16, 44, 14, 0, -44 },
  { 9263, 23, 58, 14, -7, -44 },
  { 9430, 28, 44, 26, 0, -44 },
  { 9584, 16, 44, 14, 0, -44 },
  { 9672, 40, 32, 42, 0, -32 },
  { 9832, 26, 32, 28, 0, -32 },
  { 9936, 24, 33, 28, 2, -32 },
  { 10035, 30, 46, 28, -3, -32 },
  { 10208, 26, 46, 28, 2, -32 },
  { 10358, 22, 32, 20, 0, -32 },
  { 10446, 22, 33, 22, 0, -32 },
  { 10537, 17, 39, 18, 2, -38 },
  { 10620, 26, 32, 28, 2, -31 },
  { 10724, 24, 31, 24, 3, -31 },
  { 10817, 36, 31, 37, 4, -31 },
  { 10957, 30, 31, 24, -3, -31 },
  { 11074, 32, 45, 24, -5, -31 },
  { 11254, 24, 31, 21, -2, -31 },
  { 11347, 22, 50, 20, 1, -41 },
  { 11485, 6, 57, 25, 9, -44 },
  { 11528, 22, 50, 20, -3, -41 },
  { 11666, 24, 9, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC58PT7B_H_
