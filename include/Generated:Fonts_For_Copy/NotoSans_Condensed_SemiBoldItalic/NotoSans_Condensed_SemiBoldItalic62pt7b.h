#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC62PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xF1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x04,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE1, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xCE, 0x7C, 0x07, 0xF1, 0xC1,
  0x80, 0x7F, 0x1C, 0x00, 0x07, 0xF1, 0xC0, 0x00, 0x7E, 0x1C, 0x00, 0x07,
  0xE3, 0x80, 0x00, 0x7F, 0x38, 0x00, 0x07, 0xF3, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xEF, 0xF0,
  0x00, 0x0E, 0x7F, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x1C, 0x7F, 0x00, 0x01,
  0xC7, 0xF0, 0x00, 0x1C, 0x7F, 0x08, 0x03, 0x87, 0xF0, 0xE0, 0x38, 0xFE,
  0x0F, 0x83, 0x9F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF,
  0xC0, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x1F,
  0x00, 0x1F, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC1, 0xF0, 0x00,
  0x7C, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F,
  0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x1F, 0x8F, 0x83,
  0xF0, 0xFC, 0x1F, 0x1F, 0x8F, 0xF8, 0xFC, 0x3F, 0x1F, 0x1F, 0xFC, 0xFC,
  0x3E, 0x3E, 0x3F, 0xFE, 0x7C, 0x7E, 0x7E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7C,
  0x7E, 0x3E, 0x7F, 0xF8, 0xFC, 0xFC, 0x3E, 0x3F, 0xF0, 0xF8, 0xF8, 0x3F,
  0x1F, 0xE1, 0xF0, 0xF8, 0x3F, 0x07, 0x83, 0xF1, 0xF8, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x3E, 0x00, 0x07, 0xC3, 0xF0,
  0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xE0, 0x7E, 0x00,
  0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03,
  0xE0, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0x03, 0xF7, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0x07, 0xFF, 0xF0, 0x3F, 0x83,
  0xFF, 0xF8, 0x3F, 0x83, 0xF9, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xFC, 0x3F, 0xCF, 0xE1, 0xFC, 0x0F, 0xEF, 0xE1, 0xFE, 0x07, 0xFF, 0xF0,
  0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xDF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF9,
  0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x30, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0xDE, 0x07,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0, 0x3F, 0xC7, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0x07, 0xF0, 0x06, 0x03, 0xF0, 0x02, 0x03, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x06, 0x1F, 0xCF, 0xEF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xF7, 0xFC,
  0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFD, 0xFC, 0xFF, 0x9F, 0xC7, 0xF3,
  0xF8, 0x3E, 0x3F, 0x83, 0xC3, 0xF8, 0x10, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0xC0,
  0x1F, 0x80, 0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0xC0, 0x07, 0xF0, 0x02,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0x40, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x1F, 0xE0, 0xE0,
  0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xDF, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xF8, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x7E, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x0C, 0x00, 0x3F, 0xE0, 0x78, 0x03, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1D,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x40, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xFC, 0x03, 0xFB, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8,
  0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xFC, 0x3F, 0x80,
  0xFF, 0x87, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0xFE, 0x01, 0xFF, 0x1F, 0x80, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x20, 0x0F, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xF0, 0x1F, 0xE0,
  0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF0, 0xFF, 0x07,
  0x00, 0xFE, 0x04, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x1F,
  0xFC, 0x1F, 0x0F, 0xC0, 0x7F, 0xFE, 0x1F, 0x0F, 0x80, 0xFF, 0xFE, 0x1F,
  0x0F, 0x81, 0xFF, 0xFC, 0x1F, 0x1F, 0x03, 0xF0, 0x7C, 0x1F, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x7C,
  0x1F, 0x81, 0xF8, 0x1F, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x7C, 0x1F, 0x01,
  0xF0, 0x3E, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0xF8, 0x3F, 0x03, 0xF0, 0x3C,
  0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0xF8, 0x3E,
  0x07, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0xE0, 0xF8, 0xF8, 0x3F, 0x0F, 0xE1,
  0xF0, 0xF8, 0x3F, 0x1F, 0xF3, 0xE0, 0xF8, 0x1F, 0xFD, 0xFF, 0xE0, 0xF8,
  0x1F, 0xF9, 0xFF, 0xC0, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xF8, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0xE0,
  0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x18, 0x03, 0xFE, 0x00, 0x20, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x10, 0x07,
  0xFE, 0x03, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xFC, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8,
  0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xF8,
  0x0F, 0xFC, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x3C, 0x03, 0xFF, 0x00, 0x04, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xE3, 0xFC,
  0x03, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xF8, 0x7F,
  0x80, 0x7F, 0xFC, 0x3F, 0xC0, 0x3F, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF8, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFD,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF,
  0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xDF, 0x80, 0x7F, 0x7F, 0x00,
  0x7F, 0x7E, 0x01, 0xF9, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xF0, 0x07,
  0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0x81, 0xFC, 0xFE, 0x00, 0xFE,
  0x3E, 0x07, 0xE3, 0xF8, 0x03, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC3, 0xF1, 0xFC, 0x01, 0xFC, 0x3F,
  0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x7E, 0x1F, 0xC0, 0x1F, 0x83, 0xF3,
  0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xCF, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x7E,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFD, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xFF, 0xC0,
  0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0xF8, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0x81, 0xFC,
  0x01, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0,
  0x1F, 0x80, 0xFF, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x7F, 0x00, 0x3F, 0x7F, 0x00,
  0xFE, 0x00, 0x7E, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0x03,
  0xF9, 0xFC, 0x0F, 0xE0, 0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0, 0xFC, 0x00,
  0xFE, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x3F,
  0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x3F, 0x00,
  0x3F, 0x81, 0xFC, 0xFE, 0x00, 0x7F, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x03,
  0xF3, 0xF8, 0x01, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xF0, 0x0F, 0xEF, 0xC0,
  0x0F, 0xE0, 0x1F, 0xDF, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01, 0xFF, 0x01,
  0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x3C, 0x01, 0xFF, 0x00, 0x20, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x40, 0x00, 0xFF, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF8,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF7, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x7E, 0x00,
  0x3F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC7, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFF, 0xC0,
  0x3F, 0x81, 0xF8, 0x07, 0xDF, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x7C, 0x07,
  0xF0, 0x3F, 0x80, 0xFD, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE7, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0x9F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x7C, 0x0F, 0xE0,
  0x3F, 0x83, 0xF1, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC7, 0xC1, 0xFC, 0x03,
  0xF8, 0x7E, 0x1F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x7C, 0x3F, 0x80, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x0F, 0xC7, 0xF0, 0x03, 0xF8,
  0xFC, 0x3F, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x00, 0x3F, 0x9F,
  0x83, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF0,
  0x3F, 0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x03,
  0xF7, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0xCF, 0xE0, 0x07, 0xF1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F,
  0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x83, 0xF0, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xFC, 0x3F,
  0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x7E, 0x03, 0xFF, 0xF7, 0xE0, 0x7F,
  0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F,
  0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF,
  0xEF, 0xC0, 0x7F, 0xFC, 0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xF9, 0xF8,
  0x01, 0xFE, 0x1F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x07,
  0xF3, 0xFF, 0x00, 0x3F, 0xBF, 0xFC, 0x01, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x03, 0xFF, 0x9F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xF8, 0x07,
  0xEF, 0xFF, 0x80, 0x7E, 0x3F, 0xF8, 0x03, 0xF0, 0xFF, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0x06, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0x07, 0xF8, 0x06, 0x07, 0xFC,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xF7,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x1F,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xCF,
  0x80, 0x07, 0xFF, 0x1F, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE3, 0xF8, 0x3F, 0xC0, 0xFC, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7,
  0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF1, 0xFC, 0x7F, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x06, 0x07, 0xF8, 0x0F, 0x03, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0xFF, 0xFB, 0xF8, 0x03,
  0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xE0, 0x07,
  0xFF, 0xDF, 0xC0, 0x07, 0xFF, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00,
  0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x01, 0x80, 0x07, 0xF8, 0x03, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC,
  0xFF, 0xC0, 0x1F, 0xDF, 0xFE, 0x01, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x01, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x7F,
  0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x1F, 0xF8, 0x3F, 0xF0,
  0x07, 0xE7, 0xFF, 0x0F, 0xFF, 0x00, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xFC, 0x01,
  0xF1, 0xFF, 0xE0, 0x1F, 0x3F, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF,
  0x87, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xF3,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0x7F, 0xDF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0x3F, 0x7F,
  0xFC, 0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xE1,
  0xFE, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xEF, 0xFF, 0x00, 0x0F, 0xCF, 0xFE, 0x00, 0x1F, 0xC7, 0xFC,
  0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xFE, 0x3F, 0x00, 0xFF, 0xF3, 0xF0,
  0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x8F, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD,
  0xFC, 0x07, 0xFF, 0xDF, 0x80, 0x3F, 0xFB, 0xF8, 0x01, 0xFE, 0x3F, 0x80,
  0x03, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0xFE, 0x01,
  0xF9, 0xFE, 0x01, 0xFB, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF7, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFD, 0xFC, 0x0F, 0xF0, 0x1C, 0x0F, 0xE0, 0x08, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x80, 0x0F, 0xF0, 0xC0, 0x1F, 0xE0, 0xFC,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x8C, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x60, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xDF, 0x80, 0x3F, 0xF9, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x03,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F,
  0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x03, 0xFB,
  0xF0, 0x0F, 0xF8, 0x07, 0xF7, 0xE0, 0x1F, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0xE0, 0x3F, 0x9F, 0x80, 0xFF, 0xC0, 0x7F, 0x3F, 0x01, 0xFF, 0x81, 0xFC,
  0x7E, 0x07, 0xFF, 0x03, 0xF8, 0xFC, 0x0F, 0xFE, 0x07, 0xE1, 0xF8, 0x1F,
  0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0xF8, 0x3F, 0x07, 0xE0, 0xFB, 0xF0, 0xFE,
  0x0F, 0xC3, 0xF7, 0xE1, 0xFC, 0x1F, 0x87, 0xEF, 0xC3, 0xF0, 0x3F, 0x0F,
  0x9F, 0x8F, 0xE0, 0x7E, 0x3F, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x7E, 0x7F,
  0x01, 0xF9, 0xF8, 0xFC, 0xFE, 0x03, 0xF3, 0xF1, 0xF9, 0xF8, 0x07, 0xE7,
  0xC3, 0xF7, 0xF0, 0x0F, 0xDF, 0x87, 0xCF, 0xC0, 0x1F, 0xBE, 0x0F, 0x9F,
  0x80, 0x3F, 0x7C, 0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x3E, 0xFC, 0x00, 0xFF,
  0xE0, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x17, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x80, 0x07, 0xFF, 0x20, 0x00, 0x1E,
  0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 18, 45, 16, 0, -44 },
  { 103, 21, 16, 24, 6, -44 },
  { 145, 33, 44, 32, 0, -44 },
  { 327, 28, 51, 28, 1, -47 },
  { 506, 40, 46, 45, 3, -45 },
  { 736, 33, 46, 34, 0, -45 },
  { 926, 10, 16, 14, 6, -44 },
  { 946, 21, 54, 17, 1, -44 },
  { 1088, 21, 55, 18, -5, -45 },
  { 1233, 24, 25, 27, 5, -47 },
  { 1308, 26, 30, 30, 3, -37 },
  { 1406, 13, 16, 15, -3, -8 },
  { 1432, 16, 7, 18, 1, -20 },
  { 1446, 9, 10, 15, 0, -9 },
  { 1458, 31, 45, 23, -3, -45 },
  { 1633, 26, 46, 28, 2, -45 },
  { 1783, 20, 44, 28, 6, -44 },
  { 1893, 30, 45, 28, -2, -45 },
  { 2062, 28, 46, 28, 0, -45 },
  { 2223, 29, 44, 28, -1, -44 },
  { 2383, 29, 45, 28, 0, -44 },
  { 2547, 28, 46, 28, 2, -45 },
  { 2708, 29, 44, 28, 2, -44 },
  { 2868, 29, 46, 28, 0, -45 },
  { 3035, 27, 46, 28, 1, -45 },
  { 3191, 14, 35, 15, 0, -34 },
  { 3253, 18, 42, 15, -3, -34 },
  { 3348, 26, 30, 30, 3, -37 },
  { 3446, 26, 18, 30, 3, -31 },
  { 3505, 26, 30, 30, 3, -37 },
  { 3603, 23, 46, 22, 2, -45 },
  { 3736, 40, 50, 43, 2, -45 },
  { 3986, 31, 44, 31, -4, -44 },
  { 4157, 32, 44, 31, 0, -44 },
  { 4333, 30, 46, 29, 3, -45 },
  { 4506, 33, 44, 34, 0, -44 },
  { 4688, 29, 44, 27, 0, -44 },
  { 4848, 29, 44, 26, 0, -44 },
  { 5008, 33, 46, 35, 3, -45 },
  { 5198, 37, 44, 35, 0, -44 },
  { 5402, 26, 44, 20, -2, -44 },
  { 5545, 26, 57, 16, -9, -44 },
  { 5731, 35, 44, 30, 1, -44 },
  { 5924, 21, 44, 25, 0, -44 },
  { 6040, 46, 44, 46, 1, -44 },
  { 6293, 39, 44, 37, 0, -44 },
  { 6508, 32, 46, 36, 3, -45 },
  { 6692, 32, 44, 30, 0, -44 },
  { 6868, 32, 56, 36, 3, -45 },
  { 7092, 30, 44, 31, 1, -44 },
  { 7257, 30, 46, 27, -1, -45 },
  { 7430, 26, 44, 26, 5, -44 },
  { 7573, 33, 45, 34, 3, -44 },
  { 7759, 29, 44, 30, 6, -44 },
  { 7919, 46, 44, 46, 5, -44 },
  { 8172, 37, 44, 29, -4, -44 },
  { 8376, 27, 44, 27, 6, -44 },
  { 8525, 32, 44, 26, -2, -44 },
  { 8701, 25, 54, 18, -2, -44 },
  { 8870, 13, 45, 23, 6, -45 },
  { 8944, 24, 54, 18, -4, -44 },
  { 9106, 28, 26, 29, 0, -44 },
  { 9197, 22, 4, 21, -6, 5 },
  { 9208, 11, 9, 18, 9, -47 },
  { 9221, 28, 35, 30, 2, -34 },
  { 9344, 29, 48, 30, 0, -47 },
  { 9518, 23, 35, 24, 2, -34 },
  { 9619, 31, 48, 30, 2, -47 },
  { 9805, 25, 35, 28, 2, -34 },
  { 9915, 32, 62, 18, -7, -47 },
  { 10163, 31, 49, 30, -1, -34 },
  { 10353, 28, 47, 30, 0, -47 },
  { 10518, 17, 47, 15, 0, -47 },
  { 10618, 25, 62, 15, -8, -47 },
  { 10812, 30, 47, 27, 0, -47 },
  { 10989, 17, 47, 15, 0, -47 },
  { 11089, 43, 34, 45, 0, -34 },
  { 11272, 28, 34, 30, 0, -34 },
  { 11391, 26, 35, 29, 2, -34 },
  { 11505, 32, 49, 30, -3, -34 },
  { 11701, 28, 49, 30, 2, -34 },
  { 11873, 24, 34, 21, 0, -34 },
  { 11975, 24, 35, 23, 0, -34 },
  { 12080, 19, 42, 19, 2, -41 },
  { 12180, 28, 35, 30, 2, -34 },
  { 12303, 25, 34, 25, 4, -34 },
  { 12410, 39, 34, 40, 4, -34 },
  { 12576, 32, 34, 26, -3, -34 },
  { 12712, 34, 49, 26, -5, -34 },
  { 12921, 26, 34, 22, -2, -34 },
  { 13032, 24, 54, 21, 1, -44 },
  { 13194, 6, 61, 26, 10, -47 },
  { 13240, 23, 54, 21, -3, -44 },
  { 13396, 26, 10, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC62PT7B_H_
