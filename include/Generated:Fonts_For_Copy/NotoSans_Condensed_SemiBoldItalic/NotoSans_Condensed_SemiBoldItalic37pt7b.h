#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC37PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x00, 0x79, 0xF7,
  0x9E, 0x79, 0xEF, 0x1E, 0xF1, 0xCF, 0x1C, 0xE3, 0xCE, 0x3C, 0xE3, 0x80,
  0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3,
  0x80, 0x1E, 0x38, 0x01, 0xC3, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x07,
  0x1C, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x1E, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1E, 0x62, 0x0F, 0x20,
  0x0F, 0x30, 0x07, 0xD8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x5F, 0x00, 0x67, 0x80, 0x33, 0xC0,
  0x19, 0xE2, 0x0D, 0xF1, 0xC5, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x80, 0xF0, 0x7F, 0x01, 0xC1, 0xEF, 0x07, 0x03, 0x9E, 0x0E, 0x0E,
  0x3C, 0x38, 0x1C, 0x78, 0xF0, 0x38, 0xF1, 0xC0, 0xF1, 0xC7, 0x01, 0xC3,
  0x8E, 0x03, 0x87, 0x38, 0x07, 0x1E, 0xF3, 0xEE, 0x39, 0xCF, 0xFE, 0xF7,
  0x3F, 0xFF, 0xCE, 0xF3, 0xBF, 0x39, 0xC7, 0x38, 0xF3, 0x8E, 0x01, 0xCF,
  0x1C, 0x07, 0x9C, 0x38, 0x0E, 0x38, 0x70, 0x38, 0x71, 0xE0, 0xF0, 0xE3,
  0x81, 0xC1, 0xC7, 0x07, 0x83, 0x9E, 0x0E, 0x07, 0xF8, 0x38, 0x0F, 0xE0,
  0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3E,
  0xF0, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xF1, 0xF1, 0xEF, 0x1E, 0x3C, 0xF9, 0xE7, 0xC7, 0xBC,
  0x78, 0x7F, 0xCF, 0x83, 0xF8, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F,
  0x0F, 0xCF, 0xF0, 0x7F, 0xFF, 0x87, 0xFE, 0xF8, 0x1F, 0xC7, 0xC0, 0x7B,
  0xDE, 0xEF, 0x7B, 0xDC, 0xE0, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x18, 0xF0, 0x7B, 0x81, 0xFE, 0xFF, 0xFF, 0xC3,
  0xFF, 0x0F, 0x84, 0x7F, 0x03, 0xDE, 0x1F, 0x38, 0x38, 0xF0, 0x43, 0xC0,
  0x04, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xFE, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x9F, 0x1F, 0x0F,
  0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C, 0x1F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xFB, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3,
  0xFD, 0xFF, 0xBE, 0xF3, 0x1E, 0x47, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x07, 0x87, 0xC0, 0xC1, 0xF0, 0x20, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x78, 0x01, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x60, 0xF8, 0x20, 0x7C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x80, 0x3F,
  0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE2, 0x01, 0xF1, 0xE7, 0xF0, 0xFF, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xDC, 0x01, 0xDE,
  0x01, 0xEF, 0x00, 0xE7, 0x80, 0xE3, 0xC0, 0xF3, 0xC0, 0xF1, 0xE0, 0x70,
  0xF0, 0x78, 0x78, 0x78, 0x7C, 0x38, 0x3C, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x20,
  0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x43, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC4,
  0x03, 0xE3, 0xC7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x3C, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xE1, 0xE0,
  0xFB, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xE7, 0x80, 0xFF, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0xE0, 0x3E, 0xF8, 0x3E, 0x3C, 0x3E, 0x1F, 0x1E, 0x07,
  0x9F, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xE0, 0xF8, 0xF8, 0xF8, 0x7F,
  0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0xF8, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xE1, 0xF1, 0xF1, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xDE, 0x01, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0x87, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0x07, 0xC7, 0xE3, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x7C,
  0x3E, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x78,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0xC3, 0xFF, 0x87, 0xFE,
  0x18, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x07, 0x0E, 0x02, 0x07, 0x1C, 0x1F, 0xE7, 0x3C, 0x3F, 0xC7, 0x38,
  0x71, 0xC7, 0x38, 0xE1, 0xC7, 0x70, 0xE3, 0xC7, 0x71, 0xC3, 0x87, 0x71,
  0xC3, 0x87, 0x71, 0xC3, 0x8E, 0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x0E, 0xE3,
  0x87, 0x1C, 0xE3, 0x8F, 0x1C, 0xE3, 0xFB, 0xF8, 0xE1, 0xFB, 0xF0, 0xE0,
  0xE1, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x01, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x78, 0xE0, 0x1E, 0x38,
  0x0F, 0x0E, 0x03, 0xC3, 0x81, 0xF0, 0xE0, 0x78, 0x3C, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00,
  0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xC3, 0xF0, 0x78, 0x3E, 0x0F, 0x07,
  0xC3, 0xE0, 0xF8, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3C, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0x87, 0xC0, 0xF0, 0x7C,
  0x3E, 0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF0,
  0xF0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xC3, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x78, 0xFE, 0x07,
  0x83, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0,
  0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07,
  0x83, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0xFC, 0x1C, 0x3F, 0x00, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x83, 0xFD, 0xF0,
  0x7F, 0x3C, 0x1F, 0xE7, 0x83, 0xFC, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC3, 0xFB,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x03, 0xC0, 0x7C,
  0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E,
  0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0,
  0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0x80, 0x78,
  0x1E, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x4F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x03, 0xC0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x7C,
  0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x00,
  0x3E, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0x78, 0x07, 0xC3,
  0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x07,
  0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xFF, 0xEF, 0xFE, 0x7F, 0xF7, 0xFF, 0x80, 0x03, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x1D, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC0, 0xF7, 0x07, 0xBC, 0x0F, 0x70, 0x73,
  0xC1, 0xE7, 0x0F, 0x78, 0x1E, 0x70, 0xF7, 0x81, 0xE7, 0x1E, 0x78, 0x1E,
  0x71, 0xE7, 0x81, 0xC7, 0x3C, 0xF8, 0x3C, 0x73, 0xCF, 0x03, 0xC7, 0x78,
  0xF0, 0x3C, 0x77, 0x8F, 0x03, 0xC7, 0xF0, 0xF0, 0x78, 0x7F, 0x1F, 0x07,
  0x87, 0xE1, 0xE0, 0x78, 0x7E, 0x1E, 0x07, 0x87, 0xC1, 0xE0, 0x78, 0x7C,
  0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0x1E, 0x0F, 0xC0, 0x3C, 0x1F,
  0x80, 0xF0, 0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x83, 0xFC,
  0x0F, 0x07, 0xB8, 0x3C, 0x0F, 0x78, 0x78, 0x1E, 0xF0, 0xF0, 0x39, 0xE1,
  0xE0, 0xF3, 0xC3, 0xC1, 0xE3, 0xCF, 0x03, 0xC7, 0x9E, 0x07, 0x8F, 0x3C,
  0x0E, 0x1E, 0x78, 0x3C, 0x1C, 0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x7F, 0x81,
  0xE0, 0xFF, 0x07, 0x81, 0xFE, 0x0F, 0x01, 0xF8, 0x1E, 0x03, 0xF0, 0x3C,
  0x07, 0xE0, 0x78, 0x0F, 0xC1, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x3F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0x80,
  0xF9, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x07,
  0xDE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xF0, 0x3E,
  0x3E, 0x0F, 0x87, 0xF7, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xC7, 0xE0, 0x78,
  0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE1, 0xE0,
  0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE7, 0xF8, 0x3F, 0xFE, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0xF8, 0x7C, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x0F, 0x3C, 0x01,
  0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xFB, 0xC0, 0x1E,
  0x78, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x3E, 0x3E, 0x0F, 0x87, 0xF7, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x1E, 0x3F, 0x07, 0x87, 0xC1, 0xE0, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0xF8, 0x7C,
  0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x79, 0xE0, 0x3E, 0x78,
  0x0F, 0x1F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x87,
  0x83, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFC, 0x70, 0x78, 0x08, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE3, 0x03, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xF1, 0xF0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC3, 0xE0, 0x3C, 0x3E,
  0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x7C, 0x07, 0x87,
  0xC0, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x0F, 0x80, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3E,
  0x0F, 0x87, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x07,
  0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x0F, 0x01, 0xFF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x03, 0xCF, 0x03,
  0xF0, 0x3C, 0xF0, 0x3F, 0x07, 0xCF, 0x03, 0xF0, 0x78, 0xF0, 0x7F, 0x07,
  0x8F, 0x07, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x0F, 0xF1, 0xF0, 0xF0,
  0xEF, 0x1E, 0x0F, 0x1E, 0xF1, 0xE0, 0xF1, 0xCF, 0x3C, 0x0F, 0x3C, 0xF3,
  0xC0, 0xF3, 0xCF, 0x7C, 0x0F, 0x38, 0xF7, 0x80, 0xF7, 0x8F, 0x78, 0x0F,
  0x70, 0xFF, 0x00, 0xFF, 0x0E, 0xF0, 0x0F, 0xF0, 0xEE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83,
  0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x00,
  0x1F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x03,
  0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0xF0, 0x1F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E,
  0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0, 0x79, 0xE0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x78, 0xF1,
  0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0F,
  0x1E, 0x3C, 0x78, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x70, 0x0F, 0x38, 0x0F, 0x1E,
  0x07, 0x0F, 0x07, 0x83, 0x83, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x3B, 0xE0,
  0x1E, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0xF8, 0xF8, 0xF1, 0xE1, 0xE1, 0xC0,
  0x07, 0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xC3, 0xE7, 0xE3, 0xE1, 0xF1, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9F,
  0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xF1, 0xF8, 0xF9, 0xF8,
  0x3F, 0xFC, 0x1F, 0xDE, 0x07, 0xCF, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x3E, 0x07, 0xBF, 0x83, 0xFF, 0xE1, 0xF9, 0xF1, 0xF0, 0x78, 0xF8,
  0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x7C, 0x7E, 0x7C,
  0x3F, 0xFC, 0x3D, 0xFE, 0x1E, 0x7C, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0xFF,
  0x87, 0xC6, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x08, 0xFC,
  0xE1, 0xFF, 0x87, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0xE7, 0x81, 0xFE, 0xF0, 0x7F, 0xFC, 0x0F, 0x9F, 0x83, 0xE1,
  0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF9, 0xF8, 0x0F, 0xF7, 0x01, 0xFE, 0xE0, 0x1F, 0x3C,
  0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF8, 0xF3, 0xE1, 0xE7, 0x83,
  0xDE, 0x0F, 0xBC, 0x3E, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x30, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0x20, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF3, 0xC1, 0xFE, 0xF0,
  0xFF, 0xB8, 0x3E, 0x7E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x7C, 0x78, 0x1E,
  0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xF1, 0xF8, 0x7C, 0xFC, 0x1F, 0xFF, 0x03,
  0xFB, 0xC0, 0x7C, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x80, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x3E, 0x07, 0xBF, 0x83, 0xFF,
  0xE1, 0xF9, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x1E,
  0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE3, 0xE0, 0xF1,
  0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07,
  0x80, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x07, 0xC3, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x07, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x1D, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0xF0, 0x1F, 0x3C, 0x07,
  0x8F, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC0,
  0xF0, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0,
  0x0F, 0x3E, 0x1F, 0x03, 0xBF, 0xDF, 0xE0, 0xEF, 0xF7, 0xF8, 0x3F, 0x3F,
  0x9F, 0x1F, 0x0F, 0xC7, 0xC7, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0xC1, 0xE3, 0xC1, 0xE0, 0xF0,
  0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x1F, 0x07, 0x83, 0xC7, 0x83, 0xE0,
  0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x8F, 0x83,
  0xC1, 0xE3, 0xC1, 0xE0, 0xF8, 0x0F, 0x3E, 0x07, 0x3F, 0x83, 0xBF, 0xE1,
  0xF9, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F,
  0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x80,
  0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E, 0x1E, 0x3C, 0x1E,
  0x7C, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0x78, 0x78, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xCF, 0x80, 0x7B, 0xF8, 0x0E, 0xFF, 0x81,
  0xF1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x81, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x9F, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1E, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE7, 0x87, 0xFB, 0xC3, 0xFF, 0xC3, 0xE7, 0xE3, 0xE1, 0xF1,
  0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07,
  0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xF0, 0xF8, 0xF9,
  0xF8, 0x7F, 0xFC, 0x1F, 0xDE, 0x07, 0xCF, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x3C, 0x3D, 0xF0, 0xEF, 0x83, 0xFE, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0x86, 0x3E, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x20, 0x7C, 0xE3, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE0, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x81, 0xFE, 0xFF, 0xDF, 0xF8, 0xF0,
  0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x91, 0xFE, 0x1F, 0xC3, 0xF8, 0x1E, 0x07,
  0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07, 0x87,
  0x83, 0xC7, 0xC3, 0xE3, 0xC1, 0xF1, 0xE1, 0xF0, 0xF9, 0xF8, 0x7F, 0xFC,
  0x1F, 0xDE, 0x07, 0xCF, 0x00, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83,
  0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0xF8, 0x71, 0xE0, 0xE3, 0xC1,
  0xCF, 0x03, 0x9E, 0x07, 0x78, 0x0E, 0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C,
  0x1E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C, 0xF1, 0xFC,
  0x78, 0xF1, 0xDC, 0x78, 0xF3, 0xDC, 0xF0, 0xF3, 0x9C, 0xF0, 0xF3, 0x9C,
  0xE0, 0xF7, 0x9D, 0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0x78,
  0x1F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07,
  0x87, 0x81, 0xF0, 0xF8, 0x7C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x78, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x03, 0x83, 0xC0, 0x38, 0x7C, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3D,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x3E,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0x3C, 0x00, 0x7C, 0x01, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x0F,
  0xE0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x38,
  0x00, 0x3C, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x07,
  0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 12, 9, 14, 4, -26 },
  { 48, 20, 26, 19, 0, -26 },
  { 113, 17, 30, 17, 0, -28 },
  { 177, 23, 27, 27, 2, -27 },
  { 255, 20, 27, 20, 0, -27 },
  { 323, 5, 9, 8, 4, -26 },
  { 329, 12, 32, 10, 1, -26 },
  { 377, 13, 33, 10, -3, -27 },
  { 431, 14, 15, 16, 3, -28 },
  { 458, 15, 18, 18, 2, -22 },
  { 492, 8, 10, 9, -2, -5 },
  { 502, 9, 4, 11, 1, -12 },
  { 507, 6, 5, 9, 0, -5 },
  { 511, 19, 27, 14, -2, -27 },
  { 576, 16, 27, 17, 1, -27 },
  { 630, 11, 26, 17, 4, -26 },
  { 666, 18, 27, 17, -1, -27 },
  { 727, 17, 27, 17, 0, -27 },
  { 785, 17, 27, 17, 0, -27 },
  { 843, 17, 26, 17, 0, -26 },
  { 899, 17, 27, 17, 1, -27 },
  { 957, 18, 26, 17, 1, -26 },
  { 1016, 17, 27, 17, 0, -27 },
  { 1074, 17, 27, 17, 0, -27 },
  { 1132, 9, 20, 9, 0, -20 },
  { 1155, 11, 25, 9, -2, -20 },
  { 1190, 15, 18, 18, 2, -22 },
  { 1224, 15, 10, 18, 2, -18 },
  { 1243, 15, 18, 18, 2, -22 },
  { 1277, 14, 27, 13, 1, -27 },
  { 1325, 24, 30, 26, 1, -27 },
  { 1415, 18, 26, 18, -2, -26 },
  { 1474, 19, 26, 19, 0, -26 },
  { 1536, 18, 27, 18, 2, -27 },
  { 1597, 20, 26, 20, 0, -26 },
  { 1662, 18, 26, 16, 0, -26 },
  { 1721, 18, 26, 15, 0, -26 },
  { 1780, 19, 27, 21, 2, -27 },
  { 1845, 22, 26, 21, 0, -26 },
  { 1917, 15, 26, 12, -1, -26 },
  { 1966, 16, 34, 9, -6, -26 },
  { 2034, 21, 26, 18, 0, -26 },
  { 2103, 13, 26, 15, 0, -26 },
  { 2146, 28, 26, 27, 0, -26 },
  { 2237, 23, 26, 22, 0, -26 },
  { 2312, 19, 27, 22, 2, -27 },
  { 2377, 19, 26, 18, 0, -26 },
  { 2439, 19, 33, 22, 2, -27 },
  { 2518, 18, 26, 18, 0, -26 },
  { 2577, 17, 27, 16, 0, -27 },
  { 2635, 15, 26, 16, 3, -26 },
  { 2684, 20, 26, 21, 2, -26 },
  { 2749, 18, 26, 18, 3, -26 },
  { 2808, 28, 26, 27, 3, -26 },
  { 2899, 22, 26, 17, -2, -26 },
  { 2971, 17, 26, 16, 3, -26 },
  { 3027, 19, 26, 15, -1, -26 },
  { 3089, 14, 33, 11, -1, -27 },
  { 3147, 7, 27, 14, 4, -27 },
  { 3171, 15, 33, 11, -3, -27 },
  { 3233, 17, 15, 17, 0, -26 },
  { 3265, 13, 3, 13, -3, 3 },
  { 3270, 7, 6, 11, 5, -28 },
  { 3276, 17, 20, 18, 1, -20 },
  { 3319, 17, 28, 18, 0, -28 },
  { 3379, 14, 20, 14, 1, -20 },
  { 3414, 19, 28, 18, 1, -28 },
  { 3481, 15, 20, 16, 1, -20 },
  { 3519, 19, 37, 11, -4, -28 },
  { 3607, 18, 29, 18, 0, -20 },
  { 3673, 17, 28, 18, 0, -28 },
  { 3733, 10, 28, 9, 0, -28 },
  { 3768, 15, 37, 9, -5, -28 },
  { 3838, 18, 28, 16, 0, -28 },
  { 3901, 10, 28, 9, 0, -28 },
  { 3936, 26, 20, 27, 0, -20 },
  { 4001, 17, 20, 18, 0, -20 },
  { 4044, 16, 20, 18, 1, -20 },
  { 4084, 19, 29, 18, -2, -20 },
  { 4153, 17, 29, 18, 1, -20 },
  { 4215, 14, 20, 12, 0, -20 },
  { 4250, 14, 20, 14, 0, -20 },
  { 4285, 11, 24, 11, 1, -24 },
  { 4318, 17, 20, 18, 1, -20 },
  { 4361, 15, 20, 15, 2, -20 },
  { 4399, 24, 20, 24, 2, -20 },
  { 4459, 19, 20, 16, -2, -20 },
  { 4507, 20, 29, 15, -3, -20 },
  { 4580, 15, 20, 13, -1, -20 },
  { 4618, 15, 32, 13, 0, -26 },
  { 4678, 4, 37, 16, 6, -28 },
  { 4697, 14, 32, 13, -2, -26 },
  { 4753, 15, 6, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC37PT7B_H_
