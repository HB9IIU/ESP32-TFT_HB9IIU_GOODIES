#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC31PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x0F,
  0x07, 0x80, 0x79, 0xDC, 0xF7, 0x3D, 0xCE, 0x73, 0xB8, 0xEE, 0x33, 0x9C,
  0x00, 0xC7, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x38, 0xC0, 0x1C,
  0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0x1C, 0x03, 0x8C, 0x01,
  0xC6, 0x00, 0xC7, 0x03, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF8, 0x18, 0xE0,
  0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x07, 0x18, 0x03, 0x9C, 0x00, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0xFE, 0x07, 0xFC, 0x3F, 0xF1, 0xEC, 0x87,
  0x30, 0x1C, 0x80, 0x7A, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0xDC, 0x03, 0x78, 0x09, 0xC4, 0x27, 0x3D, 0xFC, 0xFF, 0xE3,
  0xFF, 0x00, 0xF0, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x1F, 0x03, 0x87,
  0xE0, 0x61, 0xCE, 0x1C, 0x39, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x38, 0x38,
  0xC6, 0x07, 0x39, 0xC0, 0xC7, 0x71, 0x98, 0xCE, 0xFB, 0xBB, 0xBF, 0xFE,
  0x77, 0x77, 0x9D, 0xC6, 0x03, 0x39, 0xC0, 0xE6, 0x38, 0x38, 0xC7, 0x07,
  0x38, 0xE1, 0xC7, 0x18, 0x30, 0xE7, 0x0E, 0x1C, 0xE3, 0x81, 0xF8, 0xF0,
  0x3E, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x00, 0xE3, 0x80, 0xF1,
  0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x23, 0xF8, 0xE3, 0xDC, 0x73, 0xCF, 0x79, 0xC7, 0xB9, 0xE1, 0xF8,
  0xF0, 0xFC, 0x78, 0x3C, 0x3C, 0x3E, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xF8,
  0xF0, 0x7B, 0x9C, 0xE7, 0x73, 0x9C, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x1C,
  0x0E, 0x00, 0x06, 0x00, 0x70, 0x07, 0x04, 0x60, 0xF6, 0x1F, 0xFE, 0x3F,
  0xF1, 0xFF, 0x3F, 0x07, 0xB0, 0xF3, 0x82, 0x3C, 0x01, 0x00, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x3C, 0x71,
  0xE3, 0x87, 0x1C, 0x78, 0x7F, 0x7F, 0xFF, 0x77, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x83, 0xFE, 0x3C,
  0xF3, 0xC3, 0x9E, 0x1C, 0xE0, 0xEF, 0x0F, 0x78, 0x7B, 0x83, 0xFC, 0x1F,
  0xE0, 0xEF, 0x07, 0x78, 0x7B, 0x83, 0xDC, 0x1C, 0xE1, 0xE7, 0x0E, 0x3C,
  0xF1, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0xF8, 0xFE, 0x7B,
  0xBD, 0xE6, 0x79, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x03, 0xF8,
  0x0F, 0xF8, 0x3F, 0xF8, 0x30, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0xF8, 0x3F, 0x80, 0xF8, 0x03,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC8,
  0x1E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x06, 0xE0, 0x3F, 0x81, 0xDE, 0x0E, 0x70, 0x39,
  0xC1, 0xC7, 0x0E, 0x3C, 0x38, 0xF1, 0xC3, 0x8F, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0x04, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC8, 0x1E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x7B, 0xE1, 0xDF, 0x87, 0xFF, 0x3E, 0x3C, 0xF0, 0x73,
  0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0xC7, 0x8F, 0x1E, 0x1F, 0xF0,
  0x7F, 0x80, 0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0xF0, 0xFB, 0xC7, 0x87, 0x1E, 0x1C, 0x78, 0x71, 0xE3, 0xC7, 0x8E,
  0x0F, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xF8, 0x3C, 0xF1, 0xE3, 0xC7, 0x07,
  0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x1F, 0xFC, 0x7F, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3,
  0xC3, 0xCE, 0x0F, 0x38, 0x3C, 0xE1, 0xF3, 0xC7, 0x8F, 0xFE, 0x1F, 0xB8,
  0x3D, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x3F, 0xE0,
  0xFF, 0x03, 0xF8, 0x00, 0x0E, 0x3C, 0x78, 0xF0, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x3E, 0x78, 0xF0, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x70,
  0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E,
  0x03, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x00, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00,
  0x1F, 0xC7, 0xFC, 0xFF, 0x90, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0xC1, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x7E,
  0x33, 0x8F, 0xE3, 0x71, 0xCE, 0x37, 0x38, 0xE3, 0x63, 0x8C, 0x7E, 0x30,
  0xC7, 0xE7, 0x1C, 0x6E, 0x71, 0xC6, 0xE7, 0x18, 0xEC, 0x73, 0x8C, 0xC7,
  0xFF, 0xCE, 0x3C, 0xF8, 0xE0, 0x84, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x40, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0x80,
  0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE1, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E, 0x78, 0x1C, 0xE0, 0x3B, 0xC0, 0x77,
  0x80, 0xFE, 0x01, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F,
  0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1F, 0xF8,
  0x1F, 0xE0, 0x3F, 0xF8, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x38, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x84, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x20, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x81, 0xE3, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x3C,
  0x0F, 0x1E, 0x07, 0x0F, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xE0, 0x78, 0x70, 0x3C, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x7E,
  0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xC1, 0xF0, 0x61, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x8E, 0x0F, 0xCF, 0x0F, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0x83, 0xC1, 0xC0, 0xF0, 0xF0,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0x81, 0xE0, 0xE0, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x0F, 0x0F,
  0x03, 0x83, 0x81, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81,
  0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x7C, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0x07, 0xC1,
  0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE7,
  0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x07, 0x78, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0x78, 0x03, 0x8E, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x87, 0x01, 0xC1, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x00, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3F, 0xF7, 0xFD, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83,
  0xF0, 0x77, 0x0F, 0xE0, 0xFE, 0x1D, 0xC3, 0xBC, 0x3B, 0x87, 0x70, 0x77,
  0x1C, 0xE1, 0xEE, 0x39, 0xC3, 0xDC, 0xF7, 0x87, 0x39, 0xCF, 0x0E, 0x77,
  0x9C, 0x1C, 0xEE, 0x38, 0x78, 0xFC, 0xF0, 0xF1, 0xF1, 0xE1, 0xC3, 0xE3,
  0x83, 0x87, 0x87, 0x07, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x00, 0x07, 0x80,
  0xE0, 0xF0, 0x1C, 0x3F, 0x07, 0x87, 0xE0, 0xF0, 0xFC, 0x1C, 0x1F, 0x83,
  0x83, 0xF0, 0x70, 0xFF, 0x1E, 0x1C, 0xE3, 0x83, 0x9C, 0x70, 0x73, 0x8E,
  0x1E, 0x79, 0xC3, 0xC7, 0x78, 0x70, 0xEE, 0x0E, 0x1D, 0xC1, 0xC3, 0xB8,
  0x78, 0x7F, 0x0F, 0x07, 0xE1, 0xC0, 0xF8, 0x38, 0x1F, 0x07, 0x03, 0xE1,
  0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1,
  0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xCE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x3E, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x0F,
  0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x7C,
  0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE1, 0xE1, 0xE0, 0x71, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xCE, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x3C, 0x1E,
  0x1E, 0x1E, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF8, 0x78, 0xF0, 0xF1, 0xE1, 0xC1, 0xC3, 0x83, 0x8F, 0x0F, 0x1E,
  0x1E, 0x38, 0x78, 0x7F, 0xF1, 0xFF, 0x83, 0xFE, 0x07, 0xBC, 0x0E, 0x38,
  0x1C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE1, 0xC3, 0x83, 0xC7, 0x07, 0x9E,
  0x0F, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xF8, 0x41, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF1, 0x01, 0xE3,
  0x07, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFF, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1C, 0x3C, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3,
  0xC1, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x1E, 0x3E,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0xE0, 0x1F, 0xC0, 0x7B, 0x80,
  0xE7, 0x03, 0xCE, 0x07, 0x9C, 0x1E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xE1,
  0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x0F, 0x78, 0x1E, 0xE0, 0x3D, 0xC0, 0x7F,
  0x80, 0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x7B, 0x81, 0xE0, 0xF7, 0x07, 0xC1,
  0xCE, 0x0F, 0x87, 0x9C, 0x3F, 0x0E, 0x38, 0x7E, 0x3C, 0x71, 0xDC, 0x78,
  0xE3, 0xB8, 0xE1, 0xC7, 0x73, 0xC3, 0x9C, 0xE7, 0x07, 0x39, 0xDE, 0x0E,
  0xE3, 0xB8, 0x1D, 0xC7, 0x70, 0x3B, 0x8F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC,
  0x37, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x70, 0x78, 0x0E, 0x1E,
  0x01, 0xE3, 0x80, 0x3C, 0xF0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00,
  0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x00, 0xE0, 0x7F,
  0x83, 0xFC, 0x3D, 0xE1, 0xC7, 0x1E, 0x38, 0xE1, 0xCF, 0x0E, 0xF0, 0x77,
  0x03, 0xF8, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x00, 0xE3,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3C,
  0x71, 0xC7, 0x1C, 0x70, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x07, 0x70, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x1C,
  0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x07, 0xF0, 0x1C, 0xFF, 0xFF, 0xFC, 0xF1,
  0xE3, 0x8E, 0x1C, 0x07, 0x9C, 0x7F, 0x71, 0xFF, 0xCF, 0x1E, 0x78, 0x79,
  0xE1, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF1, 0xE3, 0xC7, 0x8F, 0xFE, 0x1F, 0xB8, 0x7C, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xBE, 0x1F,
  0xF8, 0x7F, 0xF1, 0xF3, 0xC7, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x83, 0xCE,
  0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF1, 0xFF, 0xCE,
  0xFE, 0x39, 0xF0, 0x07, 0xF0, 0xFE, 0x1F, 0xE3, 0xC2, 0x78, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08,
  0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x03, 0xCE, 0x1F, 0xFC, 0x3F, 0xF8,
  0xF1, 0xE1, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xF0,
  0x71, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x0F, 0x1E, 0x1F, 0xFC, 0x1F, 0xB8,
  0x3E, 0x70, 0x07, 0xE0, 0xFF, 0x1F, 0xF3, 0xC7, 0x78, 0x77, 0x87, 0x70,
  0xFF, 0xFE, 0xFF, 0xCF, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x04, 0xFF,
  0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x0E, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0x20, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xCE,
  0x1F, 0xDC, 0x3F, 0xF8, 0xF1, 0xE1, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x3C,
  0x1E, 0x78, 0x38, 0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E,
  0x1F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x08,
  0x1C, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xBE, 0x1F, 0xFC, 0x7F,
  0xF1, 0xF3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0E, 0x38,
  0x39, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x3C,
  0x3C, 0x07, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1E, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F,
  0x1E, 0x3C, 0x3C, 0xF0, 0x71, 0xC0, 0xE7, 0x81, 0xDE, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFB, 0x81, 0xE7, 0x03, 0x8F, 0x07, 0x1E,
  0x0E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0,
  0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0x0C, 0xF8, 0xF0,
  0xEF, 0xCF, 0xC7, 0xFF, 0xFE, 0x3E, 0x7C, 0x71, 0xE3, 0xC3, 0x8E, 0x1E,
  0x1C, 0xF0, 0xE0, 0xE7, 0x87, 0x0F, 0x38, 0x38, 0x79, 0xC3, 0xC3, 0x9E,
  0x1E, 0x1C, 0xF0, 0xE0, 0xE7, 0x87, 0x0F, 0x38, 0x38, 0x79, 0xC3, 0xC3,
  0x9E, 0x1E, 0x1C, 0xF0, 0xE1, 0xE0, 0x0C, 0xF8, 0x77, 0xF1, 0xFF, 0xC7,
  0xCF, 0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0E, 0x38, 0x38, 0xE0, 0xE7,
  0x87, 0x9E, 0x1E, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x3C, 0x3C, 0xF0, 0xF0,
  0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF7, 0x87, 0xBC, 0x3D, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xB8, 0x1D, 0xC1, 0xEE, 0x0E, 0x78, 0xF3, 0xFF,
  0x0F, 0xF0, 0x3F, 0x00, 0x06, 0x7C, 0x1D, 0xF8, 0x3F, 0xF8, 0x7C, 0xF0,
  0xF0, 0xE1, 0xC1, 0xC7, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0xF0,
  0x71, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0xFE, 0x3F, 0xF8, 0x7B, 0xE0,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x07, 0x9C, 0x3F, 0x71, 0xFF, 0xCF, 0x1E, 0x38, 0x79, 0xE1, 0xE7,
  0x07, 0xBC, 0x1C, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x38, 0x3C, 0xE0, 0xE3,
  0xC7, 0x8F, 0xFE, 0x1F, 0xF8, 0x7D, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0C, 0xF1, 0xDE, 0x1D, 0xE1,
  0xFE, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xE1, 0xFF,
  0x3F, 0xE3, 0xC2, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x03, 0xC0, 0x3C, 0x03, 0xC8, 0x3C, 0xFF, 0x8F, 0xF8, 0xFF, 0x00, 0x0E,
  0x07, 0x07, 0x07, 0xF7, 0xFB, 0xFC, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x7E, 0x3F, 0x0F, 0x80, 0x1C, 0x3C,
  0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x39, 0xE1, 0xE7, 0x87, 0x9C, 0x1C,
  0x70, 0x71, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0xFE,
  0x3F, 0xB8, 0x7C, 0xC0, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE,
  0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xEF, 0x0E, 0xE0, 0xFE, 0x0F,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x00, 0xE0, 0xE0, 0xFC, 0x3C, 0x3F, 0x87,
  0x87, 0x71, 0xF0, 0xEE, 0x3E, 0x3D, 0xC6, 0xC7, 0x39, 0xD9, 0xE7, 0x33,
  0x38, 0xEE, 0x67, 0x1D, 0xCD, 0xC3, 0xB1, 0xB8, 0x7E, 0x77, 0x0F, 0xCF,
  0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0xF0, 0x7B, 0xC0, 0xF7, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xDE, 0x07,
  0x9C, 0x1E, 0x38, 0x38, 0x78, 0xF0, 0xF0, 0x07, 0x03, 0x83, 0x83, 0xC1,
  0xC1, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x0F, 0x38,
  0x07, 0xBC, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x38,
  0x03, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F, 0x03, 0xF0, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0xFC, 0x0F,
  0x80, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0x7F, 0xFF, 0xE0, 0x7E,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 10, 8, 12, 3, -22 },
  { 36, 17, 22, 16, 0, -22 },
  { 83, 14, 26, 14, 0, -24 },
  { 129, 19, 22, 22, 2, -22 },
  { 182, 17, 22, 17, 0, -22 },
  { 229, 5, 8, 7, 3, -22 },
  { 234, 10, 27, 9, 1, -22 },
  { 268, 10, 27, 9, -2, -22 },
  { 302, 12, 13, 14, 3, -24 },
  { 322, 13, 14, 15, 1, -18 },
  { 345, 7, 8, 7, -2, -4 },
  { 352, 8, 3, 9, 0, -10 },
  { 355, 5, 4, 7, 0, -4 },
  { 358, 16, 22, 11, -2, -22 },
  { 402, 13, 22, 14, 1, -22 },
  { 438, 10, 22, 14, 3, -22 },
  { 466, 15, 22, 14, -1, -22 },
  { 508, 14, 22, 14, 0, -22 },
  { 547, 14, 22, 14, 0, -22 },
  { 586, 14, 22, 14, 0, -22 },
  { 625, 14, 22, 14, 1, -22 },
  { 664, 15, 22, 14, 1, -22 },
  { 706, 14, 22, 14, 0, -22 },
  { 745, 14, 22, 14, 0, -22 },
  { 784, 7, 17, 8, 0, -17 },
  { 799, 9, 21, 8, -2, -17 },
  { 823, 13, 15, 15, 1, -19 },
  { 848, 13, 9, 15, 1, -15 },
  { 863, 13, 15, 15, 1, -19 },
  { 888, 11, 22, 11, 1, -22 },
  { 919, 20, 25, 21, 1, -22 },
  { 982, 15, 22, 15, -2, -22 },
  { 1024, 16, 22, 16, 0, -22 },
  { 1068, 16, 22, 15, 1, -22 },
  { 1112, 17, 22, 17, 0, -22 },
  { 1159, 15, 22, 13, 0, -22 },
  { 1201, 15, 22, 13, 0, -22 },
  { 1243, 17, 22, 18, 1, -22 },
  { 1290, 18, 22, 18, 0, -22 },
  { 1340, 13, 22, 10, -1, -22 },
  { 1376, 14, 28, 8, -5, -22 },
  { 1425, 18, 22, 15, 0, -22 },
  { 1475, 11, 22, 13, 0, -22 },
  { 1506, 23, 22, 23, 0, -22 },
  { 1570, 19, 22, 19, 0, -22 },
  { 1623, 17, 22, 18, 1, -22 },
  { 1670, 16, 22, 15, 0, -22 },
  { 1714, 17, 27, 18, 1, -22 },
  { 1772, 15, 22, 15, 0, -22 },
  { 1814, 15, 22, 13, 0, -22 },
  { 1856, 13, 22, 13, 2, -22 },
  { 1892, 17, 22, 17, 1, -22 },
  { 1939, 15, 22, 15, 3, -22 },
  { 1981, 23, 22, 23, 3, -22 },
  { 2045, 19, 22, 14, -2, -22 },
  { 2098, 13, 22, 14, 3, -22 },
  { 2134, 16, 22, 13, -1, -22 },
  { 2178, 12, 27, 9, -1, -22 },
  { 2219, 6, 22, 12, 3, -22 },
  { 2236, 12, 27, 9, -2, -22 },
  { 2277, 14, 13, 14, 0, -22 },
  { 2300, 11, 2, 11, -3, 3 },
  { 2303, 6, 5, 9, 4, -24 },
  { 2307, 14, 17, 15, 1, -17 },
  { 2337, 14, 24, 15, 0, -24 },
  { 2379, 12, 17, 12, 1, -17 },
  { 2405, 15, 24, 15, 1, -24 },
  { 2450, 12, 17, 14, 1, -17 },
  { 2476, 17, 31, 9, -4, -24 },
  { 2542, 15, 24, 15, 0, -17 },
  { 2587, 14, 24, 15, 0, -24 },
  { 2629, 8, 23, 7, 0, -23 },
  { 2652, 12, 30, 7, -4, -23 },
  { 2697, 15, 24, 14, 0, -24 },
  { 2742, 9, 24, 7, 0, -24 },
  { 2769, 21, 17, 22, 0, -17 },
  { 2814, 14, 17, 15, 0, -17 },
  { 2844, 13, 17, 15, 1, -17 },
  { 2872, 15, 24, 15, -1, -17 },
  { 2917, 14, 24, 15, 1, -17 },
  { 2959, 12, 17, 10, 0, -17 },
  { 2985, 12, 17, 12, 0, -17 },
  { 3011, 9, 20, 9, 1, -20 },
  { 3034, 14, 17, 15, 1, -17 },
  { 3064, 12, 17, 13, 2, -17 },
  { 3090, 19, 17, 20, 2, -17 },
  { 3131, 15, 17, 13, -1, -17 },
  { 3163, 17, 24, 13, -3, -17 },
  { 3214, 13, 17, 11, -1, -17 },
  { 3242, 13, 27, 11, 0, -22 },
  { 3286, 3, 31, 13, 5, -24 },
  { 3298, 12, 27, 11, -2, -22 },
  { 3339, 14, 4, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC31PT7B_H_
