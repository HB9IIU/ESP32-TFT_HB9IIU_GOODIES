#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x7C, 0x0F,
  0x83, 0xF0, 0x7E, 0x07, 0x80, 0x7C, 0xFB, 0xE7, 0xDF, 0x3E, 0xF1, 0xE7,
  0x8F, 0x3C, 0x79, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x70, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3C, 0x78, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x03, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07, 0x0E, 0x00, 0x78, 0xF0, 0x03,
  0x87, 0x00, 0x1C, 0x38, 0x01, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0,
  0x07, 0x8F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7C, 0xCC, 0x0F,
  0x30, 0x01, 0xE6, 0x00, 0x3C, 0xC0, 0x07, 0xD8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0x7C, 0x00, 0x6F, 0x80, 0x0C, 0xF0, 0x01, 0x9E, 0x10, 0x67, 0xC3, 0x0C,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x1E, 0x07,
  0xF0, 0x0E, 0x07, 0xF8, 0x0F, 0x07, 0x9E, 0x07, 0x03, 0xCF, 0x07, 0x81,
  0xC7, 0x87, 0x81, 0xE3, 0xC3, 0x80, 0xE1, 0xE3, 0xC0, 0x70, 0xE1, 0xC0,
  0x78, 0x71, 0xE0, 0x3C, 0x79, 0xE0, 0x1E, 0x3C, 0xE1, 0x8F, 0x1C, 0xF3,
  0xF7, 0x9E, 0x73, 0xFF, 0xCE, 0x7B, 0xFE, 0xFF, 0x79, 0xC7, 0x7F, 0x3D,
  0xE3, 0x9F, 0x3C, 0xF1, 0xC0, 0x1C, 0x70, 0xE0, 0x1E, 0x78, 0x70, 0x0E,
  0x3C, 0x78, 0x0F, 0x1E, 0x3C, 0x0F, 0x0E, 0x1E, 0x07, 0x07, 0x0E, 0x07,
  0x83, 0x8F, 0x03, 0x81, 0xC7, 0x03, 0xC0, 0xFF, 0x83, 0xC0, 0x3F, 0x83,
  0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x3E, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0x1F, 0xF8, 0xF9,
  0xF3, 0xE7, 0x9F, 0x1F, 0x7C, 0xF8, 0x7F, 0xC7, 0x83, 0xFE, 0x7C, 0x0F,
  0xE3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x3F, 0x83, 0xF7, 0xFE, 0x1F,
  0xFF, 0xF0, 0x7F, 0xE7, 0xC1, 0xFC, 0x3E, 0x00, 0x7D, 0xF7, 0xDE, 0x79,
  0xE7, 0xBC, 0xF3, 0xCE, 0x00, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0x02,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x04, 0x3C, 0x1E, 0x70, 0x3F, 0xE7,
  0xFF, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x7F, 0x01, 0xFE, 0x07, 0xDE, 0x1F,
  0x1C, 0x0C, 0x3C, 0x08, 0x70, 0x00, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x0F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x11, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x7C, 0x1E,
  0x3E, 0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x03, 0xEF, 0x81, 0xF7, 0xC0,
  0xFB, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE7, 0x81, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0xF9, 0xFF, 0x9F, 0xBC,
  0x73, 0xE1, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x7E, 0x06,
  0x07, 0xC0, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x87, 0xC0, 0x81, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x80, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xDE, 0x00, 0xEF, 0x80, 0x7B,
  0xC0, 0x1C, 0xF0, 0x0E, 0x3C, 0x07, 0x9F, 0x03, 0xC7, 0xC0, 0xE1, 0xE0,
  0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x87, 0x83, 0xE3, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x41, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0xC0, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF3, 0xF0, 0x3D, 0xFE, 0x1F, 0xFF,
  0x87, 0xFF, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0x78,
  0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x3C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xEF,
  0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xBE,
  0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0xCF, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x1F, 0xFE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E,
  0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83,
  0xE1, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFB, 0xE0, 0x38, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC0,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF1, 0xC3, 0xE2,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x0E,
  0x07, 0xE1, 0xC7, 0x87, 0xFC, 0x71, 0xC3, 0xFF, 0x1C, 0xF1, 0xE3, 0xC7,
  0x38, 0x70, 0xE1, 0xDE, 0x3C, 0x38, 0x77, 0x0E, 0x1E, 0x1D, 0xC7, 0x87,
  0x87, 0x71, 0xE1, 0xC3, 0x9C, 0x70, 0x70, 0xEF, 0x1C, 0x3C, 0x3B, 0xC7,
  0x0F, 0x1C, 0xF1, 0xC7, 0xC7, 0x38, 0x7B, 0xF3, 0x8F, 0x1F, 0xDF, 0xC3,
  0xC3, 0xE3, 0xE0, 0xF0, 0x30, 0x20, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E,
  0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3E, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1E, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x07, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x07, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0x7C, 0x1E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC7,
  0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF,
  0xE0, 0x7E, 0x1C, 0x1F, 0x80, 0x87, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x04, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF0, 0x3F,
  0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x0F,
  0x07, 0xE0, 0x10, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xF3,
  0xE0, 0x7F, 0x9F, 0x07, 0xFC, 0xF8, 0x3F, 0xE7, 0xC0, 0x1E, 0x3E, 0x00,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x78, 0x0F, 0x80, 0x78, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x03,
  0xE0, 0x1E, 0x07, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0,
  0x03, 0xC3, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00,
  0x7D, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x78, 0xF0, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF,
  0x03, 0xDE, 0x0F, 0x7C, 0x0F, 0x78, 0x3D, 0xF0, 0x3D, 0xE0, 0xF7, 0x81,
  0xF7, 0x87, 0x9E, 0x07, 0x9E, 0x1E, 0x78, 0x1E, 0x78, 0xF3, 0xE0, 0x78,
  0xE3, 0xCF, 0x81, 0xE3, 0x9E, 0x3C, 0x0F, 0x8E, 0x78, 0xF0, 0x3C, 0x3B,
  0xC3, 0xC0, 0xF0, 0xEF, 0x1F, 0x03, 0xC3, 0xF8, 0x7C, 0x0F, 0x0F, 0xE1,
  0xE0, 0x7C, 0x3F, 0x07, 0x81, 0xE0, 0xFC, 0x3E, 0x07, 0x83, 0xE0, 0xF8,
  0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x00, 0x03, 0xF0, 0x07, 0x81,
  0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x7E, 0x01, 0xE0, 0x7F, 0x00, 0xF0,
  0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E,
  0x07, 0xFE, 0x0F, 0x03, 0xCF, 0x0F, 0x81, 0xE7, 0x87, 0xC0, 0xF3, 0xC3,
  0xC0, 0x79, 0xE1, 0xE0, 0x7C, 0xF8, 0xF0, 0x3C, 0x3C, 0xF8, 0x1E, 0x1E,
  0x7C, 0x0F, 0x0F, 0x3C, 0x07, 0x87, 0xDE, 0x07, 0xC1, 0xEF, 0x03, 0xC0,
  0xF7, 0x81, 0xE0, 0x7F, 0x80, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C,
  0x07, 0xF0, 0x3C, 0x03, 0xF8, 0x1E, 0x01, 0xF8, 0x0F, 0x00, 0xFC, 0x0F,
  0x80, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03,
  0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xCF, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x03, 0xE0, 0xF0, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xC0,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0,
  0xFC, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xC7, 0xE0, 0x7C, 0x3F, 0x07,
  0xC1, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x07, 0xE0, 0xF1, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFE, 0x78, 0x1F, 0x01, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x84, 0x01, 0xF0, 0xE0, 0x7C, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x7C,
  0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F,
  0x80, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x3F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xCF, 0x00,
  0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x07,
  0xC3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C,
  0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x79, 0xE0,
  0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x07,
  0x80, 0x7D, 0xE0, 0x1E, 0x01, 0xF7, 0x80, 0xF8, 0x07, 0x9E, 0x03, 0xE0,
  0x3E, 0x78, 0x0F, 0x80, 0xF1, 0xE0, 0x7E, 0x07, 0xC7, 0x81, 0xF8, 0x1F,
  0x1E, 0x0F, 0xE0, 0x78, 0x78, 0x3F, 0x83, 0xE1, 0xE0, 0xEE, 0x0F, 0x07,
  0x87, 0xB8, 0x7C, 0x1E, 0x1F, 0xE1, 0xF0, 0x78, 0xF7, 0x87, 0x81, 0xE3,
  0xDE, 0x3E, 0x07, 0x8E, 0x78, 0xF0, 0x3E, 0x79, 0xE7, 0xC0, 0xF9, 0xE7,
  0x9F, 0x03, 0xEF, 0x1E, 0x78, 0x0F, 0xBC, 0x7B, 0xE0, 0x3E, 0xE1, 0xEF,
  0x00, 0xFF, 0x87, 0xBC, 0x03, 0xDE, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x79, 0xF0, 0x00, 0xFB,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x7C,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xE1,
  0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x03, 0xCF, 0x01,
  0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1C, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0,
  0x79, 0xF0, 0x0F, 0xF8, 0x03, 0xC0, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0,
  0xF9, 0xF1, 0xE3, 0xE3, 0xC3, 0x87, 0x80, 0x01, 0xF1, 0xC1, 0xFE, 0xF0,
  0xFF, 0xBC, 0x3F, 0xFF, 0x1F, 0x0F, 0xCF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F,
  0xDF, 0xE1, 0xFF, 0xF0, 0x7F, 0xBC, 0x0F, 0xCF, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x9F, 0x03, 0xEF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xC7, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3, 0xC0,
  0xF9, 0xF0, 0x3E, 0x7C, 0x1F, 0x1F, 0x87, 0xC7, 0xF7, 0xE1, 0xFF, 0xF0,
  0xF7, 0xFC, 0x3C, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x7F,
  0xE1, 0xF0, 0x47, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x21, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF3, 0xC0, 0x7F, 0xBC,
  0x0F, 0xFB, 0xC0, 0xFF, 0xFC, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x87, 0xE0, 0xFD, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xBC, 0x03,
  0xF3, 0xC0, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xDF, 0x1F, 0x0F,
  0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7B, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF0, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x08, 0x7C, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF9, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x09, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8,
  0xE0, 0x7F, 0xBC, 0x1F, 0xF7, 0x83, 0xFF, 0xF0, 0xF8, 0x7E, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0xF8,
  0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFD, 0xE0,
  0x3F, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x82,
  0x01, 0xF0, 0x70, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x9F, 0x03, 0xEF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E,
  0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0x81, 0xF1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x80, 0x01, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0xBF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x83, 0xF0, 0xF8,
  0x3E, 0x0F, 0x87, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x1F,
  0x3C, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x1F, 0x07,
  0xC0, 0xF3, 0xF9, 0xFE, 0x0F, 0x7F, 0xBF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC7, 0xF1, 0xF0, 0xF8, 0x7E, 0x1F, 0x1F, 0x07, 0xC1, 0xE1, 0xF0, 0x7C,
  0x1E, 0x1F, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0x3E, 0x1E, 0x0F, 0x83, 0xE3,
  0xE0, 0xF8, 0x3C, 0x3E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F,
  0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0x87, 0xC1, 0xE0, 0x78,
  0x78, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F, 0x83,
  0xE0, 0xF0, 0x07, 0x1F, 0x03, 0xCF, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x0F,
  0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF1,
  0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0xF8,
  0x1E, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF0, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBC,
  0x07, 0xDE, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x01, 0xC7, 0xC0, 0x3C, 0xFE, 0x03, 0xDF, 0xF0, 0x3F,
  0xFF, 0x03, 0xF1, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x07,
  0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xF8, 0x7C,
  0x1F, 0xDF, 0x81, 0xFF, 0xF0, 0x3E, 0xFF, 0x03, 0xE7, 0xC0, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xC1,
  0xFE, 0xF0, 0xFF, 0xBC, 0x3F, 0xFF, 0x1F, 0x0F, 0xCF, 0x83, 0xE3, 0xE0,
  0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xBC, 0x0F, 0xDF, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0x1E, 0x1E,
  0x7C, 0x3D, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xE0,
  0x47, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0x01,
  0xF3, 0xDF, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x81, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3E, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0x0F, 0x03, 0xC7,
  0xC0, 0xF1, 0xF0, 0x7C, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x1F, 0x8F, 0xDF, 0xC1, 0xFF, 0xF0, 0x7F, 0xBC, 0x0F, 0xCF, 0x00, 0xF8,
  0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE3, 0xC1, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C,
  0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x3E,
  0x07, 0xFE, 0x0F, 0x81, 0xEF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x3C, 0xF8,
  0x7E, 0x1F, 0x3E, 0x3F, 0x87, 0x8F, 0x8E, 0xE1, 0xE3, 0xE3, 0xB8, 0xF8,
  0xF9, 0xEE, 0x3C, 0x3E, 0x73, 0x9F, 0x0F, 0xBC, 0xE7, 0x83, 0xEF, 0x39,
  0xE0, 0xF3, 0x8E, 0xF0, 0x3D, 0xE3, 0xBC, 0x0F, 0x70, 0xEF, 0x03, 0xFC,
  0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC1,
  0xF8, 0x3E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3E, 0x7C, 0x01,
  0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0x87, 0x80,
  0x7C, 0x3C, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xF0, 0x0F, 0x07,
  0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00,
  0x3C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x27, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x01, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF4, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 11, 29, 10, 0, -29 },
  { 41, 13, 11, 16, 4, -29 },
  { 59, 21, 29, 21, 0, -29 },
  { 136, 19, 32, 18, 0, -30 },
  { 212, 25, 29, 29, 2, -29 },
  { 303, 21, 29, 22, 0, -29 },
  { 380, 6, 11, 9, 4, -29 },
  { 389, 13, 35, 11, 1, -29 },
  { 446, 13, 35, 11, -3, -29 },
  { 503, 15, 17, 18, 4, -31 },
  { 535, 17, 19, 19, 2, -24 },
  { 576, 8, 10, 10, -2, -5 },
  { 586, 10, 4, 12, 1, -13 },
  { 591, 6, 6, 10, 0, -6 },
  { 596, 20, 29, 15, -2, -29 },
  { 669, 17, 29, 18, 1, -29 },
  { 731, 13, 29, 18, 4, -29 },
  { 779, 19, 29, 18, -1, -29 },
  { 848, 18, 29, 18, 0, -29 },
  { 914, 18, 29, 18, 0, -29 },
  { 980, 19, 29, 18, 0, -29 },
  { 1049, 18, 29, 18, 1, -29 },
  { 1115, 19, 29, 18, 1, -29 },
  { 1184, 19, 29, 18, 0, -29 },
  { 1253, 18, 29, 18, 0, -29 },
  { 1319, 9, 22, 10, 0, -22 },
  { 1344, 11, 27, 10, -2, -22 },
  { 1382, 17, 19, 19, 2, -24 },
  { 1423, 17, 12, 19, 2, -20 },
  { 1449, 17, 19, 19, 2, -24 },
  { 1490, 15, 29, 14, 1, -29 },
  { 1545, 26, 32, 28, 1, -29 },
  { 1649, 19, 29, 20, -2, -29 },
  { 1718, 20, 29, 20, 0, -29 },
  { 1791, 19, 29, 19, 2, -29 },
  { 1860, 21, 29, 22, 0, -29 },
  { 1937, 19, 29, 17, 0, -29 },
  { 2006, 19, 29, 16, 0, -29 },
  { 2075, 21, 29, 23, 2, -29 },
  { 2152, 24, 29, 23, 0, -29 },
  { 2239, 17, 29, 13, -2, -29 },
  { 2301, 17, 37, 10, -6, -29 },
  { 2380, 23, 29, 19, 0, -29 },
  { 2464, 14, 29, 16, 0, -29 },
  { 2515, 30, 29, 29, 0, -29 },
  { 2624, 25, 29, 24, 0, -29 },
  { 2715, 21, 29, 23, 2, -29 },
  { 2792, 20, 29, 19, 0, -29 },
  { 2865, 21, 36, 23, 2, -29 },
  { 2960, 20, 29, 20, 0, -29 },
  { 3033, 19, 29, 17, 0, -29 },
  { 3102, 17, 29, 17, 3, -29 },
  { 3164, 21, 29, 22, 2, -29 },
  { 3241, 19, 29, 19, 4, -29 },
  { 3310, 30, 29, 30, 3, -29 },
  { 3419, 23, 29, 18, -2, -29 },
  { 3503, 17, 29, 18, 4, -29 },
  { 3565, 20, 29, 17, -1, -29 },
  { 3638, 16, 35, 12, -1, -29 },
  { 3708, 8, 29, 15, 4, -29 },
  { 3737, 16, 35, 12, -3, -29 },
  { 3807, 18, 17, 18, 0, -29 },
  { 3846, 15, 3, 14, -4, 3 },
  { 3852, 7, 7, 12, 6, -31 },
  { 3859, 18, 22, 20, 1, -22 },
  { 3909, 18, 30, 19, 0, -30 },
  { 3977, 15, 22, 15, 1, -22 },
  { 4019, 20, 30, 20, 1, -30 },
  { 4094, 16, 22, 18, 1, -22 },
  { 4138, 21, 41, 12, -5, -31 },
  { 4246, 19, 32, 20, 0, -22 },
  { 4322, 18, 30, 19, 0, -30 },
  { 4390, 11, 30, 9, 0, -30 },
  { 4432, 16, 40, 9, -5, -30 },
  { 4512, 20, 30, 18, 0, -30 },
  { 4587, 11, 30, 9, 0, -30 },
  { 4629, 28, 22, 29, 0, -22 },
  { 4706, 18, 22, 19, 0, -22 },
  { 4756, 17, 22, 19, 1, -22 },
  { 4803, 20, 31, 19, -2, -22 },
  { 4881, 18, 32, 20, 1, -22 },
  { 4953, 15, 22, 13, 0, -22 },
  { 4995, 15, 22, 15, 0, -22 },
  { 5037, 11, 26, 12, 2, -26 },
  { 5073, 18, 22, 19, 1, -22 },
  { 5123, 17, 22, 16, 2, -22 },
  { 5170, 26, 22, 26, 2, -22 },
  { 5242, 21, 22, 17, -2, -22 },
  { 5300, 22, 32, 17, -3, -22 },
  { 5388, 16, 22, 14, -1, -22 },
  { 5432, 16, 35, 14, 0, -29 },
  { 5502, 3, 40, 17, 7, -31 },
  { 5517, 15, 35, 14, -2, -29 },
  { 5583, 17, 6, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC40PT7B_H_
