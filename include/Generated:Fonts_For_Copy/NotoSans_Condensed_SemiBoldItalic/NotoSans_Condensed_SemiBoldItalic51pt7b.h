#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x00, 0x30, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x8F,
  0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78,
  0x3C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x07, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x10, 0xF0,
  0x78, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFB, 0x7C, 0x07, 0xE7, 0x0C, 0x07, 0xE7, 0x00,
  0x07, 0xC6, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xEE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1B, 0xF0, 0x00, 0x3B, 0xF8, 0x00, 0x39, 0xF8, 0x00, 0x31, 0xF8,
  0x00, 0x31, 0xF8, 0x40, 0x71, 0xF0, 0x70, 0x73, 0xF0, 0x7C, 0x6F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x08, 0x07, 0xF8,
  0x00, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x1F, 0xFC, 0x01, 0xE0, 0x1F, 0x3C,
  0x03, 0xE0, 0x3E, 0x3C, 0x07, 0xC0, 0x3C, 0x3E, 0x07, 0x80, 0x7C, 0x3E,
  0x0F, 0x80, 0x7C, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x1F, 0x00, 0xF8, 0x3C,
  0x3E, 0x00, 0xF8, 0x3C, 0x3C, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF0, 0x7C,
  0x78, 0x00, 0xF0, 0x78, 0xF8, 0x00, 0xF0, 0xF9, 0xF1, 0xFC, 0xF0, 0xF9,
  0xE3, 0xFE, 0xF1, 0xF3, 0xE7, 0xFE, 0xF9, 0xF3, 0xCF, 0xFF, 0xFF, 0xE7,
  0xCF, 0x9F, 0x7F, 0xC7, 0x9F, 0x1F, 0x7F, 0x8F, 0x1E, 0x0F, 0x1E, 0x1F,
  0x1E, 0x1F, 0x00, 0x1E, 0x3E, 0x1F, 0x00, 0x3E, 0x3C, 0x1F, 0x00, 0x3C,
  0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x1E, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0xF0,
  0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x3E, 0x01, 0xE0, 0x7C, 0x3C, 0x03, 0xE0,
  0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x78, 0x07, 0x80, 0x3F, 0xF8, 0x0F, 0x80,
  0x3F, 0xF0, 0x0F, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x83, 0xF0, 0xFF, 0xF8, 0x7E, 0x3F, 0xBF, 0x0F,
  0x8F, 0xE7, 0xE3, 0xF1, 0xF8, 0x7E, 0x7C, 0x7E, 0x0F, 0xDF, 0x8F, 0xC0,
  0xFF, 0xE1, 0xF0, 0x1F, 0xFC, 0x7E, 0x01, 0xFF, 0x0F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x3F, 0xE0, 0x7F, 0xBF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x3F, 0x80,
  0xFF, 0x83, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x20, 0x78, 0x03, 0x87, 0x80, 0x7E,
  0x78, 0x07, 0xFF, 0x8F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xBC, 0x03, 0xFB, 0xE0,
  0x3F, 0x1F, 0x01, 0xE1, 0xF0, 0x0C, 0x1F, 0x80, 0x40, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x3E, 0x7E,
  0x7F, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x1F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0x7C, 0x7C, 0xFC,
  0x38, 0xFC, 0x30, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xE0,
  0x7F, 0x00, 0xC0, 0x3F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E, 0x3F,
  0xC0, 0x60, 0x1F, 0x80, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x20, 0x03, 0xF8,
  0x60, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF1, 0xF8,
  0x03, 0xE1, 0xF8, 0x03, 0xC1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0,
  0x0F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x80, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x06, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x80, 0x0F, 0xE0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x20, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE3, 0xF8, 0x0F, 0xBF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xC1, 0xF8, 0xFE, 0x03,
  0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x0F, 0xE3, 0xF0,
  0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x87, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xF7, 0xC0, 0xFF, 0xBF, 0x00, 0xF8, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x07, 0xC0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00,
  0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0x87, 0xF1, 0x80, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07,
  0x83, 0xE0, 0x3F, 0x83, 0xE1, 0xE0, 0x7F, 0xF0, 0xF1, 0xE0, 0x7F, 0xF8,
  0x78, 0xF0, 0x7F, 0xFC, 0x3C, 0xF0, 0x7C, 0x3C, 0x1E, 0x78, 0x3C, 0x1E,
  0x0F, 0x7C, 0x3C, 0x1F, 0x07, 0xBC, 0x1E, 0x0F, 0x87, 0xDE, 0x1F, 0x07,
  0x83, 0xDF, 0x0F, 0x03, 0xC1, 0xEF, 0x07, 0x83, 0xE0, 0xF7, 0x87, 0xC1,
  0xF0, 0x7B, 0xC3, 0xC0, 0xF0, 0x79, 0xE1, 0xE0, 0x78, 0x3C, 0xF0, 0xF0,
  0x7C, 0x3C, 0x78, 0x78, 0x3E, 0x1E, 0x3C, 0x3C, 0x3F, 0x1E, 0x1E, 0x1F,
  0x3F, 0x9F, 0x0F, 0x0F, 0xFF, 0xFF, 0x07, 0x83, 0xFC, 0xFF, 0x03, 0xC0,
  0xFC, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01,
  0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xF8, 0xFF, 0xC0, 0x7E, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81,
  0xF8, 0x1F, 0xC0, 0x7E, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x1F, 0xF0, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xE0, 0x3F, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF9, 0xF0, 0x0F, 0xF0, 0x08,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x01, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x7E, 0x07,
  0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0xC7, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x40,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0xFC,
  0x03, 0xFC, 0x01, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xE0, 0x3F,
  0xF8, 0x7E, 0x03, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0xFE, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0,
  0x7F, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x05, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xDE, 0x00,
  0x7F, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xFF, 0x80,
  0x7E, 0xF8, 0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0x1F, 0x7E, 0x01, 0xF3, 0xE0,
  0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0xFB, 0xF0, 0x07, 0xCF, 0x83, 0xE7, 0xE0,
  0x1F, 0x9F, 0x07, 0xCF, 0xC0, 0x3F, 0x3E, 0x1F, 0x1F, 0x80, 0x7C, 0x7C,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0xF8, 0xFC, 0x01, 0xF1, 0xF1, 0xF1, 0xF8,
  0x07, 0xE3, 0xE7, 0xC3, 0xF0, 0x0F, 0xC7, 0xCF, 0x87, 0xC0, 0x1F, 0x0F,
  0x9F, 0x0F, 0x80, 0x3E, 0x1F, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0xF8, 0x7E,
  0x01, 0xF8, 0x7F, 0xE0, 0xFC, 0x03, 0xE0, 0xFF, 0xC1, 0xF0, 0x07, 0xC0,
  0xFF, 0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x3E, 0x01, 0xFF, 0x00,
  0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00,
  0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xEF, 0x80,
  0xFC, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0x07, 0xEF, 0xC0,
  0xF8, 0x07, 0xC7, 0xC1, 0xF8, 0x07, 0xC7, 0xC1, 0xF8, 0x07, 0xC7, 0xC1,
  0xF0, 0x07, 0xC7, 0xE1, 0xF0, 0x0F, 0xC7, 0xE3, 0xF0, 0x0F, 0xC3, 0xE3,
  0xF0, 0x0F, 0x83, 0xE3, 0xF0, 0x0F, 0x83, 0xE3, 0xE0, 0x1F, 0x83, 0xF3,
  0xE0, 0x1F, 0x81, 0xF3, 0xE0, 0x1F, 0x01, 0xF7, 0xE0, 0x1F, 0x01, 0xF7,
  0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xFF,
  0xC0, 0x3E, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0xFF,
  0x80, 0x7E, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x7F,
  0x80, 0x7C, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00,
  0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E,
  0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00,
  0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xC3, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xF8, 0x0C, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xC0, 0x0F, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFD,
  0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7B,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xC0,
  0x1F, 0x9F, 0x00, 0x7F, 0x00, 0x7E, 0x7C, 0x01, 0xFC, 0x03, 0xF1, 0xF0,
  0x0F, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0xC0, 0x3E, 0x1F, 0x00, 0xFF, 0x01,
  0xF8, 0x7C, 0x07, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0xF0, 0x3F, 0x07, 0xC0,
  0xFF, 0xC0, 0xFC, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7C, 0x1F, 0x7C, 0x1F,
  0x81, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0xC1, 0xF7, 0xC3, 0xF0, 0x3F, 0x0F,
  0x9F, 0x0F, 0xC0, 0xFC, 0x3E, 0x7C, 0x3E, 0x03, 0xF1, 0xF1, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC7, 0xC7, 0xC0, 0x3F, 0x1F, 0x1F, 0x3F, 0x00, 0xFC, 0xF8,
  0x7C, 0xFC, 0x03, 0xF3, 0xE1, 0xF3, 0xE0, 0x0F, 0xDF, 0x07, 0xDF, 0x80,
  0x3F, 0x7C, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x81,
  0xEF, 0xC0, 0x0F, 0xFE, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xC0, 0xFC,
  0x1F, 0x07, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x3C,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x00, 0x7E, 0x1F,
  0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xBE, 0x07, 0xFF, 0xBE, 0x07, 0xFF, 0xFE,
  0x0F, 0xE1, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0,
  0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x1F, 0xE0, 0x7F, 0x7F, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F, 0xC7, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF3, 0xF0,
  0x03, 0xE7, 0xF8, 0x03, 0xEF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x03, 0xF0, 0x7F, 0x87, 0xF0, 0x7F, 0xCF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7D, 0xFF, 0xC0, 0xF9, 0xFF, 0x80, 0xF8, 0xFE, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFE, 0x04, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x02, 0x07, 0xFB, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x3E, 0x00, 0xFF, 0xEF, 0x80, 0x7F,
  0xFB, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0x83, 0xF8, 0x07, 0xF3, 0xFE, 0x01, 0xFF, 0xEF, 0x80, 0x3F, 0xFB,
  0xC0, 0x0F, 0xFC, 0xF0, 0x01, 0xFC, 0x7C, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x3F,
  0x87, 0xE0, 0xFC, 0x3F, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF9, 0xF8,
  0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x02, 0x0F,
  0xE0, 0x70, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87,
  0xC0, 0x1F, 0xF1, 0xF0, 0x0F, 0xFE, 0xF8, 0x07, 0xFF, 0xBE, 0x01, 0xFF,
  0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x7F, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0x7C, 0x00, 0xFF, 0x9F,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x20, 0x03, 0xF0, 0x0E,
  0x01, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x3E, 0x7F, 0xC0, 0x7D, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F,
  0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF1, 0xF8, 0x01,
  0xF9, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFB, 0xE0, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03,
  0xE3, 0xF0, 0x1F, 0x80, 0x78, 0xFF, 0x0F, 0xF8, 0x0F, 0x3F, 0xF3, 0xFF,
  0x03, 0xEF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF,
  0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x0F, 0xC0,
  0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x1F, 0x87,
  0xC0, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF8, 0x1F,
  0x87, 0xE0, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x01, 0xF8,
  0x0F, 0x87, 0xE0, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0x3E, 0x1F,
  0x80, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xC3, 0xF0, 0x07, 0x8F, 0xF8, 0x0F, 0x3F, 0xF0, 0x3E,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x0F, 0xC1, 0xFC, 0x1F, 0x87, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x3F, 0x87, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x3F, 0x80, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xF9, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0x7C, 0x07, 0xF1, 0xF8, 0x1F, 0x87,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x78,
  0xFF, 0x00, 0x3C, 0xFF, 0xC0, 0x3E, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x03, 0xF8, 0x0F, 0x81,
  0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xBF, 0xF8, 0x07, 0xCF, 0xF8, 0x07, 0xE7, 0xF0, 0x03, 0xF0,
  0x40, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x1F, 0x00, 0xFF, 0x1F, 0x03, 0xFF, 0xBE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0xBF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F, 0xCF, 0xC0,
  0x02, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x3F, 0x83, 0xEF, 0xF0, 0x7D, 0xFC,
  0x0F, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x81, 0x87, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x30,
  0x1F, 0xC7, 0xCF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF,
  0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC8,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x30, 0x00, 0x0F, 0xC0,
  0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0xC3,
  0xFC, 0x3F, 0xBF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xBE, 0x07, 0xFC, 0xF8,
  0x0F, 0xE3, 0xE0, 0x04, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F,
  0x1F, 0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3E, 0xFC, 0x0F, 0xE0, 0x7E,
  0xFC, 0x1F, 0xE0, 0x7C, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x3F, 0xE0, 0xFC,
  0xFC, 0x3D, 0xE0, 0xF8, 0xF8, 0x3D, 0xE1, 0xF8, 0xF8, 0x7D, 0xE1, 0xF0,
  0xF8, 0x7B, 0xE3, 0xF0, 0xF8, 0xFB, 0xE3, 0xE0, 0xF8, 0xFB, 0xE3, 0xE0,
  0xF8, 0xF3, 0xE7, 0xE0, 0xF9, 0xF3, 0xE7, 0xC0, 0xF9, 0xE3, 0xEF, 0xC0,
  0xFB, 0xE3, 0xEF, 0x80, 0xFB, 0xE3, 0xEF, 0x80, 0xFB, 0xC3, 0xFF, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xC1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xE7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF1, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x04, 0xFF,
  0x80, 0x37, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x01, 0xFF, 0x20, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 14, 37, 13, 0, -36 },
  { 66, 17, 13, 20, 5, -36 },
  { 94, 27, 36, 26, 0, -36 },
  { 216, 24, 42, 23, 0, -39 },
  { 342, 32, 37, 37, 3, -37 },
  { 490, 27, 38, 28, 0, -37 },
  { 619, 8, 13, 12, 5, -36 },
  { 632, 17, 45, 14, 1, -37 },
  { 728, 17, 45, 14, -4, -37 },
  { 824, 20, 21, 22, 4, -39 },
  { 877, 22, 24, 25, 2, -30 },
  { 943, 11, 13, 12, -3, -6 },
  { 961, 13, 5, 15, 1, -16 },
  { 970, 8, 8, 12, 0, -7 },
  { 978, 26, 37, 19, -3, -37 },
  { 1099, 22, 38, 23, 1, -37 },
  { 1204, 16, 36, 23, 5, -36 },
  { 1276, 24, 37, 23, -1, -37 },
  { 1387, 23, 38, 23, 0, -37 },
  { 1497, 24, 37, 23, -1, -37 },
  { 1608, 24, 37, 23, 0, -36 },
  { 1719, 22, 38, 23, 2, -37 },
  { 1824, 24, 36, 23, 2, -36 },
  { 1932, 24, 38, 23, 0, -37 },
  { 2046, 22, 38, 23, 1, -37 },
  { 2151, 12, 29, 12, 0, -28 },
  { 2195, 15, 35, 12, -3, -28 },
  { 2261, 22, 25, 25, 2, -31 },
  { 2330, 22, 15, 25, 2, -25 },
  { 2372, 22, 25, 25, 2, -31 },
  { 2441, 18, 38, 18, 2, -37 },
  { 2527, 33, 41, 35, 2, -37 },
  { 2697, 25, 37, 25, -3, -37 },
  { 2813, 26, 36, 26, 0, -36 },
  { 2930, 25, 38, 24, 2, -37 },
  { 3049, 27, 36, 28, 0, -36 },
  { 3171, 24, 36, 22, 0, -36 },
  { 3279, 24, 36, 21, 0, -36 },
  { 3387, 28, 38, 29, 2, -37 },
  { 3520, 30, 36, 29, 0, -36 },
  { 3655, 22, 36, 16, -2, -36 },
  { 3754, 22, 46, 13, -8, -36 },
  { 3881, 29, 36, 25, 0, -36 },
  { 4012, 18, 36, 21, 0, -36 },
  { 4093, 39, 36, 37, 0, -36 },
  { 4269, 32, 36, 31, 0, -36 },
  { 4413, 27, 38, 30, 2, -37 },
  { 4542, 26, 36, 25, 0, -36 },
  { 4659, 27, 46, 30, 2, -37 },
  { 4815, 25, 36, 25, 0, -36 },
  { 4928, 24, 38, 22, 0, -37 },
  { 5042, 21, 36, 21, 4, -36 },
  { 5137, 28, 37, 28, 2, -36 },
  { 5267, 24, 36, 25, 5, -36 },
  { 5375, 38, 36, 38, 4, -36 },
  { 5546, 30, 36, 24, -3, -36 },
  { 5681, 22, 36, 23, 5, -36 },
  { 5780, 26, 36, 21, -2, -36 },
  { 5897, 20, 45, 15, -1, -37 },
  { 6010, 10, 37, 19, 5, -37 },
  { 6057, 20, 45, 15, -4, -37 },
  { 6170, 23, 21, 24, 0, -36 },
  { 6231, 18, 4, 17, -5, 4 },
  { 6240, 9, 8, 15, 7, -39 },
  { 6249, 24, 29, 25, 1, -28 },
  { 6336, 24, 40, 25, 0, -39 },
  { 6456, 20, 29, 20, 1, -28 },
  { 6529, 26, 40, 25, 1, -39 },
  { 6659, 21, 29, 23, 1, -28 },
  { 6736, 27, 51, 15, -6, -39 },
  { 6909, 26, 40, 25, -1, -28 },
  { 7039, 23, 39, 25, 0, -39 },
  { 7152, 14, 38, 12, 0, -38 },
  { 7219, 20, 50, 12, -6, -38 },
  { 7344, 25, 39, 23, 0, -39 },
  { 7466, 14, 39, 12, 0, -39 },
  { 7535, 35, 28, 37, 0, -28 },
  { 7658, 23, 28, 25, 0, -28 },
  { 7739, 22, 29, 24, 1, -28 },
  { 7819, 25, 40, 25, -2, -28 },
  { 7944, 24, 40, 25, 1, -28 },
  { 8064, 19, 28, 17, 0, -28 },
  { 8131, 19, 29, 19, 0, -28 },
  { 8200, 15, 35, 16, 2, -34 },
  { 8266, 22, 29, 25, 2, -28 },
  { 8346, 21, 28, 21, 3, -28 },
  { 8420, 32, 28, 33, 3, -28 },
  { 8532, 26, 28, 22, -2, -28 },
  { 8623, 28, 40, 21, -4, -28 },
  { 8763, 22, 28, 18, -2, -28 },
  { 8840, 20, 44, 17, 1, -36 },
  { 8950, 5, 51, 22, 8, -39 },
  { 8982, 20, 44, 17, -3, -36 },
  { 9092, 22, 8, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC51PT7B_H_
