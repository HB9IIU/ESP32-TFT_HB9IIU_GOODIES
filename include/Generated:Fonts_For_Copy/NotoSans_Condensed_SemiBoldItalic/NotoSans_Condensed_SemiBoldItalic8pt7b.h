#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0xA0, 0xF0, 0x35, 0x76, 0xFA, 0x25, 0x42, 0xEC, 0x6D, 0xAE,
  0xF3, 0xAC, 0x25, 0x67, 0xBF, 0xC0, 0x29, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0x5F, 0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x44, 0x88, 0x25, 0x9A,
  0xAE, 0x75, 0xA0, 0x65, 0x22, 0x4E, 0x61, 0x26, 0x2E, 0x12, 0x6A, 0xE2,
  0x74, 0x42, 0x2E, 0x34, 0x6A, 0xAE, 0x71, 0x22, 0x4C, 0x65, 0x66, 0xAE,
  0x65, 0x96, 0x2C, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0x64,
  0xA1, 0x00, 0x3A, 0x6F, 0xBF, 0xC1, 0xC0, 0x11, 0x33, 0x5D, 0x75, 0x56,
  0x9E, 0x34, 0x48, 0x86, 0x65, 0x55, 0x9E, 0x74, 0x46, 0x8E, 0x74, 0x46,
  0x88, 0x3A, 0x11, 0x69, 0x38, 0x4A, 0x94, 0xE9, 0x48, 0x69, 0x25, 0x80,
  0x24, 0x94, 0x94, 0x5A, 0x98, 0xCA, 0x50, 0x49, 0x29, 0xC0, 0x65, 0xB6,
  0xDE, 0xBA, 0xA0, 0x4B, 0x5A, 0xEB, 0x48, 0x32, 0x53, 0x29, 0x30, 0x65,
  0x56, 0x88, 0x32, 0x53, 0x29, 0x30, 0xC0, 0x65, 0x56, 0xAA, 0x74, 0x42,
  0x2E, 0xEA, 0x49, 0x00, 0x4A, 0x94, 0xA9, 0x30, 0xBA, 0xAC, 0xC8, 0xA6,
  0xAE, 0xBC, 0xB2, 0x80, 0x55, 0x66, 0xAA, 0xB7, 0x49, 0x00, 0x72, 0x24,
  0x8E, 0x69, 0x49, 0x30, 0xFC, 0x32, 0x22, 0x22, 0xC0, 0x26, 0x69, 0xE0,
  0xC0, 0x79, 0xAE, 0x44, 0x79, 0xAE, 0x72, 0x70, 0x11, 0x79, 0xAE, 0x7E,
  0x70, 0x32, 0x72, 0x44, 0x4C, 0x79, 0xAE, 0x2C, 0x44, 0x75, 0xAA, 0x45,
  0xA0, 0x20, 0x94, 0x94, 0x45, 0x64, 0xAA, 0x55, 0xA0, 0x7E, 0xAA, 0xAA,
  0x75, 0xAA, 0x69, 0xAE, 0x79, 0xAE, 0x88, 0x79, 0xAE, 0x22, 0x6A, 0x40,
  0xE8, 0xE0, 0x5D, 0x4C, 0x5A, 0xAE, 0xBA, 0xC4, 0xAE, 0xAD, 0x34, 0x74,
  0x4A, 0x59, 0x88, 0x44, 0x60, 0x6A, 0x60, 0x29, 0x64, 0xB0, 0xFF, 0x49,
  0x35, 0x20, 0xF0,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 5, 6, 6, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 2, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 3, 3, 4, 1, -6 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 2, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 4, 6, 3, 0, -6 },
  { 34, 4, 6, 4, 0, -6 },
  { 37, 2, 6, 4, 1, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 4, 4, 4, 0, -5 },
  { 68, 4, 2, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 5, 7, 6, 0, -6 },
  { 79, 4, 6, 4, -1, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 4, 0, -6 },
  { 91, 4, 6, 3, 0, -6 },
  { 94, 4, 6, 3, 0, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 3, 6, 3, 0, -6 },
  { 108, 3, 8, 2, -1, -6 },
  { 111, 5, 6, 4, 0, -6 },
  { 115, 3, 6, 3, 0, -6 },
  { 118, 6, 6, 6, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 5, 7, 5, 0, -6 },
  { 139, 4, 6, 4, 0, -6 },
  { 142, 4, 6, 3, 0, -6 },
  { 145, 3, 6, 3, 1, -6 },
  { 148, 5, 6, 4, 0, -6 },
  { 152, 4, 6, 4, 1, -6 },
  { 155, 6, 6, 6, 1, -6 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 3, 6, 4, 1, -6 },
  { 166, 4, 6, 3, 0, -6 },
  { 169, 3, 7, 2, 0, -6 },
  { 172, 1, 6, 3, 1, -6 },
  { 173, 4, 7, 2, -1, -6 },
  { 177, 4, 4, 4, 0, -6 },
  { 179, 3, 1, 3, -1, 0 },
  { 180, 2, 1, 2, 1, -6 },
  { 181, 4, 4, 4, 0, -4 },
  { 183, 4, 6, 4, 0, -6 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 4, 6, 4, 0, -6 },
  { 191, 3, 4, 4, 0, -4 },
  { 193, 4, 8, 2, -1, -6 },
  { 197, 4, 6, 4, 0, -4 },
  { 200, 4, 6, 4, 0, -6 },
  { 203, 2, 6, 2, 0, -6 },
  { 205, 3, 8, 2, -1, -6 },
  { 208, 4, 6, 4, 0, -6 },
  { 211, 2, 6, 2, 0, -6 },
  { 213, 6, 4, 6, 0, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -4 },
  { 223, 4, 6, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 3, 4, 3, 0, -4 },
  { 230, 3, 5, 2, 0, -5 },
  { 232, 4, 4, 4, 0, -4 },
  { 234, 4, 4, 3, 0, -4 },
  { 236, 6, 4, 5, 0, -4 },
  { 239, 4, 4, 3, 0, -4 },
  { 241, 5, 6, 3, -1, -4 },
  { 245, 3, 4, 3, 0, -4 },
  { 247, 3, 7, 3, 0, -6 },
  { 250, 1, 8, 3, 1, -6 },
  { 251, 3, 7, 3, 0, -6 },
  { 254, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC8PT7B_H_
