#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x00, 0xB8, 0x3B, 0xD5, 0xE6, 0x50, 0x27, 0x66, 0x3B,
  0x44, 0x25, 0xAA, 0xAF, 0x6C, 0xD4, 0xC0, 0x22, 0x94, 0xCA, 0xDB, 0xC0,
  0xC0, 0x29, 0x49, 0x30, 0x24, 0x92, 0x56, 0x5D, 0x50, 0x2F, 0x22, 0xC0,
  0xC0, 0x80, 0x12, 0x44, 0x88, 0x25, 0x5D, 0x9A, 0xE0, 0x79, 0x25, 0x00,
  0x25, 0x13, 0x24, 0xE0, 0x25, 0x16, 0x33, 0xE0, 0x33, 0x5A, 0xF2, 0x74,
  0x61, 0x3E, 0x12, 0x47, 0x99, 0x60, 0x78, 0x88, 0x44, 0x60, 0x25, 0x56,
  0xF9, 0xE0, 0x25, 0x55, 0x72, 0xE0, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x61,
  0xFF, 0xC3, 0x68, 0x27, 0x26, 0x40, 0xC0, 0x3D, 0x7A, 0xED, 0xAA, 0x07,
  0x00, 0x19, 0x4A, 0x74, 0xE4, 0x7A, 0x9C, 0xA9, 0x70, 0x13, 0x50, 0x8C,
  0x61, 0xC0, 0x7A, 0x52, 0xB9, 0x70, 0x74, 0x74, 0x8E, 0x74, 0x74, 0x88,
  0x13, 0x50, 0xBC, 0xE9, 0xC0, 0x6A, 0x5E, 0xA9, 0x48, 0x69, 0x25, 0x80,
  0x32, 0x22, 0x44, 0x48, 0x5A, 0x98, 0xCA, 0x48, 0x49, 0x29, 0xC0, 0x66,
  0xD9, 0xB3, 0xAB, 0x55, 0x80, 0x6D, 0xA6, 0x9A, 0x9A, 0x40, 0x13, 0x52,
  0x9C, 0xE9, 0xC0, 0x72, 0xD4, 0xC8, 0x40, 0x13, 0x52, 0x9C, 0xE9, 0xC4,
  0x10, 0x75, 0x56, 0xA9, 0x25, 0x46, 0x22, 0xE0, 0xE9, 0x49, 0x00, 0x4A,
  0x52, 0xA9, 0x38, 0x9A, 0xAC, 0xC8, 0xB6, 0xDD, 0xB6, 0xD2, 0x40, 0x2C,
  0xA1, 0x0C, 0x73, 0x60, 0xBA, 0xC8, 0x88, 0x72, 0x24, 0x8E, 0x69, 0x29,
  0x30, 0xAA, 0x50, 0x31, 0x22, 0x22, 0xC0, 0x25, 0xD0, 0xE0, 0xD0, 0x75,
  0x99, 0xE0, 0x44, 0x75, 0x59, 0xE0, 0x74, 0x88, 0x60, 0x08, 0x9C, 0xA9,
  0x4B, 0xC0, 0x75, 0xE8, 0x60, 0x19, 0x1C, 0x42, 0x21, 0x08, 0xC0, 0x75,
  0x99, 0xE2, 0xE0, 0x64, 0x75, 0x59, 0xA0, 0x45, 0x68, 0x20, 0x92, 0x92,
  0xC0, 0x44, 0x56, 0x6A, 0xA0, 0x69, 0x25, 0x20, 0x7D, 0x55, 0x65, 0xAC,
  0x75, 0x59, 0xA0, 0x75, 0x99, 0x60, 0x75, 0x59, 0xE8, 0x80, 0x75, 0x99,
  0xE2, 0x20, 0x69, 0x48, 0x69, 0x9E, 0x5D, 0x29, 0x80, 0x55, 0x59, 0xE0,
  0xB7, 0x68, 0xAF, 0x7D, 0x6A, 0x00, 0x56, 0x66, 0xA0, 0x29, 0x4C, 0x62,
  0x13, 0x00, 0x65, 0x6E, 0x32, 0x48, 0x44, 0x40, 0xFF, 0x80, 0x32, 0x21,
  0x22, 0xC0, 0x79,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 5, 6, 5, 0, -6 },
  { 9, 4, 8, 4, 0, -7 },
  { 13, 6, 7, 6, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 2, 2, 1, -6 },
  { 25, 3, 7, 3, 0, -6 },
  { 28, 3, 8, 3, -1, -7 },
  { 31, 3, 4, 4, 1, -7 },
  { 33, 4, 4, 4, 0, -5 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 2, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 0, -1 },
  { 38, 4, 6, 3, 0, -6 },
  { 41, 4, 7, 4, 0, -7 },
  { 45, 3, 6, 4, 1, -6 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 5, 6, 4, 0, -6 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 4, 7, 4, 0, -7 },
  { 78, 2, 5, 2, 0, -5 },
  { 80, 2, 6, 2, 0, -5 },
  { 82, 4, 4, 4, 0, -5 },
  { 84, 4, 2, 4, 0, -4 },
  { 85, 4, 4, 4, 0, -5 },
  { 87, 4, 7, 3, 0, -7 },
  { 91, 6, 7, 6, 0, -6 },
  { 97, 5, 6, 4, -1, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 7, 4, 0, -7 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 4, 6, 4, 0, -6 },
  { 117, 4, 6, 4, 0, -6 },
  { 120, 5, 7, 5, 0, -7 },
  { 125, 5, 6, 5, 0, -6 },
  { 129, 3, 6, 3, 0, -6 },
  { 132, 4, 8, 2, -1, -6 },
  { 136, 5, 6, 4, 0, -6 },
  { 140, 3, 6, 4, 0, -6 },
  { 143, 7, 6, 7, 0, -6 },
  { 149, 6, 6, 5, 0, -6 },
  { 154, 5, 7, 5, 0, -7 },
  { 159, 5, 6, 4, 0, -6 },
  { 163, 5, 9, 5, 0, -7 },
  { 169, 4, 6, 4, 0, -6 },
  { 172, 4, 7, 4, 0, -7 },
  { 176, 3, 6, 4, 1, -6 },
  { 179, 5, 6, 5, 0, -6 },
  { 183, 4, 6, 4, 1, -6 },
  { 186, 6, 6, 7, 1, -6 },
  { 191, 6, 6, 4, -1, -6 },
  { 196, 4, 6, 4, 1, -6 },
  { 199, 4, 6, 4, 0, -6 },
  { 202, 3, 7, 3, 0, -6 },
  { 205, 2, 6, 3, 1, -6 },
  { 207, 4, 7, 3, -1, -6 },
  { 211, 4, 3, 4, 0, -6 },
  { 213, 3, 1, 3, -1, 1 },
  { 214, 2, 2, 3, 1, -7 },
  { 215, 4, 5, 4, 0, -5 },
  { 218, 4, 7, 4, 0, -7 },
  { 222, 4, 5, 3, 0, -5 },
  { 225, 5, 7, 4, 0, -7 },
  { 230, 4, 5, 4, 0, -5 },
  { 233, 5, 9, 3, -1, -7 },
  { 239, 4, 7, 4, 0, -5 },
  { 243, 4, 7, 4, 0, -7 },
  { 247, 2, 7, 2, 0, -7 },
  { 249, 3, 9, 2, -1, -7 },
  { 253, 4, 7, 4, 0, -7 },
  { 257, 3, 7, 2, 0, -7 },
  { 260, 6, 5, 7, 0, -5 },
  { 264, 4, 5, 4, 0, -5 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 4, 7, 4, 0, -5 },
  { 274, 4, 7, 4, 0, -5 },
  { 278, 3, 5, 3, 0, -5 },
  { 280, 3, 5, 3, 0, -5 },
  { 282, 3, 6, 3, 0, -6 },
  { 285, 4, 5, 4, 0, -5 },
  { 288, 3, 5, 4, 1, -5 },
  { 290, 5, 5, 6, 1, -5 },
  { 294, 4, 5, 4, 0, -5 },
  { 297, 5, 7, 4, -1, -5 },
  { 302, 3, 5, 3, 0, -5 },
  { 304, 4, 7, 3, 0, -6 },
  { 308, 1, 9, 4, 1, -7 },
  { 310, 4, 7, 3, -1, -6 },
  { 314, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC9PT7B_H_
