#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC67PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE, 0x7F, 0x87, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF8,
  0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFE, 0x71, 0xF0, 0x0F, 0xF1, 0xC1, 0x80, 0x3F, 0x8F, 0x02, 0x00,
  0xFE, 0x38, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x1F, 0xC3, 0x80, 0x00, 0x7F,
  0x8E, 0x00, 0x01, 0xFE, 0x78, 0x00, 0x07, 0xFD, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0x7F, 0xC0, 0x00, 0x1C, 0xFF, 0x00, 0x00,
  0xE1, 0xFC, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x0E, 0x1F, 0xC0, 0x00, 0x38,
  0x7F, 0x0C, 0x01, 0xE3, 0xFC, 0x38, 0x07, 0x0F, 0xE0, 0xF8, 0x1C, 0x7F,
  0x83, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x8F, 0xC1, 0xFE, 0x3E, 0x07, 0xE3, 0xF0,
  0xFF, 0xCF, 0x83, 0xF1, 0xF8, 0x7F, 0xFB, 0xF0, 0xFC, 0x7E, 0x3F, 0xFE,
  0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xBF, 0xFF, 0x9F, 0x8F, 0xE7, 0xFF, 0xFF,
  0xC7, 0xE3, 0xF0, 0xFD, 0xFF, 0xE3, 0xF1, 0xF8, 0x3F, 0x3F, 0xF0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xF8, 0x7E, 0x1F, 0x03, 0xF0, 0x20, 0x3F, 0x0F, 0xC0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0xFC,
  0x00, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x0F,
  0xFB, 0xFC, 0x1F, 0xE0, 0xFF, 0x1F, 0xE1, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0xC0, 0xFF, 0x7F, 0x87, 0xF8, 0x0F,
  0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x7F,
  0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xF8, 0x07,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF1, 0xFE,
  0x00, 0xFF, 0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x01, 0x00, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0xF8, 0x3E, 0x00,
  0x7F, 0x1F, 0x00, 0x3F, 0xEF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFE,
  0x1F, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFC,
  0xFC, 0x03, 0xFC, 0x7E, 0x03, 0xFE, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1E,
  0x07, 0xF0, 0x06, 0x03, 0xF8, 0x01, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0x1F, 0x8F, 0xF7, 0xFD, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF9, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x07,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80,
  0x0F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xBF,
  0xCF, 0xF9, 0xFC, 0x3F, 0x0F, 0xE0, 0xF0, 0xFF, 0x07, 0x07, 0xF8, 0x10,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x78,
  0x03, 0xFE, 0x00, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x80, 0x00, 0xFF, 0x81, 0x80, 0x03, 0xFF, 0x03, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x3F, 0x0F,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x0F,
  0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x40, 0x00, 0x7F, 0xC0, 0xE0, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x06, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x0F, 0x00, 0x07, 0xF1, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0x00, 0xFF, 0x7F,
  0xFE, 0x03, 0xFB, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xC7, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0,
  0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x7F,
  0xC3, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFE, 0xFE, 0x01, 0xFF,
  0xEF, 0xF0, 0x07, 0xFC, 0x7F, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x30, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x0F, 0x83, 0xFE, 0x07, 0x00, 0x7F, 0x02, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x7F, 0xF0, 0x3F, 0x07,
  0xE0, 0x1F, 0xFF, 0xC3, 0xF0, 0x7E, 0x03, 0xFF, 0xF8, 0x3F, 0x0F, 0xC0,
  0x7F, 0xFF, 0x83, 0xF0, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0x1F, 0x81, 0xFC,
  0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xF3, 0xF0, 0x3E, 0x03, 0xF0, 0x3F, 0x3E, 0x07, 0xE0, 0x3F, 0x03,
  0xE3, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x7E, 0x0F, 0xC0, 0x7E, 0x03, 0xE7,
  0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xC7, 0xC0,
  0xF8, 0x07, 0xC0, 0x7C, 0x7C, 0x1F, 0x80, 0xFC, 0x07, 0xCF, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0x1F,
  0x81, 0xF8, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0x83,
  0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1, 0xFC, 0xFF, 0xCF, 0xE0,
  0xFC, 0x0F, 0xFF, 0x7F, 0xFC, 0x0F, 0xC0, 0xFF, 0xE7, 0xFF, 0x80, 0xFC,
  0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x00, 0x7C, 0x00,
  0xC0, 0x02, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xF9, 0xF8,
  0x00, 0xFF, 0xC0, 0x1C, 0x00, 0xFF, 0xC0, 0x02, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0x0F, 0xFE, 0x0F, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x17, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8,
  0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0x18, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0xF8,
  0x7F, 0x80, 0x3F, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0xFF, 0x80, 0x3F,
  0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x1F,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x07, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xBF, 0xC0, 0x0F,
  0xEF, 0xE0, 0x0F, 0xCF, 0xF0, 0x07, 0xF9, 0xF8, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0x7E, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0xFE, 0x7F, 0x80,
  0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0xE0, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x83, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F,
  0xF0, 0x03, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x8F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF9, 0xFC,
  0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xDF,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFF,
  0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F,
  0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x1F,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xF8,
  0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x07, 0xE7, 0xF0, 0x0F, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF8, 0x03, 0xF9,
  0xFC, 0x03, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x87, 0xF0, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x0F, 0xE1, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xDF,
  0xC0, 0x0F, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF0, 0x07, 0xF7, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x07, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF1, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x8F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x3C, 0x00, 0xFF, 0x80, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x40, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x7F, 0xC0, 0x7C, 0x01,
  0xFF, 0x80, 0x7F, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xC1, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFB, 0xF0, 0x1F, 0xE0, 0x7F,
  0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0x7E, 0x3F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x1F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0x87, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC1, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0xFC, 0x7F, 0x80,
  0x1F, 0xC7, 0xF0, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x3F, 0x3F, 0xC0,
  0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC0, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFC, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x7E, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0xFF, 0x01, 0xFB, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x7E, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC,
  0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x1F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xC0, 0x02, 0x00, 0x7F, 0xE1, 0xF8, 0x01, 0xFF, 0xE3, 0xF0, 0x07,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0xFE, 0x00, 0xFF,
  0xF9, 0xF8, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7F, 0x1F, 0xF0, 0x01, 0xFE, 0x7F, 0xF0, 0x03, 0xFD, 0xFF,
  0xF0, 0x07, 0xF7, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF,
  0xC0, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F,
  0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0x80, 0x7E, 0x7F, 0xFE,
  0x00, 0xFC, 0x7F, 0xF8, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xF8, 0x0C, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0x01, 0xFF,
  0x03, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0x7F, 0xF9, 0xFC,
  0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8,
  0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFD, 0xFC, 0x00,
  0x3F, 0xFE, 0x7E, 0x00, 0x07, 0xFF, 0x1F, 0x80, 0x00, 0xFF, 0x07, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xFC, 0x1F, 0xFC, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x08, 0x1F, 0xE0,
  0x06, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x60, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0E, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x40, 0x01, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0xF1, 0xF8, 0x00, 0x7F, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFD, 0xFC,
  0x00, 0x0F, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0C, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x80, 0x01, 0xFF, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x0F,
  0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x8F, 0xFC, 0x01, 0xFE, 0x7F, 0xF8, 0x07, 0xFB,
  0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x02, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xBF, 0xC0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0x7F, 0xFE,
  0x7F, 0xFE, 0x01, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0xC1, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFF, 0xC0, 0x0F, 0xC7, 0xFF, 0x80,
  0x7E, 0x3F, 0xFE, 0x01, 0xF9, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE1, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE1, 0xFF, 0x00, 0x01, 0xF8, 0xFF, 0xE0, 0x00, 0xFE, 0x7F,
  0xFC, 0x00, 0x3F, 0xBF, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xE0, 0x03, 0xFF,
  0xCF, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFB, 0xFF, 0xF8, 0x00, 0xFE, 0x7F, 0xFC,
  0x00, 0x3F, 0x9F, 0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x1C,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x02, 0x00, 0x7F,
  0xE1, 0xF8, 0x01, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF,
  0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0,
  0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFB, 0xF8, 0x00, 0xFF, 0xE7,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x0F, 0xE0, 0x0F, 0xCF, 0xF8, 0x07, 0xF3, 0xFE, 0x01, 0xFD, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xC3, 0xF0, 0x3F, 0xE0, 0x18, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x20, 0x01, 0xFE, 0x0F, 0x01,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x08, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x70, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x03,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF,
  0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDF, 0x80,
  0x7F, 0xFF, 0x7E, 0x01, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xC7, 0xE0, 0x07,
  0xFC, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x7F,
  0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF8, 0x03,
  0xFB, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0xE0, 0x3F, 0xCF, 0xE0, 0x3F, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x3F, 0x81, 0xFF, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7D, 0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xDF, 0x83, 0xF8, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x0F, 0xE1,
  0xF9, 0xF8, 0x7F, 0x03, 0xF8, 0x7C, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x1F,
  0x8F, 0xE0, 0x3F, 0x8F, 0xC7, 0xE3, 0xF8, 0x0F, 0xE7, 0xE1, 0xF9, 0xFC,
  0x03, 0xF9, 0xF8, 0x7E, 0x7F, 0x00, 0xFE, 0x7E, 0x1F, 0xBF, 0x80, 0x3F,
  0xBF, 0x07, 0xEF, 0xE0, 0x0F, 0xEF, 0xC1, 0xFB, 0xF8, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0x7F, 0x00, 0x3F, 0x7E, 0x07, 0xDF,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0C, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0D, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x11, 0xFF, 0x80, 0x01,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE8, 0x00, 0x0F, 0xF8, 0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 19, 49, 17, 0, -48 },
  { 118, 22, 17, 26, 7, -48 },
  { 165, 35, 48, 34, 1, -48 },
  { 375, 30, 55, 30, 1, -51 },
  { 582, 42, 50, 48, 4, -49 },
  { 845, 36, 50, 37, 0, -49 },
  { 1070, 10, 17, 15, 7, -48 },
  { 1092, 23, 59, 19, 1, -48 },
  { 1262, 22, 60, 19, -5, -49 },
  { 1427, 25, 27, 29, 6, -51 },
  { 1512, 28, 32, 33, 3, -40 },
  { 1624, 14, 17, 16, -3, -8 },
  { 1654, 17, 8, 19, 1, -22 },
  { 1671, 10, 10, 16, 0, -9 },
  { 1684, 33, 48, 25, -3, -48 },
  { 1882, 28, 50, 30, 2, -49 },
  { 2057, 21, 48, 31, 7, -48 },
  { 2183, 32, 49, 30, -2, -49 },
  { 2379, 31, 50, 30, 0, -49 },
  { 2573, 32, 48, 31, -1, -48 },
  { 2765, 31, 49, 30, 0, -48 },
  { 2955, 30, 50, 30, 2, -49 },
  { 3143, 32, 48, 30, 2, -48 },
  { 3335, 31, 50, 30, 0, -49 },
  { 3529, 29, 50, 30, 1, -49 },
  { 3711, 16, 38, 16, 0, -37 },
  { 3787, 20, 46, 16, -4, -37 },
  { 3902, 28, 32, 33, 3, -40 },
  { 4014, 28, 19, 33, 3, -33 },
  { 4081, 28, 32, 33, 3, -40 },
  { 4193, 25, 50, 24, 2, -49 },
  { 4350, 44, 54, 46, 2, -48 },
  { 4647, 33, 48, 33, -4, -48 },
  { 4845, 33, 48, 34, 1, -48 },
  { 5043, 33, 50, 32, 3, -49 },
  { 5250, 35, 48, 37, 1, -48 },
  { 5460, 31, 48, 29, 1, -48 },
  { 5646, 31, 48, 28, 1, -48 },
  { 5832, 36, 50, 38, 3, -49 },
  { 6057, 38, 48, 38, 1, -48 },
  { 6285, 29, 48, 21, -3, -48 },
  { 6459, 29, 62, 17, -10, -48 },
  { 6684, 38, 48, 33, 1, -48 },
  { 6912, 22, 48, 27, 1, -48 },
  { 7044, 50, 48, 49, 1, -48 },
  { 7344, 41, 48, 40, 1, -48 },
  { 7590, 35, 50, 39, 3, -49 },
  { 7809, 33, 48, 33, 1, -48 },
  { 8007, 35, 60, 39, 3, -49 },
  { 8270, 32, 48, 33, 1, -48 },
  { 8462, 32, 50, 29, -1, -49 },
  { 8662, 28, 48, 28, 5, -48 },
  { 8830, 36, 49, 37, 3, -48 },
  { 9051, 32, 48, 32, 6, -48 },
  { 9243, 49, 48, 50, 6, -48 },
  { 9537, 40, 48, 31, -4, -48 },
  { 9777, 30, 48, 30, 6, -48 },
  { 9957, 34, 48, 28, -2, -48 },
  { 10161, 26, 59, 20, -2, -48 },
  { 10353, 13, 48, 25, 7, -48 },
  { 10431, 27, 59, 20, -5, -48 },
  { 10631, 29, 29, 31, 1, -48 },
  { 10737, 24, 4, 23, -6, 6 },
  { 10749, 11, 10, 19, 10, -51 },
  { 10763, 31, 38, 33, 2, -37 },
  { 10911, 31, 52, 33, 0, -51 },
  { 11113, 25, 38, 26, 2, -37 },
  { 11232, 34, 52, 33, 2, -51 },
  { 11453, 27, 38, 30, 2, -37 },
  { 11582, 35, 67, 19, -8, -51 },
  { 11876, 34, 53, 33, -1, -37 },
  { 12102, 30, 51, 33, 0, -51 },
  { 12294, 18, 50, 16, 0, -50 },
  { 12407, 27, 66, 16, -9, -50 },
  { 12630, 33, 51, 30, 0, -51 },
  { 12841, 19, 51, 16, 0, -51 },
  { 12963, 46, 37, 48, 0, -37 },
  { 13176, 30, 37, 33, 0, -37 },
  { 13315, 28, 38, 32, 2, -37 },
  { 13448, 34, 53, 33, -3, -37 },
  { 13674, 31, 53, 33, 2, -37 },
  { 13880, 26, 37, 23, 0, -37 },
  { 14001, 26, 38, 25, 0, -37 },
  { 14125, 19, 45, 20, 3, -44 },
  { 14232, 30, 37, 32, 2, -36 },
  { 14371, 27, 36, 28, 4, -36 },
  { 14493, 42, 36, 43, 4, -36 },
  { 14682, 34, 36, 28, -3, -36 },
  { 14835, 36, 52, 28, -5, -36 },
  { 15069, 28, 36, 24, -2, -36 },
  { 15195, 26, 59, 23, 1, -48 },
  { 15387, 6, 66, 28, 11, -51 },
  { 15437, 26, 59, 23, -4, -48 },
  { 15629, 28, 11, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC67PT7B_H_
