#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x07, 0x83, 0xE0, 0xF8, 0x1C, 0x00, 0x79, 0xEF,
  0x3D, 0xC7, 0xF8, 0xFF, 0x1D, 0xE7, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0x70,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x03, 0x87, 0x00, 0x71, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00,
  0x70, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E,
  0x3C, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x3F, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x3C, 0x98, 0x1C, 0xC0, 0x1E, 0x60, 0x0F, 0x30, 0x07,
  0xD0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xDF, 0x00, 0x67, 0x80, 0x33, 0x84, 0x13, 0xC3, 0x9B,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x78, 0x3F, 0x80, 0xE0, 0xFF, 0x03,
  0x81, 0xCE, 0x0F, 0x07, 0x9C, 0x1C, 0x0E, 0x38, 0x70, 0x1C, 0x70, 0xE0,
  0x78, 0xE3, 0x80, 0xE1, 0xCF, 0x01, 0xC7, 0x9C, 0x03, 0x8E, 0x71, 0xE7,
  0x1C, 0xE7, 0xEE, 0x7B, 0x9F, 0xDF, 0xEF, 0x7B, 0xDF, 0x9C, 0xE3, 0x9E,
  0x73, 0xC7, 0x00, 0xE7, 0x1E, 0x03, 0x8E, 0x38, 0x0F, 0x1C, 0x70, 0x1C,
  0x78, 0xE0, 0x78, 0xE1, 0xC0, 0xE1, 0xC7, 0x03, 0x83, 0x8E, 0x0F, 0x07,
  0xF8, 0x1C, 0x07, 0xF0, 0x78, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x70, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC3, 0xC7, 0xFC, 0x79, 0xE7, 0x9E, 0x7C, 0xFB, 0xCF,
  0x0F, 0xF1, 0xE1, 0xFE, 0x78, 0x1F, 0x8F, 0x03, 0xE1, 0xF0, 0x7C, 0x3E,
  0x3F, 0xC3, 0xFF, 0xF8, 0x7F, 0xEF, 0x87, 0xF8, 0xF8, 0x7B, 0xDF, 0xEF,
  0x7B, 0xDC, 0xE7, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x3C, 0x10, 0xE0, 0x63,
  0x81, 0xEE, 0x1F, 0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x3E, 0x03, 0xFC, 0x1F,
  0x70, 0x79, 0xE0, 0xC3, 0xC1, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0,
  0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x3B, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C,
  0x1E, 0xF8, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E,
  0x1E, 0x3E, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x7C,
  0x1F, 0x8F, 0xE3, 0xFC, 0xFF, 0xBE, 0xF7, 0xBC, 0x47, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x70, 0x78, 0x10, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x60, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC4, 0x03, 0xE3, 0x87, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xDE, 0x03, 0xDE, 0x03, 0x9E, 0x07, 0x3C, 0x0F,
  0x3C, 0x0E, 0x3C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x78, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xE7, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC4, 0x03, 0xC3, 0xC7, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xF7, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x40, 0x3D, 0xF8, 0x7B,
  0xF8, 0x7F, 0xFC, 0x7E, 0x7C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0xF8, 0x79, 0xF0, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF9, 0xF0, 0xF0, 0xF8,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x01, 0xFF,
  0x80, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7C, 0xF8, 0x7C,
  0x3C, 0x3C, 0x1F, 0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0xC1, 0xE1,
  0xE1, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3E, 0x3F, 0x3F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xDE, 0x07, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0xC3, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0x06, 0x0F, 0x1F, 0x1F, 0x1F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x78, 0xF8, 0xF8, 0xF0, 0x01, 0xC0, 0xF0,
  0x3C, 0x1F, 0x03, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x07, 0xE0,
  0xFF, 0x8F, 0xFE, 0x3D, 0xF1, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x1F, 0x86, 0x1C, 0x3F, 0xC7, 0x38, 0x7F, 0xC7, 0x38,
  0xE3, 0x87, 0x70, 0xE3, 0x86, 0x71, 0xC3, 0x8E, 0x71, 0xC3, 0x8E, 0x63,
  0x87, 0x8E, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x1C, 0xE3, 0x8F, 0x1C, 0xE3,
  0x8F, 0x38, 0xE3, 0xFF, 0xF8, 0xE1, 0xF3, 0xF0, 0xE1, 0xE3, 0xC0, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0x78,
  0x03, 0xDE, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x78, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE1, 0xFF, 0xF8, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x79,
  0xE0, 0x1E, 0xF8, 0x07, 0xBC, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFF, 0x81, 0xE3, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x1F, 0x1E, 0x0F, 0x87, 0x8F, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xE0, 0xF8, 0x10, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF9, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x78, 0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7,
  0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1E,
  0x07, 0xC7, 0xC1, 0xF0, 0xF0, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x08, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x87, 0xF9, 0xE0, 0xFF, 0x3C, 0x1F, 0xE7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C,
  0x1F, 0x8F, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xC0,
  0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x78,
  0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x4F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x07,
  0x80, 0x78, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xE3, 0xC0, 0x0F,
  0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x00, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x7F, 0xF7, 0xFF, 0x7F,
  0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7B, 0x81, 0xFE, 0x0F, 0xF0,
  0x3B, 0xC1, 0xDE, 0x0F, 0x78, 0x7B, 0xC1, 0xEF, 0x0E, 0x78, 0x3D, 0xE3,
  0xDE, 0x07, 0x9C, 0x73, 0xC0, 0xE3, 0x9E, 0x78, 0x3C, 0x73, 0x8F, 0x07,
  0x8E, 0xF1, 0xE0, 0xF1, 0xDC, 0x78, 0x1E, 0x3F, 0x8F, 0x07, 0x87, 0xE1,
  0xE0, 0xF0, 0xFC, 0x3C, 0x1E, 0x1F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0x70,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x1F, 0x80, 0xF0,
  0x7E, 0x03, 0xC1, 0xF8, 0x0F, 0x07, 0xE0, 0x3C, 0x1F, 0xC1, 0xE0, 0xFF,
  0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3D, 0xC1, 0xC0, 0xE7, 0x8F,
  0x07, 0x9E, 0x3C, 0x1E, 0x78, 0xF0, 0x78, 0xE3, 0xC1, 0xE3, 0xCE, 0x0F,
  0x0F, 0x78, 0x3C, 0x3D, 0xE0, 0xF0, 0xF7, 0x83, 0xC1, 0xDE, 0x0F, 0x07,
  0xF0, 0x78, 0x1F, 0xC1, 0xE0, 0x7F, 0x07, 0x80, 0xFC, 0x1E, 0x03, 0xF0,
  0x70, 0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x1E, 0x7C, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80,
  0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01,
  0xF3, 0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x7C, 0x3F, 0x3F,
  0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x7C, 0x3E, 0x1E,
  0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0x8F, 0x80, 0xF1,
  0xE0, 0x1E, 0x7C, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E,
  0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x01, 0xF1, 0xF0, 0x7C, 0x3F,
  0x3F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0x87, 0xC1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8,
  0x78, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x78, 0x1E, 0x3E, 0x07, 0x80, 0x00, 0xFE,
  0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0x20, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x84, 0x07, 0xC3, 0xEF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x0F, 0x01, 0xE3, 0xE0, 0x7C,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x01, 0xF1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0xF8, 0x3F,
  0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF7, 0x80, 0xF3, 0xC0, 0xF9,
  0xE0, 0x78, 0xF0, 0x3C, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x1E, 0x07, 0x8F,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F,
  0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xFE, 0x03, 0xC0, 0x7B,
  0xC0, 0x78, 0x0F, 0x78, 0x1F, 0x03, 0xCF, 0x03, 0xE0, 0x79, 0xE0, 0x7C,
  0x0F, 0x3C, 0x1F, 0x83, 0xC7, 0x83, 0xF0, 0x78, 0xF0, 0xFE, 0x1E, 0x1E,
  0x1D, 0xC3, 0xC3, 0xC7, 0xB8, 0x78, 0x78, 0xF7, 0x1E, 0x0F, 0x1C, 0xE3,
  0xC1, 0xE7, 0x9C, 0xF0, 0x3C, 0xE3, 0x9E, 0x07, 0xBC, 0x73, 0xC0, 0xF7,
  0x8E, 0xF0, 0x1E, 0xE1, 0xDE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1,
  0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xE7, 0x80, 0x1E,
  0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0x83, 0xE0,
  0x78, 0x0F, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0xF8, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x39, 0xE0,
  0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38,
  0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0x87, 0x0E, 0x1E, 0x3C, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xBC, 0x07, 0xBC, 0x07, 0x1C, 0x0E, 0x1E,
  0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x07, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0x03, 0xC7, 0x83,
  0xF3, 0x83, 0xFF, 0xC3, 0xFF, 0xE3, 0xE3, 0xF1, 0xE0, 0xF1, 0xF0, 0x78,
  0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x83, 0xE3, 0xC1, 0xF1, 0xE1, 0xF0, 0xF9, 0xF8, 0x7F, 0xFC, 0x1F,
  0xDE, 0x07, 0xCE, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x0F, 0x7E, 0x07,
  0xFF, 0x83, 0xFF, 0xC3, 0xF1, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E,
  0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE7, 0xC1,
  0xE3, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7F, 0xF8, 0x7B, 0xF8, 0x3C,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x41, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x3C, 0x07, 0xEF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0xF8, 0xFC, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xE7, 0xE0, 0xFF, 0xF8, 0x1F, 0xDE, 0x03,
  0xE7, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xCF, 0x3E, 0x1C, 0xF0,
  0x77, 0x83, 0xDE, 0x0F, 0x79, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x31, 0xFF, 0xC3, 0xFF, 0x07,
  0xF8, 0x00, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0xFC, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0x1F, 0x87, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0F, 0x03, 0xC7, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F,
  0x87, 0x83, 0xE1, 0xE1, 0xF0, 0x7C, 0xFC, 0x1F, 0xFF, 0x03, 0xFB, 0xC0,
  0x7D, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x81,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x3C, 0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x8F, 0x1F,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0xF8, 0x3C, 0xF0, 0x78, 0x03, 0x81, 0xF0, 0x7C, 0x1E, 0x03, 0x00,
  0x00, 0x00, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3E, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x1E, 0x78, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC0,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x00, 0x0E, 0x3C,
  0x1E, 0x07, 0x3F, 0x3F, 0x83, 0xBF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xF8,
  0xF8, 0x78, 0xF8, 0x7C, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3,
  0xC1, 0xE1, 0xE3, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C,
  0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x07,
  0x80, 0x0E, 0x1C, 0x0E, 0x7E, 0x0E, 0xFF, 0x0F, 0xFF, 0x1F, 0x8F, 0x1F,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0xF8, 0x3C, 0xF0, 0x78, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xE3, 0xE3, 0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x1F, 0x78, 0x3C, 0xF9,
  0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0x8F, 0x00, 0x73, 0xF0,
  0x0E, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x3C, 0x0F, 0x87, 0xC1, 0xE0, 0xF8,
  0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03,
  0xFF, 0xC0, 0xF7, 0xF0, 0x1E, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x07, 0xE7, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0xF8,
  0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0x78, 0x3E, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x0E, 0x3C, 0x39, 0xE0, 0xEF, 0x83, 0xFE, 0x1F, 0xC8, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x87, 0xDE, 0x3E, 0x08, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x20, 0x78, 0xC3, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0,
  0x03, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xFE, 0x7F, 0xDF, 0xFB, 0xFE, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x0F, 0x81, 0xFE, 0x1F, 0xC3, 0xF8, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xF8, 0x7F, 0x70, 0x3E,
  0x70, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E,
  0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE0, 0xE7, 0x81, 0xCF, 0x03, 0x9C, 0x07,
  0x78, 0x0E, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x7B, 0xC3, 0xF0, 0xF7,
  0x87, 0xE1, 0xEF, 0x0F, 0xC7, 0x9E, 0x3F, 0x8F, 0x3C, 0x7F, 0x3C, 0x79,
  0xFE, 0x78, 0xF3, 0xB8, 0xE1, 0xE7, 0x73, 0xC3, 0xDC, 0xE7, 0x87, 0xB9,
  0xDE, 0x0F, 0xF3, 0xBC, 0x1F, 0xC7, 0x70, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x00, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x1E, 0x03, 0xE7, 0xC0, 0x3C,
  0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDE,
  0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x7C, 0x1F,
  0x00, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x07,
  0x83, 0xC0, 0x38, 0x78, 0x03, 0x87, 0x80, 0x38, 0xF8, 0x03, 0x8F, 0x00,
  0x38, 0xF0, 0x03, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xB8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0xE3,
  0xFF, 0x87, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x7C, 0x01,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x0F, 0x80, 0x3F, 0x01,
  0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0xF8,
  0x0F, 0xE0, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x80,
  0x30, 0x00, 0x7E, 0x03, 0xFF, 0x9F, 0xFF, 0xFC, 0x1F, 0xF8, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 11, 10, 14, 4, -26 },
  { 48, 19, 26, 19, 0, -26 },
  { 110, 17, 29, 16, 0, -27 },
  { 172, 23, 26, 26, 2, -26 },
  { 247, 19, 26, 20, 0, -26 },
  { 309, 5, 10, 8, 4, -26 },
  { 316, 12, 32, 10, 1, -26 },
  { 364, 12, 32, 10, -3, -26 },
  { 412, 14, 15, 16, 3, -28 },
  { 439, 15, 17, 18, 2, -21 },
  { 471, 8, 9, 9, -2, -4 },
  { 480, 9, 4, 10, 1, -12 },
  { 485, 5, 5, 9, 0, -5 },
  { 489, 18, 26, 13, -2, -26 },
  { 548, 15, 26, 16, 1, -26 },
  { 597, 11, 26, 16, 4, -26 },
  { 633, 17, 26, 16, -1, -26 },
  { 689, 17, 26, 16, 0, -26 },
  { 745, 16, 26, 16, 0, -26 },
  { 797, 17, 26, 16, 0, -26 },
  { 853, 16, 26, 16, 1, -26 },
  { 905, 17, 26, 16, 1, -26 },
  { 961, 17, 26, 16, 0, -26 },
  { 1017, 16, 26, 16, 0, -26 },
  { 1069, 8, 20, 9, 0, -20 },
  { 1089, 10, 25, 9, -2, -20 },
  { 1121, 15, 18, 18, 2, -22 },
  { 1155, 15, 11, 18, 2, -18 },
  { 1176, 15, 18, 18, 2, -22 },
  { 1210, 13, 26, 13, 1, -26 },
  { 1253, 24, 29, 25, 1, -26 },
  { 1340, 18, 26, 18, -2, -26 },
  { 1399, 18, 26, 18, 0, -26 },
  { 1458, 17, 26, 17, 2, -26 },
  { 1514, 19, 26, 20, 0, -26 },
  { 1576, 17, 26, 15, 0, -26 },
  { 1632, 17, 26, 15, 0, -26 },
  { 1688, 19, 26, 20, 2, -26 },
  { 1750, 21, 26, 20, 0, -26 },
  { 1819, 15, 26, 11, -1, -26 },
  { 1868, 16, 33, 9, -6, -26 },
  { 1934, 21, 26, 18, 0, -26 },
  { 2003, 12, 26, 15, 0, -26 },
  { 2042, 27, 26, 26, 0, -26 },
  { 2130, 22, 26, 22, 0, -26 },
  { 2202, 19, 26, 21, 2, -26 },
  { 2264, 18, 26, 18, 0, -26 },
  { 2323, 19, 32, 21, 2, -26 },
  { 2399, 18, 26, 18, 0, -26 },
  { 2458, 17, 26, 16, 0, -26 },
  { 2514, 15, 26, 15, 3, -26 },
  { 2563, 19, 26, 20, 2, -26 },
  { 2625, 17, 26, 17, 3, -26 },
  { 2681, 27, 26, 27, 3, -26 },
  { 2769, 21, 26, 17, -2, -26 },
  { 2838, 16, 26, 16, 3, -26 },
  { 2890, 18, 26, 15, -1, -26 },
  { 2949, 14, 32, 11, -1, -26 },
  { 3005, 7, 26, 13, 4, -26 },
  { 3028, 15, 32, 11, -3, -26 },
  { 3088, 16, 16, 17, 0, -26 },
  { 3120, 12, 2, 12, -3, 3 },
  { 3123, 7, 6, 10, 5, -28 },
  { 3129, 17, 20, 18, 1, -20 },
  { 3172, 17, 27, 18, 0, -27 },
  { 3230, 14, 20, 14, 1, -20 },
  { 3265, 18, 27, 18, 1, -27 },
  { 3326, 14, 20, 16, 1, -20 },
  { 3361, 19, 37, 10, -4, -28 },
  { 3449, 18, 29, 18, 0, -20 },
  { 3515, 16, 27, 18, 0, -27 },
  { 3569, 10, 27, 8, 0, -27 },
  { 3603, 15, 36, 9, -5, -27 },
  { 3671, 18, 27, 16, 0, -27 },
  { 3732, 10, 27, 8, 0, -27 },
  { 3766, 25, 20, 26, 0, -20 },
  { 3829, 16, 20, 18, 0, -20 },
  { 3869, 15, 20, 17, 1, -20 },
  { 3907, 19, 29, 18, -2, -20 },
  { 3976, 16, 29, 18, 1, -20 },
  { 4034, 14, 20, 12, 0, -20 },
  { 4069, 14, 20, 14, 0, -20 },
  { 4104, 11, 24, 11, 1, -24 },
  { 4137, 16, 20, 17, 1, -20 },
  { 4177, 15, 20, 15, 2, -20 },
  { 4215, 23, 20, 23, 2, -20 },
  { 4273, 19, 20, 15, -2, -20 },
  { 4321, 20, 29, 15, -3, -20 },
  { 4394, 15, 20, 13, -1, -20 },
  { 4432, 15, 32, 12, 0, -26 },
  { 4492, 3, 36, 15, 6, -28 },
  { 4506, 14, 32, 12, -2, -26 },
  { 4562, 15, 5, 18, 2, -15 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC36PT7B_H_
