#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x26, 0x64, 0x0C, 0xC0, 0x6A, 0x57, 0xB0, 0x0B, 0x1A,
  0x12, 0x7F, 0x7F, 0x24, 0x2C, 0xFE, 0x48, 0x48, 0xD0, 0x08, 0x7C, 0xAB,
  0x43, 0x07, 0x07, 0x0E, 0x9D, 0xF0, 0x81, 0x00, 0x71, 0x29, 0xB4, 0x92,
  0x8B, 0x55, 0x5F, 0x7A, 0x29, 0x34, 0x92, 0xD1, 0xC0, 0x1C, 0x36, 0x36,
  0x34, 0x3C, 0x38, 0x7B, 0xCA, 0xCE, 0xCE, 0x76, 0x6D, 0x60, 0x08, 0x8C,
  0x46, 0x31, 0x18, 0xC6, 0x30, 0x86, 0x00, 0x10, 0xC6, 0x31, 0x8C, 0x62,
  0x11, 0x88, 0xCC, 0x00, 0x13, 0x47, 0xCC, 0x58, 0x40, 0x30, 0xC3, 0x3F,
  0x30, 0xC3, 0x00, 0x2D, 0x60, 0xFF, 0xF0, 0x03, 0x06, 0x06, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x1C, 0x7C, 0x9B, 0x36, 0x68, 0xD1,
  0x66, 0xCC, 0xB1, 0xC0, 0x37, 0xFB, 0x26, 0x66, 0x64, 0xC0, 0x1C, 0xFC,
  0x98, 0x30, 0xC1, 0x86, 0x18, 0x61, 0xFB, 0xE0, 0x1C, 0x7C, 0x18, 0x30,
  0xC7, 0x03, 0x06, 0x0D, 0x33, 0xC0, 0x06, 0x1C, 0x30, 0xA2, 0xCD, 0x93,
  0x7E, 0xFC, 0x30, 0x60, 0x3E, 0x7C, 0x81, 0x07, 0x8F, 0x83, 0x06, 0x0D,
  0x33, 0xC0, 0x0E, 0x3C, 0xC3, 0x07, 0xCF, 0x99, 0x22, 0xCC, 0xD9, 0xE0,
  0x7F, 0xF8, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x61, 0x83, 0x00, 0x1C, 0x7C,
  0x99, 0x33, 0xC7, 0x1B, 0x66, 0xCD, 0x99, 0xE0, 0x1C, 0x7D, 0x9B, 0x36,
  0x6D, 0x9D, 0x06, 0x09, 0x33, 0xC0, 0x76, 0x00, 0x00, 0xCC, 0x19, 0x80,
  0x00, 0x01, 0x8C, 0x46, 0x00, 0x04, 0x77, 0x30, 0xE0, 0xF0, 0x40, 0xFC,
  0x00, 0x3F, 0x83, 0x83, 0x83, 0x3B, 0x88, 0x00, 0x77, 0xC6, 0x33, 0x31,
  0x18, 0x06, 0x20, 0x07, 0x06, 0x33, 0x04, 0x9D, 0x4B, 0x56, 0x95, 0x27,
  0x4A, 0xDF, 0x90, 0x04, 0x00, 0xF8, 0x06, 0x1C, 0x28, 0xD1, 0xA2, 0x4C,
  0x9F, 0x62, 0xC7, 0x08, 0x3C, 0x3E, 0x33, 0x22, 0x26, 0x7C, 0x66, 0x66,
  0x46, 0xCC, 0xF8, 0x1E, 0x7D, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x91,
  0xE0, 0x3C, 0x3E, 0x33, 0x23, 0x23, 0x63, 0x63, 0x66, 0x46, 0xFC, 0xF8,
  0x3E, 0x7C, 0xC1, 0x02, 0x0F, 0x98, 0x30, 0x41, 0xF3, 0xE0, 0x3E, 0x7C,
  0xC1, 0x02, 0x0F, 0x9F, 0x30, 0x41, 0x83, 0x00, 0x1F, 0x3E, 0x60, 0xC0,
  0xC0, 0xCE, 0xDE, 0xC4, 0xC4, 0xEC, 0x7C, 0x31, 0x98, 0xCC, 0x44, 0x62,
  0x33, 0xF9, 0x8C, 0xC4, 0x46, 0x63, 0x31, 0x80, 0x1E, 0x78, 0x60, 0xC1,
  0x82, 0x04, 0x18, 0x30, 0x63, 0xE0, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86,
  0x10, 0xC3, 0x0C, 0xE3, 0x80, 0x31, 0x99, 0x8D, 0x85, 0x82, 0x83, 0xC1,
  0xE0, 0xD8, 0x4C, 0x66, 0x33, 0x00, 0x31, 0x8C, 0x42, 0x31, 0x8C, 0x47,
  0xFE, 0x38, 0x67, 0x1C, 0xE3, 0x9C, 0xF3, 0x94, 0xD6, 0x9A, 0xB2, 0x76,
  0x4C, 0xD9, 0x93, 0x36, 0x00, 0x30, 0x9C, 0xCE, 0x67, 0x32, 0x93, 0x69,
  0xBC, 0x9E, 0x47, 0x63, 0x31, 0x80, 0x1C, 0x3E, 0x62, 0xC3, 0xC3, 0xC2,
  0xC6, 0x86, 0xCC, 0xDC, 0x78, 0x3C, 0x3E, 0x33, 0x23, 0x26, 0x6E, 0x7C,
  0x60, 0x40, 0xC0, 0xC0, 0x1C, 0x3E, 0x62, 0xC3, 0xC3, 0xC2, 0xC6, 0x86,
  0xCC, 0xDC, 0x78, 0x18, 0x18, 0x1C, 0x3C, 0x7C, 0xC9, 0x12, 0x6F, 0x9E,
  0x34, 0x4D, 0x9B, 0x30, 0x1C, 0x7D, 0x83, 0x07, 0x07, 0x06, 0x06, 0x0D,
  0xB3, 0xC0, 0x7F, 0xF3, 0x0C, 0x21, 0x86, 0x18, 0x61, 0x0C, 0x00, 0x63,
  0x62, 0x66, 0x46, 0xC6, 0xC6, 0xC4, 0xCC, 0x8C, 0xD8, 0xF8, 0xC3, 0xC6,
  0xC6, 0xCC, 0xCC, 0x58, 0x58, 0x50, 0x70, 0x60, 0x60, 0xC6, 0x38, 0xCF,
  0x39, 0xE7, 0x6D, 0xED, 0xAD, 0x35, 0xE7, 0xB8, 0xE7, 0x1C, 0xE3, 0x18,
  0x00, 0x11, 0x8D, 0x86, 0xC3, 0xC0, 0xC0, 0x60, 0x70, 0x68, 0x34, 0x33,
  0x31, 0x80, 0xC6, 0x99, 0x32, 0xC7, 0x8E, 0x18, 0x30, 0x60, 0xC1, 0x00,
  0x1F, 0x1F, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xFC, 0x39,
  0xC8, 0x46, 0x31, 0x88, 0x46, 0x31, 0x0E, 0x00, 0x92, 0x4D, 0xB2, 0x49,
  0x80, 0x1C, 0xF0, 0x82, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x08, 0xE0, 0x08,
  0x30, 0x71, 0x66, 0x48, 0xB1, 0x80, 0xF8, 0xCC, 0x3A, 0xCD, 0x9A, 0x3C,
  0x59, 0xB7, 0x3E, 0x30, 0x60, 0xC1, 0x77, 0x6C, 0xD9, 0xA3, 0x4D, 0xDB,
  0xE0, 0x3D, 0x96, 0x10, 0xC3, 0x06, 0x9E, 0x03, 0x03, 0x02, 0x3A, 0x66,
  0x66, 0x46, 0x44, 0xCC, 0xCC, 0x7C, 0x3D, 0x96, 0x5F, 0xE3, 0x04, 0x9E,
  0x07, 0x0C, 0x0C, 0x1E, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x30, 0xE0, 0xC0, 0x3A, 0xCD, 0x9A, 0x3C, 0x59, 0xB7, 0x3E, 0x08, 0x33,
  0xE3, 0x00, 0x30, 0x60, 0xC1, 0xF7, 0x6C, 0xD9, 0xA2, 0x4D, 0x9B, 0x30,
  0x33, 0x02, 0x66, 0x64, 0x4C, 0xC0, 0x0C, 0x30, 0x42, 0x18, 0x61, 0x86,
  0x10, 0xC3, 0x0C, 0x23, 0x8C, 0x00, 0x30, 0x60, 0xC1, 0x36, 0xCF, 0x1E,
  0x3C, 0x59, 0x93, 0x30, 0x33, 0x32, 0x66, 0x64, 0x4C, 0xC0, 0x3D, 0xDD,
  0x96, 0x65, 0x93, 0x44, 0xD3, 0x3C, 0xCB, 0x36, 0x3E, 0xED, 0x9B, 0x34,
  0x49, 0xB3, 0x66, 0x3C, 0xCD, 0x9A, 0x3C, 0x59, 0x93, 0x3C, 0x17, 0x3B,
  0x33, 0x33, 0x23, 0x26, 0x76, 0x7C, 0x60, 0x40, 0x40, 0xC0, 0x3A, 0xCD,
  0x9A, 0x34, 0x59, 0xB3, 0x3E, 0x08, 0x10, 0x60, 0xC0, 0x3D, 0xD6, 0x18,
  0x41, 0x0C, 0x30, 0x7D, 0x96, 0x1C, 0x38, 0x69, 0xBC, 0x26, 0xF4, 0xCC,
  0xC8, 0x8E, 0x26, 0xCD, 0x9B, 0x24, 0x49, 0xB7, 0x3E, 0x8F, 0x6D, 0xB4,
  0xF3, 0x8E, 0x30, 0xDD, 0xCC, 0xE6, 0x57, 0x6A, 0xA7, 0x73, 0x39, 0x98,
  0x33, 0x16, 0x1C, 0x18, 0x18, 0x3C, 0x6C, 0xCC, 0x33, 0x32, 0x36, 0x34,
  0x3C, 0x38, 0x38, 0x30, 0x30, 0x20, 0xE0, 0x80, 0x7C, 0x61, 0x8C, 0x61,
  0x8C, 0x3C, 0x0C, 0x71, 0x04, 0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x70,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xE1, 0x86, 0x18, 0x60, 0xC7, 0x30, 0xC2,
  0x18, 0xE0, 0xFE, 0x60,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 6, 1, -11 },
  { 10, 8, 11, 8, 0, -11 },
  { 21, 7, 12, 7, 0, -11 },
  { 32, 9, 11, 11, 1, -11 },
  { 45, 8, 11, 8, 0, -11 },
  { 56, 3, 4, 3, 1, -11 },
  { 58, 5, 13, 4, 0, -11 },
  { 67, 5, 13, 4, -1, -11 },
  { 76, 6, 6, 7, 1, -11 },
  { 81, 6, 7, 7, 1, -9 },
  { 87, 3, 4, 4, -1, -2 },
  { 89, 4, 2, 4, 0, -5 },
  { 90, 2, 2, 4, 0, -2 },
  { 91, 8, 11, 6, -1, -11 },
  { 102, 7, 11, 7, 0, -11 },
  { 112, 4, 11, 7, 2, -11 },
  { 118, 7, 11, 7, 0, -11 },
  { 128, 7, 11, 7, 0, -11 },
  { 138, 7, 11, 7, 0, -11 },
  { 148, 7, 11, 7, 0, -11 },
  { 158, 7, 11, 7, 0, -11 },
  { 168, 7, 11, 7, 1, -11 },
  { 178, 7, 11, 7, 0, -11 },
  { 188, 7, 11, 7, 0, -11 },
  { 198, 4, 8, 4, 0, -8 },
  { 202, 5, 10, 4, -1, -8 },
  { 209, 6, 7, 7, 1, -9 },
  { 215, 6, 4, 7, 1, -7 },
  { 218, 6, 7, 7, 1, -9 },
  { 224, 5, 11, 5, 1, -11 },
  { 231, 10, 12, 10, 0, -11 },
  { 246, 7, 11, 7, -1, -11 },
  { 256, 8, 11, 8, 0, -11 },
  { 267, 7, 11, 7, 1, -11 },
  { 277, 8, 11, 8, 0, -11 },
  { 288, 7, 11, 6, 0, -11 },
  { 298, 7, 11, 6, 0, -11 },
  { 308, 8, 11, 8, 1, -11 },
  { 319, 9, 11, 9, 0, -11 },
  { 332, 7, 11, 5, -1, -11 },
  { 342, 6, 14, 4, -2, -11 },
  { 353, 9, 11, 7, 0, -11 },
  { 366, 5, 11, 6, 0, -11 },
  { 373, 11, 11, 11, 0, -11 },
  { 389, 9, 11, 9, 0, -11 },
  { 402, 8, 11, 9, 1, -11 },
  { 413, 8, 11, 7, 0, -11 },
  { 424, 8, 14, 9, 1, -11 },
  { 438, 7, 11, 7, 0, -11 },
  { 448, 7, 11, 7, 0, -11 },
  { 458, 6, 11, 6, 1, -11 },
  { 467, 8, 11, 8, 1, -11 },
  { 478, 8, 11, 7, 1, -11 },
  { 489, 11, 11, 11, 1, -11 },
  { 505, 9, 11, 7, -1, -11 },
  { 518, 7, 11, 7, 1, -11 },
  { 528, 8, 11, 6, -1, -11 },
  { 539, 5, 13, 4, 0, -11 },
  { 548, 3, 11, 6, 2, -11 },
  { 553, 6, 13, 4, -1, -11 },
  { 563, 7, 7, 7, 0, -11 },
  { 570, 5, 1, 5, -1, 1 },
  { 571, 3, 2, 4, 2, -11 },
  { 572, 7, 8, 7, 0, -8 },
  { 579, 7, 11, 7, 0, -11 },
  { 589, 6, 8, 6, 0, -8 },
  { 595, 8, 11, 7, 0, -11 },
  { 606, 6, 8, 7, 0, -8 },
  { 612, 8, 15, 4, -2, -11 },
  { 627, 7, 12, 7, 0, -8 },
  { 638, 7, 11, 7, 0, -11 },
  { 648, 4, 11, 4, 0, -11 },
  { 654, 6, 15, 4, -2, -11 },
  { 666, 7, 11, 7, 0, -11 },
  { 676, 4, 11, 4, 0, -11 },
  { 682, 10, 8, 11, 0, -8 },
  { 692, 7, 8, 7, 0, -8 },
  { 699, 7, 8, 7, 0, -8 },
  { 706, 8, 12, 7, -1, -8 },
  { 718, 7, 12, 7, 0, -8 },
  { 729, 6, 8, 5, 0, -8 },
  { 735, 6, 8, 6, 0, -8 },
  { 741, 4, 10, 5, 1, -10 },
  { 746, 7, 8, 7, 0, -8 },
  { 753, 6, 8, 6, 1, -8 },
  { 759, 9, 8, 10, 1, -8 },
  { 768, 8, 8, 6, -1, -8 },
  { 776, 8, 12, 6, -1, -8 },
  { 788, 6, 8, 5, 0, -8 },
  { 794, 6, 13, 5, 0, -11 },
  { 804, 2, 14, 6, 2, -11 },
  { 808, 6, 13, 5, -1, -11 },
  { 818, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC15PT7B_H_
