#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0x00, 0x08, 0x00, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F,
  0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x00,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C,
  0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0xF8, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0xE3, 0x80, 0xFC, 0x70, 0x40,
  0x7E, 0x38, 0x00, 0x3F, 0x18, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xCE, 0x00,
  0x07, 0xF7, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0x7F, 0x00, 0x03,
  0x1F, 0x80, 0x01, 0x8F, 0xC0, 0x01, 0xC7, 0xE1, 0x00, 0xE3, 0xF0, 0xC0,
  0x63, 0xF0, 0x78, 0x33, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xE0, 0x1F, 0x3E, 0x00,
  0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0xF0, 0x7C,
  0x0F, 0x80, 0x7C, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x81, 0xE0, 0x07, 0xC1,
  0xE0, 0xF8, 0x01, 0xE0, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x3E,
  0x0F, 0x8F, 0x80, 0x0F, 0x83, 0xC3, 0xC0, 0x03, 0xE1, 0xF1, 0xF0, 0x60,
  0xF8, 0x7C, 0xF8, 0x7F, 0x3E, 0x1E, 0x3E, 0x7F, 0xEF, 0x8F, 0x9F, 0x3F,
  0xFB, 0xE7, 0xC7, 0x8F, 0xFF, 0xFF, 0xF3, 0xE7, 0xC7, 0xDF, 0xF9, 0xF1,
  0xF1, 0xF3, 0xFC, 0x7C, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x00, 0x0F,
  0x8F, 0x07, 0xC0, 0x07, 0xC7, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x7C, 0x00,
  0xF8, 0x7C, 0x1E, 0x00, 0x7C, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0x83, 0xE0,
  0x0F, 0x83, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x3C, 0x01, 0xF0, 0x3E, 0x1F,
  0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xE3, 0xE0, 0x1F, 0x00, 0x7F,
  0xF0, 0x0F, 0x80, 0x1F, 0xFC, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x87, 0xFF, 0xC1, 0xF8, 0x3F, 0x7F,
  0x0F, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8, 0x3F, 0x7E,
  0x1F, 0x81, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x7F,
  0x00, 0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03,
  0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0, 0x3F, 0xF0, 0x7F, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x40, 0x78, 0x07, 0x07, 0x80, 0x7C, 0x78,
  0x0F, 0xF7, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xF8, 0x10, 0x7F, 0xC0, 0x0F, 0xBC, 0x03, 0xFB, 0xE0, 0x7F,
  0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x1F, 0x81, 0xC1, 0xF8, 0x08, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x04,
  0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x30, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF3, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01,
  0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xBF,
  0x3F, 0x3F, 0x0F, 0x1F, 0x87, 0x0F, 0xC1, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x3E,
  0x07, 0xF0, 0x03, 0x80, 0x7E, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC7, 0xFC, 0x07, 0x00, 0xFE,
  0x01, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x80, 0x07, 0xF0, 0x70, 0x0F, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0,
  0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07,
  0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x70, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xC0, 0x0F, 0xF0, 0x78, 0x0F, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0x06, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0x00, 0x3F, 0x3F, 0xC0, 0x3F, 0x7F, 0xE0, 0x7E, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xF0, 0x7F, 0x83, 0xF8, 0xFF, 0x03,
  0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xFB, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0x87, 0xF0,
  0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xF7, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x3F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F,
  0x3F, 0x00, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x0F, 0xF9, 0xFE, 0x3F, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0x07, 0xFE, 0xFC, 0x03,
  0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0x00, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x1F,
  0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x07, 0xC0,
  0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0x40, 0x00,
  0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3E, 0x1F, 0xC3, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x20, 0x0F, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0xF0, 0x1F,
  0xFE, 0x1E, 0x3E, 0x0F, 0xFF, 0x83, 0xC7, 0x81, 0xF1, 0xF0, 0x79, 0xF0,
  0x7C, 0x3E, 0x0F, 0x3C, 0x1F, 0x07, 0xC3, 0xEF, 0x83, 0xC0, 0xF0, 0x7D,
  0xF0, 0xF8, 0x3E, 0x0F, 0xBC, 0x1E, 0x07, 0xC1, 0xE7, 0x87, 0xC0, 0xF8,
  0x3D, 0xF0, 0xF8, 0x1E, 0x07, 0xBE, 0x1E, 0x07, 0xC1, 0xF7, 0x83, 0xC0,
  0xF8, 0x3C, 0xF0, 0x78, 0x1F, 0x07, 0x9E, 0x1F, 0x07, 0xC1, 0xF3, 0xC3,
  0xE0, 0xF8, 0x3C, 0x78, 0x7C, 0x3F, 0x0F, 0x8F, 0x07, 0xC7, 0xE3, 0xE1,
  0xE0, 0xFF, 0xDF, 0xF8, 0x3C, 0x1F, 0xF3, 0xFE, 0x07, 0x81, 0xFC, 0x7F,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x80, 0x00, 0xFF, 0xC7, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0x87, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF8, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0x00, 0xFF, 0x80,
  0x40, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x20, 0x07, 0xF8, 0x1C, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x01, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0xC0,
  0x3F, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xF7, 0xF8, 0x07, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0x04, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0xF8, 0xFE, 0x03, 0xFF, 0x87, 0xE0, 0x1F, 0xFC, 0x3F, 0x01, 0xFF, 0xE1,
  0xF8, 0x0F, 0xFF, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x7E,
  0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xF9,
  0xF8, 0x07, 0xE7, 0xC0, 0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x01,
  0xF9, 0xF0, 0x7E, 0x7E, 0x00, 0xF8, 0xF8, 0x3E, 0x3F, 0x00, 0xFC, 0x7C,
  0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0x0F, 0x8F,
  0xC0, 0x1F, 0x8F, 0x8F, 0x87, 0xE0, 0x0F, 0x87, 0xC7, 0xC3, 0xF0, 0x0F,
  0xC3, 0xE7, 0xE1, 0xF0, 0x07, 0xE1, 0xF3, 0xE1, 0xF8, 0x03, 0xF0, 0xFB,
  0xF0, 0xFC, 0x01, 0xF0, 0x7D, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0x07,
  0xE0, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF,
  0x01, 0xF8, 0x03, 0xF7, 0xC0, 0x7E, 0x00, 0xF9, 0xF8, 0x1F, 0x80, 0x3E,
  0x7E, 0x07, 0xE0, 0x1F, 0x9F, 0x81, 0xF0, 0x07, 0xE3, 0xE0, 0xFC, 0x01,
  0xF8, 0xF8, 0x3F, 0x00, 0x7E, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF0, 0xF8, 0x03, 0xF0, 0x7C, 0x7E, 0x00, 0xFC, 0x1F, 0x9F,
  0x80, 0x3E, 0x07, 0xE7, 0xE0, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xE0, 0x3E,
  0x7C, 0x01, 0xF8, 0x0F, 0xBF, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x1F, 0x00,
  0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x07,
  0xE0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF8, 0x1F,
  0x81, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xF0, 0x38, 0x0F, 0xE0, 0x04, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC1, 0x00, 0x0F, 0xE0, 0xE0, 0x0F, 0xF0, 0x7C,
  0x1F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x01,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x3F, 0x80, 0x1F,
  0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xFC, 0x07, 0xE0, 0xFC, 0x0F,
  0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x7C, 0x0F,
  0xC0, 0xFC, 0x1F, 0x7C, 0x1F, 0xC0, 0xFC, 0x3F, 0x7C, 0x1F, 0x80, 0xFC,
  0x3E, 0x7C, 0x1F, 0x80, 0xFC, 0x3E, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x7C,
  0x3F, 0x00, 0xF8, 0x7C, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x7C, 0x7E, 0x00,
  0xF8, 0xF8, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x7C, 0xFC, 0x00, 0xF9, 0xF0,
  0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x7C, 0xF8, 0x00, 0xFB, 0xF0, 0x7D, 0xF8,
  0x00, 0xFB, 0xE0, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x01,
  0xFC, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F,
  0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x7F, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x3E, 0x1F,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0x1F, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xBF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0,
  0x7F, 0xE7, 0xC0, 0x1F, 0xC7, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0E, 0x00, 0x3F,
  0x3F, 0xC0, 0x1F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFE, 0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0,
  0xFE, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F,
  0x0F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xF0,
  0x7F, 0x07, 0xFF, 0xFF, 0x03, 0xEF, 0xFF, 0x81, 0xF7, 0xFF, 0x81, 0xF9,
  0xFF, 0x80, 0xF8, 0x7F, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xBC,
  0x1F, 0xE0, 0x41, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x10, 0xFE, 0x06, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1C, 0x1F, 0x80, 0x0F, 0xF3, 0xF0, 0x07,
  0xFF, 0x7E, 0x01, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xF7, 0xFE,
  0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F,
  0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xF7, 0xC0, 0x1F,
  0xFD, 0xF8, 0x01, 0xFF, 0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x87, 0xF0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x1F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0xFF, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0x87, 0xFC, 0x7C, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x9F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFC, 0x7C, 0x01, 0xFF, 0xDF, 0x80, 0x7F, 0xFB, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0x7E, 0x00, 0xFF, 0xDF, 0x80, 0x0F, 0xF3,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0C, 0x00, 0xFE,
  0x01, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x00,
  0x3F, 0x3F, 0xC0, 0x1F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x18, 0x00, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x8F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x07, 0xC7,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x1F, 0xE0, 0xFF, 0x00, 0xF9, 0xFF,
  0x8F, 0xFC, 0x07, 0xDF, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0x7F, 0xFB, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xF8, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xF1,
  0xFE, 0x00, 0xF9, 0xFF, 0x80, 0x7D, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFC, 0x1F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xF7, 0xF0, 0x0F, 0xDF,
  0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFE,
  0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F,
  0x1F, 0xE0, 0x03, 0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0x00, 0x7E, 0x3F, 0x80,
  0x0F, 0xC1, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x1F, 0x03, 0xFF, 0x9F, 0x07, 0xFF, 0xBF, 0x07, 0xFF, 0xFE,
  0x0F, 0xF7, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x7F, 0xEF, 0xC0,
  0x3F, 0xCF, 0xC0, 0x04, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x1F, 0x80,
  0xF9, 0xFC, 0x07, 0xDF, 0xE0, 0x3E, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFD,
  0x80, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xF0, 0xF0, 0x7F, 0x01, 0x83, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x10, 0x07, 0xF0, 0xC0, 0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0C,
  0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xC0, 0x7F, 0xE7,
  0xC0, 0x3F, 0xC7, 0xC0, 0x04, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xC1,
  0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC7, 0xE0,
  0x1F, 0x1F, 0x80, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xDF, 0x80, 0x1F,
  0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x07, 0xEF,
  0xC0, 0x7F, 0x01, 0xFB, 0xF0, 0x3F, 0xC0, 0x7E, 0xFC, 0x0F, 0xF0, 0x3F,
  0x3F, 0x03, 0xFC, 0x0F, 0xCF, 0xC1, 0xFF, 0x07, 0xE3, 0xF0, 0x7B, 0xC1,
  0xF8, 0xFC, 0x3E, 0xF0, 0x7E, 0x3F, 0x0F, 0xBC, 0x3F, 0x0F, 0xC7, 0xCF,
  0x0F, 0xC3, 0xF1, 0xF7, 0xC3, 0xE0, 0xFC, 0x7D, 0xF1, 0xF8, 0x3F, 0x3E,
  0x7C, 0x7C, 0x0F, 0xCF, 0x9F, 0x3F, 0x03, 0xF7, 0xC7, 0xCF, 0xC0, 0xFD,
  0xF1, 0xF3, 0xE0, 0x3F, 0x7C, 0x7D, 0xF8, 0x0F, 0xFE, 0x1F, 0x7C, 0x03,
  0xFF, 0x87, 0xFF, 0x00, 0xFB, 0xC1, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x07, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0x1F, 0x03, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x08,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x0A, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x7F,
  0xE0, 0x0D, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0x40, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 15, 40, 14, 0, -39 },
  { 76, 18, 14, 21, 5, -39 },
  { 108, 29, 39, 28, 0, -39 },
  { 250, 25, 44, 24, 0, -41 },
  { 388, 34, 39, 39, 3, -39 },
  { 554, 29, 40, 29, 0, -39 },
  { 699, 9, 14, 12, 5, -39 },
  { 715, 18, 48, 15, 1, -39 },
  { 823, 18, 48, 15, -4, -39 },
  { 931, 20, 22, 24, 5, -41 },
  { 986, 23, 26, 26, 2, -32 },
  { 1061, 12, 14, 13, -3, -7 },
  { 1082, 14, 5, 16, 1, -17 },
  { 1091, 8, 9, 13, 0, -8 },
  { 1100, 27, 39, 20, -3, -39 },
  { 1232, 23, 40, 24, 1, -39 },
  { 1347, 17, 39, 25, 6, -39 },
  { 1430, 27, 39, 24, -2, -39 },
  { 1562, 25, 40, 24, 0, -39 },
  { 1687, 26, 39, 25, -1, -39 },
  { 1814, 25, 40, 24, 0, -39 },
  { 1939, 24, 40, 24, 2, -39 },
  { 2059, 25, 39, 24, 2, -39 },
  { 2181, 25, 40, 24, 0, -39 },
  { 2306, 23, 40, 24, 1, -39 },
  { 2421, 13, 31, 13, 0, -30 },
  { 2472, 16, 37, 13, -3, -30 },
  { 2546, 23, 26, 26, 2, -32 },
  { 2621, 23, 16, 26, 2, -27 },
  { 2667, 23, 26, 26, 2, -32 },
  { 2742, 19, 40, 19, 2, -39 },
  { 2837, 35, 44, 37, 2, -39 },
  { 3030, 26, 39, 27, -3, -39 },
  { 3157, 27, 39, 27, 0, -39 },
  { 3289, 27, 40, 26, 2, -39 },
  { 3424, 29, 39, 30, 0, -39 },
  { 3566, 26, 39, 23, 0, -39 },
  { 3693, 26, 39, 22, 0, -39 },
  { 3820, 29, 40, 31, 2, -39 },
  { 3965, 32, 39, 31, 0, -39 },
  { 4121, 23, 39, 17, -2, -39 },
  { 4234, 23, 50, 14, -8, -39 },
  { 4378, 31, 39, 26, 0, -39 },
  { 4530, 19, 39, 22, 0, -39 },
  { 4623, 41, 39, 40, 0, -39 },
  { 4823, 34, 39, 33, 0, -39 },
  { 4989, 29, 40, 32, 2, -39 },
  { 5134, 27, 39, 26, 0, -39 },
  { 5266, 29, 48, 32, 2, -39 },
  { 5440, 27, 39, 27, 0, -39 },
  { 5572, 25, 40, 23, 0, -39 },
  { 5697, 23, 39, 23, 4, -39 },
  { 5810, 29, 40, 30, 2, -39 },
  { 5955, 26, 39, 26, 5, -39 },
  { 6082, 40, 39, 40, 5, -39 },
  { 6277, 32, 39, 25, -3, -39 },
  { 6433, 24, 39, 24, 5, -39 },
  { 6550, 28, 39, 23, -2, -39 },
  { 6687, 22, 48, 16, -2, -39 },
  { 6819, 10, 39, 20, 6, -39 },
  { 6868, 21, 48, 16, -4, -39 },
  { 6994, 24, 23, 25, 0, -39 },
  { 7063, 19, 3, 18, -5, 5 },
  { 7071, 9, 8, 16, 8, -41 },
  { 7080, 24, 31, 26, 2, -30 },
  { 7173, 25, 42, 26, 0, -41 },
  { 7305, 20, 31, 21, 2, -30 },
  { 7383, 27, 42, 26, 2, -41 },
  { 7525, 21, 31, 24, 2, -30 },
  { 7607, 28, 54, 16, -6, -41 },
  { 7796, 27, 43, 26, -1, -30 },
  { 7942, 25, 41, 26, 0, -41 },
  { 8071, 15, 41, 13, 0, -41 },
  { 8148, 22, 54, 13, -7, -41 },
  { 8297, 26, 41, 24, 0, -41 },
  { 8431, 15, 41, 13, 0, -41 },
  { 8508, 37, 30, 39, 0, -30 },
  { 8647, 25, 30, 26, 0, -30 },
  { 8741, 22, 31, 26, 2, -30 },
  { 8827, 27, 43, 26, -2, -30 },
  { 8973, 24, 43, 26, 2, -30 },
  { 9102, 21, 30, 18, 0, -30 },
  { 9181, 21, 31, 20, 0, -30 },
  { 9263, 16, 37, 16, 2, -36 },
  { 9337, 24, 30, 26, 2, -29 },
  { 9427, 22, 29, 22, 3, -29 },
  { 9507, 34, 29, 35, 3, -29 },
  { 9631, 28, 29, 23, -3, -29 },
  { 9733, 29, 42, 22, -4, -29 },
  { 9886, 23, 29, 20, -2, -29 },
  { 9970, 21, 48, 18, 1, -39 },
  { 10096, 5, 53, 23, 9, -41 },
  { 10130, 21, 48, 18, -3, -39 },
  { 10256, 23, 8, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC54PT7B_H_
