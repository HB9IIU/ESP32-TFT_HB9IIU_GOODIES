#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x61, 0x80, 0x18, 0xE3, 0x80,
  0x6F, 0xDB, 0x36, 0x6D, 0x80, 0x06, 0xC1, 0x98, 0x32, 0x04, 0xC3, 0xFE,
  0xB2, 0x06, 0xC0, 0x98, 0xFF, 0x9F, 0xF0, 0x98, 0x33, 0x06, 0x40, 0x98,
  0x00, 0x02, 0x03, 0x87, 0xE7, 0xB3, 0x41, 0xA0, 0xF0, 0x3C, 0x0F, 0x05,
  0x82, 0xD1, 0x6F, 0xE7, 0xE0, 0x40, 0x20, 0x3C, 0x73, 0x62, 0x13, 0x31,
  0x99, 0x0C, 0xD8, 0x65, 0xBB, 0x6B, 0xFE, 0xDB, 0x05, 0x98, 0x6C, 0xC6,
  0x64, 0x33, 0x63, 0x1B, 0x30, 0xF0, 0x0F, 0x83, 0x30, 0x66, 0x0C, 0xC1,
  0xB0, 0x3C, 0x07, 0x01, 0xE7, 0x66, 0xDC, 0xFB, 0x1E, 0x73, 0x8F, 0xF8,
  0xFB, 0x80, 0x6F, 0x6C, 0x0E, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x60,
  0xC1, 0x87, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0x0E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x1C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0xE0, 0x19, 0x33,
  0xEB, 0xF3, 0x8D, 0x33, 0x24, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x36, 0x6C, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xC0,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x30, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0xE3, 0xC3, 0xC7, 0xC7,
  0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0xF8, 0x1C, 0xF7, 0xFF, 0x58, 0x61, 0x8E,
  0x30, 0xC3, 0x0C, 0x71, 0x80, 0x0F, 0x87, 0xF1, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F,
  0x8F, 0xC0, 0x60, 0x30, 0x38, 0x38, 0x70, 0x3C, 0x07, 0x01, 0x81, 0xD0,
  0xEF, 0xE7, 0xE0, 0x03, 0x81, 0xC1, 0xE1, 0xE1, 0xB0, 0xD8, 0xCC, 0xCE,
  0x46, 0x7F, 0xFF, 0xC1, 0xC0, 0xC0, 0x60, 0x1F, 0x8F, 0xC6, 0x06, 0x03,
  0x01, 0xF1, 0xFC, 0x0E, 0x03, 0x01, 0x81, 0xD0, 0xCF, 0xE7, 0xE0, 0x02,
  0x87, 0x87, 0x46, 0x06, 0x03, 0x03, 0xF9, 0xFC, 0xE6, 0x63, 0x31, 0x98,
  0xCC, 0xE7, 0xE1, 0xE0, 0x7F, 0xBF, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x1F, 0x9D, 0xCC, 0x66,
  0x33, 0x38, 0xF8, 0x70, 0x7C, 0x67, 0x71, 0xB0, 0xDC, 0x6F, 0xE3, 0xE0,
  0x04, 0x0F, 0x8F, 0xE6, 0x37, 0x1B, 0x8D, 0x8E, 0xE7, 0x3F, 0x1D, 0x80,
  0xC0, 0xC0, 0xE7, 0xE3, 0xE0, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x67, 0x38,
  0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x18, 0xC3, 0x00, 0x01,
  0x07, 0x1E, 0x78, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x0F, 0x3C, 0xF0, 0xC0,
  0x80, 0x7C, 0xDC, 0x18, 0x30, 0xC3, 0x8E, 0x38, 0x60, 0xC0, 0x02, 0x0E,
  0x18, 0x00, 0x07, 0xE0, 0xE1, 0x8C, 0x04, 0xC2, 0x36, 0x7D, 0xE6, 0x4F,
  0x66, 0x7B, 0x32, 0x99, 0xB4, 0xD9, 0xA7, 0xF9, 0x19, 0x8C, 0x00, 0x60,
  0x41, 0xFC, 0x03, 0x80, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x0D, 0x83, 0x61,
  0x98, 0x66, 0x3F, 0x8F, 0xE7, 0x1D, 0x87, 0xE1, 0xF0, 0x70, 0x1F, 0x87,
  0xF1, 0x8C, 0xE3, 0x31, 0xCC, 0xE3, 0xE0, 0xFE, 0x71, 0x98, 0x66, 0x39,
  0x8E, 0xFF, 0x3F, 0x80, 0x02, 0x03, 0xF3, 0xF8, 0xE0, 0x70, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x87, 0xE0, 0x1F,
  0x83, 0xF8, 0x63, 0x1C, 0x73, 0x8E, 0x61, 0xCC, 0x31, 0x86, 0x70, 0xCC,
  0x39, 0x8E, 0x33, 0x8F, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC6, 0x07, 0x03,
  0x81, 0x80, 0xFC, 0x7E, 0x70, 0x30, 0x18, 0x0C, 0x0F, 0xE7, 0xF0, 0x1F,
  0x8F, 0xC6, 0x07, 0x03, 0x81, 0x80, 0xFC, 0x7E, 0x70, 0x30, 0x18, 0x0C,
  0x0E, 0x07, 0x00, 0x01, 0x01, 0xFC, 0x7F, 0x1C, 0x07, 0x00, 0xC0, 0x38,
  0x07, 0x3E, 0xC7, 0x98, 0x33, 0x06, 0x61, 0xCE, 0x30, 0xFE, 0x0F, 0xC0,
  0x1C, 0x71, 0x86, 0x18, 0x63, 0x86, 0x38, 0xE3, 0x0E, 0x3F, 0xC3, 0xFC,
  0x70, 0xC6, 0x1C, 0x61, 0x86, 0x18, 0xE1, 0x8E, 0x38, 0x1F, 0x87, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0x07, 0x87,
  0xE0, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0xF8, 0x78, 0x00, 0x18, 0xF1,
  0x8C, 0x19, 0x83, 0xB8, 0x37, 0x03, 0x60, 0x3E, 0x03, 0xE0, 0x76, 0x06,
  0x60, 0x67, 0x06, 0x70, 0x63, 0x0E, 0x38, 0x1C, 0x30, 0x61, 0xC3, 0x06,
  0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0F, 0xFF, 0xC0, 0x1C, 0x1E, 0x38, 0x3C,
  0x70, 0x79, 0xA1, 0xE3, 0x43, 0xC6, 0xCD, 0x8D, 0x9F, 0x1B, 0x6C, 0x66,
  0xD8, 0xCF, 0x31, 0x9E, 0x63, 0x39, 0xC6, 0x73, 0x18, 0xC6, 0x00, 0x1C,
  0x31, 0xC3, 0x1C, 0x33, 0x63, 0x36, 0x63, 0x66, 0x36, 0x63, 0x76, 0x63,
  0xE6, 0x3C, 0x63, 0xC6, 0x3C, 0xE1, 0xCC, 0x1C, 0x02, 0x07, 0xE3, 0xFC,
  0xC3, 0x70, 0xD8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1B, 0x0E, 0xE3,
  0x1F, 0xC7, 0xC0, 0x1F, 0x87, 0xF1, 0x8C, 0xE3, 0x30, 0xCC, 0x73, 0x38,
  0xFC, 0x7E, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x02, 0x07, 0xE3,
  0xFC, 0xC3, 0x70, 0xD8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1B, 0x0E,
  0xE3, 0x1F, 0xC7, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x1F, 0x87, 0xF1, 0x9C,
  0xE7, 0x31, 0xCC, 0x63, 0xF8, 0xFC, 0x76, 0x19, 0x86, 0x71, 0x8C, 0x63,
  0x38, 0xE0, 0x1F, 0x9F, 0xCC, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x03, 0x81, 0xD0, 0xCF, 0xE7, 0xE0, 0xFF, 0xFF, 0x38, 0x30, 0x30, 0x30,
  0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x30, 0xE6, 0x19, 0xC3,
  0x38, 0xE6, 0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xE3, 0x98, 0x73, 0x0C, 0x73,
  0x8F, 0xE0, 0xF8, 0x00, 0xC1, 0xE1, 0xF0, 0xD8, 0xEC, 0x66, 0x73, 0x31,
  0x98, 0xD8, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x00, 0xC3, 0x0F, 0x8E, 0x1B,
  0x1C, 0x66, 0x38, 0xCC, 0xF3, 0x99, 0xE6, 0x36, 0xCC, 0x6D, 0xB0, 0xD3,
  0x61, 0xE7, 0xC3, 0xCF, 0x07, 0x1E, 0x0E, 0x38, 0x18, 0x70, 0x00, 0x1C,
  0x70, 0xCE, 0x0C, 0xC0, 0xD8, 0x0F, 0x80, 0xF0, 0x06, 0x00, 0xE0, 0x1F,
  0x01, 0xB0, 0x33, 0x07, 0x30, 0x63, 0x8E, 0x38, 0xC3, 0xE3, 0xB1, 0x9D,
  0x86, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x00,
  0x1F, 0xE3, 0xF8, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x78,
  0xF8, 0xCC, 0xC6, 0x66, 0x66, 0x66, 0x33, 0x33, 0x1E, 0x0C, 0x18, 0x30,
  0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x78, 0xF0, 0x06,
  0x07, 0x03, 0x83, 0x63, 0x31, 0x99, 0x87, 0xC3, 0xFE, 0xEC, 0x80, 0x3D,
  0xBF, 0x99, 0xDC, 0x6C, 0x36, 0x3B, 0x19, 0x8C, 0xCE, 0x7F, 0x3D, 0x80,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x71, 0xFC, 0xE6, 0x63, 0x71, 0xB0, 0xD8,
  0xEC, 0x66, 0x37, 0xF3, 0x70, 0x1E, 0x7D, 0x87, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0xF1, 0xE0, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x3F, 0x9F, 0xC6, 0x73,
  0x8C, 0xC3, 0x31, 0xCC, 0x63, 0x18, 0xCE, 0x3F, 0x8F, 0x60, 0x1E, 0x3E,
  0x67, 0xE6, 0xCE, 0xFC, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C, 0x03, 0xC1, 0xE0,
  0x60, 0x18, 0x0F, 0x87, 0xC0, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x0E, 0x03, 0x00, 0x1E, 0xCF,
  0xE3, 0x39, 0xC6, 0x61, 0x98, 0xE6, 0x31, 0x8C, 0x67, 0x1F, 0xC7, 0xF0,
  0x18, 0x06, 0x23, 0x8F, 0xC1, 0xC0, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x71,
  0xFC, 0xE6, 0x63, 0x71, 0xB1, 0xD8, 0xCC, 0x66, 0x37, 0x3B, 0x1C, 0x18,
  0xC6, 0x03, 0x98, 0xC6, 0x73, 0x98, 0xC6, 0x73, 0x00, 0x03, 0x03, 0x03,
  0x00, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x38, 0xF0, 0xE0, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x39, 0xCC,
  0xE3, 0x70, 0xD8, 0x7C, 0x1F, 0x07, 0xC1, 0xB8, 0x66, 0x39, 0x8C, 0x70,
  0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x00,
  0x37, 0x38, 0xFF, 0xF3, 0x9D, 0xCC, 0x67, 0x73, 0x99, 0x8C, 0x66, 0x31,
  0x98, 0xC6, 0x63, 0x3B, 0x9C, 0xCC, 0x63, 0x00, 0x37, 0x1F, 0xCE, 0x66,
  0x37, 0x1B, 0x1D, 0x8C, 0xC6, 0x63, 0x71, 0xB1, 0xC0, 0x1E, 0x7E, 0x67,
  0xE3, 0xC3, 0xC7, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x1B, 0x87, 0xF1, 0xCC,
  0x63, 0x38, 0xCC, 0x33, 0x1C, 0xC6, 0x31, 0x9F, 0xC6, 0xF1, 0x80, 0x60,
  0x18, 0x0E, 0x03, 0x00, 0x1D, 0xBF, 0x99, 0xDC, 0x6C, 0x36, 0x3B, 0x19,
  0x8C, 0xCE, 0x7F, 0x3F, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x37, 0x3E,
  0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0x1F, 0x3E, 0x70,
  0x70, 0x78, 0x3C, 0x1C, 0x0C, 0x8C, 0xFC, 0xF8, 0x30, 0xC7, 0xFE, 0x61,
  0x86, 0x38, 0xC3, 0x0C, 0x3C, 0xF0, 0x73, 0xB1, 0x98, 0xCC, 0x6E, 0x76,
  0x33, 0x19, 0x8C, 0xCE, 0x7F, 0x3D, 0x00, 0xC3, 0xC7, 0xC6, 0xCE, 0xCC,
  0xCC, 0xD8, 0x58, 0x70, 0x70, 0x60, 0xC7, 0x3E, 0x39, 0xB3, 0xCD, 0x9E,
  0xCD, 0xB6, 0x6D, 0xF3, 0x4F, 0x1E, 0x58, 0xF3, 0x87, 0x1C, 0x38, 0xC0,
  0x38, 0xC6, 0x61, 0xB8, 0x7C, 0x0E, 0x03, 0x81, 0xE0, 0xF8, 0x36, 0x19,
  0xCE, 0x30, 0x18, 0x63, 0x1C, 0x63, 0x0E, 0x60, 0xD8, 0x1B, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x1C, 0x07, 0x00,
  0x1F, 0x9F, 0x81, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x3F, 0x3F,
  0x80, 0x07, 0x0F, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x70, 0xE0, 0x70, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C,
  0x1C, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F, 0x06, 0x1E, 0x18, 0x18, 0x30,
  0x30, 0x30, 0xF0, 0xE0, 0x61, 0xFD, 0x9F,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 11, 14, 10, 0, -14 },
  { 37, 9, 16, 9, 0, -15 },
  { 55, 13, 14, 14, 1, -14 },
  { 78, 11, 14, 11, 0, -14 },
  { 98, 3, 5, 5, 2, -14 },
  { 100, 7, 17, 6, 0, -14 },
  { 115, 7, 17, 6, -2, -14 },
  { 130, 7, 8, 9, 2, -15 },
  { 137, 8, 10, 10, 1, -12 },
  { 147, 4, 5, 5, -1, -2 },
  { 150, 5, 2, 6, 0, -6 },
  { 152, 3, 3, 5, 0, -3 },
  { 154, 10, 14, 7, -1, -14 },
  { 172, 8, 14, 9, 1, -14 },
  { 186, 6, 14, 9, 2, -14 },
  { 197, 10, 14, 9, -1, -14 },
  { 215, 9, 14, 9, 0, -14 },
  { 231, 9, 14, 9, 0, -14 },
  { 247, 9, 14, 9, 0, -14 },
  { 263, 9, 15, 9, 1, -15 },
  { 280, 9, 14, 9, 1, -14 },
  { 296, 9, 14, 9, 0, -14 },
  { 312, 9, 15, 9, 0, -15 },
  { 329, 5, 11, 5, 0, -11 },
  { 336, 6, 14, 5, -1, -11 },
  { 347, 8, 10, 10, 1, -12 },
  { 357, 8, 6, 10, 1, -10 },
  { 363, 8, 10, 10, 1, -12 },
  { 373, 7, 14, 7, 1, -14 },
  { 386, 13, 16, 14, 1, -14 },
  { 412, 10, 14, 10, -1, -14 },
  { 430, 10, 14, 10, 0, -14 },
  { 448, 10, 15, 9, 1, -15 },
  { 467, 11, 14, 11, 0, -14 },
  { 487, 9, 14, 9, 0, -14 },
  { 503, 9, 14, 8, 0, -14 },
  { 519, 11, 15, 11, 1, -15 },
  { 540, 12, 14, 11, 0, -14 },
  { 561, 9, 14, 6, -1, -14 },
  { 577, 9, 18, 5, -3, -14 },
  { 598, 12, 14, 10, 0, -14 },
  { 619, 7, 14, 8, 0, -14 },
  { 632, 15, 14, 15, 0, -14 },
  { 659, 12, 14, 12, 0, -14 },
  { 680, 10, 15, 12, 1, -15 },
  { 699, 10, 14, 10, 0, -14 },
  { 717, 10, 18, 12, 1, -15 },
  { 740, 10, 14, 10, 0, -14 },
  { 758, 9, 14, 9, 0, -14 },
  { 774, 8, 14, 8, 2, -14 },
  { 788, 11, 14, 11, 1, -14 },
  { 808, 9, 14, 10, 2, -14 },
  { 824, 15, 14, 15, 2, -14 },
  { 851, 12, 14, 9, -1, -14 },
  { 872, 9, 14, 9, 2, -14 },
  { 888, 11, 14, 8, -1, -14 },
  { 908, 8, 17, 6, -1, -14 },
  { 925, 4, 14, 7, 2, -14 },
  { 932, 7, 17, 6, -1, -14 },
  { 947, 9, 8, 9, 0, -14 },
  { 956, 7, 1, 7, -2, 2 },
  { 957, 3, 3, 6, 3, -15 },
  { 959, 9, 11, 10, 1, -11 },
  { 972, 9, 15, 10, 0, -15 },
  { 989, 7, 11, 8, 1, -11 },
  { 999, 10, 15, 10, 1, -15 },
  { 1018, 8, 11, 9, 1, -11 },
  { 1029, 10, 20, 6, -2, -15 },
  { 1054, 10, 16, 10, 0, -11 },
  { 1074, 9, 15, 10, 0, -15 },
  { 1091, 5, 15, 5, 0, -15 },
  { 1101, 8, 20, 5, -3, -15 },
  { 1121, 10, 15, 9, 0, -15 },
  { 1140, 6, 15, 5, 0, -15 },
  { 1152, 14, 11, 14, 0, -11 },
  { 1172, 9, 11, 10, 0, -11 },
  { 1185, 8, 11, 10, 1, -11 },
  { 1196, 10, 16, 10, -1, -11 },
  { 1216, 9, 16, 10, 1, -11 },
  { 1234, 8, 11, 7, 0, -11 },
  { 1245, 8, 11, 8, 0, -11 },
  { 1256, 6, 13, 6, 1, -13 },
  { 1266, 9, 11, 10, 1, -11 },
  { 1279, 8, 11, 8, 1, -11 },
  { 1290, 13, 11, 13, 1, -11 },
  { 1308, 10, 11, 8, -1, -11 },
  { 1322, 11, 16, 8, -2, -11 },
  { 1344, 9, 11, 7, -1, -11 },
  { 1357, 8, 17, 7, 0, -14 },
  { 1374, 2, 20, 8, 3, -15 },
  { 1379, 8, 17, 7, -1, -14 },
  { 1396, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC20PT7B_H_
