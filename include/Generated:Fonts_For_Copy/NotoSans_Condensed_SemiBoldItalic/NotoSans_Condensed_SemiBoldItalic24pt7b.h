#ifndef _NOTOSANS_CONDENSED_SEMIBOLDITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x60, 0xC3, 0x80,
  0x00, 0x18, 0x78, 0xE0, 0x77, 0x77, 0x67, 0x66, 0x66, 0xE6, 0x03, 0x30,
  0x39, 0x81, 0x98, 0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98, 0x18,
  0xC0, 0xCC, 0x3F, 0xF9, 0xFF, 0xC3, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0xC0,
  0x66, 0x00, 0x01, 0x80, 0x20, 0x3F, 0x8F, 0xF1, 0xB4, 0x74, 0x0E, 0x81,
  0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x02, 0xE0, 0x5D, 0x1B, 0xBE, 0xE7, 0xFC,
  0x7E, 0x01, 0x00, 0x60, 0x00, 0x1E, 0x0C, 0x7C, 0x31, 0x98, 0xC3, 0x31,
  0x86, 0x66, 0x1C, 0xCC, 0x33, 0xB2, 0x66, 0xEF, 0xFD, 0xBE, 0xF6, 0xEC,
  0x0D, 0x98, 0x33, 0x30, 0xE6, 0x61, 0x8C, 0xC6, 0x1B, 0x0C, 0x3E, 0x30,
  0x78, 0x07, 0xC0, 0x7F, 0x03, 0x38, 0x39, 0xC1, 0xCC, 0x0E, 0xE0, 0x3E,
  0x01, 0xE0, 0x1E, 0x39, 0xF9, 0x9D, 0xDD, 0xC7, 0xCE, 0x3E, 0x70, 0xE3,
  0x8F, 0x0F, 0xFC, 0x7E, 0xF0, 0x77, 0x66, 0x6E, 0x07, 0x0C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x1C, 0x38, 0x30,
  0x70, 0xE0, 0x0E, 0x06, 0x1B, 0x1F, 0xF3, 0xF8, 0xE1, 0xD8, 0xEC, 0x27,
  0x02, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x39, 0x9C, 0xCE, 0x60, 0x7D, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x00, 0x0F, 0x87, 0xE3, 0x9C, 0xC7, 0x71, 0xDC, 0x7E, 0x1F,
  0x87, 0xE1, 0xB8, 0xEC, 0x3B, 0x0E, 0xC3, 0x31, 0xCE, 0xE3, 0xF8, 0x7C,
  0x00, 0x07, 0x0F, 0x3E, 0x76, 0xEE, 0x4E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x07, 0xE1, 0xFE, 0x0C, 0x70, 0x87,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xC3, 0xFC, 0x63,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0xFC, 0x1F, 0x00, 0xF0, 0x06, 0x00,
  0xE0, 0x1C, 0x07, 0x21, 0xE7, 0xF8, 0xFE, 0x00, 0x00, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x7C, 0x1B, 0x87, 0x70, 0xCC, 0x31, 0x8E, 0x71, 0x8E, 0x7F,
  0xEF, 0xFC, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x0F, 0xE1, 0xFC, 0x70,
  0x0E, 0x01, 0x80, 0x70, 0x0F, 0x81, 0xFC, 0x3F, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x31, 0xE7, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x70,
  0x1C, 0x03, 0x00, 0xE0, 0x1B, 0xC7, 0xFC, 0xF3, 0x9C, 0x73, 0x8E, 0x71,
  0xCC, 0x39, 0xC6, 0x39, 0xC7, 0xF0, 0x7C, 0x00, 0x3F, 0xEF, 0xFC, 0x03,
  0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0x73,
  0x9C, 0x73, 0x8E, 0x31, 0xC7, 0x70, 0x7C, 0x1F, 0x07, 0x71, 0xC7, 0x70,
  0xEE, 0x1D, 0xC3, 0xB8, 0xE3, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xF8, 0xF3,
  0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x8F, 0x3B, 0xC7, 0xF8, 0x77, 0x00,
  0xC0, 0x38, 0x06, 0x23, 0xC7, 0xF0, 0xFC, 0x00, 0x18, 0xF3, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x38, 0xE0, 0x0E, 0x3C, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0x87, 0x0C, 0x38, 0x60, 0x00, 0xC0, 0xF0, 0xF8,
  0x78, 0x78, 0x38, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x70, 0x04, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x70, 0x7C, 0x7C, 0x7C, 0x38, 0x08, 0x00, 0x3F, 0x3F, 0x98,
  0xE0, 0x60, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x0C, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0x78, 0x70, 0x38, 0xC0,
  0x33, 0x0E, 0x6C, 0x7E, 0xD9, 0x99, 0xB3, 0x33, 0xCC, 0x67, 0x98, 0xCF,
  0x33, 0x1E, 0x66, 0x6C, 0xDD, 0xD9, 0xEF, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x40, 0x7F, 0x80, 0x7E, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x7E,
  0x0D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x9C, 0xFF, 0x9F, 0xF3, 0x0E, 0xE1,
  0xDC, 0x1F, 0x03, 0xE0, 0x60, 0x0F, 0xE1, 0xFF, 0x1C, 0xF1, 0xC7, 0x1C,
  0x71, 0x87, 0x38, 0xE3, 0xFC, 0x3F, 0xC3, 0x9C, 0x30, 0xE7, 0x0E, 0x70,
  0xE7, 0x1C, 0x63, 0xCF, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x1E, 0x23,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x71, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFF,
  0x87, 0x3C, 0x38, 0xF1, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x0E, 0x38, 0xF1, 0xDF, 0x1F, 0xF0, 0xFE,
  0x00, 0x0F, 0xE3, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xFE,
  0x3F, 0x87, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xE3, 0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x3F, 0x87, 0xF0, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x00, 0x07, 0xF8, 0x7F, 0x87, 0x84, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE3, 0xF7, 0x1F, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x71,
  0xE7, 0x0F, 0xF8, 0x3F, 0xC0, 0x0E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x06,
  0x1C, 0x38, 0x60, 0xE3, 0x83, 0x8F, 0xFE, 0x3F, 0xF0, 0xE1, 0xC3, 0x07,
  0x1C, 0x1C, 0x70, 0x61, 0xC3, 0x87, 0x0E, 0x38, 0x38, 0xE0, 0xE0, 0x0F,
  0xC7, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x83, 0xF8, 0xFE, 0x00, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x3E,
  0x0F, 0xC1, 0xE0, 0x00, 0x0E, 0x3C, 0x71, 0xE1, 0xC7, 0x07, 0x38, 0x1D,
  0xC0, 0x67, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xB8, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x06, 0x1C, 0x18, 0x70, 0xE1, 0xC0, 0x0E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70,
  0x70, 0xFF, 0xFF, 0x0F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x3E,
  0x1F, 0x0D, 0x87, 0xC3, 0xE3, 0xB1, 0xB8, 0xEC, 0x6E, 0x3B, 0x3B, 0x0C,
  0xCD, 0xC3, 0x37, 0x71, 0xCD, 0x9C, 0x73, 0xE6, 0x1C, 0xF1, 0x86, 0x3C,
  0xE1, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x0E, 0x0E, 0x3C, 0x1C, 0x7C, 0x30,
  0xF8, 0x61, 0xF1, 0xC3, 0x63, 0x8E, 0xC7, 0x1D, 0xCC, 0x3B, 0x98, 0x63,
  0x70, 0xC6, 0xE3, 0x8F, 0xC7, 0x1F, 0x0E, 0x3E, 0x18, 0x3C, 0x70, 0x78,
  0xE0, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0x1C, 0x70, 0xF3, 0x83, 0xB8, 0x1D,
  0xC0, 0xFE, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70,
  0xF1, 0xCF, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0xF1, 0xC7,
  0x1C, 0x71, 0x87, 0x38, 0x73, 0x8E, 0x3F, 0xE3, 0xFC, 0x3F, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x87,
  0x1C, 0x70, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x77, 0x03,
  0xB8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0xF1, 0xCF, 0x0F, 0xF0, 0x3F, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xC1, 0xFE, 0x1C, 0xF1,
  0xC7, 0x1C, 0x71, 0x87, 0x38, 0xE3, 0x9E, 0x3F, 0xC3, 0xF8, 0x33, 0x87,
  0x38, 0x73, 0x87, 0x18, 0x61, 0xC6, 0x1C, 0xE1, 0xC0, 0x0F, 0xE3, 0xFC,
  0x71, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x31, 0xE7, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xF1,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x39, 0xC1, 0xCE, 0x0C,
  0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x07, 0x38,
  0x39, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0xCE, 0x0F, 0xF0, 0x3F, 0x00, 0xE0,
  0xFE, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE7,
  0x0E, 0x60, 0x6E, 0x06, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x00, 0xE0, 0xC1, 0xF8, 0x70, 0xEE, 0x1C, 0x3B, 0x8F, 0x0C, 0xE3, 0xC7,
  0x39, 0xF1, 0xCE, 0x6C, 0xE3, 0x9B, 0x38, 0xEE, 0xCC, 0x3B, 0x37, 0x0F,
  0xCD, 0xC3, 0xE3, 0xE0, 0xD8, 0xF8, 0x3E, 0x3C, 0x0F, 0x0F, 0x03, 0xC3,
  0x80, 0xE0, 0xE0, 0x00, 0x0E, 0x1C, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x06,
  0xE0, 0x1B, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0x60, 0x19, 0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0xE0, 0xE0, 0xE1, 0xFC,
  0x39, 0x8E, 0x31, 0xC7, 0x70, 0xEC, 0x1F, 0x83, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x10, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x4F, 0xF8, 0xFF, 0x80,
  0x07, 0xC3, 0xE0, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0xF0, 0xF8, 0x00, 0xE3, 0x18, 0xC6, 0x39, 0xCE, 0x31, 0x8C, 0x63, 0x9C,
  0xE3, 0x18, 0x07, 0xC3, 0xE0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0xC1, 0xF0, 0xF8, 0x00, 0x03, 0x00, 0xE0, 0x1E, 0x06, 0xC0, 0xD8,
  0x33, 0x8E, 0x31, 0x86, 0x70, 0xDC, 0x1C, 0xFF, 0xFF, 0xF3, 0x8E, 0x1E,
  0xE7, 0xF9, 0xEF, 0x38, 0xEE, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x9C,
  0xF3, 0x9C, 0x7D, 0x87, 0xB0, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x37, 0x87, 0xF9, 0xE7, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x77, 0x0E, 0xE3,
  0x9C, 0x73, 0x9C, 0xFF, 0x99, 0xE0, 0x1F, 0x9F, 0x9E, 0x4E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x9F, 0xC7, 0xC0, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xEE, 0x3F, 0xC7, 0xBC, 0x71, 0xCE, 0x1C,
  0xE1, 0x8E, 0x18, 0xE3, 0x8C, 0x38, 0xC3, 0x8E, 0x70, 0xFF, 0x07, 0xB0,
  0x1F, 0x1F, 0xDC, 0x6E, 0x3E, 0x3F, 0xFB, 0xF9, 0x80, 0xC0, 0x60, 0x38,
  0x5F, 0xC7, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x70, 0x07, 0x00, 0x38, 0x03,
  0xF0, 0x3F, 0x80, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x7C, 0x03, 0xE0, 0x1C, 0x00, 0x0F, 0x71, 0xFE, 0x3D, 0xE3, 0x8E,
  0x70, 0xE7, 0x0E, 0x70, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0x73, 0x87, 0xD8,
  0x3F, 0x80, 0x38, 0x03, 0x80, 0x70, 0xFF, 0x0F, 0xE0, 0x78, 0x00, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x37, 0x87, 0xF9, 0xE7, 0x38, 0xE7,
  0x1C, 0xC3, 0x38, 0x67, 0x1C, 0xE3, 0x9C, 0x73, 0x0C, 0xE3, 0x9C, 0x70,
  0x0C, 0x3C, 0x70, 0x00, 0x03, 0x8E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E,
  0x1C, 0x30, 0xE1, 0xC0, 0x01, 0x80, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x3E, 0x0F, 0x03, 0x80, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x8F, 0x18, 0xC3, 0x9C, 0x3B, 0x83,
  0x70, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0x70, 0x67, 0x06, 0x38, 0xE3, 0x8E,
  0x38, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0xE1, 0xC0, 0x1B, 0xCF, 0x1F, 0xFF, 0x8F, 0x3C, 0xE7,
  0x1C, 0x73, 0x8E, 0x31, 0x86, 0x39, 0xC7, 0x1C, 0xE3, 0x8E, 0x71, 0xC6,
  0x30, 0xC3, 0x18, 0x63, 0x9C, 0x71, 0xCE, 0x38, 0xE0, 0x1B, 0xC7, 0xFC,
  0xF3, 0x9C, 0x73, 0x8E, 0x61, 0x9C, 0x33, 0x8E, 0x71, 0xCE, 0x39, 0x86,
  0x70, 0xCE, 0x38, 0x1F, 0x0F, 0xE7, 0x99, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F,
  0x86, 0xC3, 0xB0, 0xEE, 0x73, 0xF8, 0x7C, 0x00, 0x0D, 0xE0, 0xFF, 0x1E,
  0x71, 0xC7, 0x1C, 0x71, 0x87, 0x38, 0x73, 0x87, 0x38, 0xE3, 0x8E, 0x39,
  0xC7, 0xFC, 0x77, 0x87, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x1E, 0xE7, 0xF9, 0xE7, 0x38, 0xEE, 0x1D, 0xC3, 0x38, 0x67, 0x1C,
  0xC3, 0x98, 0x73, 0x9C, 0x7F, 0x87, 0xF0, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x1B, 0x9F, 0xCF, 0xC7, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x00, 0x1F, 0x9F, 0xCC, 0x4E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xA3, 0x9F, 0xCF, 0xC0, 0x18, 0x30,
  0xE3, 0xFF, 0xEE, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x3E, 0x7C,
  0x30, 0xEE, 0x19, 0xC7, 0x38, 0xE6, 0x1C, 0xC3, 0x38, 0xE7, 0x1C, 0xE3,
  0x9C, 0xF3, 0x9C, 0x7D, 0x87, 0xB0, 0xE1, 0xF8, 0x6E, 0x39, 0x8C, 0x67,
  0x19, 0xC6, 0xE1, 0xB8, 0x6C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x00, 0xE3,
  0x87, 0xE3, 0x8E, 0xE7, 0x8C, 0xE7, 0x9C, 0xE7, 0x9C, 0xED, 0x98, 0xED,
  0xB8, 0xFD, 0xB0, 0xF9, 0xB0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1,
  0xC0, 0x1C, 0x71, 0xCE, 0x1C, 0xC0, 0xDC, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x03, 0xB8, 0x33, 0x87, 0x38, 0xE1, 0xC0, 0x1C, 0x38, 0x61,
  0x83, 0x1C, 0x18, 0xE0, 0xCE, 0x06, 0x70, 0x33, 0x01, 0xB8, 0x0D, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0xF8,
  0x07, 0x80, 0x38, 0x00, 0x1F, 0xC7, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xC1, 0xE0,
  0x70, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x1E, 0x0E, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x03, 0xC0, 0xF0, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x0F, 0x01, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x1C, 0x0E, 0x03, 0xC1, 0xE1, 0xE1, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x1C, 0x3C, 0x1E, 0x0C, 0x00, 0x7C, 0x7F, 0xF8, 0x7C,
};

const GFXglyph NotoSans_Condensed_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 8, 6, 9, 2, -17 },
  { 22, 13, 17, 12, 0, -17 },
  { 50, 11, 19, 11, 0, -18 },
  { 77, 15, 17, 17, 1, -17 },
  { 109, 13, 17, 13, 0, -17 },
  { 137, 4, 6, 5, 2, -17 },
  { 140, 8, 21, 7, 1, -17 },
  { 161, 8, 21, 7, -2, -17 },
  { 182, 9, 10, 11, 2, -18 },
  { 194, 10, 11, 12, 1, -14 },
  { 208, 5, 6, 6, -1, -3 },
  { 212, 6, 3, 7, 0, -8 },
  { 215, 4, 3, 6, 0, -3 },
  { 217, 12, 17, 9, -1, -17 },
  { 243, 10, 17, 11, 1, -17 },
  { 265, 8, 17, 11, 2, -17 },
  { 282, 12, 17, 11, -1, -17 },
  { 308, 11, 17, 11, 0, -17 },
  { 332, 11, 17, 11, 0, -17 },
  { 356, 11, 17, 11, 0, -17 },
  { 380, 11, 17, 11, 1, -17 },
  { 404, 11, 17, 11, 1, -17 },
  { 428, 11, 17, 11, 0, -17 },
  { 452, 11, 17, 11, 0, -17 },
  { 476, 6, 13, 6, 0, -13 },
  { 486, 7, 16, 6, -1, -13 },
  { 500, 10, 11, 12, 1, -14 },
  { 514, 10, 7, 12, 1, -12 },
  { 523, 10, 11, 12, 1, -14 },
  { 537, 9, 17, 9, 1, -17 },
  { 557, 15, 19, 17, 1, -17 },
  { 593, 11, 17, 12, -1, -17 },
  { 617, 12, 17, 12, 0, -17 },
  { 643, 12, 17, 11, 1, -17 },
  { 669, 13, 17, 13, 0, -17 },
  { 697, 11, 17, 10, 0, -17 },
  { 721, 11, 17, 10, 0, -17 },
  { 745, 13, 17, 14, 1, -17 },
  { 773, 14, 17, 14, 0, -17 },
  { 803, 10, 17, 8, -1, -17 },
  { 825, 11, 22, 6, -4, -17 },
  { 856, 14, 17, 12, 0, -17 },
  { 886, 8, 17, 10, 0, -17 },
  { 903, 18, 17, 18, 0, -17 },
  { 942, 15, 17, 14, 0, -17 },
  { 974, 13, 17, 14, 1, -17 },
  { 1002, 12, 17, 12, 0, -17 },
  { 1028, 13, 21, 14, 1, -17 },
  { 1063, 12, 17, 12, 0, -17 },
  { 1089, 11, 17, 10, 0, -17 },
  { 1113, 10, 17, 10, 2, -17 },
  { 1135, 13, 17, 13, 1, -17 },
  { 1163, 12, 17, 12, 2, -17 },
  { 1189, 18, 17, 18, 2, -17 },
  { 1228, 14, 17, 11, -1, -17 },
  { 1258, 11, 17, 11, 2, -17 },
  { 1282, 12, 17, 10, -1, -17 },
  { 1308, 10, 21, 7, -1, -17 },
  { 1335, 5, 17, 9, 2, -17 },
  { 1346, 10, 21, 7, -2, -17 },
  { 1373, 11, 10, 11, 0, -17 },
  { 1387, 8, 2, 8, -2, 2 },
  { 1389, 5, 3, 7, 3, -18 },
  { 1391, 11, 13, 12, 1, -13 },
  { 1409, 11, 18, 12, 0, -18 },
  { 1434, 9, 13, 9, 1, -13 },
  { 1449, 12, 18, 12, 1, -18 },
  { 1476, 9, 13, 11, 1, -13 },
  { 1491, 13, 24, 7, -3, -18 },
  { 1530, 12, 19, 12, 0, -13 },
  { 1559, 11, 18, 12, 0, -18 },
  { 1584, 7, 18, 6, 0, -18 },
  { 1600, 10, 24, 6, -3, -18 },
  { 1630, 12, 18, 11, 0, -18 },
  { 1657, 7, 18, 6, 0, -18 },
  { 1673, 17, 13, 17, 0, -13 },
  { 1701, 11, 13, 12, 0, -13 },
  { 1719, 10, 13, 11, 1, -13 },
  { 1736, 12, 19, 12, -1, -13 },
  { 1765, 11, 19, 12, 1, -13 },
  { 1792, 9, 13, 8, 0, -13 },
  { 1807, 9, 13, 9, 0, -13 },
  { 1822, 7, 16, 7, 1, -16 },
  { 1836, 11, 13, 12, 1, -13 },
  { 1854, 10, 13, 10, 1, -13 },
  { 1871, 16, 13, 15, 1, -13 },
  { 1897, 12, 13, 10, -1, -13 },
  { 1917, 13, 19, 10, -2, -13 },
  { 1948, 10, 13, 9, -1, -13 },
  { 1965, 10, 21, 8, 0, -17 },
  { 1992, 2, 24, 10, 4, -18 },
  { 1998, 9, 21, 8, -1, -17 },
  { 2022, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_SEMIBOLDITALIC24PT7B_H_
