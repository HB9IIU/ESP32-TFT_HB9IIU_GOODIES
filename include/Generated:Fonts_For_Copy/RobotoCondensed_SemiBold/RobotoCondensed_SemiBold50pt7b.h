#ifndef _ROBOTOCONDENSED_SEMIBOLD50PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x9F, 0x7F, 0xFF, 0xFD, 0xF1, 0xE0, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0E, 0xF0, 0xE0, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x00, 0x7C,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0xC1, 0xFC, 0x7F, 0x9F, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x78, 0xF8, 0x18, 0x07, 0x87, 0x81, 0xE0, 0xF8,
  0x78, 0x3C, 0x0F, 0x87, 0xC3, 0xC0, 0xF8, 0x7C, 0x78, 0x0F, 0x87, 0xC7,
  0x80, 0xF8, 0x78, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0x7C, 0xF9, 0xE0, 0x07,
  0xFF, 0xBE, 0x00, 0x3F, 0xF3, 0xC0, 0x01, 0xFE, 0x78, 0x00, 0x0F, 0xC7,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x1E, 0x7F, 0x80, 0x03, 0xCF, 0xFC, 0x00, 0x3D, 0xFF, 0xE0, 0x07,
  0x9F, 0x1E, 0x00, 0x79, 0xE1, 0xE0, 0x0F, 0x1E, 0x1F, 0x00, 0xF1, 0xE1,
  0xF0, 0x1E, 0x1E, 0x1F, 0x03, 0xE1, 0xE1, 0xF0, 0x3C, 0x1E, 0x1F, 0x07,
  0x81, 0xE1, 0xE0, 0x38, 0x1F, 0x1E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xF3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x7C, 0x3F, 0xFE, 0x3F, 0x1F, 0xFF, 0x8F, 0xC7, 0xE7, 0xF3, 0xF3, 0xF8,
  0xFE, 0xFC, 0xFC, 0x1F, 0xFE, 0x3F, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xE3,
  0xF0, 0x1F, 0xF0, 0xFE, 0x07, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF3, 0xF8, 0x1F, 0xF8, 0xFE, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x20, 0x06, 0x01, 0xE0, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0E, 0x00, 0x20, 0x40,
  0x07, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x78,
  0x07, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xC3, 0xC1, 0xDF, 0x8E,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x8F,
  0x80, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0x1C, 0x07, 0x00, 0x40, 0x20, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7C, 0xFC, 0xF8, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFE, 0x3F,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE7, 0xF9, 0xFE, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0x7F, 0x9F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0,
  0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xE1, 0xFE, 0x1C, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xE0, 0xFE, 0x7F, 0x1F, 0xE7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x0F, 0xDF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF9, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7,
  0xF0, 0xFE, 0x7F, 0x9F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE,
  0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x0F,
  0xE7, 0xE0, 0xFC, 0x7F, 0x1F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x1F, 0xCF, 0xE0, 0xFE, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xE0, 0xFE, 0xFF, 0x1F, 0xE7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF9,
  0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x7F, 0x8F, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFB, 0xF0, 0x3E, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3,
  0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x3C, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0x3F, 0xDF, 0xC3, 0xFB, 0xF0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x03, 0xC1, 0xF0, 0x0F, 0xC0, 0x78, 0x78, 0x0F, 0xF8, 0x1E, 0x3E,
  0x07, 0xFF, 0x87, 0x8F, 0x01, 0xFF, 0xE0, 0xE3, 0xC0, 0xF8, 0xF8, 0x3D,
  0xF0, 0x7C, 0x3E, 0x0F, 0x78, 0x1F, 0x0F, 0x83, 0xDE, 0x0F, 0x83, 0xE0,
  0xF7, 0x83, 0xE0, 0xF8, 0x3D, 0xE0, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0x03, 0xFE, 0x1F, 0x03, 0xC0, 0xFF, 0x87, 0xC0, 0xF0, 0x3F, 0xE1, 0xF0,
  0x3C, 0x0F, 0xF0, 0x7C, 0x0F, 0x03, 0xFC, 0x1F, 0x03, 0xC0, 0xFF, 0x07,
  0xC0, 0xF0, 0x3F, 0xE1, 0xF0, 0x7C, 0x0E, 0xF8, 0x7C, 0x1F, 0x07, 0xBE,
  0x1F, 0x07, 0xC1, 0xE7, 0x83, 0xE3, 0xF0, 0xF1, 0xE0, 0xFF, 0xFE, 0x7C,
  0x78, 0x3F, 0xFF, 0xFE, 0x1F, 0x07, 0xF9, 0xFF, 0x07, 0xC0, 0xFC, 0x3F,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0x00, 0x01, 0xFE, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xF8, 0x7F, 0xEF, 0xE0,
  0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0xFF, 0xBF, 0xF0, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x07,
  0xE3, 0xF0, 0x07, 0xF1, 0xFC, 0x07, 0xF8, 0x7F, 0xCF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xC7, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x00,
  0xFC, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0,
  0x1F, 0x9F, 0xC0, 0xFF, 0x3F, 0x8F, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x80,
  0x1F, 0x9F, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03,
  0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0xDF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFF,
  0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F,
  0xC3, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7,
  0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xFE, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xBF, 0xFD, 0xF0, 0x0F,
  0xBF, 0xFD, 0xF8, 0x1F, 0xBF, 0xFD, 0xF8, 0x1F, 0x3F, 0xFD, 0xF8, 0x1F,
  0x3F, 0xFC, 0xF8, 0x3F, 0x3F, 0xFC, 0xFC, 0x3F, 0x3F, 0xFC, 0xFC, 0x3E,
  0x3F, 0xFC, 0x7C, 0x7E, 0x7F, 0xFC, 0x7E, 0x7E, 0x7F, 0xFC, 0x7E, 0x7C,
  0x7F, 0xFC, 0x3E, 0x7C, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8,
  0x7F, 0xFC, 0x1F, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xFC, 0x1F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0,
  0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xC1,
  0xFF, 0xF7, 0xF0, 0xFF, 0xF9, 0xF8, 0x7F, 0xFC, 0xFE, 0x3F, 0xFE, 0x3F,
  0x1F, 0xFF, 0x1F, 0xCF, 0xFF, 0x87, 0xE7, 0xFF, 0xC3, 0xFB, 0xFF, 0xE0,
  0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF,
  0xBF, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFC,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xC3,
  0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F,
  0xBF, 0x80, 0x7F, 0x7F, 0x01, 0xFC, 0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xF9, 0xFF, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xDF, 0xE0, 0x3F, 0x9F, 0xFB, 0xFF, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x7E,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E,
  0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFE, 0x7E, 0x03, 0xF8,
  0x0F, 0xE7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x03, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0xC0, 0xFC, 0x3F, 0x03, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0xC0, 0xFC,
  0x3F, 0x07, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xE1, 0xF8, 0x1F, 0x87, 0xFE,
  0x1F, 0x81, 0xF8, 0x7F, 0xE1, 0xF8, 0x1F, 0x8F, 0xFE, 0x1F, 0x81, 0xF8,
  0xFB, 0xF1, 0xF8, 0x1F, 0x8F, 0x9F, 0x3F, 0x81, 0xF8, 0xF9, 0xF3, 0xF0,
  0x0F, 0xCF, 0x9F, 0x3F, 0x00, 0xFD, 0xF9, 0xF3, 0xF0, 0x0F, 0xDF, 0x1F,
  0xBF, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xE7,
  0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1E, 0xF0, 0x0F, 0x7C, 0x0F, 0x9E, 0x07, 0xCF, 0x83,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x0F,
  0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x7F, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x1F, 0xF7, 0xE0, 0x7C, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x7E, 0x0F, 0xDF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xF9, 0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7E, 0xFF, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFD, 0xFF, 0x0F, 0xC7, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7E, 0x07, 0xEF,
  0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x8F, 0xE7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE3, 0xF1, 0xFF, 0xBF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF9, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x8F, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFB, 0xF0, 0x7E, 0x3F, 0x01, 0xFC,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF8,
  0xFE, 0x7E, 0x07, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x47, 0xF0, 0x0C,
  0x7F, 0xC3, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF8, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFC, 0xFF, 0x7F, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0xCF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFB, 0xF0, 0x3E, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF1, 0x80, 0x7F, 0x1E, 0x0F, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xC1, 0xFB, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xC0, 0x39, 0xFB, 0xF7, 0xFF, 0xDF, 0x9E,
  0x00, 0x00, 0x03, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xE0, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x78, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x3F, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x7E, 0x0F,
  0xF3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x3F,
  0x3F, 0x81, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0,
  0x7F, 0x7E, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x7E, 0x07,
  0xE1, 0xFB, 0xFE, 0x1F, 0xF3, 0xFF, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x3F, 0xFF, 0x83, 0xFC, 0x1F,
  0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF,
  0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF,
  0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0x03,
  0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F,
  0xC0, 0xFC, 0xF8, 0x7E, 0x1F, 0xBF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFE, 0x7F, 0xBF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0,
  0x7E, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x7E, 0x0F, 0xDF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xEF, 0xF1, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFE, 0xFF, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFD, 0xFF, 0x0F, 0xC7, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF1, 0xFF, 0xBF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xF8, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x8F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFB, 0xF0, 0x7E, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x3F, 0xBF, 0x83, 0xF7, 0xE0, 0x7F, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0xD1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF8,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xF7, 0xE1,
  0xF8, 0xFC, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xF7, 0xE0, 0x7E,
  0x7E, 0x07, 0xE7, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0x81, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xF9,
  0xF8, 0x0F, 0xDF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0xFF, 0xF0,
  0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x1F,
  0xC1, 0xF9, 0xF8, 0x7F, 0x87, 0xE7, 0xE1, 0xFE, 0x1F, 0x0F, 0x87, 0xF8,
  0xFC, 0x3F, 0x3F, 0xE3, 0xF0, 0xFC, 0xFF, 0xCF, 0xC3, 0xF3, 0xFF, 0x3F,
  0x0F, 0xCF, 0xFC, 0xF8, 0x1F, 0x7C, 0xF3, 0xE0, 0x7D, 0xF3, 0xFF, 0x81,
  0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xFE, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xEF,
  0xC0, 0x3F, 0x7E, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xBF, 0x01, 0xF9, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC,
  0x7E, 0x07, 0xF7, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC, 0x1F, 0x9F, 0x81, 0xF9, 0xF8,
  0x1F, 0x9F, 0x80, 0xFB, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x30, 0x07, 0x80, 0x7C, 0x07, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x7F, 0x83, 0xF8,
  0x1F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x80, 0xF8, 0x03, 0xC0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x60, 0x03, 0xC0, 0x1F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC3, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xE0, 0x0C, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xC0, 0x7C, 0xFF, 0xC0, 0xFB, 0xFF, 0x81, 0xE7, 0xFF, 0x87, 0xDF,
  0x9F, 0xDF, 0xBE, 0x1F, 0xFF, 0x7C, 0x1F, 0xFC, 0xF0, 0x1F, 0xF1, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 36, 13, 3, -36 },
  { 33, 12, 13, 16, 2, -38 },
  { 53, 23, 36, 27, 2, -36 },
  { 157, 21, 46, 25, 2, -41 },
  { 278, 28, 36, 32, 2, -36 },
  { 404, 26, 37, 29, 2, -36 },
  { 525, 5, 13, 8, 2, -38 },
  { 534, 12, 51, 16, 3, -40 },
  { 611, 12, 51, 16, 1, -40 },
  { 688, 21, 21, 22, 1, -36 },
  { 744, 20, 26, 24, 2, -30 },
  { 809, 8, 14, 12, 1, -6 },
  { 823, 11, 5, 17, 3, -18 },
  { 830, 8, 7, 14, 3, -7 },
  { 837, 16, 39, 17, 0, -36 },
  { 915, 21, 36, 25, 2, -36 },
  { 1010, 13, 36, 25, 4, -36 },
  { 1069, 21, 36, 25, 2, -36 },
  { 1164, 20, 36, 25, 2, -36 },
  { 1254, 21, 36, 25, 2, -36 },
  { 1349, 20, 36, 25, 3, -36 },
  { 1439, 20, 36, 25, 3, -36 },
  { 1529, 21, 36, 25, 2, -36 },
  { 1624, 20, 36, 25, 3, -36 },
  { 1714, 20, 36, 25, 2, -36 },
  { 1804, 8, 27, 13, 3, -27 },
  { 1831, 9, 35, 12, 1, -27 },
  { 1871, 17, 23, 22, 2, -27 },
  { 1920, 19, 16, 25, 3, -24 },
  { 1958, 18, 23, 23, 3, -27 },
  { 2010, 19, 36, 22, 1, -36 },
  { 2096, 34, 46, 38, 2, -35 },
  { 2292, 28, 36, 30, 1, -36 },
  { 2418, 22, 36, 28, 3, -36 },
  { 2517, 25, 36, 28, 2, -36 },
  { 2630, 23, 36, 28, 3, -36 },
  { 2734, 20, 36, 25, 3, -36 },
  { 2824, 19, 36, 24, 3, -36 },
  { 2910, 25, 36, 29, 2, -36 },
  { 3023, 25, 36, 31, 3, -36 },
  { 3136, 7, 36, 13, 3, -36 },
  { 3168, 20, 36, 24, 1, -36 },
  { 3258, 25, 36, 28, 3, -36 },
  { 3371, 20, 36, 24, 3, -36 },
  { 3461, 32, 36, 38, 3, -36 },
  { 3605, 25, 36, 31, 3, -36 },
  { 3718, 26, 36, 30, 2, -36 },
  { 3835, 23, 36, 28, 3, -36 },
  { 3939, 26, 42, 30, 2, -36 },
  { 4076, 23, 36, 27, 3, -36 },
  { 4180, 23, 36, 27, 2, -36 },
  { 4284, 25, 36, 27, 1, -36 },
  { 4397, 23, 36, 28, 3, -36 },
  { 4501, 27, 36, 29, 1, -36 },
  { 4623, 36, 36, 38, 1, -36 },
  { 4785, 26, 36, 28, 1, -36 },
  { 4902, 26, 36, 27, 0, -36 },
  { 5019, 23, 36, 26, 2, -36 },
  { 5123, 9, 49, 13, 3, -41 },
  { 5179, 19, 39, 19, 0, -36 },
  { 5272, 9, 49, 13, 1, -41 },
  { 5328, 17, 18, 19, 1, -36 },
  { 5367, 19, 5, 20, 1, 0 },
  { 5379, 12, 7, 16, 1, -37 },
  { 5390, 20, 26, 24, 2, -26 },
  { 5455, 20, 38, 25, 3, -38 },
  { 5550, 20, 26, 23, 2, -26 },
  { 5615, 20, 38, 25, 2, -38 },
  { 5710, 20, 26, 24, 2, -26 },
  { 5775, 15, 39, 16, 1, -39 },
  { 5849, 20, 36, 25, 2, -26 },
  { 5939, 19, 38, 25, 3, -38 },
  { 6030, 7, 36, 12, 3, -36 },
  { 6062, 10, 46, 12, -1, -36 },
  { 6120, 21, 38, 24, 3, -38 },
  { 6220, 6, 38, 12, 3, -38 },
  { 6249, 31, 26, 37, 3, -26 },
  { 6350, 19, 26, 25, 3, -26 },
  { 6412, 21, 26, 25, 2, -26 },
  { 6481, 20, 36, 25, 3, -26 },
  { 6571, 20, 36, 25, 2, -26 },
  { 6661, 12, 26, 16, 3, -26 },
  { 6700, 19, 26, 23, 2, -26 },
  { 6762, 13, 33, 15, 1, -33 },
  { 6816, 19, 26, 24, 3, -26 },
  { 6878, 20, 26, 22, 1, -26 },
  { 6943, 30, 26, 32, 1, -26 },
  { 7041, 21, 26, 22, 1, -26 },
  { 7110, 20, 36, 22, 1, -26 },
  { 7200, 18, 26, 22, 2, -26 },
  { 7259, 13, 48, 15, 1, -39 },
  { 7337, 4, 43, 13, 4, -36 },
  { 7359, 13, 48, 15, 1, -39 },
  { 7437, 23, 11, 28, 3, -20 },
};

const GFXfont RobotoCondensed_SemiBold50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_SEMIBOLD50PT7B_H_
