#ifndef _ROBOTOCONDENSED_SEMIBOLD42PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x77, 0xFF, 0xFF, 0xB8, 0xF3, 0xFC, 0xFF, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xB8, 0xEE, 0x38, 0x01, 0xC7,
  0x80, 0x38, 0xF0, 0x0F, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E,
  0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xE0,
  0x0F, 0x1C, 0x01, 0xE3, 0x83, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x1C, 0x78, 0x07, 0x8E, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x03, 0x87, 0x00,
  0x71, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x3F, 0x0F, 0x9F, 0x07, 0xEF, 0x81, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xF7, 0xC1, 0xFB,
  0xFB, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xDF, 0x04, 0x0F, 0x1E, 0x0E, 0x1E, 0x3C, 0x38,
  0x3C, 0x38, 0xF0, 0x78, 0x71, 0xC0, 0xF1, 0xE7, 0x81, 0xE3, 0xCE, 0x03,
  0xEF, 0xBC, 0x03, 0xFE, 0x70, 0x03, 0xF9, 0xE0, 0x03, 0xE3, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x71, 0xF0, 0x01, 0xE7, 0xF0, 0x03,
  0x9F, 0xF0, 0x0F, 0x7D, 0xE0, 0x1C, 0xF1, 0xE0, 0x79, 0xC3, 0xC0, 0xE3,
  0x87, 0x83, 0xC7, 0x0F, 0x07, 0x0E, 0x1E, 0x1E, 0x1E, 0x3C, 0x18, 0x3E,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0,
  0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x3E, 0x3F, 0xF1, 0xF3, 0xEF, 0x8F, 0xBF, 0x7E, 0x79,
  0xF1, 0xFB, 0xCF, 0x87, 0xFE, 0x7C, 0x3F, 0xF3, 0xE0, 0xFF, 0x1F, 0x03,
  0xF8, 0xFC, 0x1F, 0x87, 0xFB, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xBF, 0x03, 0xF0, 0xFC, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC,
  0x00, 0x81, 0xC1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0,
  0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0x40,
  0x40, 0x18, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x07,
  0x83, 0xC0, 0x60, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x70, 0x6F, 0x9C, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0x83, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x07, 0x9E,
  0x03, 0xE3, 0xC0, 0xF0, 0x78, 0x1C, 0x1C, 0x02, 0x02, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x3E, 0x79, 0xF3, 0xC1, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7,
  0xF7, 0xF3, 0xE0, 0xF9, 0xF0, 0x7D, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3E, 0x7E, 0x1F, 0x3F, 0xBF, 0x8F, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF7, 0xF7,
  0xE1, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F,
  0xFF, 0xCF, 0xF7, 0xF7, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F, 0x7F, 0x3F,
  0x9F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1E, 0x7C, 0x03,
  0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x7E, 0x0F, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF9, 0xF9, 0xFC, 0x30, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3E, 0xF8, 0x3F,
  0x7E, 0x1F, 0xBF, 0xBF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x3E,
  0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFD, 0xFF, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x1F, 0x7E, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xF7, 0xF3,
  0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0xCF, 0xC7, 0xE3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F,
  0xFE, 0x3F, 0x1F, 0x9F, 0x07, 0xDF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xBF, 0xBF, 0x9F, 0xFF, 0xC7, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC7, 0xF7, 0xE3, 0xE1, 0xFB, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7E, 0xFE, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xC0, 0xF3, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x7B, 0xEF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF,
  0xFF, 0xF7, 0x80, 0x1C, 0x3E, 0x7E, 0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x30, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0,
  0xFF, 0x81, 0xFC, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xE0, 0x03,
  0x80, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xE1, 0xE0, 0x3E, 0x07, 0x1E, 0x07, 0xFC, 0x3C, 0xF0, 0x7F, 0xF0, 0xE7,
  0x83, 0xE7, 0x87, 0x38, 0x3C, 0x38, 0x3B, 0xC1, 0xE1, 0xC1, 0xDE, 0x1E,
  0x0E, 0x0E, 0xF0, 0xF0, 0x70, 0x77, 0x87, 0x87, 0x83, 0xBC, 0x3C, 0x3C,
  0x1D, 0xC3, 0xC1, 0xE0, 0xEE, 0x1E, 0x0F, 0x07, 0x70, 0xF0, 0x78, 0x3B,
  0x87, 0x83, 0xC3, 0xDE, 0x3E, 0x1E, 0x1C, 0xF0, 0xF1, 0xF0, 0xE7, 0x87,
  0xFF, 0x8F, 0x3C, 0x3F, 0xDF, 0xF0, 0xE0, 0xFE, 0xFF, 0x07, 0x83, 0xC3,
  0xE0, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x80, 0x03, 0xFC, 0x7C, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F,
  0x07, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3E, 0xF8, 0x3F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBE, 0x07, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x81,
  0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x7E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF9, 0xF0, 0x3F, 0x3E, 0x03, 0xF7, 0xC0, 0x7E, 0xF8,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC0,
  0x7E, 0xF8, 0x1F, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0x80,
  0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x3F, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0x00, 0xF8, 0x07, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0xCF, 0x81, 0xFC, 0xF8,
  0x1F, 0x8F, 0x83, 0xF0, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0xBF, 0x00, 0xFB, 0xF0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFE, 0xFC,
  0x0F, 0xCF, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xF0, 0xF8, 0x3F, 0x0F, 0x83,
  0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFE, 0xF8,
  0x07, 0xEF, 0x80, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xDF, 0xFF, 0xC0, 0xF7, 0xFE, 0xF8,
  0x7D, 0xFF, 0xBE, 0x1F, 0x7F, 0xEF, 0x87, 0x9F, 0xF9, 0xE3, 0xE7, 0xFE,
  0x7C, 0xF9, 0xFF, 0x9F, 0x3C, 0x7F, 0xE3, 0xDF, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F,
  0x87, 0xFE, 0x1F, 0xC1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8,
  0x3E, 0x07, 0xFE, 0x07, 0x81, 0xF0, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFB, 0xE1, 0xFF, 0x9F, 0x1F, 0xF9, 0xF1, 0xFF, 0x8F, 0x9F, 0xF8, 0xF9,
  0xFF, 0x87, 0xDF, 0xF8, 0x7D, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x83,
  0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x7E,
  0x7F, 0x03, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0x1F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x7F, 0x07, 0xF1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x10,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFD, 0xF0, 0x3F, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7C, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x9F,
  0x03, 0xF3, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFD,
  0xFC, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x0F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x03,
  0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0x0F,
  0x9F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0, 0x3F, 0x07, 0xE7,
  0xE1, 0xFC, 0x1F, 0x9F, 0x87, 0xF8, 0x7C, 0x3E, 0x1F, 0xE1, 0xF0, 0xF8,
  0x7F, 0x87, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0x8F, 0xF8, 0xFC, 0x3E, 0x3F,
  0xF3, 0xE0, 0x7C, 0xF7, 0xCF, 0x81, 0xF3, 0xCF, 0x3E, 0x07, 0xCF, 0x3C,
  0xF8, 0x1F, 0x7C, 0xF3, 0xE0, 0x7D, 0xF3, 0xFF, 0x81, 0xF7, 0x8F, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xDF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00, 0x7C, 0xFC, 0x01,
  0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xC7,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xFF, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3E,
  0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x1F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x3E, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xFB, 0xFD, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0xEF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3,
  0xEF, 0xF9, 0xF1, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7F, 0x7E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0x7F, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xF3, 0xE3,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFD, 0xFE, 0xFE, 0xFC, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x83, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x0F, 0x8F, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF7, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x06, 0x3F, 0xDF, 0x9F, 0xFF,
  0xC7, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFF, 0x1F, 0xD1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xBF, 0xDF, 0xFF, 0xE7,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7C, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x98, 0x0F, 0x8F, 0x1F, 0xCF, 0xFF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F,
  0xC0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0xFB,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x31, 0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x01,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x06, 0x07, 0x87, 0xE3, 0xF1, 0xF8, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xEF, 0xF7, 0xFB,
  0xF9, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC3, 0xFB, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC3,
  0xF7, 0xE0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC1, 0xFB,
  0xF0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x3F, 0x1F, 0x7F, 0x8F, 0xF3, 0xFF, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0x07, 0xC0, 0xFF, 0xE0, 0xF8,
  0x1F, 0xFC, 0x1F, 0x03, 0xFF, 0x83, 0xE0, 0x7F, 0xF0, 0x7C, 0x0F, 0xFE,
  0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x3F, 0xF8, 0x3E, 0x07, 0xFF, 0x07, 0xC0,
  0xFF, 0xE0, 0xF8, 0x1F, 0xFC, 0x1F, 0x03, 0xFF, 0x83, 0xE0, 0x7F, 0xF0,
  0x7C, 0x0F, 0xFE, 0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x3F, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF7, 0xF7, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xBF, 0xBF, 0x9F,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xF8, 0xF8, 0x7D, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xF7, 0xF7, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xBF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xE7, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xBF, 0xDF, 0x83, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xC0, 0xFD,
  0xF0, 0x3F, 0x7E, 0x0F, 0xDF, 0xEF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC1, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0xF9, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xDF, 0x0F, 0x9F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xCF,
  0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x3E, 0x07, 0x9F, 0x03, 0xEF, 0x81, 0xF7, 0x80, 0xFB, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F,
  0x87, 0xCF, 0x07, 0xC3, 0xE7, 0xC7, 0xE1, 0xF3, 0xE3, 0xF8, 0xF9, 0xF1,
  0xFC, 0x7C, 0xF8, 0xFE, 0x3C, 0x3C, 0xFF, 0x3E, 0x1F, 0x7B, 0xDF, 0x0F,
  0xBD, 0xEF, 0x87, 0xDE, 0xF7, 0x81, 0xFE, 0x7B, 0xC0, 0xFF, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0x80, 0xFC, 0x1F, 0xBE, 0x0F, 0x9F, 0x8F, 0xC7, 0xC7, 0xC3, 0xF7, 0xE0,
  0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0x7C, 0x1F, 0xBF, 0x0F, 0x8F, 0x8F, 0xC7, 0xE7, 0xC1, 0xF7, 0xE0, 0xFC,
  0x7C, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xF9, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F,
  0x87, 0xC3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x38, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xFC, 0x0F, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x70, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x40, 0x1C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xE0,
  0xFC, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x3E,
  0x07, 0x01, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x0F, 0x3F, 0xE1, 0xE7, 0xFF,
  0x1E, 0x7F, 0xFF, 0xEF, 0x8F, 0xFE, 0xF0, 0x7F, 0xCF, 0x03, 0xF8, 0x00,
  0x1F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 30, 11, 3, -30 },
  { 20, 10, 11, 13, 2, -32 },
  { 34, 19, 30, 22, 2, -30 },
  { 106, 17, 38, 21, 2, -34 },
  { 187, 23, 30, 27, 2, -30 },
  { 274, 21, 30, 24, 2, -30 },
  { 353, 5, 11, 7, 1, -32 },
  { 360, 9, 42, 14, 3, -33 },
  { 408, 10, 42, 14, 1, -33 },
  { 461, 18, 18, 19, 1, -30 },
  { 502, 18, 22, 20, 1, -25 },
  { 552, 7, 12, 10, 1, -5 },
  { 563, 10, 4, 14, 2, -15 },
  { 568, 6, 6, 12, 3, -6 },
  { 573, 13, 33, 14, 0, -30 },
  { 627, 17, 30, 21, 2, -30 },
  { 691, 11, 30, 21, 3, -30 },
  { 733, 17, 30, 21, 2, -30 },
  { 797, 17, 30, 21, 2, -30 },
  { 861, 19, 30, 21, 1, -30 },
  { 933, 17, 30, 21, 2, -30 },
  { 997, 17, 30, 21, 2, -30 },
  { 1061, 18, 30, 21, 1, -30 },
  { 1129, 17, 30, 21, 2, -30 },
  { 1193, 17, 30, 21, 2, -30 },
  { 1257, 6, 23, 11, 3, -23 },
  { 1275, 8, 30, 10, 1, -23 },
  { 1305, 15, 20, 19, 1, -23 },
  { 1343, 15, 14, 21, 3, -20 },
  { 1370, 15, 20, 19, 3, -23 },
  { 1408, 16, 30, 19, 1, -30 },
  { 1468, 29, 38, 32, 2, -29 },
  { 1606, 23, 30, 25, 1, -30 },
  { 1693, 18, 30, 23, 3, -30 },
  { 1761, 21, 30, 24, 2, -30 },
  { 1840, 19, 30, 24, 3, -30 },
  { 1912, 16, 30, 21, 3, -30 },
  { 1972, 16, 30, 20, 3, -30 },
  { 2032, 21, 30, 25, 2, -30 },
  { 2111, 20, 30, 26, 3, -30 },
  { 2186, 5, 30, 11, 3, -30 },
  { 2205, 17, 30, 21, 1, -30 },
  { 2269, 20, 30, 23, 3, -30 },
  { 2344, 16, 30, 20, 3, -30 },
  { 2404, 26, 30, 32, 3, -30 },
  { 2502, 20, 30, 26, 3, -30 },
  { 2577, 21, 30, 25, 2, -30 },
  { 2656, 19, 30, 24, 3, -30 },
  { 2728, 21, 35, 25, 2, -30 },
  { 2820, 19, 30, 23, 3, -30 },
  { 2892, 19, 30, 22, 2, -30 },
  { 2964, 21, 30, 23, 1, -30 },
  { 3043, 20, 30, 24, 2, -30 },
  { 3118, 23, 30, 24, 1, -30 },
  { 3205, 30, 30, 32, 1, -30 },
  { 3318, 22, 30, 23, 1, -30 },
  { 3401, 22, 30, 23, 0, -30 },
  { 3484, 19, 30, 22, 2, -30 },
  { 3556, 8, 42, 11, 2, -35 },
  { 3598, 16, 33, 16, 0, -30 },
  { 3664, 7, 42, 11, 1, -35 },
  { 3701, 14, 15, 16, 1, -30 },
  { 3728, 16, 4, 17, 0, 0 },
  { 3736, 10, 6, 14, 1, -31 },
  { 3744, 16, 22, 20, 2, -22 },
  { 3788, 17, 32, 21, 2, -32 },
  { 3856, 16, 22, 19, 2, -22 },
  { 3900, 17, 32, 21, 1, -32 },
  { 3968, 17, 22, 20, 2, -22 },
  { 4015, 12, 32, 14, 1, -32 },
  { 4063, 17, 31, 21, 2, -22 },
  { 4129, 16, 32, 21, 2, -32 },
  { 4193, 6, 31, 10, 2, -31 },
  { 4217, 9, 40, 10, -1, -31 },
  { 4262, 18, 32, 20, 2, -32 },
  { 4334, 5, 32, 10, 3, -32 },
  { 4354, 27, 22, 31, 2, -22 },
  { 4429, 16, 22, 21, 2, -22 },
  { 4473, 17, 22, 21, 2, -22 },
  { 4520, 17, 31, 21, 2, -22 },
  { 4586, 18, 31, 21, 1, -22 },
  { 4656, 11, 22, 14, 2, -22 },
  { 4687, 16, 22, 19, 1, -22 },
  { 4731, 12, 28, 13, 0, -28 },
  { 4773, 16, 22, 21, 2, -22 },
  { 4817, 17, 22, 19, 1, -22 },
  { 4864, 25, 22, 27, 1, -22 },
  { 4933, 17, 22, 19, 1, -22 },
  { 4980, 18, 31, 18, 0, -22 },
  { 5050, 15, 22, 19, 2, -22 },
  { 5092, 11, 40, 13, 1, -33 },
  { 5147, 3, 36, 11, 4, -30 },
  { 5161, 10, 40, 13, 1, -33 },
  { 5211, 20, 9, 24, 2, -17 },
};

const GFXfont RobotoCondensed_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_SEMIBOLD42PT7B_H_
