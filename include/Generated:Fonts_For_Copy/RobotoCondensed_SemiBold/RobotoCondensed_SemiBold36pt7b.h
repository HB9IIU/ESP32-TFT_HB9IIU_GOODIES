#ifndef _ROBOTOCONDENSED_SEMIBOLD36PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xC0, 0x00, 0x3B, 0xFF, 0xFB, 0x80, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1C, 0xE0, 0x18, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x39, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C,
  0x7D, 0xE1, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE1, 0xF7, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0,
  0x3F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x3E, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0x71, 0xC3, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x38, 0xE3, 0x87,
  0x1C, 0xE0, 0xE3, 0x98, 0x1F, 0xF7, 0x01, 0xFD, 0xC0, 0x1F, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x73, 0xE0, 0x0E, 0xFE, 0x03, 0x9F, 0xE0,
  0x77, 0x1C, 0x1C, 0xE3, 0x83, 0x9C, 0x70, 0xE3, 0x8E, 0x1C, 0x71, 0xC7,
  0x0E, 0x38, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x3E, 0x78, 0x03, 0xDF, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x87, 0x8F, 0xF8, 0xF3, 0xEF, 0x9C, 0x79,
  0xF7, 0x9F, 0x1F, 0xF3, 0xE1, 0xFE, 0x7C, 0x3F, 0xC7, 0x83, 0xF0, 0xF8,
  0x7E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xF7, 0xC0, 0xF8, 0xFC, 0xFF,
  0xFF, 0xFF, 0xEE, 0xE0, 0x01, 0x01, 0x81, 0xE1, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03,
  0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x60, 0x10, 0x40, 0x70,
  0x3C, 0x0E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38,
  0x3C, 0x1C, 0x04, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x61, 0xC6, 0x7D, 0xDE, 0x7F, 0xFF, 0x1F, 0xFC, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x08, 0x10, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x7B, 0xDE, 0xF7, 0xBD,
  0xFE, 0xF3, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xEF, 0xFE, 0x78, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0xFE,
  0x78, 0x7B, 0xE1, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x7D, 0xF1, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x3F, 0x00, 0x00, 0x83, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x07,
  0xDE, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7F, 0xC0, 0xFF, 0x83, 0xEF, 0x87, 0xDF, 0xFF, 0x1F, 0xFE, 0x1F, 0xF0,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0x7C, 0x0F, 0x7C, 0x0E, 0x7C,
  0x1E, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x78, 0x7C, 0x78, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF7,
  0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xC7, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0x81, 0xEF, 0x87, 0xDF, 0x0F, 0x9F,
  0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0x80, 0x01, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF7, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0xDF, 0x0F, 0xBE, 0x0F, 0x78,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xCF, 0x8F,
  0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFE, 0x7C, 0xFB, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7D, 0xE1, 0xF7, 0xC7, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC7, 0xFF, 0x9F, 0x1E, 0xF8, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE1, 0xF7, 0xFF, 0xDF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0x80,
  0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0xF8, 0xFB, 0xE1, 0xEF, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x7D, 0xFF, 0xF7, 0xFF,
  0xCF, 0xEF, 0x0F, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x0F,
  0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x7B, 0xEF, 0xFE, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF, 0x9E, 0x39,
  0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0xF3, 0xCF, 0x3C, 0xE7, 0x9E, 0xF1, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x3E,
  0x07, 0xF0, 0xFF, 0x9F, 0xE3, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x01, 0xF8, 0x3F, 0xC7, 0xFC, 0xFF,
  0x8F, 0xF0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1F, 0xFE, 0xF8, 0xFB, 0xE1, 0xEF, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x78, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x38, 0x0F, 0x07, 0x1C, 0x1F, 0xE1,
  0xCE, 0x1F, 0xF0, 0xEE, 0x0E, 0x38, 0x77, 0x0F, 0x1C, 0x3B, 0x87, 0x0E,
  0x1D, 0xC7, 0x87, 0x0E, 0xE3, 0xC3, 0x87, 0x71, 0xE1, 0xC3, 0xB8, 0xE0,
  0xE1, 0xDC, 0x70, 0x70, 0xEE, 0x38, 0x78, 0x67, 0x1E, 0x3C, 0x73, 0x8F,
  0x3E, 0x39, 0xC3, 0xFF, 0xF8, 0xE1, 0xFB, 0xF8, 0x78, 0x78, 0xF8, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x06, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x07,
  0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF0, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xC0, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC1,
  0xF3, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xFB, 0xE0,
  0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xF3, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE7, 0xE1, 0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xF7,
  0xC0, 0x7B, 0xF0, 0x7C, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1, 0xF7, 0xFF, 0x9F, 0xFE, 0x3F,
  0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xF8,
  0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xBF, 0xFE, 0x0F, 0x7F, 0xFE, 0x1E, 0xFF, 0xBC,
  0x79, 0xFF, 0x78, 0xF3, 0xFE, 0xF1, 0xE7, 0xFC, 0xF3, 0x9F, 0xF9, 0xEF,
  0x3F, 0xF3, 0xDE, 0x7F, 0xE3, 0xFC, 0xFF, 0xC7, 0xF1, 0xFF, 0x8F, 0xE3,
  0xFF, 0x1F, 0xC7, 0xFE, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F,
  0xF0, 0x78, 0x7C, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xBC, 0x7F, 0xEF, 0x1F, 0xF9, 0xE7, 0xFE, 0x79, 0xFF, 0x8F,
  0x7F, 0xE3, 0xDF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E,
  0x1F, 0x9F, 0x03, 0xEF, 0x80, 0x7B, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1E, 0x7C,
  0x0F, 0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x81, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF,
  0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0x7C, 0x0F, 0x9F, 0x87, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1E,
  0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F,
  0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7,
  0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0xFB,
  0xF0, 0xF8, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xFC, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xEF, 0x81, 0xF3, 0xE0, 0xF9, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xC1, 0xE0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xF0, 0x07, 0xDE, 0x00, 0x3D, 0xE0,
  0x03, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x1E, 0x07, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xEF, 0x07, 0xC1, 0xF7, 0x83, 0xE0, 0xF3,
  0xC1, 0xF8, 0x79, 0xF1, 0xFC, 0x3C, 0xF8, 0xFE, 0x3E, 0x7C, 0x7F, 0x1F,
  0x1E, 0x3F, 0x8F, 0x8F, 0x1D, 0xE7, 0x87, 0x9E, 0xF3, 0xC3, 0xEF, 0x79,
  0xE1, 0xF7, 0xBC, 0xF0, 0x7B, 0xCE, 0xF8, 0x3D, 0xC7, 0xFC, 0x1F, 0xE3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xDF, 0x03, 0xF7, 0xC0,
  0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xE0, 0x3E, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xF3,
  0xE0, 0x7C, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE1, 0xF9, 0xF0, 0x3E,
  0xFC, 0x0F, 0xFE, 0x01, 0xF0, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC3, 0xC0, 0xF8, 0xF8,
  0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0x83, 0xF8,
  0x3D, 0xC3, 0x9C, 0x79, 0xC7, 0x9E, 0x70, 0xEF, 0x0E, 0xF0, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0x80,
  0x0F, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xF9, 0xF0, 0xF3, 0xC1, 0xEF, 0x83,
  0xDF, 0x07, 0x9E, 0x1F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0x78, 0x7C, 0xF8,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF3, 0xE1, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBE, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xEF,
  0xE3, 0xCF, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7,
  0xCF, 0x07, 0xBE, 0x0F, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x83, 0xEF, 0x07, 0x9F, 0x0F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xBE, 0x7F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x07, 0xDF, 0x0F, 0xBF, 0xFF,
  0x3F, 0xFE, 0x3F, 0xBC, 0x3E, 0x78, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xDE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x03, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0xC3, 0xF1, 0xFC, 0x7F, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7,
  0xC3, 0xEF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xEF, 0x03, 0xDF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFE,
  0x3F, 0xBC, 0x3E, 0x78, 0x01, 0xF0, 0x03, 0xE2, 0x07, 0xCF, 0xFF, 0x1F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xC0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x1F,
  0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFE, 0xFE, 0xFC, 0xF8, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x7D, 0xE1, 0xF3, 0xC7, 0xE7, 0x8F, 0x8F, 0x3E, 0x1E, 0xF8, 0x3D, 0xF0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0x9E, 0x1E,
  0x3E, 0x3C, 0x3C, 0x78, 0x7C, 0xF0, 0x7D, 0xE0, 0xFB, 0xC0, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF3, 0xE1, 0xF1, 0xEF, 0xE7, 0xF3, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0x87, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F,
  0xF8, 0x3E, 0x1F, 0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xFF,
  0x83, 0xE1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F, 0xF8,
  0x3E, 0x1F, 0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0, 0xF8, 0xF3,
  0xE3, 0xDF, 0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xC0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF3,
  0xE1, 0xEF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0xBE, 0x1F, 0x7F, 0xFE, 0xFF, 0xF9, 0xEF, 0xE3, 0xCF, 0x87, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x0F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xEF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xEF, 0x07, 0xDF, 0x0F, 0xBF, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x3E, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0xF3, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7D, 0xE1, 0xF7, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0xE0, 0xFF,
  0x87, 0xDF, 0xFF, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0xC7,
  0xF0, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xE1, 0xFF, 0x8F, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF1, 0xE7,
  0xC0, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0xDE, 0x1E, 0x78, 0x79, 0xE3, 0xE7,
  0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x70, 0x7F, 0x87, 0x83, 0xFC, 0x3E, 0x3F, 0xF1, 0xF1, 0xE7, 0x8F, 0x8F,
  0x3C, 0xFC, 0x79, 0xE7, 0xF3, 0xCF, 0x3F, 0x9E, 0x3D, 0xDD, 0xE1, 0xFE,
  0xEF, 0x0F, 0xF7, 0xF8, 0x7F, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC1,
  0xE0, 0xF8, 0x7C, 0xF0, 0xF9, 0xF3, 0xE1, 0xE7, 0xC3, 0xEF, 0x03, 0xFE,
  0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x01,
  0xFE, 0x07, 0xFE, 0x0F, 0xBC, 0x3E, 0x7C, 0x7C, 0x79, 0xF0, 0xFB, 0xE1,
  0xF0, 0x78, 0x1E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xE3, 0xC3, 0xC7, 0xCF,
  0x8F, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0x78, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFE, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0x03, 0xC3, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x3E, 0x07, 0x83, 0xC0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1F,
  0x07, 0x80, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x40, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC7,
  0xE3, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xE1, 0xF0, 0xF0, 0x20, 0x00, 0x1E, 0x00, 0x1F, 0x83, 0x9F, 0xE1,
  0xDF, 0xF9, 0xEF, 0x3F, 0xF7, 0x0F, 0xF3, 0x83, 0xF8, 0x00, 0x70,
};

const GFXglyph RobotoCondensed_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 9, 9, 12, 1, -27 },
  { 29, 16, 26, 19, 2, -26 },
  { 81, 14, 33, 18, 2, -30 },
  { 139, 19, 26, 23, 2, -26 },
  { 201, 19, 26, 21, 1, -26 },
  { 263, 4, 9, 6, 1, -27 },
  { 268, 9, 37, 12, 2, -29 },
  { 310, 9, 37, 12, 1, -29 },
  { 352, 16, 15, 16, 0, -26 },
  { 382, 15, 18, 17, 1, -21 },
  { 416, 5, 10, 8, 1, -4 },
  { 423, 8, 4, 12, 2, -13 },
  { 427, 6, 5, 10, 2, -5 },
  { 431, 12, 28, 12, 0, -26 },
  { 473, 14, 26, 18, 2, -26 },
  { 519, 9, 26, 18, 3, -26 },
  { 549, 16, 26, 18, 1, -26 },
  { 601, 15, 26, 18, 1, -26 },
  { 650, 16, 26, 18, 1, -26 },
  { 702, 15, 26, 18, 2, -26 },
  { 751, 15, 26, 18, 2, -26 },
  { 800, 16, 26, 18, 1, -26 },
  { 852, 14, 26, 18, 2, -26 },
  { 898, 14, 26, 18, 2, -26 },
  { 944, 6, 20, 10, 2, -20 },
  { 959, 6, 26, 9, 1, -20 },
  { 979, 13, 16, 16, 1, -19 },
  { 1005, 14, 11, 18, 2, -17 },
  { 1025, 13, 16, 16, 2, -19 },
  { 1051, 14, 26, 16, 1, -26 },
  { 1097, 25, 33, 28, 1, -25 },
  { 1201, 21, 26, 21, 0, -26 },
  { 1270, 16, 26, 20, 2, -26 },
  { 1322, 17, 26, 21, 2, -26 },
  { 1378, 17, 26, 20, 2, -26 },
  { 1434, 15, 26, 18, 2, -26 },
  { 1483, 14, 26, 17, 2, -26 },
  { 1529, 17, 26, 21, 2, -26 },
  { 1585, 18, 26, 22, 2, -26 },
  { 1644, 5, 26, 10, 2, -26 },
  { 1661, 14, 26, 18, 1, -26 },
  { 1707, 18, 26, 20, 2, -26 },
  { 1766, 14, 26, 17, 2, -26 },
  { 1812, 23, 26, 27, 2, -26 },
  { 1887, 18, 26, 22, 2, -26 },
  { 1946, 18, 26, 22, 2, -26 },
  { 2005, 17, 26, 20, 2, -26 },
  { 2061, 18, 31, 22, 2, -26 },
  { 2131, 17, 26, 20, 2, -26 },
  { 2187, 17, 26, 19, 1, -26 },
  { 2243, 17, 26, 19, 1, -26 },
  { 2299, 17, 26, 20, 2, -26 },
  { 2355, 20, 26, 21, 0, -26 },
  { 2420, 25, 26, 27, 1, -26 },
  { 2502, 18, 26, 20, 1, -26 },
  { 2561, 19, 26, 19, 0, -26 },
  { 2623, 17, 26, 19, 1, -26 },
  { 2679, 7, 36, 9, 2, -30 },
  { 2711, 14, 28, 14, 0, -26 },
  { 2760, 6, 36, 9, 1, -30 },
  { 2787, 12, 13, 14, 1, -26 },
  { 2807, 14, 4, 14, 0, 0 },
  { 2814, 9, 5, 12, 1, -27 },
  { 2820, 15, 19, 17, 1, -19 },
  { 2856, 15, 27, 18, 2, -27 },
  { 2907, 15, 19, 17, 1, -19 },
  { 2943, 15, 27, 18, 1, -27 },
  { 2994, 15, 19, 17, 1, -19 },
  { 3030, 10, 27, 12, 1, -27 },
  { 3064, 15, 26, 18, 1, -19 },
  { 3113, 14, 27, 18, 2, -27 },
  { 3161, 5, 27, 9, 2, -27 },
  { 3178, 8, 34, 9, -1, -27 },
  { 3212, 15, 27, 17, 2, -27 },
  { 3263, 5, 27, 9, 2, -27 },
  { 3280, 23, 19, 27, 2, -19 },
  { 3335, 14, 19, 18, 2, -19 },
  { 3369, 16, 19, 18, 1, -19 },
  { 3407, 15, 26, 18, 2, -19 },
  { 3456, 15, 26, 18, 1, -19 },
  { 3505, 9, 19, 12, 2, -19 },
  { 3527, 14, 19, 16, 1, -19 },
  { 3561, 10, 24, 11, 0, -24 },
  { 3591, 14, 19, 18, 2, -19 },
  { 3625, 14, 19, 16, 1, -19 },
  { 3659, 21, 19, 23, 1, -19 },
  { 3709, 15, 19, 16, 1, -19 },
  { 3745, 15, 26, 16, 0, -19 },
  { 3794, 14, 19, 16, 1, -19 },
  { 3828, 9, 34, 11, 1, -28 },
  { 3867, 3, 31, 9, 3, -26 },
  { 3879, 9, 34, 11, 1, -28 },
  { 3918, 17, 8, 20, 2, -15 },
};

const GFXfont RobotoCondensed_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_SEMIBOLD36PT7B_H_
