#ifndef _ROBOTOCONDENSED_SEMIBOLD39PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x1E, 0x7F, 0xF7, 0xDE, 0xE7, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE7, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x1C,
  0x70, 0x0F, 0x3C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1C, 0x70, 0x07, 0x1C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0F, 0x3C, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7C, 0x7E, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xE7, 0x82, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x1C, 0x39, 0xE0, 0xE1, 0xCE,
  0x07, 0x9E, 0xF0, 0x1F, 0xE7, 0x00, 0xFF, 0x70, 0x01, 0xE3, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0xEF, 0xF0, 0x0E, 0x7F,
  0x80, 0x77, 0x9E, 0x07, 0x38, 0x70, 0x39, 0xC3, 0x83, 0x8E, 0x1C, 0x3C,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0, 0x3C,
  0x7C, 0x03, 0xE7, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0xC3, 0xC7, 0xFE, 0x3C, 0x7F, 0xF3, 0xCF, 0x9F, 0x3C,
  0xF8, 0xFF, 0xCF, 0x0F, 0xF8, 0xF0, 0x7F, 0x8F, 0x83, 0xF8, 0xF8, 0x3F,
  0x0F, 0xC7, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF7, 0xE0, 0xFC,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0xC0, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x06, 0x01, 0x40, 0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0,
  0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0x80, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0xE3, 0x86,
  0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x38, 0x38, 0x00, 0x10, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x3C, 0xF3, 0xCF, 0x3D, 0xF7, 0x9E, 0xF3, 0xC6,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x11, 0xF7, 0xFF, 0x7C, 0xE0, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x07, 0xE0, 0x1F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3F, 0xFC, 0x3F, 0xF8,
  0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x40, 0xF0, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7,
  0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7,
  0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0xFB,
  0xC0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xBE, 0x03, 0xDF,
  0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0x78,
  0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xE0, 0x7F,
  0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7C, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC,
  0x3E, 0x7E, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x79, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFE, 0x7E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0x78, 0x3E, 0x7C, 0x3E, 0x7E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7,
  0xDF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x07, 0xDF, 0x1F, 0xBF, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0x3E, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x01, 0xFC,
  0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF0, 0x00, 0x11, 0xF7, 0xFF, 0x7C,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x11, 0xF7, 0xFF, 0x7C,
  0xE0, 0x00, 0x79, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF3,
  0xC1, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F,
  0xE7, 0xFE, 0x3F, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x7C, 0x03,
  0xF0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0xE0,
  0x02, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xE7,
  0xDF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0x1E,
  0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x38, 0x0F,
  0x83, 0x9E, 0x0F, 0xF0, 0xE7, 0x87, 0xFE, 0x1D, 0xC1, 0xE7, 0x87, 0xF0,
  0xF1, 0xE1, 0xFC, 0x38, 0x78, 0x7E, 0x1E, 0x1E, 0x1F, 0x87, 0x87, 0x87,
  0xE1, 0xE1, 0xE1, 0xF8, 0x78, 0x70, 0x7E, 0x1C, 0x1C, 0x1F, 0x87, 0x07,
  0x07, 0xE1, 0xC1, 0xC1, 0xF8, 0x78, 0xF0, 0xEE, 0x1E, 0x3C, 0x3B, 0x87,
  0xDF, 0x9E, 0xE1, 0xFF, 0xFF, 0x3C, 0x3F, 0x3F, 0x87, 0x07, 0x87, 0xC1,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x78, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC, 0x3F, 0xBF, 0x03, 0xEF,
  0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0,
  0x7C, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x1F,
  0xBF, 0x03, 0xEF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1,
  0xFC, 0xF8, 0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7E, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xF8, 0xFE, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x7F, 0x3F, 0x07, 0xEF, 0xC0, 0xFB,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0xC1, 0xFB,
  0xF0, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xF9, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x80, 0xF9, 0xFC, 0x7F,
  0x3F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E,
  0xFE, 0x7E, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F, 0xDF, 0x80, 0xFD,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x78, 0x3F, 0xFF, 0xBE, 0x1E, 0xFF, 0xDF, 0x0F, 0x7F,
  0xE7, 0x8F, 0xBF, 0xF3, 0xC7, 0x9F, 0xF9, 0xF3, 0xCF, 0xFC, 0x79, 0xE7,
  0xFE, 0x3D, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF, 0x87, 0xF8, 0xFF, 0xC3, 0xFC,
  0x7F, 0xE1, 0xFC, 0x3F, 0xF0, 0xFE, 0x1F, 0xF8, 0x3F, 0x0F, 0xFC, 0x1F,
  0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x03, 0xC1, 0xF0, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFB, 0xE1, 0xFF,
  0xBE, 0x1F, 0xF9, 0xF1, 0xFF, 0x9F, 0x1F, 0xF8, 0xF9, 0xFF, 0x8F, 0x9F,
  0xF8, 0x7D, 0xFF, 0x87, 0xDF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x9F, 0xC7, 0xE0, 0x7C, 0x7C, 0x03, 0xEF,
  0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xE7, 0xC0,
  0x3E, 0x7E, 0x07, 0xC3, 0xF9, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0xFF, 0xCF, 0xC1, 0xFD, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x7E, 0x03, 0xEF, 0xC0, 0x7D, 0xF8,
  0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0x9F, 0xC7,
  0xE0, 0x7C, 0x7C, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xC3, 0xF9, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xC3, 0xF9, 0xF8, 0x1F,
  0x3F, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x80, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xFC, 0x1F, 0x8F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xE0, 0xFC, 0xFC, 0x0F, 0x9F, 0x81, 0xFB,
  0xF0, 0x1F, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0x1F, 0x9F, 0x83, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xDF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xFC, 0x7F, 0x3F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xFD, 0xFC, 0x7E, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBF,
  0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0,
  0x0F, 0x9F, 0x00, 0x3C, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBC, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x03, 0xFF,
  0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xBE, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8,
  0x3E, 0xF8, 0x3F, 0x07, 0x9F, 0x0F, 0xE1, 0xF3, 0xE1, 0xFC, 0x3E, 0x3C,
  0x3F, 0xC7, 0xC7, 0xC7, 0xF8, 0xF8, 0xF8, 0xFF, 0x1F, 0x1F, 0x3D, 0xE3,
  0xC3, 0xE7, 0xBC, 0xF8, 0x7C, 0xF7, 0x9F, 0x07, 0x9E, 0x7B, 0xE0, 0xF3,
  0xCF, 0x7C, 0x1F, 0xF1, 0xEF, 0x83, 0xFE, 0x3D, 0xE0, 0x7F, 0xC7, 0xBC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x7E,
  0x7E, 0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x9F,
  0x80, 0xF9, 0xF0, 0x0F, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFB, 0xF0, 0x1F, 0x9F, 0x01,
  0xF1, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7E,
  0x7C, 0x07, 0xEF, 0xC0, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80,
  0xFC, 0x7C, 0x07, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xFC, 0x0E,
  0xE0, 0x77, 0x87, 0xBC, 0x3C, 0xE1, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x07,
  0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF,
  0xEF, 0xC7, 0xDF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x0F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xF7, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBC, 0x1F, 0x7C, 0x3E, 0xF8,
  0xFD, 0xFF, 0xF9, 0xFF, 0xF3, 0xFD, 0xF1, 0xF3, 0xE0, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF9, 0xF0, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xF8,
  0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0x9F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x0F, 0x8F, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x04, 0xFC, 0x1C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xC0, 0x7E, 0x00, 0x03, 0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x07, 0xCF, 0x1F, 0xEF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x0F, 0x7C, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x78, 0x0F, 0x7C,
  0x0F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xEF, 0x07,
  0xCF, 0x00, 0x1F, 0x00, 0x1F, 0x10, 0x1F, 0x1C, 0x3F, 0x3F, 0xFE, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0xF1, 0xF7, 0xF3,
  0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0,
  0x7F, 0xFF, 0xF7, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x1F, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFC, 0xF8, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0xFC, 0xF8, 0xF8, 0xF9, 0xF8, 0xFB, 0xF0,
  0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFD, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF9, 0xF0, 0x7C, 0x7D, 0xFC, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xC7, 0xF1, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF,
  0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F,
  0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83,
  0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xF8, 0xF9, 0xF1, 0xF7, 0xF3, 0xFF,
  0xF7, 0xFF, 0xEF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9,
  0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xF7, 0x80, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7E, 0x3F, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xF9, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFB, 0xF8,
  0xF9, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x1F, 0xEF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x9F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xFF, 0xE7, 0xC3, 0xEF, 0x87, 0xDF, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x1F, 0x7C, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xF8, 0x7F, 0x0F, 0xE0, 0x7C, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x7E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFF,
  0xF1, 0xF3, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x7C,
  0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x78, 0x3F,
  0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC3, 0xE1, 0xE7, 0x87, 0xC3, 0xCF,
  0x1F, 0x8F, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F, 0x3E, 0x3C, 0xFE, 0x78, 0x7B,
  0xDC, 0xF0, 0xF7, 0xBD, 0xE1, 0xEF, 0x7F, 0xC3, 0xFC, 0xFF, 0x03, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x07,
  0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x3E,
  0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x1F, 0xF8, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xFC, 0x7E, 0x7C, 0x7C, 0x7E,
  0xFC, 0x3E, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C, 0x1F, 0x3C, 0x0F,
  0xBE, 0x07, 0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xE0, 0x7C, 0x3E,
  0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF8, 0xFC, 0x3E, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x0F,
  0x03, 0xE0, 0x7C, 0x0E, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0xC3, 0xF0, 0x7C, 0x3F,
  0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x0F, 0x83, 0xC0, 0x40, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0xF7, 0xFC, 0x3D, 0xFF, 0x9F, 0xF9, 0xFF, 0xBC, 0x3F, 0xEF,
  0x07, 0xF0, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_SemiBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 9, 10, 13, 2, -29 },
  { 34, 18, 28, 21, 2, -28 },
  { 97, 16, 36, 20, 2, -32 },
  { 169, 21, 28, 25, 2, -28 },
  { 243, 20, 28, 22, 2, -28 },
  { 313, 4, 10, 6, 1, -29 },
  { 318, 9, 40, 13, 2, -31 },
  { 363, 9, 40, 13, 1, -31 },
  { 408, 16, 17, 17, 1, -28 },
  { 442, 16, 21, 19, 1, -24 },
  { 484, 6, 11, 9, 1, -5 },
  { 493, 9, 4, 13, 2, -14 },
  { 498, 6, 6, 11, 2, -6 },
  { 503, 12, 30, 13, 0, -28 },
  { 548, 16, 28, 20, 2, -28 },
  { 604, 10, 28, 20, 3, -28 },
  { 639, 17, 28, 20, 1, -28 },
  { 699, 17, 28, 20, 1, -28 },
  { 759, 17, 28, 20, 1, -28 },
  { 819, 16, 28, 20, 2, -28 },
  { 875, 16, 28, 20, 2, -28 },
  { 931, 17, 28, 20, 1, -28 },
  { 991, 16, 28, 20, 2, -28 },
  { 1047, 15, 28, 20, 2, -28 },
  { 1100, 6, 22, 10, 2, -22 },
  { 1117, 7, 28, 9, 1, -22 },
  { 1142, 14, 18, 17, 1, -21 },
  { 1174, 14, 12, 19, 3, -19 },
  { 1195, 14, 18, 18, 2, -21 },
  { 1227, 15, 28, 17, 1, -28 },
  { 1280, 26, 36, 30, 2, -27 },
  { 1397, 22, 28, 23, 1, -28 },
  { 1474, 18, 28, 22, 2, -28 },
  { 1537, 19, 28, 22, 2, -28 },
  { 1604, 18, 28, 22, 2, -28 },
  { 1667, 16, 28, 19, 2, -28 },
  { 1723, 16, 28, 19, 2, -28 },
  { 1779, 19, 28, 23, 2, -28 },
  { 1846, 20, 28, 24, 2, -28 },
  { 1916, 5, 28, 10, 3, -28 },
  { 1934, 16, 28, 19, 1, -28 },
  { 1990, 20, 28, 22, 2, -28 },
  { 2060, 16, 28, 19, 2, -28 },
  { 2116, 25, 28, 30, 2, -28 },
  { 2204, 20, 28, 24, 2, -28 },
  { 2274, 20, 28, 24, 2, -28 },
  { 2344, 19, 28, 22, 2, -28 },
  { 2411, 20, 33, 24, 2, -28 },
  { 2494, 19, 28, 21, 2, -28 },
  { 2561, 18, 28, 21, 1, -28 },
  { 2624, 19, 28, 21, 1, -28 },
  { 2691, 18, 28, 22, 2, -28 },
  { 2754, 21, 28, 22, 1, -28 },
  { 2828, 27, 28, 29, 1, -28 },
  { 2923, 20, 28, 22, 1, -28 },
  { 2993, 21, 28, 21, 0, -28 },
  { 3067, 18, 28, 21, 1, -28 },
  { 3130, 7, 38, 10, 2, -32 },
  { 3164, 15, 30, 15, 0, -28 },
  { 3221, 7, 38, 10, 1, -32 },
  { 3255, 13, 14, 15, 1, -28 },
  { 3278, 15, 4, 16, 0, 0 },
  { 3286, 9, 6, 13, 1, -29 },
  { 3293, 15, 21, 18, 2, -21 },
  { 3333, 16, 29, 19, 2, -29 },
  { 3391, 16, 21, 18, 1, -21 },
  { 3433, 16, 29, 19, 1, -29 },
  { 3491, 15, 21, 19, 2, -21 },
  { 3531, 11, 29, 13, 1, -29 },
  { 3571, 16, 29, 20, 1, -21 },
  { 3629, 15, 29, 19, 2, -29 },
  { 3684, 5, 29, 10, 2, -29 },
  { 3703, 8, 37, 9, -1, -29 },
  { 3740, 16, 29, 18, 2, -29 },
  { 3798, 5, 29, 10, 2, -29 },
  { 3817, 25, 21, 29, 2, -21 },
  { 3883, 15, 21, 19, 2, -21 },
  { 3923, 17, 21, 19, 1, -21 },
  { 3968, 16, 29, 19, 2, -21 },
  { 4026, 16, 29, 19, 1, -21 },
  { 4084, 10, 21, 13, 2, -21 },
  { 4111, 15, 21, 18, 1, -21 },
  { 4151, 11, 26, 12, 0, -26 },
  { 4187, 15, 21, 19, 2, -21 },
  { 4227, 16, 21, 17, 1, -21 },
  { 4269, 23, 21, 25, 1, -21 },
  { 4330, 16, 21, 18, 1, -21 },
  { 4372, 17, 29, 17, 0, -21 },
  { 4434, 14, 21, 18, 2, -21 },
  { 4471, 10, 37, 12, 1, -30 },
  { 4518, 4, 33, 10, 3, -28 },
  { 4535, 10, 37, 12, 1, -30 },
  { 4582, 18, 8, 22, 2, -15 },
};

const GFXfont RobotoCondensed_SemiBold39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_SEMIBOLD39PT7B_H_
