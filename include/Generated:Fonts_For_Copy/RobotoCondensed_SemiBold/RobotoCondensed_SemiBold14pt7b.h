#ifndef _ROBOTOCONDENSED_SEMIBOLD14PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xB6, 0xD0, 0x28, 0xA2, 0xBF, 0x59, 0x4F, 0xD4,
  0x51, 0x40, 0x23, 0xB7, 0x9C, 0x30, 0xE3, 0x8E, 0xDC, 0x40, 0xE1, 0x4A,
  0xA5, 0x4F, 0x03, 0xCA, 0x95, 0x4A, 0x1C, 0x71, 0xB3, 0x66, 0x86, 0x1E,
  0xAD, 0x4E, 0xDC, 0xF8, 0xFF, 0x2D, 0x6D, 0x24, 0x9B, 0x26, 0x40, 0x84,
  0x62, 0x23, 0x33, 0x32, 0x26, 0x48, 0x10, 0x4F, 0xCC, 0x79, 0x20, 0x10,
  0x41, 0x3F, 0xFC, 0x41, 0x04, 0x69, 0x60, 0xE0, 0xF0, 0x11, 0x32, 0x22,
  0x64, 0x4C, 0xC0, 0x76, 0xF7, 0x18, 0xC6, 0x3B, 0xDB, 0x80, 0x3F, 0xB3,
  0x33, 0x33, 0x33, 0x76, 0xE6, 0x31, 0x99, 0x8C, 0xC7, 0xC0, 0x76, 0xE6,
  0x31, 0xB8, 0x71, 0xDB, 0x80, 0x0C, 0x38, 0x71, 0xE2, 0xCD, 0x93, 0x7F,
  0x0C, 0x18, 0xFF, 0xF1, 0xED, 0x84, 0x39, 0xDB, 0x80, 0x31, 0xCC, 0x3C,
  0xDB, 0x2C, 0xF2, 0xF9, 0xC0, 0xFC, 0x10, 0xC3, 0x18, 0x61, 0x0C, 0x30,
  0x80, 0x76, 0xF7, 0xBD, 0xBB, 0x71, 0xDB, 0x80, 0x76, 0xF7, 0x18, 0xED,
  0xE3, 0x73, 0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58, 0x08, 0xDD, 0x87,
  0x0C, 0x20, 0xFF, 0xC1, 0xFF, 0x80, 0x87, 0x1C, 0x37, 0x72, 0x00, 0x79,
  0xEC, 0xC3, 0x18, 0xC3, 0x00, 0x30, 0xC0, 0x1E, 0x31, 0x90, 0x71, 0x99,
  0x4D, 0xA6, 0xD3, 0x49, 0xB4, 0xCF, 0xB0, 0x0C, 0x03, 0xC0, 0x18, 0x18,
  0x1C, 0x3C, 0x34, 0x26, 0x7E, 0x7E, 0x63, 0xC3, 0xFB, 0xFC, 0xF3, 0xCF,
  0xEC, 0xF3, 0xFF, 0xE0, 0x79, 0xFB, 0x16, 0x0C, 0x18, 0x30, 0x62, 0xFC,
  0xF0, 0xF3, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xC0, 0xFB, 0xEC, 0x30,
  0xC3, 0xEC, 0x30, 0xFF, 0xF0, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC6, 0x00,
  0x79, 0xFB, 0x16, 0x0C, 0x1B, 0xF1, 0xE3, 0xFE, 0xF0, 0xC7, 0x8F, 0x1E,
  0x3F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8C, 0xFF, 0xFF, 0xF0, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xF3, 0x7D, 0xE0, 0xCD, 0x9B, 0x67, 0x8F, 0x1E, 0x36, 0x6C,
  0xCD, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xC3, 0xF1, 0xF8,
  0xFC, 0xFF, 0x7F, 0xAF, 0x57, 0xBB, 0xD9, 0xEC, 0xC0, 0xC7, 0x8F, 0x9F,
  0x3F, 0x7A, 0xF7, 0xE7, 0xCF, 0x8C, 0x79, 0xFB, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xFC, 0xF0, 0xFB, 0xFC, 0xF3, 0xFF, 0xEC, 0x30, 0xC3, 0x00, 0x79,
  0xFB, 0x1E, 0x38, 0x70, 0xF1, 0xE3, 0xFC, 0xF8, 0x30, 0x20, 0xFB, 0xFC,
  0xF3, 0xFF, 0xED, 0xB6, 0xCF, 0x30, 0x7B, 0xFC, 0xF0, 0xF0, 0xE0, 0xE3,
  0xFD, 0xE0, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0, 0xC3, 0x62, 0x66, 0x66, 0x66,
  0x34, 0x3C, 0x3C, 0x18, 0x18, 0xCC, 0xD3, 0x36, 0xED, 0xBB, 0x6E, 0x9E,
  0xA3, 0xB8, 0xCE, 0x33, 0x8C, 0x40, 0x66, 0x66, 0x3C, 0x3C, 0x18, 0x18,
  0x3C, 0x2C, 0x66, 0x66, 0xC6, 0xCD, 0x91, 0x63, 0x87, 0x06, 0x0C, 0x18,
  0x30, 0xFF, 0xF1, 0x84, 0x31, 0x86, 0x30, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC2, 0x18, 0xC2, 0x18, 0xC2, 0x18, 0xC6, 0xED, 0xB6, 0xDB, 0x6D,
  0xB7, 0xC0, 0x31, 0x9C, 0xB5, 0x80, 0xF8, 0x62, 0x76, 0xC6, 0xFD, 0xCF,
  0x7F, 0xC6, 0x31, 0xED, 0xE7, 0x39, 0xCE, 0xEC, 0x76, 0xE7, 0x08, 0x4F,
  0x6E, 0x0C, 0x30, 0xDF, 0x6D, 0x34, 0xD3, 0x4D, 0xF3, 0x40, 0x76, 0xE7,
  0x1F, 0xC3, 0x6E, 0x37, 0x6F, 0x66, 0x66, 0x66, 0x60, 0x6E, 0xE7, 0x39,
  0xCF, 0xEF, 0x1E, 0xFC, 0x84, 0x21, 0x6D, 0xCE, 0x73, 0x9C, 0xE6, 0xF3,
  0xFF, 0xFC, 0x4C, 0x36, 0xDB, 0x6D, 0xBD, 0x80, 0xC3, 0x0C, 0x36, 0xF3,
  0xCE, 0x3C, 0xF3, 0x6D, 0x80, 0xFF, 0xFF, 0xFC, 0xB7, 0x6F, 0xB6, 0x7B,
  0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xB6, 0xE7, 0x39, 0xCE, 0x73, 0x76, 0xE3,
  0x18, 0xC7, 0x6E, 0xB6, 0xF3, 0x9C, 0xE7, 0x7E, 0xC6, 0x30, 0x75, 0xB4,
  0xD3, 0x4D, 0x36, 0xCF, 0x0C, 0x30, 0xC0, 0xBF, 0x6D, 0xB6, 0x39, 0xB4,
  0x1C, 0x38, 0x36, 0xDE, 0x6F, 0x66, 0x66, 0x67, 0x30, 0x9C, 0xE7, 0x39,
  0xCF, 0xFF, 0xCD, 0x36, 0x9E, 0x78, 0xE3, 0x0C, 0xC9, 0xAC, 0x97, 0x4E,
  0xE7, 0x73, 0xB8, 0xD8, 0x4C, 0x4D, 0xA3, 0x8C, 0x31, 0xE6, 0xB3, 0xCD,
  0x36, 0x9E, 0x78, 0xC3, 0x0C, 0x31, 0x86, 0x00, 0xF8, 0x8C, 0xC6, 0x63,
  0x1F, 0x32, 0x66, 0x66, 0xC6, 0x66, 0x62, 0x10, 0xFF, 0xF0, 0x46, 0x66,
  0x66, 0x36, 0x66, 0x64, 0x40, 0x67, 0xF9, 0x80,
};

const GFXglyph RobotoCondensed_SemiBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 3, 4, 4, 1, -11 },
  { 6, 6, 10, 7, 1, -10 },
  { 14, 5, 12, 7, 1, -11 },
  { 22, 7, 10, 9, 1, -10 },
  { 31, 7, 10, 8, 1, -10 },
  { 40, 2, 4, 2, 0, -11 },
  { 41, 3, 14, 5, 1, -11 },
  { 47, 4, 14, 5, 0, -11 },
  { 54, 6, 6, 6, 0, -10 },
  { 59, 6, 8, 7, 0, -9 },
  { 65, 3, 4, 3, 0, -2 },
  { 67, 3, 1, 5, 1, -5 },
  { 68, 2, 2, 4, 1, -2 },
  { 69, 4, 11, 5, 0, -10 },
  { 75, 5, 10, 7, 1, -10 },
  { 82, 4, 10, 7, 1, -10 },
  { 87, 5, 10, 7, 1, -10 },
  { 94, 5, 10, 7, 1, -10 },
  { 101, 7, 10, 7, 0, -10 },
  { 110, 5, 10, 7, 1, -10 },
  { 117, 6, 10, 7, 1, -10 },
  { 125, 6, 10, 7, 0, -10 },
  { 133, 5, 10, 7, 1, -10 },
  { 140, 5, 10, 7, 1, -10 },
  { 147, 2, 8, 4, 1, -8 },
  { 149, 3, 10, 3, 0, -8 },
  { 153, 5, 7, 6, 0, -8 },
  { 158, 5, 5, 7, 1, -7 },
  { 162, 5, 7, 6, 1, -8 },
  { 167, 6, 10, 6, 0, -10 },
  { 175, 9, 13, 11, 1, -10 },
  { 190, 8, 10, 8, 0, -10 },
  { 200, 6, 10, 8, 1, -10 },
  { 208, 7, 10, 8, 1, -10 },
  { 217, 6, 10, 8, 1, -10 },
  { 225, 6, 10, 7, 1, -10 },
  { 233, 5, 10, 7, 1, -10 },
  { 240, 7, 10, 8, 1, -10 },
  { 249, 7, 10, 9, 1, -10 },
  { 258, 2, 10, 4, 1, -10 },
  { 261, 6, 10, 7, 0, -10 },
  { 269, 7, 10, 8, 1, -10 },
  { 278, 5, 10, 7, 1, -10 },
  { 285, 9, 10, 11, 1, -10 },
  { 297, 7, 10, 9, 1, -10 },
  { 306, 7, 10, 8, 1, -10 },
  { 315, 6, 10, 8, 1, -10 },
  { 323, 7, 12, 8, 1, -10 },
  { 334, 6, 10, 8, 1, -10 },
  { 342, 6, 10, 7, 1, -10 },
  { 350, 7, 10, 8, 0, -10 },
  { 359, 6, 10, 8, 1, -10 },
  { 367, 8, 10, 8, 0, -10 },
  { 377, 10, 10, 11, 0, -10 },
  { 390, 8, 10, 8, 0, -10 },
  { 400, 7, 10, 8, 0, -10 },
  { 409, 6, 10, 7, 1, -10 },
  { 417, 2, 14, 4, 1, -12 },
  { 421, 5, 11, 5, 0, -10 },
  { 428, 3, 14, 4, 0, -12 },
  { 434, 5, 5, 5, 0, -10 },
  { 438, 5, 1, 6, 0, 0 },
  { 439, 4, 2, 5, 0, -10 },
  { 440, 5, 8, 7, 1, -8 },
  { 445, 5, 11, 7, 1, -11 },
  { 452, 5, 8, 6, 1, -8 },
  { 457, 6, 11, 7, 0, -11 },
  { 466, 5, 8, 7, 1, -8 },
  { 471, 4, 11, 5, 0, -11 },
  { 477, 5, 11, 7, 1, -8 },
  { 484, 5, 11, 7, 1, -11 },
  { 491, 2, 11, 3, 1, -11 },
  { 494, 3, 14, 3, 0, -11 },
  { 500, 6, 11, 7, 1, -11 },
  { 509, 2, 11, 3, 1, -11 },
  { 512, 9, 8, 10, 1, -8 },
  { 521, 5, 8, 7, 1, -8 },
  { 526, 5, 8, 7, 1, -8 },
  { 531, 5, 11, 7, 1, -8 },
  { 538, 6, 11, 7, 0, -8 },
  { 547, 3, 8, 5, 1, -8 },
  { 550, 6, 8, 6, 0, -8 },
  { 556, 4, 9, 4, 0, -9 },
  { 561, 5, 8, 7, 1, -8 },
  { 566, 6, 8, 6, 0, -8 },
  { 572, 9, 8, 9, 0, -8 },
  { 581, 6, 8, 6, 0, -8 },
  { 587, 6, 11, 6, 0, -8 },
  { 596, 5, 8, 6, 1, -8 },
  { 601, 4, 13, 4, 0, -11 },
  { 608, 1, 12, 4, 1, -10 },
  { 610, 4, 13, 4, 0, -11 },
  { 617, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_SemiBold14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_SEMIBOLD14PT7B_H_
