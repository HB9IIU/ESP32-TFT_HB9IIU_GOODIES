#ifndef _ROBOTOCONDENSED_SEMIBOLD25PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xC0, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0D, 0x87, 0xFF, 0x7F,
  0xF1, 0x98, 0x19, 0x81, 0x98, 0x19, 0x8F, 0xFE, 0xFF, 0xE3, 0x30, 0x33,
  0x03, 0x30, 0x33, 0x03, 0x30, 0x06, 0x01, 0x80, 0x60, 0x7C, 0x3F, 0x9F,
  0xF7, 0x1D, 0xC7, 0x71, 0xDC, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F,
  0x87, 0xE1, 0xFC, 0x77, 0xFC, 0xFE, 0x1F, 0x03, 0x00, 0xC0, 0x38, 0x01,
  0xF0, 0x0E, 0xE2, 0x31, 0x98, 0xC6, 0xC3, 0xBB, 0x07, 0xD8, 0x0E, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x67, 0x01, 0xBE, 0x0D, 0xDC, 0x36, 0x31, 0x98,
  0xC6, 0x73, 0x00, 0xF8, 0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xE0, 0xE3,
  0x07, 0x18, 0x39, 0xC0, 0xFE, 0x07, 0xE0, 0x1C, 0x01, 0xF3, 0x9F, 0xDD,
  0xCE, 0xEE, 0x7F, 0x71, 0xF3, 0xC7, 0x8F, 0xFC, 0x7F, 0xF0, 0xF3, 0xC0,
  0xFF, 0xFC, 0x04, 0x31, 0xC6, 0x38, 0xC7, 0x1C, 0x71, 0x86, 0x18, 0xE3,
  0x86, 0x18, 0x61, 0xC7, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x10, 0x83, 0x0E,
  0x18, 0x70, 0xC3, 0x8E, 0x38, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3,
  0x8E, 0x31, 0xC6, 0x38, 0xC2, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x33, 0x2F,
  0xFE, 0x7F, 0x83, 0x80, 0xD8, 0x3B, 0x86, 0x38, 0x42, 0x00, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x00, 0x33, 0x33, 0x76, 0x60, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0,
  0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0x1F, 0x0F, 0xE7, 0xF9,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFC, 0x77, 0x1D, 0xFE, 0x3F, 0x87, 0x80, 0x06, 0x3F, 0xFF, 0xFD, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x1F,
  0x07, 0xF1, 0xFF, 0x78, 0xEE, 0x1D, 0xC3, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x1F, 0xE7, 0xFF, 0xC7, 0xE1, 0xC0, 0x70, 0x1C, 0x7E, 0x1F, 0x07,
  0xE0, 0x3C, 0x07, 0x01, 0xF8, 0x7E, 0x1F, 0xFF, 0x7F, 0x87, 0x80, 0x03,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x3F, 0x06, 0xE1, 0xDC, 0x33, 0x8E,
  0x71, 0x8E, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x3F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC3, 0xFC, 0x7F,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1D, 0xC3, 0x9C, 0x73, 0xFE, 0x3F, 0x83,
  0xE0, 0x07, 0x03, 0xE0, 0xFC, 0x1C, 0x07, 0x00, 0xE0, 0x1F, 0xC7, 0xFC,
  0xFF, 0xDE, 0x3B, 0x87, 0x70, 0xFF, 0x1E, 0xE3, 0x9C, 0x73, 0xFE, 0x3F,
  0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xC7, 0x71, 0xDC, 0x77, 0x1D,
  0xFE, 0x3F, 0x0F, 0xE7, 0x3F, 0xC7, 0xE1, 0xF8, 0x7F, 0x1D, 0xFF, 0x7F,
  0x87, 0xC0, 0x1E, 0x0F, 0xC7, 0xF9, 0xCF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xF1, 0xDF, 0xF7, 0xFC, 0xF7, 0x01, 0xC0, 0xE0, 0x78, 0xFC, 0x3E, 0x0F,
  0x00, 0x5F, 0xF0, 0x00, 0x01, 0x7F, 0xC0, 0x27, 0xF7, 0x00, 0x00, 0x00,
  0x07, 0x77, 0x7E, 0xEC, 0x00, 0x83, 0xC7, 0xEF, 0xCF, 0x87, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xC0, 0x20, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x3E, 0x0F, 0xC1, 0xF8, 0x3C, 0x7E, 0xFC, 0xF8,
  0x70, 0x20, 0x00, 0x3E, 0x3F, 0xBF, 0xFC, 0x7E, 0x38, 0x1C, 0x1E, 0x1E,
  0x0E, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0x38, 0x3C, 0x0C, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0x83, 0x83, 0x00, 0xE3, 0x00, 0x33, 0x87,
  0x19, 0x8F, 0xC6, 0xC6, 0x63, 0xE7, 0x31, 0xE3, 0x18, 0xF1, 0x8C, 0x78,
  0xC6, 0x3C, 0xE3, 0x1E, 0x31, 0x8F, 0x19, 0xCD, 0x8F, 0xFE, 0x63, 0x9E,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0xC1, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x1C, 0xF0, 0x38, 0xE0, 0x71, 0xC1, 0xFF, 0x83,
  0xFF, 0x87, 0xFF, 0x1E, 0x0E, 0x38, 0x1E, 0x70, 0x1D, 0xE0, 0x38, 0xFF,
  0x1F, 0xF3, 0xFF, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x3E, 0xFF, 0x9F,
  0xFB, 0x87, 0x70, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0xFE, 0xFF, 0x9F, 0xE0,
  0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x0F, 0x70, 0x7F, 0x07, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x77, 0x07, 0x70, 0xF7, 0xFE,
  0x3F, 0xE0, 0xF8, 0xFE, 0x1F, 0xF3, 0xFE, 0x70, 0xEE, 0x1D, 0xC3, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xB8, 0x77,
  0xFE, 0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xFE, 0xFF, 0xBF, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0x7F, 0xBF, 0xDC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x8F, 0x70, 0x7F, 0x07, 0xF0, 0x0F, 0x00,
  0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x07, 0xF0, 0x77, 0x07, 0x78, 0x77, 0xFF,
  0x3F, 0xF0, 0xFC, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xF8, 0xFE, 0x3B, 0xFE, 0x7F, 0x0F, 0x80,
  0xE1, 0xEE, 0x1E, 0xE3, 0xCE, 0x38, 0xE7, 0x8E, 0xF0, 0xEE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0x70, 0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1E,
  0xE1, 0xEE, 0x0F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x6F, 0xD9, 0xDF, 0xBB, 0xBF, 0x77, 0x7E, 0x6C,
  0xFC, 0xF9, 0xF9, 0xF3, 0xF3, 0xC7, 0xE3, 0x8F, 0xC7, 0x1C, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEE, 0x7E,
  0xE7, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x0F, 0x0F, 0x81, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xB8, 0x39,
  0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xFF, 0x1F, 0xFB, 0xFF, 0x70,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xFF, 0xDF, 0xFB, 0xFC, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x81, 0xFF, 0x1F,
  0xFC, 0xF1, 0xE7, 0x07, 0x78, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xB8, 0x39, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0,
  0x7F, 0x00, 0x3C, 0x00, 0xE0, 0x02, 0x00, 0xFF, 0x1F, 0xF3, 0xFF, 0x70,
  0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xFF, 0xDF, 0xF3, 0xFC, 0x73, 0xCE,
  0x39, 0xC7, 0x38, 0xF7, 0x0E, 0xE1, 0xFC, 0x1C, 0x1F, 0x07, 0xF9, 0xFF,
  0xF8, 0x7F, 0x0F, 0xE0, 0x1C, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0x80,
  0x7E, 0x0F, 0xC1, 0xFC, 0x3B, 0xFF, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0x70, 0xF7, 0xFE,
  0x3F, 0xC1, 0xF8, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x38, 0x78,
  0xE1, 0xC3, 0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x03, 0xB8,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE1,
  0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x78, 0xFF, 0x3E, 0x73, 0x9F, 0x39,
  0xCF, 0x9C, 0xE6, 0xCE, 0x77, 0x67, 0x3B, 0xBB, 0x8D, 0xDF, 0x87, 0xCF,
  0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x1C, 0x1C, 0x0E,
  0x0E, 0x00, 0xF0, 0xFF, 0x0F, 0x70, 0xE7, 0x9E, 0x39, 0xC3, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0xC3, 0x9C, 0x79,
  0xE7, 0x0E, 0xF0, 0xFE, 0x0F, 0xF0, 0x7B, 0x83, 0xDE, 0x1C, 0x71, 0xE3,
  0x8E, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xFF, 0xF8, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0xF8, 0x18, 0x38, 0x3C,
  0x3C, 0x7C, 0x6E, 0xE6, 0xE7, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xC3,
  0x86, 0x1E, 0x1F, 0xE7, 0xFB, 0xCE, 0x03, 0x8F, 0xE7, 0xFB, 0xCE, 0xE3,
  0xB8, 0xEF, 0xF9, 0xFF, 0x3D, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0xC7, 0xFF, 0xFF, 0xEE, 0xF0, 0x1E, 0x1F, 0xE7, 0xFB, 0x87, 0xE1,
  0xF8, 0x0E, 0x03, 0x80, 0xE1, 0xF8, 0x77, 0xF9, 0xFE, 0x1E, 0x00, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x73, 0xDD, 0xFF, 0xFF, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF, 0xDF, 0xF3, 0xDC, 0x1F,
  0x1F, 0xE7, 0xFF, 0xC7, 0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x27,
  0xFD, 0xFF, 0x1F, 0x00, 0x1E, 0x7C, 0xFB, 0xC7, 0x0E, 0x3F, 0x7E, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x3D, 0xDF, 0xF7,
  0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x77, 0xFD, 0xFF,
  0x3D, 0xC0, 0x70, 0x1D, 0xFF, 0x7F, 0x8F, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xFC, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0x7F, 0x60, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x3C, 0xF1, 0x80, 0x00, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFB, 0xEF, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0xF7, 0x1C, 0xE7, 0x9D,
  0xE3, 0xB8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3D, 0xC7, 0x3C, 0xE3, 0x9C, 0x7B,
  0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xEF, 0x1E,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7,
  0xE7, 0x3F, 0xEF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x1F, 0x0F, 0xF1, 0xFF, 0x78, 0xEE, 0x1D,
  0xC3, 0xB8, 0x7F, 0x0F, 0xE1, 0xDE, 0x39, 0xFF, 0x3F, 0xC1, 0xF0, 0xEF,
  0x3F, 0xEF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7F,
  0xFF, 0xFE, 0xEF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3D, 0xDF,
  0xFF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F, 0xFD,
  0xFF, 0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xEF, 0xFF, 0xFF,
  0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x3E, 0x3F, 0xBD,
  0xFC, 0x7F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xF1, 0xFD, 0xEF, 0xF3, 0xE0,
  0x38, 0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0xCF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xFC, 0x77, 0xFD, 0xFF, 0x3D, 0xC0, 0x71, 0xEE, 0x39, 0xC7, 0x38,
  0xE3, 0xB8, 0x77, 0x0E, 0xE0, 0xDC, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x00,
  0xE0, 0x71, 0x8E, 0xE7, 0x1D, 0xCF, 0x3B, 0x9E, 0x77, 0x3C, 0xC6, 0xFB,
  0x8F, 0xFF, 0x1F, 0x3E, 0x3E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xE1, 0xC1,
  0xC3, 0x80, 0x71, 0xCF, 0x38, 0xEE, 0x1F, 0xC1, 0xF0, 0x3E, 0x03, 0x80,
  0xF8, 0x1F, 0x07, 0x70, 0xEE, 0x3C, 0xE7, 0x1E, 0xF1, 0xEE, 0x39, 0xC7,
  0x38, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xD8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x38, 0x3F, 0xFF, 0xFF, 0xF8,
  0x08, 0x73, 0x8E, 0x30, 0xC3, 0x0C, 0x71, 0xCF, 0x38, 0xE1, 0xC7, 0x0C,
  0x30, 0xC3, 0x0C, 0x38, 0xE1, 0xC2, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x83, 0x8E, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x87, 0x3C, 0xE7, 0x1C,
  0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x20, 0x3C, 0x77, 0xE7, 0x7F, 0xEE, 0x7E,
  0xE1, 0xC0,
};

const GFXglyph RobotoCondensed_SemiBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 18, 6, 2, -18 },
  { 8, 6, 7, 8, 1, -19 },
  { 14, 12, 18, 13, 1, -18 },
  { 41, 10, 23, 13, 1, -21 },
  { 70, 14, 18, 16, 1, -18 },
  { 102, 13, 18, 14, 1, -18 },
  { 132, 2, 7, 4, 1, -19 },
  { 134, 6, 26, 8, 1, -20 },
  { 154, 6, 26, 8, 1, -20 },
  { 174, 11, 11, 11, 0, -18 },
  { 190, 10, 13, 12, 1, -15 },
  { 207, 4, 7, 6, 0, -3 },
  { 211, 6, 3, 8, 1, -9 },
  { 214, 3, 4, 7, 2, -4 },
  { 216, 8, 20, 9, 0, -18 },
  { 236, 10, 18, 13, 1, -18 },
  { 259, 7, 18, 13, 2, -18 },
  { 275, 11, 18, 13, 1, -18 },
  { 300, 10, 18, 13, 1, -18 },
  { 323, 11, 18, 13, 1, -18 },
  { 348, 11, 18, 13, 1, -18 },
  { 373, 11, 18, 13, 1, -18 },
  { 398, 11, 18, 13, 1, -18 },
  { 423, 10, 18, 13, 1, -18 },
  { 446, 10, 18, 13, 1, -18 },
  { 469, 3, 14, 7, 2, -14 },
  { 475, 4, 18, 6, 1, -14 },
  { 484, 9, 11, 11, 1, -13 },
  { 497, 9, 8, 12, 2, -12 },
  { 506, 9, 11, 11, 2, -13 },
  { 519, 9, 18, 11, 1, -18 },
  { 540, 17, 23, 19, 1, -17 },
  { 589, 15, 18, 15, 0, -18 },
  { 623, 11, 18, 14, 2, -18 },
  { 648, 12, 18, 14, 1, -18 },
  { 675, 11, 18, 14, 2, -18 },
  { 700, 10, 18, 12, 2, -18 },
  { 723, 9, 18, 12, 2, -18 },
  { 744, 12, 18, 15, 1, -18 },
  { 771, 12, 18, 15, 2, -18 },
  { 798, 3, 18, 7, 2, -18 },
  { 805, 10, 18, 12, 1, -18 },
  { 828, 12, 18, 14, 2, -18 },
  { 855, 9, 18, 12, 2, -18 },
  { 876, 15, 18, 19, 2, -18 },
  { 910, 12, 18, 15, 2, -18 },
  { 937, 13, 18, 15, 1, -18 },
  { 967, 11, 18, 14, 2, -18 },
  { 992, 13, 21, 15, 1, -18 },
  { 1027, 11, 18, 14, 2, -18 },
  { 1052, 11, 18, 13, 1, -18 },
  { 1077, 12, 18, 13, 1, -18 },
  { 1104, 12, 18, 14, 1, -18 },
  { 1131, 14, 18, 14, 0, -18 },
  { 1163, 17, 18, 19, 1, -18 },
  { 1202, 12, 18, 14, 1, -18 },
  { 1229, 13, 18, 13, 0, -18 },
  { 1259, 11, 18, 13, 1, -18 },
  { 1284, 5, 25, 7, 1, -21 },
  { 1300, 10, 20, 9, 0, -18 },
  { 1325, 5, 25, 7, 0, -21 },
  { 1341, 8, 9, 10, 1, -18 },
  { 1350, 10, 3, 10, 0, 0 },
  { 1354, 6, 4, 8, 1, -19 },
  { 1357, 10, 13, 12, 1, -13 },
  { 1374, 10, 19, 12, 1, -19 },
  { 1398, 10, 13, 12, 1, -13 },
  { 1415, 10, 19, 12, 1, -19 },
  { 1439, 10, 13, 12, 1, -13 },
  { 1456, 7, 19, 8, 1, -19 },
  { 1473, 10, 18, 13, 1, -13 },
  { 1496, 10, 19, 12, 1, -19 },
  { 1520, 4, 18, 6, 1, -18 },
  { 1529, 6, 23, 6, -1, -18 },
  { 1547, 11, 19, 12, 1, -19 },
  { 1574, 3, 19, 6, 2, -19 },
  { 1582, 16, 13, 19, 1, -13 },
  { 1608, 10, 13, 12, 1, -13 },
  { 1625, 11, 13, 12, 1, -13 },
  { 1643, 10, 18, 12, 1, -13 },
  { 1666, 10, 18, 12, 1, -13 },
  { 1689, 7, 13, 8, 1, -13 },
  { 1701, 9, 13, 11, 1, -13 },
  { 1716, 7, 16, 8, 0, -16 },
  { 1730, 10, 13, 12, 1, -13 },
  { 1747, 11, 13, 11, 0, -13 },
  { 1765, 15, 13, 16, 0, -13 },
  { 1790, 11, 13, 11, 0, -13 },
  { 1808, 11, 18, 11, 0, -13 },
  { 1833, 9, 13, 11, 1, -13 },
  { 1848, 6, 24, 8, 1, -20 },
  { 1866, 2, 21, 6, 2, -18 },
  { 1872, 6, 24, 8, 1, -20 },
  { 1890, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_SemiBold25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_SEMIBOLD25PT7B_H_
