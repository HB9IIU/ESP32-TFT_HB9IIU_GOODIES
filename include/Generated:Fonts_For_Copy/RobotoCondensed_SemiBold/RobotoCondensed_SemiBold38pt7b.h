#ifndef _ROBOTOCONDENSED_SEMIBOLD38PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0xFD, 0xE7, 0x80, 0xF3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3B, 0xCE, 0xE3, 0xB8, 0xE0, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xF3, 0x80, 0x71, 0xC0, 0x38, 0xE0,
  0x1C, 0x70, 0x0E, 0x38, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE1, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0,
  0x79, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x00, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE,
  0x7C, 0x7C, 0xF8, 0x7D, 0xE0, 0xFB, 0xC1, 0xF7, 0xC3, 0xEF, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7D, 0xF1, 0xFB,
  0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x01, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xE7,
  0x06, 0x0E, 0x3C, 0x38, 0x70, 0xE3, 0x83, 0x87, 0x1C, 0x1C, 0x39, 0xC0,
  0xE3, 0xDC, 0x07, 0x9C, 0xE0, 0x1F, 0xEE, 0x00, 0xFE, 0x70, 0x01, 0xE7,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x9F, 0x00, 0x1D, 0xFC, 0x01, 0xDF, 0xF0,
  0x0E, 0xE3, 0x80, 0xE7, 0x1C, 0x0F, 0x38, 0xF0, 0x71, 0xC7, 0x87, 0x0E,
  0x3C, 0x38, 0x71, 0xC1, 0x83, 0x8E, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1E, 0x3C, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xE1, 0xE3, 0xFF, 0x3E, 0x7D, 0xFB, 0xE7, 0xCF, 0xBC, 0x78,
  0x7F, 0xCF, 0x87, 0xFC, 0x78, 0x3F, 0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xBE, 0x07, 0xE3, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0x01, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x04, 0x40,
  0x70, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1C,
  0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x06, 0x1C, 0x13, 0xCE, 0x79, 0xFF, 0xFC, 0xFF, 0xFF,
  0x07, 0xF8, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE3, 0xC0, 0xF1,
  0xE0, 0x70, 0x70, 0x00, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0xF3, 0xCF, 0x7D, 0xF7,
  0x9E, 0xF3, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xFF, 0xDF,
  0x78, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xEF, 0x07, 0x9F, 0x1F, 0x3F, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00,
  0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x03, 0xF0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xE3, 0xE0, 0xF9, 0xF0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1F, 0x78, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x1F, 0x7E, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0x9E, 0x03,
  0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78,
  0x78, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF7, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF7, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xCF, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F,
  0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xDF, 0x1F, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F,
  0xE0, 0x1F, 0x80, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x79, 0xF0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFC, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7C,
  0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7,
  0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0xF8, 0x79, 0xF1, 0xF1,
  0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xFE, 0x3E, 0x3E, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0x1F, 0xBF, 0xFE,
  0x3F, 0xFC, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xC7, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x8F, 0xDF, 0xFF, 0xBF, 0xFF,
  0x3F, 0xFE, 0x1E, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x78, 0x00, 0x79, 0xFF, 0xDF,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0xF7, 0xDE,
  0x3C, 0xFD, 0xFB, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x79, 0xE0, 0x80,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0xF8,
  0x3F, 0x80, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0xCF, 0xFC, 0xFF,
  0xC3, 0xFC, 0x0F, 0xC0, 0x38, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xC7,
  0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x1F,
  0x03, 0x9E, 0x0F, 0xF0, 0xE7, 0x07, 0xFC, 0x39, 0xC3, 0xE7, 0x0E, 0xF0,
  0xF1, 0xC3, 0xB8, 0x78, 0x70, 0x6E, 0x1E, 0x1C, 0x1B, 0x87, 0x07, 0x07,
  0xE1, 0xC1, 0xC1, 0xB8, 0xF0, 0x70, 0xEE, 0x3C, 0x3C, 0x3B, 0x8F, 0x0F,
  0x0E, 0xE3, 0xC3, 0xC3, 0xB8, 0x70, 0xF1, 0xCE, 0x1E, 0x7C, 0x73, 0x87,
  0xFF, 0xF8, 0xF0, 0xFD, 0xFC, 0x1C, 0x1E, 0x1E, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x1C,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xF7, 0xC0,
  0x07, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83,
  0xF7, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFE, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xDF,
  0x01, 0xF7, 0xE1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0x80, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7F,
  0x3E, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0x9F, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xDF, 0x01,
  0xF7, 0xF0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xC0,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x1F, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F,
  0x00, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x83,
  0xF1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E,
  0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFE, 0xF8, 0x1F, 0x9F, 0x83, 0xF1, 0xF0, 0x7C, 0x3F,
  0x0F, 0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xF8, 0x0F,
  0xDF, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xEF, 0xFF, 0xC1, 0xEF, 0xFB, 0xC1, 0xEF, 0xFB, 0xC3, 0xEF,
  0xFB, 0xE3, 0xCF, 0xF9, 0xE3, 0xCF, 0xF9, 0xE3, 0xCF, 0xF9, 0xF7, 0x8F,
  0xF8, 0xF7, 0x8F, 0xF8, 0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F,
  0xF8, 0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x3E, 0x0F,
  0xF8, 0x3E, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xEF, 0x0F, 0xFD, 0xF1, 0xFF, 0x9E,
  0x3F, 0xF3, 0xE7, 0xFE, 0x3C, 0xFF, 0xC7, 0xDF, 0xF8, 0x7B, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xF8,
  0x0F, 0x9F, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0xC7, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xF8, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xF1, 0xF8, 0xF8, 0x0F, 0xBF, 0x01, 0xF7, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0xC7, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F, 0xBE, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E,
  0xF8, 0x3F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0xCF, 0x81,
  0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xBE, 0x03, 0xFF, 0x80, 0x7C, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F, 0x03, 0xE7,
  0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xDF, 0x03, 0xF7,
  0xF1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBF,
  0x03, 0xE7, 0xE1, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x78,
  0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xF8, 0x1F, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0, 0x7C, 0x1F, 0x3C, 0x0F,
  0x83, 0xE7, 0xC3, 0xF0, 0x7C, 0xF8, 0x7F, 0x0F, 0x9F, 0x0F, 0xE1, 0xF3,
  0xE1, 0xFC, 0x3C, 0x3C, 0x3F, 0x8F, 0x87, 0x8F, 0xF1, 0xF0, 0xF9, 0xEE,
  0x3E, 0x1F, 0x3D, 0xE7, 0xC3, 0xE7, 0xBC, 0xF0, 0x7C, 0xF7, 0x9E, 0x07,
  0xBC, 0xF3, 0xC0, 0xF7, 0x8E, 0xF8, 0x1E, 0xF1, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xEF, 0x80,
  0xFD, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xF0, 0xF8, 0x3E, 0x3F, 0x07, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x81, 0xF1, 0xF0, 0x3E, 0x3F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7E, 0x7E, 0x07, 0xCF, 0x80, 0xFF, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x00,
  0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x0E, 0xE0, 0xF7, 0x07, 0xBC,
  0x38, 0xE3, 0xC7, 0x1E, 0x3C, 0xE1, 0xEF, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C,
  0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF, 0x87, 0xDF, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xE3, 0xEF, 0x87,
  0xDE, 0x0F, 0xBC, 0x1F, 0x7C, 0x7E, 0xFF, 0xFD, 0xFF, 0xF9, 0xFF, 0xF0,
  0xF9, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF3, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0xFF, 0xDF, 0x8F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x7F, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0x9F, 0x00, 0x07, 0xE0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xC3, 0xEF, 0x87, 0xDE, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x03, 0xDF,
  0x07, 0xBE, 0x1F, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x9F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x02, 0x7E, 0x0E, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x03,
  0xE1, 0xFC, 0x7F, 0x8F, 0xF1, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x1F,
  0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x07, 0xCF, 0x1F, 0xEF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x10,
  0x1F, 0x18, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF3, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF,
  0x8F, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x7F, 0xFF, 0xF7, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFE, 0xFC, 0xF8,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xFC,
  0xF9, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF9, 0xF0, 0xF8, 0xFF, 0xF9, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF1, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7D, 0xF0, 0x1E,
  0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xE7, 0x80, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0x7E, 0x00, 0xF1, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0xC7, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xE7, 0xCF, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x0F, 0x9F, 0x1F, 0xFF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C,
  0x1F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0x9F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC7, 0xCF, 0x07, 0xDF, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xFF, 0x07, 0xFE, 0x0F, 0xBE, 0x1F, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF1, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xC3, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFE, 0xF8, 0xF9, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xC1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E, 0x1E, 0x3C, 0x3C, 0xF8,
  0x7D, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x78, 0x3F,
  0xE1, 0xE0, 0xFF, 0x87, 0x87, 0xFE, 0x3F, 0x1F, 0x78, 0xFC, 0x7D, 0xE3,
  0xF1, 0xE7, 0x8F, 0xC7, 0x9F, 0x7F, 0x9E, 0x3D, 0xFE, 0xF8, 0xF7, 0xBB,
  0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0x1F, 0xC1,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0xF8, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xC3,
  0xEF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xBE, 0x1F, 0x7C, 0x7C, 0x7C,
  0xF8, 0xFB, 0xF0, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C,
  0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x81, 0xC1, 0xE1, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0xFC, 0x7C, 0x3E, 0x1F, 0x83,
  0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x70, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x78, 0x3E, 0x0F, 0x03,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x3C, 0x1F, 0x87, 0xC1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x04,
  0x00, 0x1E, 0x00, 0x0F, 0xE0, 0xF7, 0xFC, 0x39, 0xFF, 0x9E, 0xF1, 0xFF,
  0xBC, 0x3F, 0xCF, 0x07, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 10, 10, 12, 1, -29 },
  { 35, 17, 27, 20, 2, -27 },
  { 93, 15, 35, 19, 2, -31 },
  { 159, 21, 27, 24, 2, -27 },
  { 230, 20, 27, 22, 1, -27 },
  { 298, 4, 10, 6, 1, -29 },
  { 303, 9, 39, 12, 2, -30 },
  { 347, 9, 39, 12, 1, -30 },
  { 391, 17, 16, 17, 0, -27 },
  { 425, 16, 19, 18, 1, -22 },
  { 463, 6, 11, 9, 1, -4 },
  { 472, 9, 4, 13, 2, -14 },
  { 477, 6, 5, 11, 2, -5 },
  { 481, 12, 29, 13, 0, -27 },
  { 525, 15, 27, 19, 2, -27 },
  { 576, 10, 27, 19, 3, -27 },
  { 610, 17, 27, 19, 1, -27 },
  { 668, 16, 27, 19, 1, -27 },
  { 722, 17, 27, 19, 1, -27 },
  { 780, 15, 27, 19, 2, -27 },
  { 831, 16, 27, 19, 2, -27 },
  { 885, 16, 27, 19, 1, -27 },
  { 939, 15, 27, 19, 2, -27 },
  { 990, 15, 27, 19, 2, -27 },
  { 1041, 6, 20, 10, 2, -20 },
  { 1056, 7, 27, 9, 1, -20 },
  { 1080, 14, 17, 17, 1, -20 },
  { 1110, 13, 12, 19, 3, -18 },
  { 1130, 14, 17, 17, 2, -20 },
  { 1160, 14, 27, 17, 1, -27 },
  { 1208, 26, 34, 29, 2, -26 },
  { 1319, 22, 27, 23, 0, -27 },
  { 1394, 17, 27, 21, 2, -27 },
  { 1452, 18, 27, 22, 2, -27 },
  { 1513, 18, 27, 22, 2, -27 },
  { 1574, 16, 27, 19, 2, -27 },
  { 1628, 15, 27, 18, 2, -27 },
  { 1679, 18, 27, 22, 2, -27 },
  { 1740, 19, 27, 23, 2, -27 },
  { 1805, 5, 27, 10, 3, -27 },
  { 1822, 15, 27, 19, 1, -27 },
  { 1873, 19, 27, 21, 2, -27 },
  { 1938, 15, 27, 18, 2, -27 },
  { 1989, 24, 27, 29, 2, -27 },
  { 2070, 19, 27, 23, 2, -27 },
  { 2135, 19, 27, 23, 2, -27 },
  { 2200, 18, 27, 21, 2, -27 },
  { 2261, 19, 32, 23, 2, -27 },
  { 2337, 18, 27, 21, 2, -27 },
  { 2398, 18, 27, 20, 1, -27 },
  { 2459, 18, 27, 20, 1, -27 },
  { 2520, 18, 27, 22, 2, -27 },
  { 2581, 21, 27, 22, 0, -27 },
  { 2652, 27, 27, 29, 1, -27 },
  { 2744, 19, 27, 21, 1, -27 },
  { 2809, 20, 27, 20, 0, -27 },
  { 2877, 18, 27, 20, 1, -27 },
  { 2938, 7, 37, 10, 2, -31 },
  { 2971, 15, 29, 14, 0, -27 },
  { 3026, 7, 37, 10, 1, -31 },
  { 3059, 13, 13, 15, 1, -27 },
  { 3081, 15, 4, 15, 0, 0 },
  { 3089, 9, 6, 12, 1, -29 },
  { 3096, 15, 20, 18, 2, -20 },
  { 3134, 15, 29, 19, 2, -29 },
  { 3189, 15, 20, 18, 1, -20 },
  { 3227, 16, 29, 19, 1, -29 },
  { 3285, 15, 20, 18, 2, -20 },
  { 3323, 11, 29, 12, 1, -29 },
  { 3363, 16, 28, 19, 1, -20 },
  { 3419, 15, 29, 19, 2, -29 },
  { 3474, 5, 28, 9, 2, -28 },
  { 3492, 8, 36, 9, -1, -28 },
  { 3528, 16, 29, 18, 2, -29 },
  { 3586, 5, 29, 9, 2, -29 },
  { 3605, 24, 20, 28, 2, -20 },
  { 3665, 15, 20, 19, 2, -20 },
  { 3703, 17, 20, 19, 1, -20 },
  { 3746, 15, 28, 19, 2, -20 },
  { 3799, 16, 28, 19, 1, -20 },
  { 3855, 10, 20, 12, 2, -20 },
  { 3880, 15, 20, 17, 1, -20 },
  { 3918, 11, 25, 12, 0, -25 },
  { 3953, 15, 20, 19, 2, -20 },
  { 3991, 15, 20, 17, 1, -20 },
  { 4029, 22, 20, 24, 1, -20 },
  { 4084, 15, 20, 17, 1, -20 },
  { 4122, 16, 28, 17, 0, -20 },
  { 4178, 14, 20, 17, 2, -20 },
  { 4213, 9, 37, 11, 1, -30 },
  { 4255, 3, 32, 10, 3, -27 },
  { 4267, 9, 37, 11, 1, -30 },
  { 4309, 18, 8, 21, 2, -15 },
};

const GFXfont RobotoCondensed_SemiBold38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_SEMIBOLD38PT7B_H_
