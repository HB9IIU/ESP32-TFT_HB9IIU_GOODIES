#ifndef _ROBOTOCONDENSED_SEMIBOLD30PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x6F, 0xF6,
  0xE7, 0xE7, 0xE6, 0xE6, 0xE6, 0xE6, 0xE6, 0xC6, 0x07, 0x30, 0x1C, 0xC0,
  0x63, 0x01, 0x9C, 0x06, 0x70, 0x19, 0xC0, 0xE6, 0x1F, 0xFF, 0x7F, 0xFC,
  0x31, 0x80, 0xCE, 0x03, 0x38, 0x0C, 0xE3, 0xFF, 0xEF, 0xFF, 0x86, 0x30,
  0x18, 0xC0, 0x67, 0x01, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xE6, 0x00, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x01, 0xFE, 0x1F, 0xF9, 0xF3, 0xCF, 0x1E,
  0x78, 0x7B, 0xC3, 0xDE, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7E, 0x00, 0xF0, 0x03, 0xBC, 0x1F, 0xE0, 0xF7, 0x87, 0x3C, 0x78, 0xFF,
  0xC7, 0xFC, 0x0F, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x1D, 0xC0, 0x0C, 0x63, 0x8E, 0x31, 0x87, 0x19, 0xC1, 0x8C, 0xC0,
  0xEE, 0xE0, 0x7E, 0x60, 0x1E, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x19,
  0xE0, 0x1D, 0xF8, 0x0D, 0xDC, 0x0E, 0xE7, 0x06, 0x63, 0x86, 0x31, 0xC3,
  0x1C, 0xE1, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x3D, 0xE0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x1E, 0x7F, 0x9C, 0x7B, 0xDC,
  0xF3, 0xFC, 0xF1, 0xFC, 0xF0, 0xFC, 0xF0, 0xF8, 0x78, 0xF8, 0x7F, 0xFC,
  0x3F, 0xFE, 0x1F, 0x9E, 0xFF, 0xFF, 0xFF, 0x04, 0x1C, 0x78, 0xE3, 0x87,
  0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1E, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC1, 0x00, 0x81,
  0x83, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x38, 0x71, 0xC3, 0x8E,
  0x18, 0x20, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x86, 0x07, 0x33, 0xBF,
  0xFC, 0xFF, 0xC0, 0xF0, 0x0F, 0x80, 0xEE, 0x0F, 0x38, 0x71, 0xC0, 0x04,
  0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x39, 0xCE, 0x73, 0x9D, 0xCE, 0x20, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7,
  0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xF9,
  0xE7, 0x8F, 0x38, 0x39, 0xC1, 0xDE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xC1, 0xEE, 0x0E, 0x70, 0x73, 0xC7, 0x9F,
  0x3C, 0x7F, 0xC1, 0xFC, 0x07, 0xC0, 0x01, 0x0F, 0x3F, 0xFF, 0xFF, 0xEF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xF3, 0xEF, 0x0F,
  0x78, 0x7B, 0xC1, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x83, 0xFE, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0xFE, 0x0F, 0xC0, 0xFE, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0xF0, 0x7F, 0x0F, 0x79, 0xF7, 0xFE, 0x3F, 0xC1,
  0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x1D, 0xE1, 0xEF, 0x0E, 0x78, 0xF3, 0xC7, 0x1E, 0x78, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F,
  0xF8, 0xFF, 0xCF, 0xFE, 0xF1, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0xE0, 0xFF, 0x1E, 0xF1, 0xE7, 0xFC, 0x3F, 0xC1, 0xF0, 0x03, 0x80,
  0xF8, 0x1F, 0x83, 0xE0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x78, 0xFF, 0xCF,
  0xFE, 0xF9, 0xEF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF,
  0x0E, 0x79, 0xE7, 0xFE, 0x3F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x07, 0xFC, 0x7F, 0xCF,
  0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0x79, 0xE7, 0xFC, 0x3F, 0x87,
  0xFC, 0xF1, 0xEF, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFF, 0x1E, 0xF1, 0xEF,
  0xFE, 0x7F, 0xC1, 0xF0, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xDE, 0x78, 0xF7,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x78, 0xF7, 0x8F, 0x7F, 0xF3,
  0xFF, 0x1E, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0xC1, 0xFC, 0x1F, 0x01,
  0xC0, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0x7B, 0xDE, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0x73, 0x9D, 0xC4, 0x00, 0x00,
  0x40, 0x30, 0x3C, 0x3F, 0x3F, 0xBF, 0x8F, 0x83, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0x00, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0, 0x7F, 0x07,
  0xF8, 0x1F, 0xC0, 0xF8, 0x1F, 0x0F, 0xEF, 0xF3, 0xF8, 0x7C, 0x0E, 0x01,
  0x00, 0x00, 0x1F, 0x0F, 0xF9, 0xFF, 0x7D, 0xFF, 0x1F, 0xE3, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF8, 0x01, 0xE1, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x00,
  0x30, 0xE0, 0xF1, 0xC6, 0x1F, 0xC6, 0x71, 0xEE, 0x33, 0x8E, 0x71, 0xD8,
  0xE3, 0x8E, 0xC7, 0x1C, 0x7E, 0x38, 0xE3, 0xF1, 0xC7, 0x1F, 0x8E, 0x38,
  0xFC, 0x71, 0xC6, 0xE3, 0x8E, 0x37, 0x1C, 0xF3, 0x98, 0xFF, 0xB8, 0xC3,
  0xEF, 0xC7, 0x0E, 0x78, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7E, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0E, 0xF0, 0x07, 0x38, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xC7,
  0x81, 0xE1, 0xC0, 0xF0, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E,
  0x07, 0x9E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3C, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFD, 0xE3, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xFF, 0xEF, 0xFE, 0x7F, 0xE0, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF1, 0xF3, 0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xB8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x0F, 0x78, 0x1E, 0xF0, 0x3C, 0xF9, 0xF1, 0xFF, 0xE1,
  0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xE3, 0xEF, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x7D, 0xFF,
  0xCF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xF3, 0xE7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xB8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xFF, 0x0F, 0xEE, 0x1F, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF8, 0x3C, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF, 0xC0,
  0xFE, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFB, 0xE7,
  0xFE, 0x3F, 0xC1, 0xF0, 0xF0, 0x7D, 0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0x8F,
  0x1E, 0x1E, 0x7C, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7, 0x81, 0xFE, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0x78, 0x3C, 0xF8, 0x78, 0xF0, 0xF1, 0xF1,
  0xE1, 0xE3, 0xC3, 0xE7, 0x83, 0xCF, 0x07, 0xDE, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xEE, 0x1F, 0xFD, 0xE3, 0xBF, 0xFC, 0x77, 0xFB, 0x8E, 0xFF,
  0x73, 0xDF, 0xEF, 0x73, 0xFC, 0xEE, 0x7F, 0x9F, 0xCF, 0xF3, 0xF1, 0xFE,
  0x3E, 0x3F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFF, 0x1E, 0x1F, 0xE1, 0xC3, 0xC0,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x87, 0xFF, 0x0F, 0xFF, 0x1F, 0xEE, 0x3F, 0xDE, 0x7F, 0x9C, 0xFF, 0x3D,
  0xFE, 0x3B, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFE, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3E, 0x7C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0, 0x7B, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xBF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3E,
  0x7C, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3C, 0x7E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x1F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0x1E, 0x3C,
  0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0, 0x7B, 0xC1, 0xF0,
  0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x78, 0x79, 0xC0, 0xF7, 0x03,
  0xDE, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0xF7, 0xC7, 0x9F, 0xFE, 0x3F,
  0xF0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFE,
  0x3E, 0xFF, 0xE3, 0xFE, 0x07, 0xE0, 0x78, 0x0F, 0xBC, 0x07, 0x9E, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0xF3, 0x80, 0x7B, 0xC0,
  0x1D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x70, 0x7F, 0x87, 0x83, 0xFC, 0x3C,
  0x1D, 0xE1, 0xF1, 0xE7, 0x0F, 0x8F, 0x38, 0x7C, 0x79, 0xE7, 0xE3, 0xCF,
  0x3F, 0x1E, 0x79, 0xFC, 0xE3, 0xCE, 0xE7, 0x0E, 0x77, 0x78, 0x73, 0xBB,
  0xC3, 0xF9, 0xDE, 0x1F, 0xCF, 0xF0, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0x78,
  0x07, 0x83, 0xC0, 0xF0, 0x3F, 0xF0, 0x79, 0xE0, 0xF3, 0xE3, 0xC3, 0xC7,
  0x87, 0xDE, 0x07, 0xBC, 0x0F, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0x78, 0x3C, 0xF0, 0x78,
  0xF1, 0xF1, 0xE3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xC0, 0xF8, 0x1F, 0x78,
  0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x78, 0x1E,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xFF, 0xFC, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF,
  0xFF, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0xF8, 0x3F, 0x0D, 0xC7, 0x31, 0xCE,
  0x73, 0xB8, 0xEE, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x9E, 0xF0, 0xF0, 0x0F, 0x1F, 0xF3,
  0xFF, 0x7C, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xF7, 0xFF, 0x7F, 0xF1,
  0xEF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x78, 0xFF, 0xCF, 0xFE, 0xF1, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1E, 0xFF, 0xEF, 0xFC, 0xE7, 0x80,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0x0F, 0x79, 0xE7, 0xFE, 0x3F, 0xC0, 0xF8,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEF,
  0x3F, 0xF7, 0xFF, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x9F, 0x7F, 0xF3, 0xF7, 0x1E, 0x70, 0x0F,
  0x83, 0xFE, 0x7F, 0xE7, 0x8F, 0x70, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x07, 0x02, 0x78, 0x67, 0xFF, 0x3F, 0xE0, 0xFC, 0x0F,
  0x1F, 0x3F, 0x3C, 0x3C, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x73,
  0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0x78, 0xF7, 0xFF, 0x3F, 0xF1, 0xE7, 0x00, 0x70,
  0x0F, 0x30, 0xF7, 0xFF, 0x3F, 0xE1, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x3C, 0xFF, 0xDF, 0xFF, 0xC7, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x78, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x3C, 0x78, 0xE0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3D,
  0xFB, 0xF7, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x1E, 0xE3, 0xEE, 0x3C, 0xE7, 0x8E, 0xF0, 0xEF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0x78, 0xE3, 0xCE, 0x3C, 0xE1, 0xEE, 0x1E,
  0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE7, 0x8F, 0x9F, 0xFB, 0xFB, 0xFF, 0xFF, 0x79, 0xF9, 0xEE,
  0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x78, 0x7F, 0x0F, 0x0F, 0xE1, 0xE1, 0xFC,
  0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8,
  0x78, 0x7F, 0x0F, 0x0F, 0xE7, 0x9D, 0xFB, 0xFF, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF1, 0xEF, 0x07, 0x78, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xE7, 0x8F, 0x3F,
  0xF8, 0xFF, 0x81, 0xF0, 0xE7, 0x8F, 0xFC, 0xFF, 0xEF, 0x1E, 0xE0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xF1, 0xEF,
  0xFE, 0xFF, 0xCE, 0x78, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x1E, 0x73, 0xF7, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0xFF, 0x3F, 0xF1,
  0xEF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xEF, 0xDF,
  0xFF, 0xFF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0x1F, 0x07, 0xF9, 0xFF, 0xB8, 0xFF, 0x0E, 0xF0, 0x1F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFC, 0x07, 0xF8, 0x7F, 0x1E, 0xFF, 0xCF, 0xF0, 0xFC, 0x3C, 0x3C,
  0x3C, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1F, 0x1F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x3F,
  0xFF, 0xDF, 0xB9, 0xE7, 0x70, 0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE3, 0x8F,
  0x1E, 0x70, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0xE1, 0xC3, 0xB8, 0x70, 0xEF, 0x1E,
  0x7B, 0xCF, 0x9E, 0x73, 0xE7, 0x9C, 0xF9, 0xC7, 0x36, 0x71, 0xFD, 0xDC,
  0x7F, 0x7F, 0x0F, 0xDF, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x8F, 0x81, 0xE1, 0xC0, 0x70, 0x70, 0xF0, 0xFF, 0x1E, 0x79, 0xE7, 0xBC,
  0x3F, 0x83, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x83, 0xFC,
  0x7B, 0xC7, 0x9E, 0xF1, 0xEF, 0x0F, 0xF0, 0x7B, 0xC3, 0x9E, 0x3C, 0xF1,
  0xE3, 0x8F, 0x1E, 0x70, 0xF7, 0x83, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x1C, 0x79, 0xE3, 0xC7, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0xCF, 0x9C, 0x3C, 0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F,
  0x1E, 0x1C, 0x3C, 0x38, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC1, 0xC3, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xE1,
  0xC7, 0x9E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x71, 0xE3, 0x86,
  0x00, 0x3C, 0x1B, 0xF1, 0xFF, 0xCF, 0xCF, 0xFC, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 8, 8, 10, 1, -23 },
  { 20, 14, 22, 16, 1, -22 },
  { 59, 13, 28, 15, 1, -25 },
  { 105, 17, 22, 19, 1, -22 },
  { 152, 16, 22, 17, 1, -22 },
  { 196, 3, 8, 5, 1, -23 },
  { 199, 7, 31, 10, 2, -24 },
  { 227, 7, 31, 10, 1, -24 },
  { 255, 13, 13, 13, 0, -22 },
  { 277, 12, 16, 14, 1, -18 },
  { 301, 5, 9, 7, 0, -4 },
  { 307, 6, 3, 10, 2, -11 },
  { 310, 4, 4, 9, 2, -4 },
  { 312, 10, 24, 10, 0, -22 },
  { 342, 13, 22, 15, 1, -22 },
  { 378, 8, 22, 15, 2, -22 },
  { 400, 13, 22, 15, 1, -22 },
  { 436, 12, 22, 15, 1, -22 },
  { 469, 13, 22, 15, 1, -22 },
  { 505, 12, 22, 15, 2, -22 },
  { 538, 12, 22, 15, 2, -22 },
  { 571, 13, 22, 15, 1, -22 },
  { 607, 12, 22, 15, 2, -22 },
  { 640, 12, 22, 15, 1, -22 },
  { 673, 4, 16, 8, 2, -16 },
  { 681, 5, 21, 7, 1, -16 },
  { 695, 10, 14, 13, 1, -16 },
  { 713, 11, 9, 15, 2, -14 },
  { 726, 11, 14, 14, 2, -16 },
  { 746, 11, 22, 13, 1, -22 },
  { 777, 21, 28, 23, 1, -21 },
  { 851, 17, 22, 18, 0, -22 },
  { 898, 13, 22, 17, 2, -22 },
  { 934, 15, 22, 17, 1, -22 },
  { 976, 13, 22, 17, 2, -22 },
  { 1012, 12, 22, 15, 2, -22 },
  { 1045, 11, 22, 14, 2, -22 },
  { 1076, 15, 22, 18, 1, -22 },
  { 1118, 15, 22, 18, 2, -22 },
  { 1160, 4, 22, 8, 2, -22 },
  { 1171, 12, 22, 15, 1, -22 },
  { 1204, 15, 22, 17, 2, -22 },
  { 1246, 12, 22, 14, 2, -22 },
  { 1279, 19, 22, 23, 2, -22 },
  { 1332, 15, 22, 18, 2, -22 },
  { 1374, 16, 22, 18, 1, -22 },
  { 1418, 14, 22, 17, 2, -22 },
  { 1457, 16, 26, 18, 1, -22 },
  { 1509, 14, 22, 16, 2, -22 },
  { 1548, 14, 22, 16, 1, -22 },
  { 1587, 14, 22, 16, 1, -22 },
  { 1626, 13, 22, 17, 2, -22 },
  { 1662, 17, 22, 17, 0, -22 },
  { 1709, 21, 22, 23, 1, -22 },
  { 1767, 15, 22, 17, 1, -22 },
  { 1809, 16, 22, 16, 0, -22 },
  { 1853, 14, 22, 16, 1, -22 },
  { 1892, 5, 30, 8, 2, -25 },
  { 1911, 12, 24, 11, 0, -22 },
  { 1947, 6, 30, 8, 0, -25 },
  { 1970, 10, 11, 12, 1, -22 },
  { 1984, 12, 3, 12, 0, 0 },
  { 1989, 7, 4, 10, 1, -22 },
  { 1993, 12, 16, 14, 1, -16 },
  { 2017, 12, 23, 15, 2, -23 },
  { 2052, 12, 16, 14, 1, -16 },
  { 2076, 12, 23, 15, 1, -23 },
  { 2111, 12, 16, 14, 1, -16 },
  { 2135, 8, 23, 10, 1, -23 },
  { 2158, 12, 22, 15, 1, -16 },
  { 2191, 11, 23, 15, 2, -23 },
  { 2223, 4, 22, 7, 2, -22 },
  { 2234, 7, 28, 7, -1, -22 },
  { 2259, 12, 23, 14, 2, -23 },
  { 2294, 4, 23, 7, 2, -23 },
  { 2306, 19, 16, 22, 2, -16 },
  { 2344, 11, 16, 15, 2, -16 },
  { 2366, 13, 16, 15, 1, -16 },
  { 2392, 12, 22, 15, 2, -16 },
  { 2425, 12, 22, 15, 1, -16 },
  { 2458, 7, 16, 10, 2, -16 },
  { 2472, 11, 16, 14, 1, -16 },
  { 2494, 8, 20, 9, 0, -20 },
  { 2514, 11, 16, 15, 2, -16 },
  { 2536, 13, 16, 13, 0, -16 },
  { 2562, 18, 16, 19, 1, -16 },
  { 2598, 12, 16, 13, 1, -16 },
  { 2622, 13, 22, 13, 0, -16 },
  { 2658, 11, 16, 13, 1, -16 },
  { 2680, 7, 28, 9, 1, -23 },
  { 2705, 2, 26, 8, 3, -22 },
  { 2712, 7, 28, 9, 1, -23 },
  { 2737, 13, 6, 17, 2, -12 },
};

const GFXfont RobotoCondensed_SemiBold30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_SEMIBOLD30PT7B_H_
