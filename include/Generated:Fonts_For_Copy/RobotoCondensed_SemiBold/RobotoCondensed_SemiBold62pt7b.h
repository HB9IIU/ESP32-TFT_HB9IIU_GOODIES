#ifndef _ROBOTOCONDENSED_SEMIBOLD62PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x3E,
  0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xF8, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x1F, 0xF7, 0xFE, 0x1F,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x1C, 0x03,
  0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x0F,
  0x80, 0x3E, 0x07, 0xC3, 0xE0, 0x0F, 0xC1, 0xF1, 0xF0, 0x03, 0xF0, 0xFC,
  0xF8, 0x00, 0x7E, 0x7E, 0x3E, 0x00, 0x1F, 0xFF, 0x9F, 0x00, 0x03, 0xFF,
  0xC7, 0xC0, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x00,
  0x20, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x00, 0x7C, 0xFF,
  0xE0, 0x00, 0x3E, 0x7F, 0xFC, 0x00, 0x0F, 0x9F, 0xFF, 0x80, 0x07, 0xCF,
  0xE7, 0xE0, 0x01, 0xF3, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x3F, 0x00, 0x7C,
  0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x83, 0xF0,
  0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x3E, 0x00, 0xC0, 0x3F, 0x9F,
  0x80, 0x10, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC1, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0xDF,
  0xF1, 0xFC, 0x7F, 0x8F, 0xF9, 0xFC, 0x7F, 0x87, 0xF9, 0xFC, 0x7F, 0x87,
  0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0x01,
  0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xF0, 0x7F, 0x80,
  0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFB, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBE, 0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x80, 0x40, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x01, 0xC0, 0x7C, 0x06, 0x7C, 0x1F, 0x0F, 0x9F, 0xE7, 0x8F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x03, 0x00,
  0x78, 0x00, 0x40, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0x3C, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x08, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xE0, 0x0F, 0xE7,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF,
  0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x8F, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x03, 0xFD, 0xFE, 0x00,
  0x7F, 0xBF, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0x87, 0xFC,
  0x7F, 0xC0, 0xFF, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01,
  0xFE, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0x9F, 0xF0,
  0x1F, 0xE7, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFB, 0xFC, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFE, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x03, 0xF0, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F,
  0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xC1, 0xF8, 0x0F, 0xF0,
  0x04, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF,
  0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x3F, 0x00, 0x7F, 0x3F, 0xF0, 0x1F, 0xDF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F,
  0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF,
  0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x7F, 0xC1, 0xFF,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F,
  0xF3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0x8F, 0xF0, 0x1F, 0xE7,
  0xF8, 0x0F, 0xF3, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xF9, 0xFF, 0x87, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x07,
  0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFB, 0xFC, 0x07, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0xC7, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xE0,
  0x7F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x04, 0x00, 0x1F, 0x87, 0xF8, 0xFF,
  0x3F, 0xF7, 0xFE, 0x7F, 0x8F, 0xF0, 0xFC, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x81, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x7F, 0xE3, 0xFE, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xFF, 0x01,
  0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0x3E, 0x3E, 0x00, 0xFF, 0xFC, 0x0F, 0x8F,
  0x80, 0x7F, 0xFF, 0x03, 0xE7, 0xE0, 0x3F, 0x87, 0xC0, 0x79, 0xF0, 0x0F,
  0xC1, 0xF0, 0x1E, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xDF, 0x01, 0xF8, 0x1F,
  0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xC0, 0x7F, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0x81,
  0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0x80,
  0x7F, 0xE0, 0x7E, 0x03, 0xE0, 0x1E, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xBE,
  0x07, 0xE0, 0x3E, 0x03, 0xEF, 0x81, 0xF8, 0x1F, 0x80, 0xFB, 0xE0, 0x7E,
  0x07, 0xE0, 0x3C, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x3F, 0x07, 0xF0, 0xFE,
  0x0F, 0xCF, 0xC0, 0xFF, 0xFF, 0xC7, 0xE3, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7C, 0x07, 0xFF, 0x7F, 0xFC, 0x1F, 0x01, 0xFF, 0x8F, 0xFE, 0x07, 0xE0,
  0x3F, 0xC1, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x00, 0x0F, 0xFC,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xF0, 0x07, 0xFC, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03,
  0xFE, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x9F, 0xE0,
  0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0,
  0x1F, 0xF8, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F,
  0xCF, 0xF0, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8,
  0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F,
  0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x80, 0x7F, 0xDF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0xFF,
  0x8F, 0xFC, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0xF0,
  0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0xE3, 0xFC, 0x01,
  0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x00,
  0xFF, 0x0F, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF1, 0xFF, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x00,
  0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x01,
  0xFF, 0x8F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xFC, 0xFF, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xBF, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0xFE, 0xFE, 0x00, 0xFE, 0xFF, 0xFD,
  0xFC, 0x01, 0xF9, 0xFF, 0xFB, 0xFC, 0x07, 0xF3, 0xFF, 0xF3, 0xF8, 0x0F,
  0xE7, 0xFF, 0xE7, 0xF0, 0x1F, 0x9F, 0xFF, 0xCF, 0xE0, 0x7F, 0x3F, 0xFF,
  0x8F, 0xE0, 0xFE, 0x7F, 0xFF, 0x9F, 0xC1, 0xFC, 0xFF, 0xFF, 0x3F, 0x83,
  0xF1, 0xFF, 0xFE, 0x3F, 0x8F, 0xE3, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xFF,
  0xF8, 0xFE, 0x3F, 0x0F, 0xFF, 0xF0, 0xFE, 0xFE, 0x1F, 0xFF, 0xE1, 0xFD,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFB, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0xCF,
  0xF0, 0xFF, 0xFF, 0x3F, 0xC3, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xF1, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFC, 0xFF, 0xFF, 0x0F, 0xF3, 0xFF, 0xFC, 0x1F, 0xEF,
  0xFF, 0xF0, 0x7F, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF3,
  0xFE, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0x07,
  0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xFC,
  0xFF, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80,
  0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0xC7, 0xFE,
  0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x27, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x02,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xE0, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE,
  0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xF9, 0xFE, 0x01,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF,
  0x07, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0x9F, 0xE0,
  0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0xBF, 0xC0, 0x03,
  0xFD, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF,
  0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xE7,
  0xFC, 0x01, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0x9F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xFC, 0x07, 0xF9, 0xFE, 0x03,
  0xFF, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xFE,
  0x07, 0xF8, 0x7F, 0x83, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x1F, 0xC1, 0xFB, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x7F, 0x8F, 0xEF, 0xC3, 0xFC, 0x0F, 0xF1,
  0xFD, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xE3,
  0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x7E, 0x3F, 0x80, 0x7F, 0x3F, 0x8F, 0xC7,
  0xF0, 0x0F, 0xE7, 0xF1, 0xFD, 0xFE, 0x01, 0xFE, 0xFC, 0x3F, 0xBF, 0xC0,
  0x3F, 0xDF, 0x83, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x7E, 0xFE, 0x00, 0x7F,
  0xFE, 0x0F, 0xDF, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x03,
  0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x1F, 0x9F, 0x81,
  0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC7, 0xE0, 0x7E,
  0x7E, 0x07, 0xEF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x83, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFE, 0x1F, 0xFC, 0xFF,
  0x0F, 0xF8, 0xFF, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x7F, 0xC1, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFC, 0x1F, 0xF7,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xC7, 0xFB, 0xFF, 0xC3, 0xFC, 0x7F, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3,
  0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF7, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F,
  0xC7, 0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF8,
  0xFE, 0x0F, 0xFE, 0x7F, 0x0F, 0xFF, 0xBF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0xFB, 0xFE, 0x03, 0xFD, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x01,
  0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x7F, 0xE1, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xF8, 0x3F,
  0xF9, 0xFC, 0x0F, 0xF8, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07,
  0xF7, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x04, 0x1F, 0xE0, 0x07, 0x0F, 0xFC, 0x0F, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xC7, 0xF0, 0x7F,
  0xF9, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0x7F, 0xC0, 0x7F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xFC, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xBF, 0xC0, 0x7F, 0x8F, 0xF0, 0x01, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x40, 0x07, 0xF8, 0x3C,
  0x03, 0xFE, 0x0F, 0xC3, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0x00, 0xFF, 0x1F, 0xE0, 0xFF, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xF8, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F,
  0xC0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x87, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F,
  0xFB, 0xFC, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFD, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xC3, 0xFE,
  0xFF, 0x81, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0x00, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xFC, 0x01,
  0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x3F, 0xDF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFD, 0xFF, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x3F, 0xDF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0x7F, 0xF8, 0x7F, 0x8F,
  0xF0, 0x3F, 0xC0, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F,
  0xC1, 0xFF, 0xCF, 0xE1, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0x7F, 0xC0, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0xBF, 0xC0, 0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0x08, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x10, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x0F,
  0xFE, 0x7F, 0x07, 0xFC, 0x7F, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFE,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3,
  0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xE0,
  0x3F, 0xDF, 0xC0, 0x7F, 0x01, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xF7, 0xF0,
  0x1F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF8, 0x1F,
  0xC7, 0xF0, 0x7F, 0xC1, 0xFE, 0x3F, 0x83, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F,
  0xF8, 0x7F, 0x0F, 0xF1, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F, 0xFE, 0x1F, 0xC1,
  0xFC, 0x7F, 0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xCF, 0xE0, 0x7F, 0x3F, 0x7E,
  0x7F, 0x03, 0xF9, 0xFB, 0xF3, 0xF8, 0x0F, 0xEF, 0xCF, 0xDF, 0xC0, 0x7F,
  0x7E, 0x7E, 0xFE, 0x03, 0xFF, 0xE3, 0xF7, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x3F, 0xC0,
  0x3F, 0xCF, 0xF0, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFC,
  0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F,
  0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x7F,
  0x81, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0xE0, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xC7, 0xFF, 0x80, 0x7E, 0x7F, 0xFE,
  0x03, 0xF3, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0xE1, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xC3, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFE, 0x3F,
  0x00, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 45, 16, 4, -44 },
  { 46, 16, 16, 20, 2, -47 },
  { 78, 28, 44, 33, 3, -44 },
  { 232, 25, 58, 31, 3, -51 },
  { 414, 34, 46, 40, 3, -45 },
  { 610, 32, 46, 35, 2, -45 },
  { 794, 6, 16, 10, 2, -47 },
  { 806, 14, 63, 20, 4, -49 },
  { 917, 15, 63, 20, 2, -49 },
  { 1036, 26, 26, 28, 1, -44 },
  { 1121, 26, 32, 30, 2, -36 },
  { 1225, 10, 18, 15, 1, -7 },
  { 1248, 14, 6, 21, 3, -22 },
  { 1259, 9, 9, 18, 4, -8 },
  { 1270, 20, 48, 21, 0, -44 },
  { 1390, 25, 46, 31, 3, -45 },
  { 1534, 16, 44, 31, 5, -44 },
  { 1622, 27, 45, 31, 2, -45 },
  { 1774, 26, 46, 31, 2, -45 },
  { 1924, 27, 44, 31, 2, -44 },
  { 2073, 26, 45, 31, 3, -44 },
  { 2220, 26, 45, 31, 3, -44 },
  { 2367, 27, 44, 31, 2, -44 },
  { 2516, 25, 46, 31, 3, -45 },
  { 2660, 25, 45, 31, 3, -45 },
  { 2801, 9, 34, 16, 4, -33 },
  { 2840, 11, 44, 15, 2, -33 },
  { 2901, 22, 28, 28, 2, -33 },
  { 2978, 23, 20, 31, 4, -30 },
  { 3036, 22, 28, 28, 4, -33 },
  { 3113, 23, 46, 27, 2, -45 },
  { 3246, 42, 57, 48, 3, -43 },
  { 3546, 35, 44, 37, 1, -44 },
  { 3739, 28, 44, 35, 4, -44 },
  { 3893, 30, 46, 35, 3, -45 },
  { 4066, 28, 44, 35, 4, -44 },
  { 4220, 25, 44, 31, 4, -44 },
  { 4358, 24, 44, 30, 4, -44 },
  { 4490, 30, 46, 36, 3, -45 },
  { 4663, 30, 44, 38, 4, -44 },
  { 4828, 8, 44, 16, 4, -44 },
  { 4872, 26, 45, 30, 1, -44 },
  { 5019, 30, 44, 34, 4, -44 },
  { 5184, 24, 44, 30, 4, -44 },
  { 5316, 39, 44, 47, 4, -44 },
  { 5531, 30, 44, 38, 4, -44 },
  { 5696, 31, 46, 37, 3, -45 },
  { 5875, 29, 44, 35, 4, -44 },
  { 6035, 31, 53, 37, 3, -45 },
  { 6241, 29, 44, 34, 4, -44 },
  { 6401, 29, 46, 33, 2, -45 },
  { 6568, 30, 44, 33, 2, -44 },
  { 6733, 29, 45, 35, 3, -44 },
  { 6897, 34, 44, 36, 1, -44 },
  { 7084, 43, 44, 47, 2, -44 },
  { 7321, 32, 44, 35, 1, -44 },
  { 7497, 32, 44, 33, 1, -44 },
  { 7673, 29, 44, 33, 2, -44 },
  { 7833, 11, 61, 16, 4, -51 },
  { 7917, 23, 48, 23, 1, -44 },
  { 8055, 11, 61, 16, 1, -51 },
  { 8139, 20, 22, 24, 2, -44 },
  { 8194, 23, 6, 25, 1, 0 },
  { 8212, 15, 9, 20, 2, -46 },
  { 8229, 24, 35, 29, 3, -34 },
  { 8334, 25, 48, 31, 3, -47 },
  { 8484, 25, 35, 29, 2, -34 },
  { 8594, 25, 48, 31, 2, -47 },
  { 8744, 25, 35, 30, 3, -34 },
  { 8854, 19, 48, 20, 1, -48 },
  { 8968, 26, 47, 31, 2, -34 },
  { 9121, 24, 47, 30, 3, -47 },
  { 9262, 9, 45, 15, 3, -45 },
  { 9313, 13, 58, 15, -1, -45 },
  { 9408, 26, 47, 29, 3, -47 },
  { 9561, 8, 47, 15, 4, -47 },
  { 9608, 40, 34, 46, 3, -34 },
  { 9778, 24, 34, 30, 3, -34 },
  { 9880, 27, 35, 31, 2, -34 },
  { 9999, 25, 47, 31, 3, -34 },
  { 10146, 25, 47, 31, 2, -34 },
  { 10293, 16, 34, 20, 3, -34 },
  { 10361, 24, 35, 28, 2, -34 },
  { 10466, 16, 42, 19, 1, -41 },
  { 10550, 24, 34, 30, 3, -33 },
  { 10652, 25, 33, 28, 1, -33 },
  { 10756, 37, 33, 40, 1, -33 },
  { 10909, 26, 33, 28, 1, -33 },
  { 11017, 25, 46, 27, 1, -33 },
  { 11161, 22, 33, 28, 3, -33 },
  { 11252, 15, 59, 19, 2, -48 },
  { 11363, 5, 52, 16, 5, -44 },
  { 11396, 15, 59, 19, 2, -48 },
  { 11507, 29, 13, 35, 3, -25 },
};

const GFXfont RobotoCondensed_SemiBold62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_SEMIBOLD62PT7B_H_
