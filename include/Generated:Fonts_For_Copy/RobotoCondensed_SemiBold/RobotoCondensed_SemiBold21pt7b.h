#ifndef _ROBOTOCONDENSED_SEMIBOLD21PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xDB, 0x6C, 0x07, 0xD8, 0xDE, 0xF7, 0xBD, 0xCC, 0x19,
  0x06, 0xC1, 0xB0, 0x6C, 0x7F, 0xDF, 0xF3, 0x20, 0xC8, 0x36, 0x3F, 0xEF,
  0xF8, 0x98, 0x24, 0x19, 0x06, 0xC0, 0x08, 0x04, 0x0F, 0x0F, 0xE7, 0x73,
  0x1B, 0x8E, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xEE, 0x3F, 0x1F, 0x9C, 0xFE,
  0x3E, 0x04, 0x02, 0x00, 0x70, 0x1F, 0x03, 0x22, 0x66, 0xCC, 0x91, 0xF6,
  0x1D, 0x80, 0x30, 0x0D, 0xC1, 0xFC, 0x6C, 0x89, 0x93, 0x32, 0x07, 0xC0,
  0x70, 0x3C, 0x0F, 0xC1, 0xDC, 0x33, 0x86, 0x60, 0xFC, 0x0F, 0x01, 0xC0,
  0x7C, 0xDD, 0xFB, 0x1F, 0x73, 0xCE, 0x78, 0xFF, 0x8F, 0x70, 0xFF, 0xC0,
  0x08, 0xCC, 0x66, 0x31, 0x8C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x63, 0x0C,
  0x61, 0x84, 0x86, 0x30, 0xC6, 0x18, 0xC6, 0x31, 0xCE, 0x73, 0x98, 0xC6,
  0x33, 0x19, 0x8C, 0x40, 0x0C, 0x06, 0x03, 0x3F, 0xF3, 0xF0, 0xE0, 0xD8,
  0x66, 0x22, 0x00, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x77, 0x76, 0x64, 0xFF, 0xC0, 0x7D, 0x80, 0x06, 0x18, 0x30, 0x61,
  0x83, 0x06, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x10, 0x60, 0x3C, 0x3F,
  0x19, 0xDC, 0x6E, 0x37, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xDC, 0x66,
  0x73, 0xF0, 0xF0, 0x0B, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x60, 0x3C, 0x3F, 0xB9, 0xDC, 0x6C, 0x30, 0x18, 0x1C, 0x1C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0xFF, 0xFE, 0x3C, 0x7F, 0xE7, 0xE3, 0x03, 0x07,
  0x1E, 0x1E, 0x07, 0x03, 0x03, 0xC3, 0xE7, 0x7E, 0x3C, 0x07, 0x07, 0x83,
  0xC3, 0xE1, 0xF1, 0xB8, 0xDC, 0xCE, 0x67, 0x63, 0xBF, 0xFF, 0xF0, 0x70,
  0x38, 0x1C, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x03, 0xF1, 0xFC, 0xCE, 0x03,
  0x81, 0xC0, 0xFC, 0x7E, 0x73, 0xF8, 0xF0, 0x0E, 0x1F, 0x0E, 0x0E, 0x06,
  0x07, 0xF3, 0xFD, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x77, 0x73, 0xF8, 0x70,
  0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0x3C, 0x3F, 0x99, 0xDC, 0x6E, 0x33, 0x39,
  0xF8, 0xFC, 0x67, 0x71, 0xB8, 0xDC, 0x6E, 0x73, 0xF8, 0xF0, 0x3C, 0x7E,
  0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0x7F, 0x3B, 0x07, 0x07, 0x0E, 0x3C,
  0x38, 0x7D, 0x80, 0x00, 0x0F, 0xB0, 0x7F, 0x80, 0x00, 0x01, 0xB7, 0xF6,
  0x02, 0x1C, 0xFF, 0xCC, 0x1F, 0x0F, 0x87, 0x02, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xF0, 0xFC, 0x1F, 0x07, 0x1F, 0xFC, 0xF0, 0x80, 0x7D,
  0xFF, 0xBE, 0x30, 0x61, 0xC7, 0x0C, 0x38, 0x70, 0x00, 0x03, 0x07, 0x0E,
  0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x06, 0x63, 0xCD, 0x9F, 0x3C,
  0x6C, 0xF3, 0x31, 0xCC, 0xC7, 0x33, 0x1C, 0xCC, 0xF3, 0x33, 0xCC, 0xCF,
  0x3F, 0xEC, 0x77, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFC, 0x03, 0xE0,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xD8, 0x19, 0xC1, 0x9C,
  0x38, 0xC3, 0x8C, 0x3F, 0xE7, 0xFE, 0x70, 0x67, 0x07, 0xE0, 0x70, 0xFE,
  0x3F, 0xEE, 0x3B, 0x86, 0xE1, 0xB8, 0xEF, 0xF3, 0xFE, 0xE3, 0xB8, 0x7E,
  0x1F, 0x87, 0xE3, 0xBF, 0xEF, 0xF0, 0x1F, 0x0F, 0xE7, 0x3F, 0x87, 0xE1,
  0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x1F, 0x87, 0x73, 0xDF, 0xE1,
  0xF0, 0xFE, 0x3F, 0xCE, 0x7B, 0x86, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x86, 0xE7, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1C,
  0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x1F, 0xE7, 0x3F, 0x87, 0xE0, 0xF8, 0x0E,
  0x03, 0x9F, 0xE7, 0xF8, 0x3E, 0x0F, 0x83, 0x71, 0xCF, 0xF1, 0xF0, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xD8, 0xEC, 0x77, 0x7B, 0xF8, 0x78, 0xE1, 0xDC, 0x73, 0x8E, 0x73,
  0x8E, 0xE1, 0xDC, 0x3F, 0x07, 0xF0, 0xFE, 0x1E, 0xE3, 0x9C, 0x71, 0xCE,
  0x39, 0xC3, 0xB8, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xCD, 0xFB, 0x37, 0xEC, 0xDF, 0xBF,
  0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x9C, 0x7E, 0x31, 0xC0, 0xE0, 0xFE,
  0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFB, 0x3F, 0x77, 0xE6, 0xFC, 0xFF,
  0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x38, 0x1F, 0x07, 0xF1, 0xCF, 0x70,
  0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0x70, 0xE7,
  0x3C, 0x7F, 0x07, 0xC0, 0xFF, 0x3F, 0xEE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xFF, 0xBF, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F,
  0x07, 0xF1, 0xCF, 0x70, 0xEE, 0x0D, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0x70, 0xE7, 0x3C, 0x7F, 0x07, 0xE0, 0x0E, 0x00, 0xC0, 0x10,
  0xFF, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xFE, 0xFF, 0x39,
  0xCE, 0x73, 0x8E, 0xE3, 0xB8, 0x7E, 0x1C, 0x3E, 0x3F, 0xBC, 0xFC, 0x7E,
  0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF8, 0x7C, 0x3F, 0x3B, 0xFC, 0xF8,
  0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F,
  0xE3, 0xE0, 0xE0, 0x77, 0x0E, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x39,
  0xC3, 0x9C, 0x19, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xC3, 0x0F, 0x0C, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9D, 0x9E, 0x66,
  0x79, 0x9B, 0xFE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x0F, 0x3C, 0x38, 0xF0,
  0xE1, 0xC3, 0x87, 0x00, 0x70, 0xEE, 0x18, 0xE7, 0x1C, 0xC1, 0xF8, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xF0, 0x6E, 0x1C, 0xE3, 0x9C, 0xE3, 0xDC,
  0x38, 0xE0, 0xEE, 0x19, 0xC7, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0xF8,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0xFF,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0xFF, 0xFE, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xFF, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0C,
  0x0E, 0x0E, 0x06, 0x07, 0x07, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFF, 0x30, 0x71, 0xE3, 0xCC, 0xD9, 0xB3, 0x00, 0xFF, 0xFF,
  0xE3, 0x8C, 0x3C, 0x7E, 0xE7, 0x07, 0x3F, 0x7F, 0xE7, 0xC7, 0xE7, 0xFF,
  0x7F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xF3, 0xFD, 0xCE, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x3B, 0xFD, 0xFC, 0x3C, 0x7E, 0xE7, 0xE3, 0xC0,
  0xC0, 0xC0, 0xE3, 0xE7, 0x7E, 0x3C, 0x03, 0x03, 0x03, 0x03, 0x03, 0x7B,
  0x7F, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F, 0x3B, 0x3C, 0x7F,
  0xE7, 0xE3, 0xFF, 0xFF, 0xC0, 0xE0, 0xE3, 0x7F, 0x3E, 0x1E, 0x7C, 0xE1,
  0x83, 0x1F, 0xBF, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3B,
  0x7F, 0xE7, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F, 0x3B, 0x03, 0x47,
  0x7F, 0x3C, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE7, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x37, 0x70, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x7E, 0xE0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x3B, 0xB9, 0xDC, 0xFC, 0x7C, 0x3F, 0x1F, 0x8E,
  0xE7, 0x33, 0x9D, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77,
  0xFF, 0xF9, 0xEF, 0xCE, 0x3E, 0x71, 0xF3, 0x8F, 0x9C, 0x7C, 0xE3, 0xE7,
  0x1F, 0x38, 0xF9, 0xC6, 0xEE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0x3C, 0x3F, 0xB9, 0xDC, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7,
  0xE7, 0x3F, 0x8F, 0x00, 0xFE, 0x7F, 0xB9, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE7, 0x7F, 0xBF, 0x9C, 0x0E, 0x07, 0x03, 0x80, 0x7B, 0x7F, 0xE7,
  0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0x7F, 0x3B, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x3C, 0x7E, 0xE7, 0xE0, 0xF0,
  0x7C, 0x1E, 0xC7, 0xE7, 0xFE, 0x3C, 0x30, 0xC3, 0x3F, 0xFC, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x3C, 0x70, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE7, 0x7F, 0x7B, 0xE3, 0xB1, 0xDC, 0xCE, 0xE3, 0x71, 0xB0, 0xD8,
  0x7C, 0x1E, 0x0E, 0x07, 0x00, 0xE3, 0x3B, 0x39, 0xD9, 0xCC, 0xEE, 0x67,
  0x7B, 0x1E, 0xF8, 0xF7, 0xC7, 0x9C, 0x3C, 0xE1, 0xC7, 0x06, 0x38, 0x73,
  0xBB, 0x8F, 0xC7, 0xC1, 0xE0, 0xE0, 0x78, 0x7C, 0x37, 0x39, 0x98, 0xE0,
  0xE3, 0xB1, 0xDC, 0xCE, 0xE3, 0x71, 0xB0, 0xF8, 0x7C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x83, 0xC1, 0xC0, 0xFE, 0xFE, 0x0E, 0x0C, 0x1C, 0x38, 0x30,
  0x70, 0xE0, 0xFF, 0xFF, 0x11, 0xDC, 0xE7, 0x39, 0xCC, 0x67, 0x38, 0xC6,
  0x39, 0xCE, 0x73, 0x8E, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x86, 0x38,
  0xC6, 0x31, 0x8C, 0x71, 0xCE, 0xE6, 0x31, 0x8C, 0x67, 0x31, 0x00, 0x30,
  0xDE, 0x3E, 0xDB, 0x1E, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 5, 6, 7, 1, -16 },
  { 11, 10, 15, 11, 1, -15 },
  { 30, 9, 19, 11, 1, -17 },
  { 52, 11, 15, 13, 1, -15 },
  { 73, 11, 15, 12, 1, -15 },
  { 94, 2, 5, 3, 1, -16 },
  { 96, 5, 22, 7, 1, -17 },
  { 110, 5, 22, 7, 1, -17 },
  { 124, 9, 9, 9, 0, -15 },
  { 135, 8, 10, 10, 1, -12 },
  { 145, 4, 6, 5, 0, -2 },
  { 148, 5, 2, 7, 1, -7 },
  { 150, 3, 3, 6, 1, -3 },
  { 152, 7, 16, 7, 0, -15 },
  { 166, 9, 15, 11, 1, -15 },
  { 183, 5, 15, 11, 2, -15 },
  { 193, 9, 15, 11, 1, -15 },
  { 210, 8, 15, 11, 1, -15 },
  { 225, 9, 15, 11, 1, -15 },
  { 242, 9, 15, 11, 1, -15 },
  { 259, 9, 15, 11, 1, -15 },
  { 276, 9, 15, 11, 1, -15 },
  { 293, 9, 15, 11, 1, -15 },
  { 310, 8, 15, 11, 1, -15 },
  { 325, 3, 12, 6, 1, -12 },
  { 330, 3, 16, 5, 1, -12 },
  { 336, 7, 9, 9, 1, -11 },
  { 344, 8, 6, 10, 1, -10 },
  { 350, 8, 9, 10, 1, -11 },
  { 359, 7, 15, 9, 1, -15 },
  { 373, 14, 20, 16, 1, -15 },
  { 408, 12, 15, 12, 0, -15 },
  { 431, 10, 15, 12, 1, -15 },
  { 450, 10, 15, 12, 1, -15 },
  { 469, 10, 15, 12, 1, -15 },
  { 488, 9, 15, 10, 1, -15 },
  { 505, 8, 15, 10, 1, -15 },
  { 520, 10, 15, 12, 1, -15 },
  { 539, 11, 15, 13, 1, -15 },
  { 560, 3, 15, 6, 1, -15 },
  { 566, 9, 15, 10, 0, -15 },
  { 583, 11, 15, 12, 1, -15 },
  { 604, 8, 15, 10, 1, -15 },
  { 619, 14, 15, 16, 1, -15 },
  { 646, 11, 15, 13, 1, -15 },
  { 667, 11, 15, 13, 1, -15 },
  { 688, 10, 15, 12, 1, -15 },
  { 707, 11, 18, 13, 1, -15 },
  { 732, 10, 15, 12, 1, -15 },
  { 751, 9, 15, 11, 1, -15 },
  { 768, 10, 15, 11, 1, -15 },
  { 787, 10, 15, 12, 1, -15 },
  { 806, 12, 15, 12, 0, -15 },
  { 829, 14, 15, 16, 1, -15 },
  { 856, 11, 15, 12, 0, -15 },
  { 877, 11, 15, 11, 0, -15 },
  { 898, 9, 15, 11, 1, -15 },
  { 915, 4, 20, 5, 1, -17 },
  { 925, 8, 16, 8, 0, -15 },
  { 941, 4, 20, 5, 0, -17 },
  { 951, 7, 7, 8, 1, -15 },
  { 958, 8, 2, 8, 0, 0 },
  { 960, 5, 3, 7, 1, -16 },
  { 962, 8, 11, 10, 1, -11 },
  { 973, 9, 16, 10, 1, -16 },
  { 991, 8, 11, 10, 1, -11 },
  { 1002, 8, 16, 10, 1, -16 },
  { 1018, 8, 11, 10, 1, -11 },
  { 1029, 7, 16, 7, 0, -16 },
  { 1043, 8, 15, 11, 1, -11 },
  { 1058, 8, 16, 10, 1, -16 },
  { 1074, 3, 15, 5, 1, -15 },
  { 1080, 4, 19, 5, 0, -15 },
  { 1090, 9, 16, 10, 1, -16 },
  { 1108, 3, 16, 5, 1, -16 },
  { 1114, 13, 11, 16, 1, -11 },
  { 1132, 8, 11, 10, 1, -11 },
  { 1143, 9, 11, 10, 1, -11 },
  { 1156, 9, 15, 10, 1, -11 },
  { 1173, 8, 15, 10, 1, -11 },
  { 1188, 5, 11, 7, 1, -11 },
  { 1195, 8, 11, 10, 1, -11 },
  { 1206, 6, 14, 6, 0, -14 },
  { 1217, 8, 11, 10, 1, -11 },
  { 1228, 9, 11, 9, 0, -11 },
  { 1241, 13, 11, 13, 0, -11 },
  { 1259, 9, 11, 9, 0, -11 },
  { 1272, 9, 15, 9, 0, -11 },
  { 1289, 8, 11, 9, 1, -11 },
  { 1300, 5, 20, 6, 1, -16 },
  { 1313, 2, 18, 5, 2, -15 },
  { 1318, 5, 20, 6, 1, -16 },
  { 1331, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_SEMIBOLD21PT7B_H_
