#ifndef _ROBOTOCONDENSED_SEMIBOLD34PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x37, 0x1B, 0x8D,
  0xC6, 0xE3, 0x00, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x1C, 0x07,
  0x18, 0x07, 0x18, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x06,
  0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x18, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xFC, 0x1F,
  0xF0, 0xFF, 0xCF, 0xFF, 0x78, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xF7, 0x80,
  0x3E, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x1F,
  0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0,
  0x03, 0x9C, 0x30, 0xE3, 0x8C, 0x38, 0xE7, 0x0E, 0x39, 0x83, 0x9C, 0xE0,
  0xFF, 0x70, 0x1F, 0x9C, 0x03, 0xCE, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x73, 0xC0, 0x3B, 0xF8, 0x0C, 0xFF, 0x07, 0x71, 0xC1, 0x9C, 0x70, 0xE7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC2, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3C,
  0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3E, 0xF0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xC7, 0x8F, 0xF1, 0xE7, 0xBE, 0x71, 0xE7, 0xFC,
  0xF8, 0xFF, 0x3E, 0x3F, 0xCF, 0x87, 0xE1, 0xE0, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x07,
  0x0F, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x78,
  0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x02, 0x40, 0xE0, 0xE0,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0x40, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x06, 0x38, 0x4F, 0x37, 0x9F, 0xFF, 0x8F, 0xFC, 0x03,
  0xC0, 0x0F, 0x80, 0x3B, 0x80, 0xF3, 0x81, 0xC7, 0x83, 0x07, 0x02, 0x08,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7B, 0xDE, 0xF7,
  0xBD, 0xDE, 0xE2, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xF7, 0xFF, 0x3F, 0xF8,
  0xFF, 0x81, 0xF0, 0x01, 0x87, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0x87, 0xCF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xFF, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7D,
  0xE0, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0x83,
  0xDE, 0x1F, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x0F, 0xF8, 0x1D, 0xF0, 0x7B, 0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x1F, 0x1E,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xC1, 0xFF, 0x8F,
  0xFF, 0x3F, 0x7E, 0x10, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7F,
  0xC1, 0xFF, 0x07, 0xBE, 0x3E, 0x7F, 0xF9, 0xFF, 0xC3, 0xFE, 0x03, 0xE0,
  0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF8, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF3, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE, 0xF8, 0x7B, 0xC1,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x87, 0x9E, 0x1E, 0x7F,
  0xF8, 0xFF, 0xC1, 0xFE, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0x78, 0xFB, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFF,
  0x3C, 0x7B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF,
  0xFF, 0xBF, 0xF8, 0xFF, 0x81, 0xF0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xFF,
  0xEF, 0x8F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xF1, 0xFF, 0xDF, 0xBF, 0xFC, 0xFF, 0xE3, 0xCF, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x07, 0xC1, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0x80, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xDC, 0x39, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xE3, 0x8E,
  0x79, 0xE7, 0x3C, 0x60, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xE7,
  0xF8, 0xFE, 0x0F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xF0,
  0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xF0, 0x0F, 0x03,
  0xF1, 0xFF, 0x7F, 0xCF, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x81,
  0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0x8F, 0xF8, 0x7F, 0xC3, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x1E,
  0x0E, 0x38, 0x3F, 0x8E, 0x38, 0x7F, 0x86, 0x70, 0xF3, 0x86, 0x70, 0xE3,
  0x86, 0x71, 0xC3, 0x87, 0x71, 0xC3, 0x87, 0x71, 0xC3, 0x87, 0x61, 0xC3,
  0x87, 0xE1, 0xC3, 0x86, 0xE3, 0xC3, 0x86, 0xE3, 0xC3, 0x8E, 0x61, 0xC7,
  0x8E, 0x71, 0xC7, 0x8C, 0x71, 0xFF, 0xFC, 0x70, 0xFB, 0xF8, 0x70, 0x70,
  0xF0, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x1F, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80,
  0x1F, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x83, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3D, 0xF1, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF,
  0xFF, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x07, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0x7C, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E,
  0xF8, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0x7C, 0x0F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFC, 0x07, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xC1, 0xFF, 0x07, 0xBE, 0x3E,
  0xFF, 0xF9, 0xFF, 0xC3, 0xFE, 0x03, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE,
  0x0F, 0x9F, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0,
  0xFB, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x03, 0xF7, 0xC1, 0xFB, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xEF, 0xFF,
  0x07, 0xBF, 0xDE, 0x1E, 0xFF, 0x78, 0x7F, 0xFD, 0xE1, 0xDF, 0xF3, 0x8F,
  0x7F, 0xCF, 0x3D, 0xFF, 0x3C, 0xE7, 0xFC, 0x77, 0x9F, 0xF1, 0xFE, 0x7F,
  0xC7, 0xF1, 0xFF, 0x1F, 0xC7, 0xFC, 0x3F, 0x1F, 0xF0, 0xFC, 0x7F, 0xC3,
  0xE1, 0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xF7, 0x87, 0xFB, 0xC3, 0xFC, 0xF1, 0xFE, 0x78, 0xFF, 0x1E, 0x7F, 0x8F,
  0x3F, 0xC3, 0xDF, 0xE1, 0xEF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0x07, 0xE0,
  0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC1, 0xF7, 0xC0, 0xFB, 0xE0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xBE, 0x07, 0xCF, 0x83, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF8, 0x3E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC1, 0xF7,
  0xC0, 0xFB, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x07, 0xBE, 0x07, 0xCF, 0x83, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00,
  0x40, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8,
  0x78, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8,
  0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x78,
  0x1F, 0x78, 0x1F, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1F, 0x7C, 0x1F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xE0, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x3E, 0x03, 0xE3, 0xC0,
  0x7C, 0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1F, 0x3C, 0x01, 0xE7,
  0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x3C,
  0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C, 0x1E, 0x78, 0x7E,
  0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x3E, 0x78, 0x7E, 0x3C, 0x7C, 0xFE,
  0x3C, 0x3C, 0xFF, 0x3C, 0x3C, 0xEF, 0x3C, 0x3C, 0xEF, 0x3C, 0x3C, 0xE7,
  0x7C, 0x3D, 0xE7, 0x78, 0x1F, 0xE7, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC7,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0x83,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x0F,
  0xBE, 0x07, 0x9F, 0x07, 0xC7, 0x83, 0xC3, 0xE3, 0xE0, 0xF1, 0xE0, 0x7D,
  0xF0, 0x1E, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x7C, 0x0F, 0xBE,
  0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xC1, 0xF3, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0,
  0x1F, 0x78, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0xF8, 0xF0, 0x3C, 0x3E, 0x1F,
  0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xEF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x7C, 0x0F, 0x83,
  0xF8, 0x77, 0x0E, 0xE3, 0xCE, 0x71, 0xCE, 0x3B, 0xC7, 0xF8, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0xC0, 0x7F,
  0xC3, 0xFF, 0x1F, 0xBE, 0x78, 0x79, 0xE1, 0xE0, 0x07, 0x83, 0xFE, 0x3F,
  0xF9, 0xFF, 0xE7, 0x87, 0xBE, 0x1E, 0xF8, 0x7B, 0xE1, 0xE7, 0xDF, 0x9F,
  0xFE, 0x3F, 0xF8, 0x7D, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF3, 0xC3, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFE, 0xF8, 0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF,
  0xF3, 0xCF, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1F, 0xFE, 0x78, 0x79,
  0xE1, 0xFF, 0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x3D, 0xE1, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x0F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x78, 0x7F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3D,
  0xE1, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xBC, 0x3C, 0xF0, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7D, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x67, 0xFF, 0x8F,
  0xFF, 0x1F, 0xF8, 0x1F, 0x80, 0x07, 0xC3, 0xF1, 0xFC, 0xFF, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0xFF, 0xBF, 0xEF, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x00, 0x0F, 0xBC, 0xFF, 0xF3, 0xFF, 0xDF, 0xFF, 0x78, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3D, 0xE0, 0xF7, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x3C, 0xF0, 0x03, 0xC0,
  0x0F, 0x10, 0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF3,
  0xC7, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x67, 0xBF, 0xE7, 0x00, 0x1E, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x0C, 0x3C, 0x78,
  0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xFF,
  0x7C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0xFB, 0xC7, 0xCF, 0x1F, 0x3C, 0xF8, 0xF7, 0xC3,
  0xDF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x3E, 0xF0,
  0xF3, 0xE3, 0xC7, 0xCF, 0x1F, 0x3C, 0x3E, 0xF0, 0xFB, 0xC1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xC3, 0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x87, 0xF8, 0x7C, 0x3F, 0xC1, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x78, 0x7F,
  0x83, 0xC3, 0xFC, 0x1E, 0x1F, 0xE0, 0xF0, 0xFF, 0x07, 0x87, 0xF8, 0x3C,
  0x3F, 0xC1, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xC0,
  0xF3, 0xC7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFC,
  0x1F, 0xF0, 0x0F, 0x80, 0xF3, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFE, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xCF, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x3C, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x78, 0x7F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3D, 0xE1,
  0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xBC, 0x3C, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFB, 0xF7, 0x87, 0xBC, 0x3D,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x3D, 0xF3, 0xEF, 0xFE, 0x3F, 0xF0, 0x7E, 0x00, 0x1E, 0x0F, 0x07, 0x83,
  0xCF, 0xFF, 0xFF, 0xFE, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xE3, 0xF0, 0xF8, 0x3C, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x79, 0xF3, 0xC0, 0xF0, 0x7B, 0xC1, 0xEF, 0x87, 0xBE, 0x3E, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x07, 0x70,
  0x1F, 0xC0, 0x7F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0xE0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF1, 0xEF, 0x1F, 0x1E, 0x79, 0xF1, 0xE7,
  0x9F, 0x9E, 0x79, 0xF9, 0xE7, 0xBF, 0x9C, 0x7B, 0xBB, 0xC3, 0xBB, 0xFC,
  0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0xF8, 0x79, 0xE3, 0xE7,
  0xCF, 0x0F, 0x7C, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0x1E, 0x3C,
  0xF8, 0xFB, 0xC1, 0xE0, 0xF8, 0x3C, 0xF0, 0x79, 0xF1, 0xF3, 0xE3, 0xE3,
  0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x07, 0x0F,
  0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C,
  0xF8, 0xF0, 0xF8, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1E, 0x1E, 0x0F, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0x1F, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0xE0, 0xC0, 0x3E, 0x00, 0xFE, 0x1D, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFC,
  0x3F, 0x80, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 9, 9, 11, 1, -26 },
  { 27, 16, 24, 18, 1, -24 },
  { 75, 13, 31, 17, 2, -28 },
  { 126, 18, 24, 22, 2, -24 },
  { 180, 18, 24, 19, 1, -24 },
  { 234, 3, 9, 6, 1, -26 },
  { 238, 8, 35, 11, 2, -27 },
  { 273, 8, 35, 11, 1, -27 },
  { 308, 15, 15, 15, 0, -24 },
  { 337, 14, 18, 16, 1, -20 },
  { 369, 5, 10, 8, 1, -4 },
  { 376, 8, 4, 11, 2, -13 },
  { 380, 5, 5, 10, 2, -5 },
  { 384, 11, 26, 12, 0, -24 },
  { 420, 13, 24, 17, 2, -24 },
  { 459, 9, 24, 17, 3, -24 },
  { 486, 15, 24, 17, 1, -24 },
  { 531, 14, 24, 17, 1, -24 },
  { 573, 15, 24, 17, 1, -24 },
  { 618, 14, 24, 17, 2, -24 },
  { 660, 14, 24, 17, 2, -24 },
  { 702, 15, 24, 17, 1, -24 },
  { 747, 13, 24, 17, 2, -24 },
  { 786, 13, 24, 17, 2, -24 },
  { 825, 5, 19, 9, 2, -19 },
  { 837, 6, 25, 8, 1, -19 },
  { 856, 12, 15, 15, 1, -18 },
  { 879, 13, 12, 17, 2, -17 },
  { 899, 12, 15, 15, 2, -18 },
  { 922, 13, 24, 15, 1, -24 },
  { 961, 24, 32, 26, 1, -24 },
  { 1057, 20, 24, 20, 0, -24 },
  { 1117, 15, 24, 19, 2, -24 },
  { 1162, 16, 24, 19, 2, -24 },
  { 1210, 16, 24, 19, 2, -24 },
  { 1258, 14, 24, 17, 2, -24 },
  { 1300, 13, 24, 16, 2, -24 },
  { 1339, 16, 24, 20, 2, -24 },
  { 1387, 17, 24, 21, 2, -24 },
  { 1438, 5, 24, 9, 2, -24 },
  { 1453, 14, 24, 17, 1, -24 },
  { 1495, 17, 24, 19, 2, -24 },
  { 1546, 13, 24, 16, 2, -24 },
  { 1585, 22, 24, 26, 2, -24 },
  { 1651, 17, 24, 21, 2, -24 },
  { 1702, 17, 24, 21, 2, -24 },
  { 1753, 16, 24, 19, 2, -24 },
  { 1801, 17, 28, 21, 2, -24 },
  { 1861, 16, 24, 19, 2, -24 },
  { 1909, 16, 24, 18, 1, -24 },
  { 1957, 16, 24, 18, 1, -24 },
  { 2005, 16, 24, 19, 2, -24 },
  { 2053, 19, 24, 20, 0, -24 },
  { 2110, 24, 24, 26, 1, -24 },
  { 2182, 17, 24, 19, 1, -24 },
  { 2233, 18, 24, 18, 0, -24 },
  { 2287, 16, 24, 18, 1, -24 },
  { 2335, 6, 34, 9, 2, -28 },
  { 2361, 13, 26, 13, 0, -24 },
  { 2404, 6, 34, 9, 1, -28 },
  { 2430, 11, 12, 13, 1, -24 },
  { 2447, 13, 3, 14, 0, 0 },
  { 2452, 8, 5, 11, 1, -25 },
  { 2457, 14, 18, 16, 1, -18 },
  { 2489, 14, 26, 17, 2, -26 },
  { 2535, 14, 18, 16, 1, -18 },
  { 2567, 14, 26, 17, 1, -26 },
  { 2613, 14, 18, 16, 1, -18 },
  { 2645, 10, 26, 11, 1, -26 },
  { 2678, 14, 25, 17, 1, -18 },
  { 2722, 13, 26, 17, 2, -26 },
  { 2765, 5, 25, 8, 2, -25 },
  { 2781, 7, 32, 8, -1, -25 },
  { 2809, 14, 26, 16, 2, -26 },
  { 2855, 4, 26, 8, 2, -26 },
  { 2868, 21, 18, 25, 2, -18 },
  { 2916, 13, 18, 17, 2, -18 },
  { 2946, 15, 18, 17, 1, -18 },
  { 2980, 14, 25, 17, 2, -18 },
  { 3024, 14, 25, 17, 1, -18 },
  { 3068, 8, 18, 11, 2, -18 },
  { 3086, 13, 18, 15, 1, -18 },
  { 3116, 9, 22, 10, 0, -22 },
  { 3141, 13, 18, 17, 2, -18 },
  { 3171, 14, 18, 15, 1, -18 },
  { 3203, 20, 18, 22, 1, -18 },
  { 3248, 14, 18, 15, 1, -18 },
  { 3280, 15, 25, 15, 0, -18 },
  { 3327, 13, 18, 15, 1, -18 },
  { 3357, 8, 33, 10, 1, -27 },
  { 3390, 3, 28, 9, 3, -24 },
  { 3401, 8, 33, 10, 1, -27 },
  { 3434, 15, 7, 19, 2, -13 },
};

const GFXfont RobotoCondensed_SemiBold34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_SEMIBOLD34PT7B_H_
