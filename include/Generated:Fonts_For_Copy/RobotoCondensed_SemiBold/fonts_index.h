#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_SemiBold6pt7b, 6, "RobotoCondensed_SemiBold6pt7b" },
  { &RobotoCondensed_SemiBold7pt7b, 7, "RobotoCondensed_SemiBold7pt7b" },
  { &RobotoCondensed_SemiBold8pt7b, 8, "RobotoCondensed_SemiBold8pt7b" },
  { &RobotoCondensed_SemiBold9pt7b, 9, "RobotoCondensed_SemiBold9pt7b" },
  { &RobotoCondensed_SemiBold10pt7b, 10, "RobotoCondensed_SemiBold10pt7b" },
  { &RobotoCondensed_SemiBold11pt7b, 11, "RobotoCondensed_SemiBold11pt7b" },
  { &RobotoCondensed_SemiBold12pt7b, 12, "RobotoCondensed_SemiBold12pt7b" },
  { &RobotoCondensed_SemiBold13pt7b, 13, "RobotoCondensed_SemiBold13pt7b" },
  { &RobotoCondensed_SemiBold14pt7b, 14, "RobotoCondensed_SemiBold14pt7b" },
  { &RobotoCondensed_SemiBold15pt7b, 15, "RobotoCondensed_SemiBold15pt7b" },
  { &RobotoCondensed_SemiBold16pt7b, 16, "RobotoCondensed_SemiBold16pt7b" },
  { &RobotoCondensed_SemiBold17pt7b, 17, "RobotoCondensed_SemiBold17pt7b" },
  { &RobotoCondensed_SemiBold18pt7b, 18, "RobotoCondensed_SemiBold18pt7b" },
  { &RobotoCondensed_SemiBold19pt7b, 19, "RobotoCondensed_SemiBold19pt7b" },
  { &RobotoCondensed_SemiBold20pt7b, 20, "RobotoCondensed_SemiBold20pt7b" },
  { &RobotoCondensed_SemiBold21pt7b, 21, "RobotoCondensed_SemiBold21pt7b" },
  { &RobotoCondensed_SemiBold22pt7b, 22, "RobotoCondensed_SemiBold22pt7b" },
  { &RobotoCondensed_SemiBold23pt7b, 23, "RobotoCondensed_SemiBold23pt7b" },
  { &RobotoCondensed_SemiBold24pt7b, 24, "RobotoCondensed_SemiBold24pt7b" },
  { &RobotoCondensed_SemiBold25pt7b, 25, "RobotoCondensed_SemiBold25pt7b" },
  { &RobotoCondensed_SemiBold26pt7b, 26, "RobotoCondensed_SemiBold26pt7b" },
  { &RobotoCondensed_SemiBold27pt7b, 27, "RobotoCondensed_SemiBold27pt7b" },
  { &RobotoCondensed_SemiBold28pt7b, 28, "RobotoCondensed_SemiBold28pt7b" },
  { &RobotoCondensed_SemiBold29pt7b, 29, "RobotoCondensed_SemiBold29pt7b" },
  { &RobotoCondensed_SemiBold30pt7b, 30, "RobotoCondensed_SemiBold30pt7b" },
  { &RobotoCondensed_SemiBold31pt7b, 31, "RobotoCondensed_SemiBold31pt7b" },
  { &RobotoCondensed_SemiBold32pt7b, 32, "RobotoCondensed_SemiBold32pt7b" },
  { &RobotoCondensed_SemiBold33pt7b, 33, "RobotoCondensed_SemiBold33pt7b" },
  { &RobotoCondensed_SemiBold34pt7b, 34, "RobotoCondensed_SemiBold34pt7b" },
  { &RobotoCondensed_SemiBold35pt7b, 35, "RobotoCondensed_SemiBold35pt7b" },
  { &RobotoCondensed_SemiBold36pt7b, 36, "RobotoCondensed_SemiBold36pt7b" },
  { &RobotoCondensed_SemiBold37pt7b, 37, "RobotoCondensed_SemiBold37pt7b" },
  { &RobotoCondensed_SemiBold38pt7b, 38, "RobotoCondensed_SemiBold38pt7b" },
  { &RobotoCondensed_SemiBold39pt7b, 39, "RobotoCondensed_SemiBold39pt7b" },
  { &RobotoCondensed_SemiBold40pt7b, 40, "RobotoCondensed_SemiBold40pt7b" },
  { &RobotoCondensed_SemiBold41pt7b, 41, "RobotoCondensed_SemiBold41pt7b" },
  { &RobotoCondensed_SemiBold42pt7b, 42, "RobotoCondensed_SemiBold42pt7b" },
  { &RobotoCondensed_SemiBold43pt7b, 43, "RobotoCondensed_SemiBold43pt7b" },
  { &RobotoCondensed_SemiBold44pt7b, 44, "RobotoCondensed_SemiBold44pt7b" },
  { &RobotoCondensed_SemiBold45pt7b, 45, "RobotoCondensed_SemiBold45pt7b" },
  { &RobotoCondensed_SemiBold46pt7b, 46, "RobotoCondensed_SemiBold46pt7b" },
  { &RobotoCondensed_SemiBold47pt7b, 47, "RobotoCondensed_SemiBold47pt7b" },
  { &RobotoCondensed_SemiBold48pt7b, 48, "RobotoCondensed_SemiBold48pt7b" },
  { &RobotoCondensed_SemiBold49pt7b, 49, "RobotoCondensed_SemiBold49pt7b" },
  { &RobotoCondensed_SemiBold50pt7b, 50, "RobotoCondensed_SemiBold50pt7b" },
  { &RobotoCondensed_SemiBold51pt7b, 51, "RobotoCondensed_SemiBold51pt7b" },
  { &RobotoCondensed_SemiBold52pt7b, 52, "RobotoCondensed_SemiBold52pt7b" },
  { &RobotoCondensed_SemiBold53pt7b, 53, "RobotoCondensed_SemiBold53pt7b" },
  { &RobotoCondensed_SemiBold54pt7b, 54, "RobotoCondensed_SemiBold54pt7b" },
  { &RobotoCondensed_SemiBold55pt7b, 55, "RobotoCondensed_SemiBold55pt7b" },
  { &RobotoCondensed_SemiBold56pt7b, 56, "RobotoCondensed_SemiBold56pt7b" },
  { &RobotoCondensed_SemiBold57pt7b, 57, "RobotoCondensed_SemiBold57pt7b" },
  { &RobotoCondensed_SemiBold58pt7b, 58, "RobotoCondensed_SemiBold58pt7b" },
  { &RobotoCondensed_SemiBold59pt7b, 59, "RobotoCondensed_SemiBold59pt7b" },
  { &RobotoCondensed_SemiBold60pt7b, 60, "RobotoCondensed_SemiBold60pt7b" },
  { &RobotoCondensed_SemiBold61pt7b, 61, "RobotoCondensed_SemiBold61pt7b" },
  { &RobotoCondensed_SemiBold62pt7b, 62, "RobotoCondensed_SemiBold62pt7b" },
  { &RobotoCondensed_SemiBold63pt7b, 63, "RobotoCondensed_SemiBold63pt7b" },
  { &RobotoCondensed_SemiBold64pt7b, 64, "RobotoCondensed_SemiBold64pt7b" },
  { &RobotoCondensed_SemiBold65pt7b, 65, "RobotoCondensed_SemiBold65pt7b" },
  { &RobotoCondensed_SemiBold66pt7b, 66, "RobotoCondensed_SemiBold66pt7b" },
  { &RobotoCondensed_SemiBold67pt7b, 67, "RobotoCondensed_SemiBold67pt7b" },
  { &RobotoCondensed_SemiBold68pt7b, 68, "RobotoCondensed_SemiBold68pt7b" },
  { &RobotoCondensed_SemiBold69pt7b, 69, "RobotoCondensed_SemiBold69pt7b" },
  { &RobotoCondensed_SemiBold70pt7b, 70, "RobotoCondensed_SemiBold70pt7b" },
  { &RobotoCondensed_SemiBold71pt7b, 71, "RobotoCondensed_SemiBold71pt7b" },
  { &RobotoCondensed_SemiBold72pt7b, 72, "RobotoCondensed_SemiBold72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
