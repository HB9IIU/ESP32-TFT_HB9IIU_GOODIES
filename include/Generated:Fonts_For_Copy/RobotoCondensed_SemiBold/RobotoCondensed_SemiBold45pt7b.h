#ifndef _ROBOTOCONDENSED_SEMIBOLD45PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFB, 0xEF, 0xBE, 0x79, 0xE0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0xDE, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x77, 0x8E,
  0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x81, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x81, 0xE3, 0xC0, 0x0E, 0x1C, 0x00,
  0x70, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF1, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF,
  0x81, 0xF7, 0xE0, 0x7D, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFD, 0xF8, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x08, 0x0F, 0x0F, 0x06, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC3,
  0x81, 0xE1, 0xE3, 0xC0, 0xF0, 0xF1, 0xC0, 0x78, 0x79, 0xE0, 0x3C, 0x3C,
  0xE0, 0x0F, 0xFC, 0xF0, 0x07, 0xFE, 0x70, 0x01, 0xFE, 0x78, 0x00, 0x3E,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x1E, 0x7F, 0x80, 0x0E, 0x7F, 0xE0, 0x0F, 0x7F, 0xF0, 0x07, 0x3C, 0x78,
  0x07, 0x9E, 0x1E, 0x03, 0x8F, 0x0F, 0x03, 0xC7, 0x87, 0x81, 0xC3, 0xC3,
  0xC1, 0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0xE0, 0x30, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xE3, 0xE0,
  0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x7C, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0xF8, 0x7F, 0xF1, 0xF1, 0xFF,
  0xE3, 0xE3, 0xE7, 0xE7, 0xCF, 0xCF, 0xEF, 0x9F, 0x8F, 0xFF, 0x3E, 0x0F,
  0xFC, 0x7C, 0x0F, 0xF8, 0xFC, 0x1F, 0xF1, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x3F,
  0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0x80, 0x70,
  0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xC1, 0xF0,
  0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xC0, 0x20, 0x40, 0x0C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x06, 0x00, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x81,
  0xC1, 0xBE, 0x38, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0x78, 0x07, 0xCF, 0x80, 0xF0,
  0xF0, 0x3E, 0x1F, 0x03, 0x81, 0xC0, 0x00, 0x10, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xFB, 0xE7, 0x82,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7D, 0xFB, 0xFF, 0xFF,
  0xCF, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x9F, 0x87, 0xE7, 0xE0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7D, 0xF0, 0x3F, 0x7C, 0x0F,
  0xDF, 0x83, 0xF7, 0xE1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xF8,
  0x0F, 0xDF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x03, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3C, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x3E,
  0x07, 0xDF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x0F,
  0xDF, 0xC1, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3F,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7C, 0x0F,
  0xDF, 0x03, 0xF7, 0xE0, 0xFD, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xF1, 0xF9, 0xF8,
  0x3F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFF, 0x83, 0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x1F, 0x87, 0xE7, 0xE1, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7D, 0xF0, 0x3F, 0x7E, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC1, 0xF3, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x7D, 0xFB, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xEF, 0xFF, 0xFF,
  0x3C, 0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x78, 0x78, 0x30, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x0F,
  0xFE, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x07,
  0xC0, 0x70, 0xF0, 0x1F, 0xE0, 0xF1, 0xE0, 0x7F, 0xE1, 0xE7, 0x81, 0xFF,
  0xC1, 0xCF, 0x07, 0xC7, 0x83, 0x9E, 0x0F, 0x0F, 0x07, 0x38, 0x3C, 0x1E,
  0x0E, 0xF0, 0x78, 0x3C, 0x1F, 0xE0, 0xF0, 0x78, 0x3F, 0xC3, 0xE0, 0xF0,
  0x7F, 0x87, 0xC1, 0xE0, 0xFF, 0x0F, 0x03, 0xC1, 0xDE, 0x1E, 0x07, 0x03,
  0xBC, 0x3C, 0x1E, 0x07, 0x78, 0x78, 0x3C, 0x0E, 0xF0, 0xF8, 0x78, 0x3D,
  0xE1, 0xF0, 0xF0, 0x73, 0xC3, 0xE3, 0xE1, 0xE7, 0x83, 0xFF, 0xE7, 0x87,
  0x07, 0xFF, 0xFF, 0x0F, 0x07, 0xF3, 0xFC, 0x1E, 0x07, 0x83, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xFD, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x8F,
  0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xE0,
  0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xEF, 0xC1, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x3F,
  0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8,
  0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xC1, 0xFC, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC,
  0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x1F,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xF7, 0xE1, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF,
  0xC0, 0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x7F, 0x0F, 0xC3,
  0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0,
  0x3F, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF,
  0x80, 0xFE, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFE, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xF3, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xDF,
  0xFB, 0xE0, 0x7D, 0xFF, 0xBE, 0x07, 0xDF, 0xFB, 0xF0, 0x79, 0xFF, 0x9F,
  0x0F, 0x9F, 0xF9, 0xF0, 0xF9, 0xFF, 0x9F, 0x0F, 0x9F, 0xF8, 0xF9, 0xF1,
  0xFF, 0x8F, 0x9F, 0x1F, 0xF8, 0xF9, 0xF1, 0xFF, 0xC7, 0xFE, 0x1F, 0xFC,
  0x7F, 0xE1, 0xFF, 0xC7, 0xFE, 0x1F, 0xFC, 0x7F, 0xC1, 0xFF, 0xC3, 0xFC,
  0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xC3, 0xFC, 0x1F, 0xFC, 0x1F, 0x81, 0xFF,
  0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC0, 0xF0, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x3F, 0xFB, 0xF0, 0xFF, 0xE7, 0xC3,
  0xFF, 0x9F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0xFC, 0xFF, 0xE1, 0xF3, 0xFF,
  0x87, 0xEF, 0xFE, 0x0F, 0xBF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E,
  0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFB, 0xF0,
  0x1F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x7E, 0x07, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0x7E, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x7E, 0x03,
  0xF3, 0xF0, 0x3F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF9, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7F,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xF0, 0xFE, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xEF, 0x80, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3E,
  0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E,
  0x7E, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7C,
  0x3E, 0x0F, 0xF0, 0x7C, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC,
  0x3F, 0x1F, 0xF8, 0xFC, 0x1F, 0x1F, 0xF8, 0xF8, 0x1F, 0x1E, 0x78, 0xF8,
  0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8,
  0x0F, 0xBE, 0x7D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0xFC,
  0x01, 0xF9, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xE7, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x9F, 0x80,
  0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE3,
  0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x1E, 0x78,
  0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xE7, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x03,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x07,
  0xEF, 0xC1, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x81, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xF8,
  0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x3E, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x7E, 0xFF, 0x8F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x80, 0xFB,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x7E, 0x07, 0xEF,
  0xE0, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFD, 0xFF, 0x1F,
  0x9F, 0x80, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xFF,
  0xFB, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x87, 0xEF, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0xFC, 0x7F, 0xBF, 0x3F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xE7, 0xC3, 0xF1, 0xF0, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xEF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x47, 0xE0, 0x71, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x8F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x7F, 0xF8, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00,
  0x07, 0xC7, 0xC7, 0xFD, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x60, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC7, 0xC3, 0xF7, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xF8, 0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3C, 0xFB, 0xFF, 0xF7,
  0xC7, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E,
  0x7C, 0x0F, 0x07, 0xC7, 0xE3, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x07,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x7F, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F,
  0x87, 0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0xDF, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7F,
  0x3F, 0x07, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7C, 0x0F, 0x87,
  0xEF, 0xF1, 0xFF, 0x3F, 0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x0F, 0xF0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF8,
  0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F,
  0xF8, 0x1F, 0x83, 0xFF, 0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0xFF, 0xF0,
  0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E,
  0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF, 0xC0, 0xFC, 0x1F,
  0xFE, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3F, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87,
  0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xDF, 0x81, 0xF9,
  0xF8, 0x7F, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x1F, 0x80, 0xFC, 0xFC, 0x1F, 0xBF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xFB, 0xF8, 0x3F, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0x7F, 0x87, 0xE7, 0xE0, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xC7,
  0xF9, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFE,
  0xFC, 0x3F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xF7, 0xF7, 0xE1,
  0xFB, 0xF0, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xEF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x0F, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x3E,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFE, 0xFC, 0x3F, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFD, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xF8, 0x1E, 0x07, 0xFF, 0x83, 0xE0, 0xFB, 0xF0, 0x7C, 0x1F, 0x3E, 0x1F,
  0x83, 0xE7, 0xC3, 0xF0, 0x7C, 0xF8, 0x7F, 0x1F, 0x9F, 0x0F, 0xE3, 0xE3,
  0xF3, 0xFC, 0x7C, 0x3E, 0x7F, 0x8F, 0x87, 0xCF, 0xF9, 0xF0, 0xF9, 0xEF,
  0x3E, 0x1F, 0x7D, 0xEF, 0x81, 0xEF, 0xBD, 0xF0, 0x3F, 0xE7, 0xFE, 0x07,
  0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0xDF,
  0x83, 0xE7, 0xE1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x07, 0xEF, 0x81, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07,
  0xFF, 0x81, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x1F, 0x9F, 0x87, 0xE7, 0xE0,
  0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F,
  0x83, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40,
  0x3C, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x1F, 0x8F, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x0E, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC1,
  0xF8, 0x7F, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x87, 0xE0,
  0xF8, 0x0E, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xCF, 0xF8,
  0x1E, 0xFF, 0xE1, 0xF7, 0xFF, 0x8F, 0xBE, 0x7F, 0xF9, 0xE1, 0xFF, 0xDF,
  0x07, 0xFC, 0xF8, 0x1F, 0xC0, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 32, 12, 3, -32 },
  { 25, 11, 12, 14, 2, -34 },
  { 42, 21, 32, 24, 2, -32 },
  { 126, 18, 41, 23, 2, -37 },
  { 219, 25, 32, 29, 2, -32 },
  { 319, 23, 32, 26, 2, -32 },
  { 411, 4, 12, 7, 2, -34 },
  { 417, 10, 46, 14, 3, -36 },
  { 475, 11, 46, 15, 1, -36 },
  { 539, 19, 19, 20, 1, -32 },
  { 585, 18, 23, 22, 2, -26 },
  { 637, 7, 13, 11, 1, -5 },
  { 649, 11, 5, 15, 2, -16 },
  { 656, 7, 6, 13, 3, -6 },
  { 662, 14, 35, 15, 0, -32 },
  { 724, 18, 32, 23, 2, -32 },
  { 796, 12, 32, 23, 3, -32 },
  { 844, 19, 32, 23, 2, -32 },
  { 920, 18, 32, 23, 2, -32 },
  { 992, 20, 32, 23, 1, -32 },
  { 1072, 19, 32, 23, 2, -32 },
  { 1148, 19, 32, 23, 2, -32 },
  { 1224, 19, 32, 23, 2, -32 },
  { 1300, 18, 32, 23, 2, -32 },
  { 1372, 18, 32, 23, 2, -32 },
  { 1444, 7, 24, 12, 3, -24 },
  { 1465, 8, 32, 11, 1, -24 },
  { 1497, 16, 21, 20, 1, -24 },
  { 1539, 16, 15, 22, 3, -22 },
  { 1569, 16, 21, 21, 3, -24 },
  { 1611, 17, 32, 20, 1, -32 },
  { 1679, 31, 41, 35, 2, -31 },
  { 1838, 25, 32, 27, 1, -32 },
  { 1938, 20, 32, 25, 3, -32 },
  { 2018, 22, 32, 26, 2, -32 },
  { 2106, 20, 32, 25, 3, -32 },
  { 2186, 18, 32, 22, 3, -32 },
  { 2258, 17, 32, 21, 3, -32 },
  { 2326, 22, 32, 26, 2, -32 },
  { 2414, 22, 32, 28, 3, -32 },
  { 2502, 6, 32, 12, 3, -32 },
  { 2526, 18, 32, 22, 1, -32 },
  { 2598, 22, 32, 25, 3, -32 },
  { 2686, 17, 32, 21, 3, -32 },
  { 2754, 28, 32, 34, 3, -32 },
  { 2866, 22, 32, 28, 3, -32 },
  { 2954, 23, 32, 27, 2, -32 },
  { 3046, 21, 32, 25, 3, -32 },
  { 3130, 23, 38, 27, 2, -32 },
  { 3240, 21, 32, 25, 3, -32 },
  { 3324, 20, 32, 24, 2, -32 },
  { 3404, 22, 32, 24, 1, -32 },
  { 3492, 21, 32, 26, 2, -32 },
  { 3576, 24, 32, 26, 1, -32 },
  { 3672, 32, 32, 34, 1, -32 },
  { 3800, 23, 32, 25, 1, -32 },
  { 3892, 24, 32, 24, 0, -32 },
  { 3988, 20, 32, 24, 2, -32 },
  { 4068, 8, 44, 12, 3, -37 },
  { 4112, 17, 35, 17, 0, -32 },
  { 4187, 8, 44, 12, 1, -37 },
  { 4231, 15, 16, 17, 1, -32 },
  { 4261, 18, 5, 18, 0, 0 },
  { 4273, 11, 7, 15, 1, -34 },
  { 4283, 18, 24, 21, 2, -24 },
  { 4337, 19, 34, 22, 2, -34 },
  { 4418, 17, 24, 21, 2, -24 },
  { 4469, 18, 34, 22, 2, -34 },
  { 4546, 18, 24, 21, 2, -24 },
  { 4600, 13, 34, 15, 1, -34 },
  { 4656, 18, 33, 23, 2, -24 },
  { 4731, 18, 34, 22, 2, -34 },
  { 4808, 7, 33, 11, 2, -33 },
  { 4837, 9, 42, 11, -1, -33 },
  { 4885, 19, 34, 21, 2, -34 },
  { 4966, 5, 34, 11, 3, -34 },
  { 4988, 29, 24, 34, 2, -24 },
  { 5075, 18, 24, 22, 2, -24 },
  { 5129, 19, 24, 22, 2, -24 },
  { 5186, 19, 33, 22, 2, -24 },
  { 5265, 18, 33, 22, 2, -24 },
  { 5340, 12, 24, 15, 2, -24 },
  { 5376, 17, 24, 20, 2, -24 },
  { 5427, 12, 30, 14, 1, -30 },
  { 5472, 18, 24, 22, 2, -24 },
  { 5526, 18, 24, 20, 1, -24 },
  { 5580, 27, 24, 29, 1, -24 },
  { 5661, 18, 24, 20, 1, -24 },
  { 5715, 19, 33, 20, 0, -24 },
  { 5794, 16, 24, 20, 2, -24 },
  { 5842, 11, 43, 14, 1, -35 },
  { 5902, 4, 38, 11, 4, -32 },
  { 5921, 11, 43, 14, 1, -35 },
  { 5981, 21, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_SemiBold45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_SEMIBOLD45PT7B_H_
