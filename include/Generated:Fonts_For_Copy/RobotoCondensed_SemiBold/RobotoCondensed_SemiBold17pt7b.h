#ifndef _ROBOTOCONDENSED_SEMIBOLD17PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xCF, 0xBB, 0xBB, 0x16, 0x34, 0x34, 0x24, 0xFF, 0x2C,
  0x2C, 0xFE, 0x68, 0x68, 0x48, 0x58, 0x10, 0x20, 0xE3, 0xEC, 0xF8, 0xF8,
  0x3C, 0x3C, 0x1F, 0x1E, 0x7F, 0xCF, 0x04, 0x08, 0x60, 0x69, 0x24, 0x92,
  0xCD, 0x43, 0x40, 0x3C, 0x2B, 0x34, 0x92, 0x49, 0x60, 0xE0, 0x38, 0x7C,
  0x6C, 0x6C, 0x78, 0x70, 0x73, 0xDB, 0xCE, 0xCE, 0xFE, 0x7B, 0xF0, 0x13,
  0x66, 0x4C, 0xCC, 0xCC, 0xCC, 0x46, 0x63, 0x10, 0x42, 0x18, 0x63, 0x18,
  0x43, 0x18, 0xC4, 0x63, 0x19, 0x88, 0x40, 0x18, 0x33, 0xFB, 0xF3, 0x85,
  0x89, 0x00, 0x30, 0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x6D, 0xB4,
  0xFF, 0xF8, 0x08, 0xC6, 0x21, 0x18, 0xC4, 0x63, 0x11, 0x8C, 0x00, 0x78,
  0xFB, 0x36, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x99, 0xF3, 0xC0, 0x1B, 0xFE,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x79, 0xFB, 0x36, 0x70, 0xC1, 0x86,
  0x1C, 0x70, 0xC3, 0xFF, 0xF0, 0x79, 0xFB, 0x30, 0x60, 0xC7, 0x8F, 0x06,
  0x07, 0x9F, 0xF3, 0xC0, 0x1C, 0x38, 0xF1, 0xE6, 0xCD, 0xB3, 0x7F, 0xFE,
  0x18, 0x30, 0x60, 0x7C, 0xF9, 0x06, 0x0F, 0x9F, 0x83, 0x83, 0xC7, 0x9D,
  0xF1, 0xC0, 0x18, 0xF1, 0x86, 0x0F, 0xDF, 0xB3, 0xE3, 0xC7, 0x9D, 0xF1,
  0xC0, 0xFF, 0xFC, 0x30, 0x60, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0x83, 0x00,
  0x79, 0xFB, 0x36, 0x6C, 0xCF, 0x9F, 0x66, 0xC7, 0x9F, 0xF3, 0xC0, 0x79,
  0xFB, 0x36, 0x7C, 0xF9, 0xFF, 0xBE, 0x0C, 0x19, 0xE3, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x6C, 0x00, 0x03, 0x6D, 0xA0, 0x04, 0x77, 0xB8, 0xE1, 0xE1,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x1D, 0xEE, 0x20, 0x3C,
  0xFD, 0x98, 0x30, 0xC3, 0x86, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x0F, 0x07,
  0x39, 0x81, 0x20, 0x3C, 0x73, 0x9A, 0x66, 0x4C, 0xD9, 0x93, 0x32, 0x66,
  0x6D, 0xE6, 0xEC, 0x00, 0xC0, 0x0C, 0x40, 0xF8, 0x0C, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x0C, 0xC3, 0x30, 0xFC, 0x7F, 0x98, 0x66, 0x1B, 0x87, 0xFC,
  0xFE, 0xC6, 0xC6, 0xC6, 0xFE, 0xFE, 0xC6, 0xC7, 0xC7, 0xFE, 0xFC, 0x3C,
  0x7E, 0xE3, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xE3, 0x7E, 0x3C, 0xF8,
  0xFE, 0xC6, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xFE, 0xF8, 0xFF,
  0xFF, 0x06, 0x0C, 0x1F, 0xBF, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xFF, 0xFF,
  0x06, 0x0C, 0x1F, 0xBF, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x3C, 0x7E, 0xE3,
  0xC3, 0xC0, 0xCF, 0xCF, 0xC3, 0xC3, 0xE3, 0x7F, 0x3E, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xE6, 0xCD, 0xF9, 0xE0, 0xC7,
  0xC6, 0xCE, 0xDC, 0xD8, 0xF8, 0xF8, 0xFC, 0xCC, 0xC6, 0xC7, 0xC3, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xE0, 0xFC,
  0x1F, 0xC7, 0xF8, 0xFF, 0x1F, 0xA6, 0xF6, 0xDE, 0xDB, 0xCE, 0x79, 0xCF,
  0x39, 0xE6, 0x30, 0xC3, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF,
  0xC7, 0xC7, 0xC3, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0x7E, 0x3C, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC7, 0xFE, 0xFC, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0x7E, 0x3E, 0x07, 0x01, 0xFC, 0xFE, 0xC7, 0xC7, 0xC6, 0xFE, 0xFC,
  0xCC, 0xCE, 0xC6, 0xC6, 0xC7, 0x7D, 0xFF, 0x1E, 0x3E, 0x0F, 0x07, 0x83,
  0xC7, 0x8F, 0xF9, 0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC7, 0x7E, 0x3C, 0xE1, 0x98, 0x66, 0x19, 0x8E, 0x33,
  0x0C, 0xC3, 0x30, 0xD8, 0x1E, 0x07, 0x81, 0xC0, 0x30, 0x66, 0x36, 0x73,
  0x67, 0x36, 0x73, 0x67, 0x36, 0xD6, 0x3D, 0xE3, 0xDE, 0x3D, 0xE3, 0x8E,
  0x38, 0xC1, 0x8C, 0x63, 0xB9, 0x8C, 0xC7, 0xC1, 0xE0, 0xE0, 0x70, 0x3C,
  0x36, 0x1B, 0x9C, 0xCC, 0x70, 0xE3, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0xFC, 0x38, 0x61, 0xC3,
  0x0C, 0x38, 0x61, 0xC3, 0xFF, 0xF0, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB7,
  0xE0, 0xC0, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60,
  0xC0, 0xFD, 0xB6, 0xDB, 0x6D, 0xB6, 0xDF, 0xE0, 0x30, 0xE3, 0x9A, 0x6D,
  0x30, 0xFF, 0xFC, 0x61, 0x8C, 0x7B, 0xFC, 0xC3, 0x7F, 0x3C, 0xFF, 0x7C,
  0xC1, 0x83, 0x06, 0x0F, 0xDF, 0xB3, 0xE3, 0xC7, 0x8F, 0x3F, 0xEF, 0xC0,
  0x7B, 0xFC, 0xF0, 0xC3, 0x0C, 0xFF, 0x78, 0x0C, 0x30, 0xC3, 0x7F, 0xFC,
  0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0x79, 0xFB, 0x37, 0xFF, 0xF8, 0x31, 0x7E,
  0x78, 0x19, 0xCC, 0xEF, 0xFD, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x77, 0xFF,
  0x3E, 0x7C, 0xF9, 0xF3, 0xFF, 0x7E, 0x1F, 0xF3, 0xC0, 0xC3, 0x0C, 0x30,
  0xFB, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCC, 0xF3, 0xFF, 0xFF, 0x6C, 0x36,
  0xDB, 0x6D, 0xB7, 0xF0, 0xC1, 0x83, 0x06, 0x0C, 0xDB, 0xB6, 0x78, 0xF9,
  0xF3, 0x76, 0x6C, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFD, 0xDF, 0xFB, 0x31,
  0xE6, 0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC, 0x60, 0xDF, 0xFC, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCC, 0x79, 0xFB, 0x3E, 0x3C, 0x78, 0xF3, 0xFE, 0x78,
  0xFD, 0xFB, 0x3E, 0x3C, 0x78, 0xF3, 0xFE, 0xFD, 0x83, 0x06, 0x00, 0x77,
  0xFC, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0x30, 0xC3, 0xFF, 0xCC, 0xCC, 0xCC,
  0xC0, 0x7B, 0xFC, 0xF8, 0x78, 0x7C, 0xFF, 0x78, 0x63, 0x3F, 0xF6, 0x31,
  0x8C, 0x63, 0xCE, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x7C, 0xE6, 0xCD,
  0x9B, 0x62, 0xC7, 0x8E, 0x1C, 0x18, 0xC4, 0xCD, 0xD9, 0xBB, 0x37, 0x66,
  0xAC, 0x77, 0x0E, 0xE1, 0x9C, 0x31, 0x80, 0x66, 0xD8, 0xF1, 0xC1, 0x87,
  0x8F, 0x37, 0x66, 0xE6, 0xCD, 0xBB, 0x63, 0xC7, 0x8E, 0x1C, 0x18, 0x61,
  0xC3, 0x00, 0xFF, 0xF1, 0x8E, 0x31, 0x8E, 0x3F, 0xFC, 0x11, 0x8C, 0x63,
  0x18, 0xDC, 0xE3, 0x0C, 0x63, 0x18, 0xC2, 0xFF, 0xFF, 0xFF, 0xF0, 0x43,
  0x18, 0xC6, 0x30, 0x87, 0x39, 0x98, 0xC6, 0x31, 0x88, 0x63, 0xF3, 0xDE,
  0xCE,
};

const GFXglyph RobotoCondensed_SemiBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 5, 1, -13 },
  { 6, 8, 12, 9, 1, -12 },
  { 18, 7, 16, 9, 1, -14 },
  { 32, 9, 12, 11, 1, -12 },
  { 46, 8, 12, 10, 1, -12 },
  { 58, 1, 4, 3, 1, -13 },
  { 59, 4, 17, 5, 1, -13 },
  { 68, 5, 17, 5, 0, -13 },
  { 79, 7, 7, 8, 0, -12 },
  { 86, 7, 9, 8, 1, -10 },
  { 94, 3, 5, 4, 0, -2 },
  { 96, 4, 2, 6, 1, -6 },
  { 97, 3, 2, 5, 1, -2 },
  { 98, 5, 13, 6, 0, -12 },
  { 107, 7, 12, 9, 1, -12 },
  { 118, 5, 12, 9, 1, -12 },
  { 126, 7, 12, 9, 1, -12 },
  { 137, 7, 12, 9, 1, -12 },
  { 148, 7, 12, 9, 1, -12 },
  { 159, 7, 12, 9, 1, -12 },
  { 170, 7, 12, 9, 1, -12 },
  { 181, 7, 12, 9, 1, -12 },
  { 192, 7, 12, 9, 1, -12 },
  { 203, 7, 12, 9, 1, -12 },
  { 214, 3, 9, 4, 1, -9 },
  { 218, 3, 12, 4, 0, -9 },
  { 223, 6, 8, 8, 1, -9 },
  { 229, 6, 5, 8, 1, -8 },
  { 233, 6, 8, 8, 1, -9 },
  { 239, 7, 12, 8, 0, -12 },
  { 250, 11, 16, 13, 1, -12 },
  { 272, 10, 12, 10, 0, -12 },
  { 287, 8, 12, 9, 1, -12 },
  { 299, 8, 12, 10, 1, -12 },
  { 311, 8, 12, 10, 1, -12 },
  { 323, 7, 12, 8, 1, -12 },
  { 334, 7, 12, 8, 1, -12 },
  { 345, 8, 12, 10, 1, -12 },
  { 357, 8, 12, 10, 1, -12 },
  { 369, 2, 12, 5, 1, -12 },
  { 372, 7, 12, 8, 0, -12 },
  { 383, 8, 12, 9, 1, -12 },
  { 395, 7, 12, 8, 1, -12 },
  { 406, 11, 12, 13, 1, -12 },
  { 423, 8, 12, 10, 1, -12 },
  { 435, 8, 12, 10, 1, -12 },
  { 447, 8, 12, 10, 1, -12 },
  { 459, 8, 14, 10, 1, -12 },
  { 473, 8, 12, 9, 1, -12 },
  { 485, 7, 12, 9, 1, -12 },
  { 496, 9, 12, 9, 0, -12 },
  { 510, 8, 12, 10, 1, -12 },
  { 522, 10, 12, 10, 0, -12 },
  { 537, 12, 12, 13, 0, -12 },
  { 555, 9, 12, 9, 0, -12 },
  { 569, 9, 12, 9, 0, -12 },
  { 583, 7, 12, 9, 1, -12 },
  { 594, 3, 17, 4, 1, -14 },
  { 601, 7, 13, 6, 0, -12 },
  { 613, 3, 17, 4, 0, -14 },
  { 620, 6, 6, 7, 0, -12 },
  { 625, 7, 2, 7, 0, 0 },
  { 627, 5, 3, 6, 0, -13 },
  { 629, 6, 9, 8, 1, -9 },
  { 636, 7, 13, 8, 1, -13 },
  { 648, 6, 9, 8, 1, -9 },
  { 655, 6, 13, 8, 1, -13 },
  { 665, 7, 9, 8, 1, -9 },
  { 673, 5, 13, 6, 0, -13 },
  { 682, 7, 12, 9, 1, -9 },
  { 693, 6, 13, 8, 1, -13 },
  { 703, 2, 12, 4, 1, -12 },
  { 706, 3, 15, 4, 0, -12 },
  { 712, 7, 13, 8, 1, -13 },
  { 724, 2, 13, 4, 1, -13 },
  { 728, 11, 9, 13, 1, -9 },
  { 741, 6, 9, 8, 1, -9 },
  { 748, 7, 9, 8, 1, -9 },
  { 756, 7, 12, 8, 1, -9 },
  { 767, 6, 12, 8, 1, -9 },
  { 776, 4, 9, 6, 1, -9 },
  { 781, 6, 9, 8, 1, -9 },
  { 788, 5, 11, 5, 0, -11 },
  { 795, 6, 9, 8, 1, -9 },
  { 802, 7, 9, 8, 0, -9 },
  { 810, 11, 9, 11, 0, -9 },
  { 823, 7, 9, 8, 0, -9 },
  { 831, 7, 12, 7, 0, -9 },
  { 842, 6, 9, 8, 1, -9 },
  { 849, 5, 16, 5, 0, -13 },
  { 859, 2, 14, 4, 1, -12 },
  { 863, 5, 16, 5, 0, -13 },
  { 873, 8, 4, 10, 1, -7 },
};

const GFXfont RobotoCondensed_SemiBold17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_SEMIBOLD17PT7B_H_
