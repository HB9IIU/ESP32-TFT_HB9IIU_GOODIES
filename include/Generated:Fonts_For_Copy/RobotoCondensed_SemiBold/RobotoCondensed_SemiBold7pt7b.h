#ifndef _ROBOTOCONDENSED_SEMIBOLD7PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xF0, 0x67, 0x6E, 0x40, 0x0E, 0xBA, 0xC0, 0xCE, 0x27, 0x30,
  0x66, 0x4B, 0x70, 0xC0, 0x1A, 0xA4, 0x25, 0x58, 0x5E, 0x80, 0x5D, 0x20,
  0xC0, 0xC0, 0x80, 0x56, 0x80, 0x76, 0xD6, 0xF8, 0x74, 0xAE, 0x65, 0x9E,
  0x2D, 0xF2, 0x73, 0x96, 0x73, 0xD6, 0xE4, 0xA4, 0x75, 0xD6, 0x77, 0x94,
  0x90, 0x88, 0x39, 0x00, 0x7C, 0x8D, 0x00, 0xE5, 0x24, 0x32, 0x6F, 0xBB,
  0xA0, 0x80, 0x26, 0x67, 0x90, 0xE9, 0xE9, 0xE0, 0x69, 0x89, 0x60, 0xE9,
  0x99, 0xE0, 0xF3, 0xCE, 0xF3, 0xC8, 0x69, 0xB9, 0x70, 0x99, 0xF9, 0x90,
  0xF8, 0x24, 0x9E, 0xBA, 0xEA, 0x90, 0x92, 0x4E, 0xCE, 0xF7, 0x5A, 0x80,
  0xDD, 0xBB, 0x90, 0x69, 0x99, 0x60, 0xE9, 0xE8, 0x80, 0x69, 0x99, 0x61,
  0xE9, 0xEA, 0x90, 0x71, 0xD6, 0xF4, 0x44, 0x40, 0x99, 0x99, 0x60, 0x99,
  0x66, 0x60, 0xAD, 0x5E, 0xA5, 0x00, 0x86, 0x66, 0xB0, 0x86, 0x64, 0x40,
  0xE5, 0x2E, 0xEA, 0xAC, 0x91, 0x24, 0xFE, 0x5A, 0x80, 0xE0, 0x40, 0x67,
  0xF0, 0x9E, 0xDE, 0x76, 0x30, 0x2E, 0xDE, 0x77, 0x30, 0x75, 0x40, 0x76,
  0xB6, 0x9E, 0xDA, 0xF8, 0xFC, 0x97, 0x6A, 0xF8, 0xFD, 0x6B, 0x50, 0xF6,
  0xD0, 0x76, 0xB0, 0xF6, 0xF8, 0x76, 0xF2, 0xEA, 0x51, 0xF0, 0x3A, 0x40,
  0xB6, 0xB0, 0xB5, 0x20, 0xBB, 0x75, 0xA9, 0x50, 0xB5, 0x24, 0x00, 0xE9,
  0x70, 0x59, 0x50, 0x78, 0x25, 0xA0, 0x5A,
};

const GFXglyph RobotoCondensed_SemiBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 4, 0, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 2, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 2, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 2, 5, 2, 0, -5 },
  { 29, 3, 5, 4, 0, -5 },
  { 31, 1, 5, 4, 1, -5 },
  { 32, 3, 5, 4, 0, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 3, 5, 4, 0, -5 },
  { 40, 3, 5, 4, 0, -5 },
  { 42, 3, 5, 4, 0, -5 },
  { 44, 3, 5, 4, 0, -5 },
  { 46, 3, 5, 4, 0, -5 },
  { 48, 1, 4, 2, 0, -4 },
  { 49, 1, 5, 2, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 2, 3, 0, -3 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 5, 3, 0, -5 },
  { 57, 5, 7, 5, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 3, 5, 3, 0, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 1, 5, 2, 0, -5 },
  { 85, 3, 5, 3, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 3, 5, 3, 0, -5 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 6, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 3, 5, 4, 0, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 5, 5, 5, 0, -5 },
  { 126, 4, 5, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 3, 5, 4, 0, -5 },
  { 134, 2, 7, 2, 0, -6 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 1, 7, 2, 0, -6 },
  { 139, 3, 3, 3, 0, -5 },
  { 141, 3, 1, 3, 0, 0 },
  { 142, 2, 1, 2, 0, -5 },
  { 143, 3, 4, 3, 0, -4 },
  { 145, 3, 5, 3, 0, -5 },
  { 147, 3, 4, 3, 0, -4 },
  { 149, 3, 5, 3, 0, -5 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 2, 5, 2, 0, -5 },
  { 155, 3, 5, 4, 0, -4 },
  { 157, 3, 5, 3, 0, -5 },
  { 159, 1, 5, 2, 0, -5 },
  { 160, 1, 7, 2, 0, -5 },
  { 161, 3, 5, 3, 0, -5 },
  { 163, 1, 5, 2, 0, -5 },
  { 164, 5, 4, 5, 0, -4 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 3, 5, 3, 0, -4 },
  { 173, 3, 5, 3, 0, -4 },
  { 175, 2, 4, 2, 0, -4 },
  { 176, 3, 4, 3, 0, -4 },
  { 178, 2, 5, 2, 0, -5 },
  { 180, 3, 4, 3, 0, -4 },
  { 182, 3, 4, 3, 0, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 3, 6, 3, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 2, 6, 2, 0, -5 },
  { 195, 1, 6, 2, 0, -5 },
  { 196, 2, 6, 2, 0, -5 },
  { 198, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_SemiBold7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_SEMIBOLD7PT7B_H_
