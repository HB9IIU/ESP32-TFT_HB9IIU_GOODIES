#ifndef _ROBOTOCONDENSED_SEMIBOLD55PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F,
  0xFF, 0x7F, 0x7F, 0x3E, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xEF, 0x87, 0xBE, 0x1E, 0xF8, 0x7B, 0xE1, 0xEF, 0x87,
  0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xCF,
  0xF9, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x01, 0xFD,
  0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x30, 0x0F, 0x87,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC0, 0xF0, 0x7C, 0x1E, 0x03, 0xC1, 0xF0,
  0xF8, 0x0F, 0x07, 0xC3, 0xC0, 0x3C, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x78,
  0x03, 0xE1, 0xF3, 0xE0, 0x0F, 0xFF, 0x8F, 0x00, 0x1F, 0xFE, 0x7C, 0x00,
  0x3F, 0xF1, 0xE0, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0x20, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x20, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x3E, 0x7F, 0xE0, 0x00, 0xF1,
  0xFF, 0xC0, 0x07, 0xCF, 0xFF, 0x80, 0x1E, 0x3E, 0x3E, 0x00, 0xF9, 0xF0,
  0x78, 0x03, 0xC7, 0xC1, 0xF0, 0x1F, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x1F,
  0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x80,
  0xE0, 0x3E, 0x3E, 0x01, 0x80, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x03, 0xE0, 0x7F, 0xFC, 0x1F, 0x07, 0xFF, 0xF1,
  0xF8, 0x7F, 0x3F, 0xCF, 0xC3, 0xF9, 0xFE, 0x7E, 0x1F, 0x87, 0xFB, 0xF1,
  0xFC, 0x1F, 0xFF, 0x8F, 0xE0, 0x7F, 0xFC, 0x7F, 0x03, 0xFF, 0xC3, 0xF8,
  0x0F, 0xFE, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0x80, 0x7F, 0xE1, 0xFE, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x10, 0x01, 0x80, 0x1E, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3C, 0x00, 0xC0, 0x02, 0x20, 0x01, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x10, 0x1F, 0x00, 0x38, 0x3E, 0x0E, 0xFE, 0x7C, 0x7D, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F,
  0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x01, 0x80, 0x70, 0x01, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF,
  0xC7, 0xE7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0xC1, 0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x0F,
  0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x9F, 0x80,
  0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xF1, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF,
  0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7,
  0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x01,
  0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0xFE, 0x07,
  0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xF7, 0xF0,
  0x03, 0xF7, 0xF0, 0x03, 0xE7, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xC7, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0x81,
  0xFE, 0x04, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0x03,
  0xF9, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x1F, 0xBF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFC, 0x3F, 0xCF, 0xF0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF,
  0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0x9F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x83, 0xF8, 0x7F, 0x9F, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC7, 0xFC, 0xFF, 0x1F, 0xC1, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x1F,
  0xE1, 0xFC, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xE7, 0xF8, 0xFF, 0x9F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xF9, 0xFF, 0x1F, 0xC1, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFC, 0x01,
  0xFB, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x07, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFD, 0xF8, 0x3F, 0xE7,
  0xE0, 0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x3F, 0x9F, 0xDF, 0xF7, 0xFB, 0xF8, 0xF8, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0x7F, 0xBF, 0xDF, 0xEF, 0xE3, 0xE0,
  0x40, 0x0F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x0F,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xDF, 0xEF, 0xF0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x3F, 0x00,
  0xF0, 0x7C, 0x03, 0xFF, 0x03, 0xE3, 0xE0, 0x1F, 0xFE, 0x07, 0x8F, 0x80,
  0xFF, 0xFC, 0x1E, 0x3C, 0x07, 0xFB, 0xF0, 0x79, 0xF0, 0x1F, 0x07, 0x81,
  0xF7, 0xC0, 0xFC, 0x1E, 0x07, 0xDF, 0x03, 0xE0, 0xF8, 0x1F, 0x7C, 0x1F,
  0x83, 0xE0, 0x3D, 0xE0, 0x7C, 0x0F, 0x80, 0xF7, 0x81, 0xF0, 0x3E, 0x03,
  0xDE, 0x07, 0xC0, 0xF8, 0x0F, 0xF8, 0x3F, 0x03, 0xE0, 0x7F, 0xE0, 0xFC,
  0x0F, 0x81, 0xFF, 0x83, 0xF0, 0x3E, 0x07, 0xFE, 0x0F, 0xC0, 0xF8, 0x1E,
  0xF8, 0x3E, 0x03, 0xE0, 0x7B, 0xE0, 0xFC, 0x0F, 0x81, 0xE7, 0x83, 0xF0,
  0x7C, 0x0F, 0x9E, 0x0F, 0xC1, 0xF0, 0x3C, 0x78, 0x3F, 0x0F, 0xE0, 0xF1,
  0xF0, 0x7E, 0x7F, 0x87, 0xC7, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0x03, 0xFF,
  0x7F, 0xF0, 0x3C, 0x0F, 0xF9, 0xFF, 0x80, 0xF8, 0x1F, 0xC3, 0xFC, 0x03,
  0xE0, 0x08, 0x01, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x40, 0x00, 0x0F, 0xFE, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x00, 0x01,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFC, 0x07, 0xFD, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03,
  0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0x7F,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x3F,
  0x9F, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x1F, 0xE3, 0xFF, 0xBF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x01,
  0xFE, 0xFF, 0x03, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0x7F, 0x80, 0x1F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x3F, 0x80,
  0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xDF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87,
  0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x3F,
  0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xCF, 0xF0,
  0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x7F, 0x80,
  0x3F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xF0, 0x07,
  0xEF, 0xFF, 0xFF, 0x00, 0xFD, 0xFF, 0xF7, 0xE0, 0x1F, 0x3F, 0xFE, 0xFC,
  0x07, 0xE7, 0xFF, 0xDF, 0xC0, 0xFC, 0xFF, 0xF9, 0xF8, 0x1F, 0xBF, 0xFF,
  0x3F, 0x07, 0xE7, 0xFF, 0xE7, 0xF0, 0xFC, 0xFF, 0xFC, 0x7E, 0x1F, 0x9F,
  0xFF, 0x8F, 0xC7, 0xE3, 0xFF, 0xF1, 0xFC, 0xFC, 0x7F, 0xFE, 0x1F, 0x9F,
  0x8F, 0xFF, 0xC3, 0xF3, 0xF1, 0xFF, 0xF8, 0x7E, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFE, 0x07, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0x01, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0x80,
  0x7E, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xBF, 0x83, 0xFF, 0xF7, 0xF0, 0x7F, 0xFE, 0x7F, 0x0F,
  0xFF, 0xCF, 0xE1, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0x1F, 0xC7, 0xFF, 0xE1,
  0xFC, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0x83, 0xFB, 0xFF, 0xF0, 0x7F, 0x7F,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xFB,
  0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFB,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0x3F,
  0xC7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x04, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F,
  0xC1, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x00,
  0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xCF, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xCF, 0xFE, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0xFF, 0xBF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0x01, 0xFD,
  0xFC, 0x03, 0xF8, 0x03, 0xFB, 0xF8, 0x07, 0xF0, 0x0F, 0xF7, 0xF0, 0x0F,
  0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x1F, 0xC0, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xFF, 0x01, 0xFC, 0x7F, 0x03,
  0xFF, 0x03, 0xF0, 0xFE, 0x07, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xFC, 0x1F,
  0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xFF, 0xE1, 0xF8, 0x1F, 0xC3, 0xEF, 0xC7,
  0xF0, 0x1F, 0x8F, 0xCF, 0x8F, 0xE0, 0x3F, 0x1F, 0x9F, 0x1F, 0xC0, 0x7F,
  0x3F, 0x3F, 0x3F, 0x80, 0xFE, 0x7C, 0x7E, 0x7E, 0x01, 0xFC, 0xF8, 0xFC,
  0xFC, 0x01, 0xFB, 0xF0, 0xF9, 0xF8, 0x03, 0xF7, 0xE1, 0xF7, 0xF0, 0x07,
  0xEF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC7,
  0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0xCF,
  0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03,
  0xF9, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xE3, 0xF9, 0xFE,
  0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F,
  0xEF, 0xE0, 0x3F, 0xBF, 0xC0, 0xFE, 0x7F, 0x0F, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFD, 0xFC, 0x3F, 0xC7, 0xF0, 0x08,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x7F, 0x83, 0xFB, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0x3F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xBF, 0xE3, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0x3F, 0xF8, 0xFC, 0x7F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xFC, 0x7F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01, 0xFB, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0,
  0x1F, 0x9F, 0xC0, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x10, 0x7F, 0x07, 0xF9, 0xFC,
  0x3F, 0xF7, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF,
  0x3F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F,
  0xDF, 0xF9, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xC3,
  0xFF, 0x3F, 0x07, 0xF8, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xF9, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03,
  0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x04, 0x3F, 0xC0, 0x38, 0x3F, 0xE1, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF9, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xBF, 0xC0,
  0xFF, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0xC0, 0xFF, 0x7F,
  0xE7, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xEF, 0xE0, 0xFF, 0x9F, 0xC0, 0x10, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x10, 0x03, 0xF8, 0x38, 0x0F, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x7F, 0x7F,
  0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF8,
  0x00, 0x7C, 0xFE, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xDF, 0xF3, 0xFC, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0xDF, 0xC0, 0xFF, 0x3F, 0x83, 0xFC,
  0x7F, 0x07, 0xF8, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07,
  0xF3, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF, 0x7F, 0x01, 0xFE,
  0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x3F, 0xC3,
  0xFB, 0xFF, 0x1F, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE7, 0xFF, 0x9F, 0xF7, 0xF8, 0x3F,
  0xE0, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8,
  0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF,
  0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0,
  0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F,
  0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC,
  0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x04, 0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFB,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFE, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x01, 0xFE,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x7F, 0xBF, 0xC0, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0x0F, 0xCF, 0xFE,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xBF,
  0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x8F,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFE, 0xFF, 0xC3,
  0xF9, 0xFE, 0x0F, 0xE0, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE3, 0xF0, 0xFF, 0xEF, 0xC7, 0xFF, 0xBF, 0x3F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xF7, 0xFC, 0x7F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x1F,
  0xDF, 0xC0, 0x7F, 0x7F, 0xC7, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0x04, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF9, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFF, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x07,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0x03,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x20, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF3,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xF7, 0xF0,
  0xFF, 0x1F, 0x80, 0x80, 0x00, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xF9, 0xFC,
  0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x3F, 0xFF, 0x01, 0xF0,
  0x1F, 0xDF, 0x81, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0x07, 0xE7, 0xE0, 0x7F,
  0x07, 0xF3, 0xF8, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xE1, 0xFC, 0x7E, 0x1F,
  0xF0, 0xFC, 0x3F, 0x0F, 0xF8, 0x7E, 0x1F, 0x87, 0xFC, 0x3F, 0x0F, 0xE7,
  0xFF, 0x3F, 0x83, 0xF3, 0xEF, 0x9F, 0x81, 0xF9, 0xF7, 0xCF, 0xC0, 0xFC,
  0xFB, 0xE7, 0xE0, 0x7E, 0xFD, 0xFB, 0xF0, 0x3F, 0x7C, 0x7D, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0x8F, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0xFE, 0x07, 0xF8, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xFB,
  0xF8, 0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xFB, 0xF8, 0x0F,
  0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xF3, 0xF8,
  0x0F, 0xEF, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0x7E, 0x1F,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x03, 0x80, 0x7E, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xE0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0x20, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xCF, 0xFE,
  0x03, 0xE7, 0xFF, 0x81, 0xF7, 0xFF, 0xE1, 0xFB, 0xFF, 0xF8, 0xFF, 0xF1,
  0xFF, 0xFD, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFE, 0x7C, 0x07, 0xFF, 0x3E,
  0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 14, 14, 18, 2, -41 },
  { 66, 26, 39, 29, 2, -39 },
  { 193, 22, 52, 28, 3, -46 },
  { 336, 30, 41, 35, 3, -40 },
  { 490, 29, 41, 31, 2, -40 },
  { 639, 5, 14, 9, 2, -41 },
  { 648, 13, 56, 18, 3, -44 },
  { 739, 14, 56, 18, 1, -44 },
  { 837, 23, 24, 25, 1, -39 },
  { 906, 22, 28, 26, 2, -32 },
  { 983, 9, 16, 13, 1, -6 },
  { 1001, 12, 6, 18, 3, -20 },
  { 1010, 8, 8, 16, 4, -7 },
  { 1018, 18, 42, 19, 0, -39 },
  { 1113, 22, 41, 28, 3, -40 },
  { 1226, 15, 39, 28, 4, -39 },
  { 1300, 23, 40, 28, 2, -40 },
  { 1415, 23, 41, 28, 2, -40 },
  { 1533, 24, 39, 28, 2, -39 },
  { 1650, 22, 40, 28, 3, -39 },
  { 1760, 23, 40, 28, 3, -39 },
  { 1875, 23, 39, 28, 2, -39 },
  { 1988, 22, 41, 28, 3, -40 },
  { 2101, 22, 40, 28, 3, -40 },
  { 2211, 9, 30, 15, 3, -29 },
  { 2245, 10, 39, 13, 1, -29 },
  { 2294, 19, 26, 25, 2, -30 },
  { 2356, 20, 17, 27, 4, -26 },
  { 2399, 20, 26, 25, 3, -30 },
  { 2464, 20, 41, 24, 2, -40 },
  { 2567, 38, 50, 42, 2, -38 },
  { 2805, 31, 39, 33, 1, -39 },
  { 2957, 25, 39, 31, 3, -39 },
  { 3079, 26, 41, 31, 3, -40 },
  { 3213, 25, 39, 31, 3, -39 },
  { 3335, 23, 39, 27, 3, -39 },
  { 3448, 22, 39, 26, 3, -39 },
  { 3556, 26, 41, 32, 3, -40 },
  { 3690, 27, 39, 34, 3, -39 },
  { 3822, 7, 39, 15, 4, -39 },
  { 3857, 23, 40, 27, 1, -39 },
  { 3972, 27, 39, 30, 3, -39 },
  { 4104, 22, 39, 26, 3, -39 },
  { 4212, 35, 39, 42, 3, -39 },
  { 4383, 27, 39, 34, 3, -39 },
  { 4515, 27, 41, 33, 3, -40 },
  { 4654, 26, 39, 31, 3, -39 },
  { 4781, 28, 47, 33, 3, -40 },
  { 4946, 26, 39, 30, 3, -39 },
  { 5073, 25, 41, 29, 2, -40 },
  { 5202, 27, 39, 30, 1, -39 },
  { 5334, 25, 40, 31, 3, -39 },
  { 5459, 30, 39, 32, 1, -39 },
  { 5606, 39, 39, 41, 1, -39 },
  { 5797, 29, 39, 31, 1, -39 },
  { 5939, 28, 39, 30, 1, -39 },
  { 6076, 25, 39, 29, 2, -39 },
  { 6198, 10, 54, 14, 3, -45 },
  { 6266, 20, 42, 21, 1, -39 },
  { 6371, 10, 54, 14, 1, -45 },
  { 6439, 19, 20, 21, 1, -39 },
  { 6487, 20, 6, 22, 1, 0 },
  { 6502, 14, 8, 18, 1, -41 },
  { 6516, 22, 31, 26, 2, -30 },
  { 6602, 22, 42, 27, 3, -41 },
  { 6718, 22, 31, 25, 2, -30 },
  { 6804, 22, 42, 27, 2, -41 },
  { 6920, 23, 31, 26, 2, -30 },
  { 7010, 16, 42, 18, 1, -42 },
  { 7094, 23, 41, 28, 2, -30 },
  { 7212, 21, 41, 27, 3, -41 },
  { 7320, 8, 41, 14, 3, -41 },
  { 7361, 11, 52, 13, -1, -41 },
  { 7433, 23, 41, 26, 3, -41 },
  { 7551, 7, 41, 14, 3, -41 },
  { 7587, 35, 30, 41, 3, -30 },
  { 7719, 21, 30, 27, 3, -30 },
  { 7798, 23, 31, 27, 2, -30 },
  { 7888, 22, 41, 27, 3, -30 },
  { 8001, 22, 41, 27, 2, -30 },
  { 8114, 14, 30, 18, 3, -30 },
  { 8167, 21, 31, 25, 2, -30 },
  { 8249, 14, 37, 17, 1, -36 },
  { 8314, 21, 30, 27, 3, -29 },
  { 8393, 23, 29, 24, 1, -29 },
  { 8477, 33, 29, 35, 1, -29 },
  { 8597, 23, 29, 25, 1, -29 },
  { 8681, 23, 40, 24, 1, -29 },
  { 8796, 21, 29, 25, 2, -29 },
  { 8873, 13, 53, 17, 2, -43 },
  { 8960, 4, 46, 14, 5, -39 },
  { 8983, 14, 53, 17, 1, -43 },
  { 9076, 25, 12, 31, 3, -22 },
};

const GFXfont RobotoCondensed_SemiBold55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_SEMIBOLD55PT7B_H_
