#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoCondensed_SemiBold
// Headers: 67

#include "RobotoCondensed_SemiBold6pt7b.h"
#include "RobotoCondensed_SemiBold7pt7b.h"
#include "RobotoCondensed_SemiBold8pt7b.h"
#include "RobotoCondensed_SemiBold9pt7b.h"
#include "RobotoCondensed_SemiBold10pt7b.h"
#include "RobotoCondensed_SemiBold11pt7b.h"
#include "RobotoCondensed_SemiBold12pt7b.h"
#include "RobotoCondensed_SemiBold13pt7b.h"
#include "RobotoCondensed_SemiBold14pt7b.h"
#include "RobotoCondensed_SemiBold15pt7b.h"
#include "RobotoCondensed_SemiBold16pt7b.h"
#include "RobotoCondensed_SemiBold17pt7b.h"
#include "RobotoCondensed_SemiBold18pt7b.h"
#include "RobotoCondensed_SemiBold19pt7b.h"
#include "RobotoCondensed_SemiBold20pt7b.h"
#include "RobotoCondensed_SemiBold21pt7b.h"
#include "RobotoCondensed_SemiBold22pt7b.h"
#include "RobotoCondensed_SemiBold23pt7b.h"
#include "RobotoCondensed_SemiBold24pt7b.h"
#include "RobotoCondensed_SemiBold25pt7b.h"
#include "RobotoCondensed_SemiBold26pt7b.h"
#include "RobotoCondensed_SemiBold27pt7b.h"
#include "RobotoCondensed_SemiBold28pt7b.h"
#include "RobotoCondensed_SemiBold29pt7b.h"
#include "RobotoCondensed_SemiBold30pt7b.h"
#include "RobotoCondensed_SemiBold31pt7b.h"
#include "RobotoCondensed_SemiBold32pt7b.h"
#include "RobotoCondensed_SemiBold33pt7b.h"
#include "RobotoCondensed_SemiBold34pt7b.h"
#include "RobotoCondensed_SemiBold35pt7b.h"
#include "RobotoCondensed_SemiBold36pt7b.h"
#include "RobotoCondensed_SemiBold37pt7b.h"
#include "RobotoCondensed_SemiBold38pt7b.h"
#include "RobotoCondensed_SemiBold39pt7b.h"
#include "RobotoCondensed_SemiBold40pt7b.h"
#include "RobotoCondensed_SemiBold41pt7b.h"
#include "RobotoCondensed_SemiBold42pt7b.h"
#include "RobotoCondensed_SemiBold43pt7b.h"
#include "RobotoCondensed_SemiBold44pt7b.h"
#include "RobotoCondensed_SemiBold45pt7b.h"
#include "RobotoCondensed_SemiBold46pt7b.h"
#include "RobotoCondensed_SemiBold47pt7b.h"
#include "RobotoCondensed_SemiBold48pt7b.h"
#include "RobotoCondensed_SemiBold49pt7b.h"
#include "RobotoCondensed_SemiBold50pt7b.h"
#include "RobotoCondensed_SemiBold51pt7b.h"
#include "RobotoCondensed_SemiBold52pt7b.h"
#include "RobotoCondensed_SemiBold53pt7b.h"
#include "RobotoCondensed_SemiBold54pt7b.h"
#include "RobotoCondensed_SemiBold55pt7b.h"
#include "RobotoCondensed_SemiBold56pt7b.h"
#include "RobotoCondensed_SemiBold57pt7b.h"
#include "RobotoCondensed_SemiBold58pt7b.h"
#include "RobotoCondensed_SemiBold59pt7b.h"
#include "RobotoCondensed_SemiBold60pt7b.h"
#include "RobotoCondensed_SemiBold61pt7b.h"
#include "RobotoCondensed_SemiBold62pt7b.h"
#include "RobotoCondensed_SemiBold63pt7b.h"
#include "RobotoCondensed_SemiBold64pt7b.h"
#include "RobotoCondensed_SemiBold65pt7b.h"
#include "RobotoCondensed_SemiBold66pt7b.h"
#include "RobotoCondensed_SemiBold67pt7b.h"
#include "RobotoCondensed_SemiBold68pt7b.h"
#include "RobotoCondensed_SemiBold69pt7b.h"
#include "RobotoCondensed_SemiBold70pt7b.h"
#include "RobotoCondensed_SemiBold71pt7b.h"
#include "RobotoCondensed_SemiBold72pt7b.h"
