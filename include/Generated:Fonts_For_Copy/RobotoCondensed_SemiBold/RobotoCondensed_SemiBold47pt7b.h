#ifndef _ROBOTOCONDENSED_SEMIBOLD47PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0xFF, 0x78, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xC3, 0xC1, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x3F, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0x0F, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0xF0, 0x30, 0x3C, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE3, 0xC0, 0xF0, 0x78, 0xE0, 0x3C,
  0x1E, 0x78, 0x0F, 0x0F, 0x1C, 0x01, 0xE3, 0xCF, 0x00, 0x7F, 0xF7, 0x80,
  0x0F, 0xF9, 0xE0, 0x03, 0xFC, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x1F, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0xE7, 0xFE, 0x00,
  0x7B, 0xFF, 0x80, 0x3C, 0xF1, 0xF0, 0x0F, 0x3C, 0x3C, 0x07, 0x8F, 0x0F,
  0x01, 0xE3, 0x83, 0xC0, 0xF0, 0xE0, 0xF0, 0x3C, 0x3C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x07, 0x03, 0xC7, 0xC0, 0x40, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7C, 0x1F, 0xF8, 0x7C,
  0x3F, 0xFC, 0x7C, 0x7E, 0xFC, 0x7C, 0x7C, 0x7E, 0x7C, 0xFC, 0x7F, 0xFC,
  0xFC, 0x3F, 0xFC, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFE, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x18, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x30, 0x02, 0x40, 0x06, 0x00,
  0x70, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x00, 0x60, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0x00,
  0xF0, 0xF1, 0xEF, 0xEF, 0x7E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x0F, 0xFF,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x0F, 0xBE, 0x01, 0xF1,
  0xF0, 0x1E, 0x1F, 0x03, 0xE0, 0xF8, 0x1C, 0x07, 0x00, 0x40, 0x40, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0xF9, 0xF7, 0xCF, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x30, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD,
  0xF8, 0x3F, 0x1F, 0x87, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0xFE, 0x0F,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC, 0x3F, 0xBF, 0x83, 0xF7, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xBF, 0x8F,
  0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7B, 0xF0, 0x07, 0xDF, 0x80, 0x7C, 0xFC, 0x03,
  0xE7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3E, 0x0F, 0xE0, 0x40,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0,
  0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x7F, 0x3F, 0x07,
  0xE7, 0xE0, 0x7E, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x87, 0xF7, 0xFF, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xFE, 0x3F, 0x9F, 0x83,
  0xF3, 0xF0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF0, 0x7F, 0x7F, 0x0F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0x7E, 0x0F, 0xCF,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0x80, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x87, 0xDF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x0C, 0x1F, 0x8F, 0xC7, 0xF3, 0xF1, 0xF8, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF0, 0xF8, 0x78, 0x08, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0x38, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xF7, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x1C, 0x3E, 0x01, 0xF0, 0x1E, 0x3C, 0x07, 0xFC, 0x1E,
  0x3C, 0x0F, 0xFE, 0x0E, 0x78, 0x1F, 0xFE, 0x0F, 0x78, 0x1F, 0x1E, 0x0F,
  0x78, 0x3E, 0x1E, 0x0F, 0x78, 0x3C, 0x1E, 0x0F, 0xF8, 0x7C, 0x1E, 0x0F,
  0xF0, 0x7C, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F,
  0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0F,
  0xF0, 0xF8, 0x3C, 0x0F, 0xF0, 0xF8, 0x3C, 0x0E, 0xF0, 0xF8, 0x3C, 0x1E,
  0xF0, 0x78, 0x7C, 0x1E, 0xF8, 0x7C, 0x7E, 0x3C, 0x78, 0x7F, 0xFF, 0x7C,
  0x78, 0x3F, 0xDF, 0xF8, 0x78, 0x3F, 0x8F, 0xF0, 0x7C, 0x0F, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x0C, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xF8,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x07, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0xFD, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0x7F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0xFC, 0x03,
  0xF1, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x0F, 0xF3, 0xF0, 0x1F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x7F,
  0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xFE, 0x01,
  0xF9, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFD, 0xF8, 0x3F, 0xBF, 0x8F,
  0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x3F,
  0x8F, 0xC0, 0xFF, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFC, 0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xE7, 0xF0, 0x0F,
  0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xF7,
  0xF0, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0xFC, 0x01, 0xFE,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0xC0, 0xFB, 0xFF, 0xDF, 0x03, 0xEF, 0xFF,
  0x7C, 0x1F, 0x3F, 0xFD, 0xF8, 0x7C, 0xFF, 0xF3, 0xE1, 0xF3, 0xFF, 0xCF,
  0x8F, 0x8F, 0xFF, 0x3F, 0x3E, 0x3F, 0xFC, 0x7C, 0xF8, 0xFF, 0xF1, 0xF7,
  0xE3, 0xFF, 0xC7, 0xDF, 0x0F, 0xFF, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x3F,
  0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0xFC, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF,
  0x7E, 0x1F, 0xFE, 0x7E, 0x3F, 0xFC, 0xFC, 0x7F, 0xF8, 0xFC, 0xFF, 0xF0,
  0xF9, 0xFF, 0xE1, 0xFB, 0xFF, 0xC1, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x3F, 0x00, 0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0,
  0x1F, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF,
  0xC0, 0x3F, 0xBF, 0x01, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x3F, 0x00,
  0xFE, 0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x08, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFE, 0xFC,
  0x03, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03,
  0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x03, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFF, 0x0F, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xE7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xDF, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0x03, 0xF7, 0xE0, 0x7F, 0x01, 0xFB, 0xF0, 0x3F, 0x81, 0xF9, 0xF8, 0x1F,
  0xE0, 0xFC, 0x7C, 0x0F, 0xF0, 0x7E, 0x3F, 0x07, 0xF8, 0x3F, 0x1F, 0x87,
  0xFC, 0x1F, 0x8F, 0xC3, 0xFE, 0x0F, 0x87, 0xE1, 0xFF, 0x8F, 0xC1, 0xF0,
  0xFF, 0xC7, 0xE0, 0xF8, 0x7B, 0xE3, 0xF0, 0x7E, 0x7D, 0xF1, 0xF8, 0x3F,
  0x3E, 0x78, 0xF8, 0x1F, 0x9F, 0x3E, 0x7C, 0x0F, 0xCF, 0x9F, 0x7E, 0x03,
  0xE7, 0x8F, 0xBF, 0x01, 0xF7, 0xC7, 0xDF, 0x80, 0xFF, 0xE1, 0xEF, 0xC0,
  0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xF7, 0xE0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xF7, 0xE0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F,
  0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x3E, 0x3C, 0x3C,
  0x3C, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFC, 0x3F, 0x3F, 0x03,
  0xF7, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF1, 0xFF, 0x7E, 0x0F, 0xCF, 0xC0, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x7D, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xF0, 0xFE, 0xFC, 0x0F,
  0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0x7C, 0x07, 0xEF, 0xC0, 0xFD, 0xFC, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0x7F, 0xC3, 0xE3, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0xFD, 0xF8, 0x7F, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x1F, 0x8F, 0xFB, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0xFE, 0xFC, 0x3F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3,
  0xFE, 0xFC, 0x1F, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x81, 0xF7, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x06, 0x3F, 0x81, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0xE3, 0xFE, 0x7C,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0xBF, 0x87, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xBF, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF1, 0x00, 0xFE, 0x38, 0x1F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x7E, 0xFF, 0x8F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0xFE, 0xFE, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0xFB, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x83, 0xF1,
  0xFC, 0x7F, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFB, 0xFE, 0xFF,
  0xBF, 0xCF, 0xE3, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0x7C, 0x1F, 0xCF, 0x83, 0xF9, 0xF0,
  0xFE, 0x3E, 0x3F, 0x87, 0xC7, 0xE0, 0xF9, 0xFC, 0x1F, 0x3F, 0x03, 0xEF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xDF, 0x83, 0xF3, 0xF0, 0x7C, 0x3F, 0x0F, 0x87,
  0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F, 0xDF, 0x01,
  0xFB, 0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xFC, 0x0F, 0x87, 0xDF,
  0xF1, 0xFF, 0x3F, 0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xF1, 0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0x03, 0xF8, 0x3F,
  0xF8, 0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x03, 0xE0, 0x7F, 0xF0,
  0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x1F, 0xFC, 0x07, 0xC0, 0xFF, 0xE0, 0x3E,
  0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0x81, 0xFF, 0xC0, 0x7C, 0x0F,
  0xFE, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x1F, 0xFC,
  0x07, 0xC0, 0xFF, 0xE0, 0x3E, 0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xF8, 0x0F,
  0x81, 0xF8, 0xFC, 0x7E, 0x1F, 0x9F, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFE, 0x3F, 0xBF, 0x83, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7E,
  0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0xFC, 0x1F, 0x7F, 0xC3, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFC, 0x3F, 0xBF, 0x03, 0xF7, 0xC0, 0x7E,
  0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB,
  0xF0, 0x3F, 0x7F, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7,
  0xDF, 0xF0, 0xF8, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0xE3, 0xFE, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xBF, 0x07, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xBF, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x3E, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xBE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xF0,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF8, 0x3F, 0xBF, 0x0F, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xBF, 0x0F, 0xC7, 0xE0,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xFB, 0xF0, 0x3F, 0x7C, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x0F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC, 0x1F, 0x83, 0xF7, 0xC1,
  0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xE3, 0xF8, 0x7E, 0x7E, 0x3F, 0xC7,
  0xE7, 0xE3, 0xFC, 0x7C, 0x3E, 0x3F, 0xC7, 0xC3, 0xE7, 0xFC, 0x7C, 0x3E,
  0x7F, 0xEF, 0xC3, 0xF7, 0xFE, 0xFC, 0x1F, 0x79, 0xEF, 0x81, 0xFF, 0x9E,
  0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF, 0x9F, 0xF8, 0x1F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0xFE, 0x07, 0xEF, 0xC1, 0xF9, 0xFC, 0x3F, 0x1F,
  0x8F, 0xC3, 0xF9, 0xF8, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x9F, 0x83, 0xF3, 0xF0,
  0x7F, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xE7,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC,
  0x1F, 0x8F, 0xC1, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF8, 0x0F, 0xDF,
  0x80, 0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x20, 0x0E, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0E, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x07, 0x00, 0xFC, 0x0F, 0xC0,
  0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x07, 0x00,
  0x60, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0xF3, 0xFF, 0x03, 0xCF, 0xFE,
  0x1F, 0x7F, 0xFC, 0xFD, 0xF1, 0xFF, 0xE7, 0x83, 0xFF, 0xBE, 0x07, 0xFC,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 33, 12, 3, -33 },
  { 26, 11, 12, 15, 2, -35 },
  { 43, 22, 33, 25, 2, -33 },
  { 134, 19, 42, 24, 2, -38 },
  { 234, 26, 33, 30, 2, -33 },
  { 342, 24, 33, 27, 2, -33 },
  { 441, 4, 12, 8, 2, -35 },
  { 447, 11, 48, 15, 3, -37 },
  { 513, 12, 48, 15, 1, -37 },
  { 585, 20, 20, 21, 1, -33 },
  { 635, 19, 25, 23, 2, -28 },
  { 695, 7, 14, 11, 1, -6 },
  { 708, 11, 5, 16, 2, -17 },
  { 715, 7, 7, 13, 3, -7 },
  { 722, 15, 36, 16, 0, -33 },
  { 790, 19, 33, 24, 2, -33 },
  { 869, 12, 33, 24, 4, -33 },
  { 919, 20, 33, 24, 2, -33 },
  { 1002, 19, 33, 24, 2, -33 },
  { 1081, 21, 33, 24, 1, -33 },
  { 1168, 20, 33, 24, 2, -33 },
  { 1251, 20, 33, 24, 2, -33 },
  { 1334, 20, 33, 24, 2, -33 },
  { 1417, 19, 33, 24, 2, -33 },
  { 1496, 19, 33, 24, 2, -33 },
  { 1575, 7, 26, 12, 3, -26 },
  { 1598, 9, 34, 11, 1, -26 },
  { 1637, 17, 22, 21, 1, -25 },
  { 1684, 17, 14, 23, 3, -22 },
  { 1714, 17, 22, 21, 3, -25 },
  { 1761, 18, 33, 21, 1, -33 },
  { 1836, 32, 43, 36, 2, -33 },
  { 2008, 26, 33, 28, 1, -33 },
  { 2116, 21, 33, 26, 3, -33 },
  { 2203, 23, 33, 27, 2, -33 },
  { 2298, 21, 33, 27, 3, -33 },
  { 2385, 19, 33, 23, 3, -33 },
  { 2464, 18, 33, 22, 3, -33 },
  { 2539, 23, 33, 28, 2, -33 },
  { 2634, 23, 33, 29, 3, -33 },
  { 2729, 6, 33, 12, 3, -33 },
  { 2754, 19, 33, 23, 1, -33 },
  { 2833, 23, 33, 26, 3, -33 },
  { 2928, 18, 33, 22, 3, -33 },
  { 3003, 30, 33, 36, 3, -33 },
  { 3127, 23, 33, 29, 3, -33 },
  { 3222, 24, 33, 28, 2, -33 },
  { 3321, 22, 33, 27, 3, -33 },
  { 3412, 24, 39, 28, 2, -33 },
  { 3529, 22, 33, 26, 3, -33 },
  { 3620, 21, 33, 25, 2, -33 },
  { 3707, 23, 33, 25, 1, -33 },
  { 3802, 21, 33, 27, 3, -33 },
  { 3889, 25, 33, 27, 1, -33 },
  { 3993, 33, 33, 35, 1, -33 },
  { 4130, 24, 33, 26, 1, -33 },
  { 4229, 25, 33, 25, 0, -33 },
  { 4333, 21, 33, 25, 2, -33 },
  { 4420, 8, 47, 12, 3, -39 },
  { 4467, 18, 36, 18, 0, -33 },
  { 4548, 8, 47, 12, 1, -39 },
  { 4595, 16, 17, 18, 1, -33 },
  { 4629, 18, 5, 19, 0, 0 },
  { 4641, 12, 7, 15, 1, -35 },
  { 4652, 19, 25, 22, 2, -25 },
  { 4712, 19, 35, 23, 3, -35 },
  { 4796, 18, 25, 22, 2, -25 },
  { 4853, 19, 35, 23, 2, -35 },
  { 4937, 19, 25, 22, 2, -25 },
  { 4997, 14, 35, 15, 1, -35 },
  { 5059, 19, 35, 24, 2, -25 },
  { 5143, 19, 35, 23, 2, -35 },
  { 5227, 6, 34, 12, 3, -34 },
  { 5253, 10, 44, 11, -1, -34 },
  { 5308, 19, 35, 22, 3, -35 },
  { 5392, 6, 35, 12, 3, -35 },
  { 5419, 29, 25, 35, 3, -25 },
  { 5510, 19, 25, 23, 2, -25 },
  { 5570, 20, 25, 23, 2, -25 },
  { 5633, 19, 35, 23, 3, -25 },
  { 5717, 19, 35, 23, 2, -25 },
  { 5801, 11, 25, 15, 3, -25 },
  { 5836, 18, 25, 21, 2, -25 },
  { 5893, 12, 31, 14, 1, -31 },
  { 5940, 19, 25, 23, 2, -25 },
  { 6000, 19, 25, 21, 1, -25 },
  { 6060, 28, 25, 30, 1, -25 },
  { 6148, 19, 25, 21, 1, -25 },
  { 6208, 20, 35, 21, 0, -25 },
  { 6296, 17, 25, 21, 2, -25 },
  { 6350, 12, 45, 14, 1, -37 },
  { 6418, 4, 39, 12, 4, -33 },
  { 6438, 12, 45, 14, 1, -37 },
  { 6506, 22, 10, 27, 2, -19 },
};

const GFXfont RobotoCondensed_SemiBold47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_SEMIBOLD47PT7B_H_
