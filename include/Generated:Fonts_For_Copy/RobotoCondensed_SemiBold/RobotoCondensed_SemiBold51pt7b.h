#ifndef _ROBOTOCONDENSED_SEMIBOLD51PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x9F, 0xFF, 0xFF, 0xFD, 0xF9, 0xE0, 0xF8, 0xFF, 0x8F,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF8, 0x00,
  0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xE1, 0xE0, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01,
  0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07,
  0x87, 0x80, 0x07, 0x8F, 0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF0, 0x3F, 0x9F, 0x81, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0,
  0xFE, 0x7F, 0x9F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x78, 0x08, 0x07,
  0x87, 0xC1, 0xE0, 0x78, 0x7C, 0x1E, 0x0F, 0x83, 0xC3, 0xC0, 0xF8, 0x3C,
  0x3C, 0x0F, 0x83, 0xC7, 0x80, 0x78, 0x7C, 0xF8, 0x07, 0x87, 0xCF, 0x00,
  0x7C, 0x79, 0xF0, 0x07, 0xFF, 0x9E, 0x00, 0x3F, 0xF3, 0xC0, 0x01, 0xFE,
  0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x7F, 0xC0, 0x03, 0xEF, 0xFE, 0x00,
  0x3C, 0xFF, 0xE0, 0x07, 0x9F, 0x1F, 0x00, 0x79, 0xF0, 0xF0, 0x0F, 0x1E,
  0x0F, 0x00, 0xF1, 0xE0, 0xF0, 0x1E, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0xF0,
  0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x38, 0x1F, 0x1F, 0x00, 0x80,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC1, 0xF0, 0x7F, 0xF0, 0x7C, 0x3F, 0xFE, 0x1F, 0x1F, 0xDF, 0xC7, 0xC7,
  0xE7, 0xFB, 0xF3, 0xF8, 0xFE, 0xFC, 0xFE, 0x1F, 0xFF, 0x3F, 0x07, 0xFF,
  0x8F, 0xC0, 0xFF, 0xE3, 0xF8, 0x1F, 0xF8, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0xFF, 0x07, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFB, 0xF8, 0x1F, 0xF8, 0x7F, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x00, 0x00, 0x20,
  0x06, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x06, 0x00, 0x20, 0x40, 0x03, 0x80, 0x1E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0x78, 0x03, 0x80,
  0x10, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0x81, 0xE0, 0x5F, 0x8F, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0xFC,
  0x7C, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x80, 0xE0, 0x38, 0x00, 0x00, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0xFC, 0x78, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xE7, 0xF0,
  0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xDF, 0x80,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xE7, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFF, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E,
  0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0x7F, 0xC7, 0xF0,
  0x7F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F,
  0xBF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xCF,
  0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xF9, 0xFE, 0x3F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFB, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0x3F, 0x80, 0xFC,
  0xFE, 0x03, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7C, 0x3F, 0x83, 0xF0, 0xFE,
  0x0F, 0x83, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x7C, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF1, 0xFE, 0x1C, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x7F, 0x9F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x7E, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE7, 0xFC, 0xFF, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x3F,
  0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFD, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0x83, 0xF8,
  0xFF, 0x7F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xF9, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE,
  0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xF0, 0xFE, 0x7F, 0x9F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xEF,
  0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFE, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xBF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xE3, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xEF, 0xC0, 0x7E, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E,
  0x3E, 0x3F, 0x1F, 0x0F, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xFF, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x7E, 0x01,
  0xE3, 0xE0, 0x1F, 0xF0, 0x3C, 0x78, 0x07, 0xFF, 0x07, 0x8F, 0x01, 0xFF,
  0xE0, 0xF3, 0xE0, 0x7E, 0x3C, 0x0F, 0x7C, 0x0F, 0x87, 0x81, 0xEF, 0x03,
  0xE0, 0xF0, 0x3D, 0xE0, 0x78, 0x1E, 0x07, 0xBC, 0x1F, 0x03, 0xC0, 0xFF,
  0x83, 0xE0, 0xF8, 0x1F, 0xF0, 0x7C, 0x1F, 0x03, 0xFE, 0x0F, 0x03, 0xE0,
  0x7F, 0xC3, 0xE0, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0x81, 0xFF, 0x0F, 0x81,
  0xF0, 0x3F, 0xE1, 0xF0, 0x3E, 0x0F, 0x7C, 0x3E, 0x07, 0x81, 0xEF, 0x87,
  0xC1, 0xF0, 0x3D, 0xF0, 0xFC, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0xE1, 0xE3,
  0xC1, 0xFF, 0xFC, 0x78, 0x7C, 0x1F, 0xF7, 0xFF, 0x0F, 0x83, 0xFE, 0xFF,
  0xC0, 0xF0, 0x3F, 0x0F, 0xF0, 0x1F, 0x00, 0x80, 0x20, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x00, 0x7F, 0x80, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0x80,
  0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03,
  0xF7, 0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0xFE,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x03, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x7F, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x80,
  0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0,
  0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xF8,
  0x0F, 0xFF, 0xFD, 0xF8, 0x0F, 0xBF, 0xFD, 0xF8, 0x1F, 0xBF, 0xFC, 0xFC,
  0x1F, 0xBF, 0xFC, 0xFC, 0x1F, 0x3F, 0xFC, 0xFC, 0x1F, 0x3F, 0xFC, 0x7C,
  0x3F, 0x3F, 0xFE, 0x7E, 0x3E, 0x3F, 0xFE, 0x7E, 0x3E, 0x3F, 0xFE, 0x3E,
  0x7E, 0x3F, 0xFE, 0x3F, 0x7E, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x0F,
  0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x07,
  0xE0, 0x3F, 0xFE, 0x03, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFB, 0xF0, 0x7F, 0xFD, 0xF8, 0x3F, 0xFE, 0x7E, 0x1F, 0xFF,
  0x3F, 0x0F, 0xFF, 0x8F, 0xC7, 0xFF, 0xC7, 0xE3, 0xFF, 0xE1, 0xF9, 0xFF,
  0xF0, 0xFE, 0xFF, 0xF8, 0x3F, 0x7F, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3,
  0xFC, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xE7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xFD, 0xFF, 0x9F, 0xE0, 0x7F, 0x3F, 0x80, 0x7F, 0x7E, 0x00, 0xFE, 0xFC,
  0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0, 0x3F, 0xDF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F,
  0xDF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x7F, 0x7E, 0x01, 0xFC,
  0x07, 0xF7, 0xE0, 0x1F, 0xC0, 0x7F, 0x7F, 0x01, 0xFC, 0x07, 0xE7, 0xF0,
  0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0xE0, 0xFE,
  0x3F, 0x03, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0xE0, 0xFE, 0x3F, 0x87, 0xFE,
  0x0F, 0xC3, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0x87, 0xFF, 0x0F, 0xC1, 0xF8,
  0x7F, 0xF0, 0xFC, 0x1F, 0x87, 0xDF, 0x1F, 0xC1, 0xF8, 0xFD, 0xF1, 0xF8,
  0x1F, 0xCF, 0xDF, 0x1F, 0x80, 0xFC, 0xF9, 0xF9, 0xF8, 0x0F, 0xCF, 0x9F,
  0x9F, 0x80, 0xFC, 0xF8, 0xF9, 0xF8, 0x0F, 0xDF, 0x8F, 0xBF, 0x00, 0xFD,
  0xF8, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x0F,
  0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF1, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0xFF,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07,
  0xF3, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0x7C, 0x0F, 0x9E, 0x07, 0xCF, 0x83, 0xC7, 0xC3, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xF8, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07,
  0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xF1, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0xFD, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0xBF, 0xEF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFD, 0xFF, 0x8F, 0xC7, 0xE0, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFC, 0xFE, 0x7E,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E, 0x07,
  0xE7, 0xFD, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x3F, 0x0F, 0xFB,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xDF, 0xF7, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0, 0x7F,
  0x7F, 0xDF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF9,
  0xF0, 0x3E, 0x1F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xE7, 0xF1, 0xFC, 0x1F, 0xCF, 0xC0, 0x7E,
  0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x87, 0xF0, 0x0E, 0x3F, 0xF1,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xEF, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xBF,
  0xEF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xDF,
  0xC0, 0xFC, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x60,
  0x1F, 0xC3, 0xE3, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x3F, 0x0F, 0xDF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xBF, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xC0, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x07, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x07,
  0x81, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFA, 0xFF, 0x7F, 0xEF,
  0xF9, 0xFF, 0x3F, 0xC7, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x1F,
  0xEF, 0xC0, 0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0xFF, 0x1F, 0x87, 0xF0, 0xFC,
  0x7F, 0x07, 0xE7, 0xF8, 0x3F, 0x3F, 0x81, 0xFB, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x83,
  0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0xFF, 0x3F, 0x03,
  0xF9, 0xF8, 0x1F, 0xEF, 0xC0, 0x7F, 0x7E, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x7E, 0x03, 0xF0, 0xFD, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF,
  0x9F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF,
  0xFD, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x7E, 0x1F, 0x9F, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xEF, 0xF9, 0xFC,
  0x1F, 0xCF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFC, 0x07, 0xF7,
  0xF0, 0x3F, 0x3F, 0xEF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x7E, 0x0F, 0xDF, 0xF8, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0xFE, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF1,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xDF, 0xF8, 0xFC,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFC, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xBF, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFE, 0x3F, 0xDF, 0x83,
  0xFF, 0xF0, 0x3F, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F,
  0xDF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFE,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFE, 0xFC, 0x3F,
  0x00, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x80, 0xFC, 0xFC, 0x0F,
  0xE7, 0xE0, 0x7F, 0x3F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xF8,
  0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x07, 0xC0, 0xFD, 0xF8, 0x0F, 0x81, 0xFB, 0xF8, 0x3F, 0x03,
  0xF3, 0xF0, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x1F, 0xCF, 0xC1, 0xFC, 0x3F,
  0x1F, 0x87, 0xF8, 0x7E, 0x1F, 0x0F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF1, 0xF8,
  0x7E, 0x3F, 0xE3, 0xE0, 0xFC, 0xFF, 0xCF, 0xC1, 0xF9, 0xFF, 0x9F, 0x81,
  0xF3, 0xEF, 0xBF, 0x03, 0xF7, 0x9F, 0x7E, 0x07, 0xFF, 0x3E, 0xF8, 0x0F,
  0xFE, 0x7D, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xFE, 0x03,
  0xFB, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F,
  0xE7, 0xE0, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xBF, 0x01, 0xFD, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F, 0x87, 0xE0,
  0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xBF, 0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x83,
  0xF1, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x03, 0x80, 0x7E, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC3, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x0E, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x60, 0x03, 0xC0, 0x1F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xC0, 0x7C, 0xFF, 0xC0, 0xFB, 0xFF, 0xC1, 0xF7, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x7C, 0x1F, 0xFE, 0xF8, 0x1F,
  0xF9, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_SemiBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 36, 13, 3, -36 },
  { 33, 12, 13, 16, 2, -38 },
  { 53, 24, 36, 27, 2, -36 },
  { 161, 21, 46, 26, 2, -41 },
  { 282, 28, 36, 33, 2, -36 },
  { 408, 26, 37, 29, 2, -36 },
  { 529, 5, 13, 8, 2, -38 },
  { 538, 12, 51, 16, 3, -40 },
  { 615, 13, 51, 16, 1, -40 },
  { 698, 21, 22, 23, 1, -36 },
  { 756, 21, 26, 25, 2, -30 },
  { 825, 8, 15, 12, 1, -6 },
  { 840, 11, 5, 17, 3, -18 },
  { 847, 8, 7, 15, 3, -7 },
  { 854, 16, 39, 17, 0, -36 },
  { 932, 21, 36, 26, 2, -36 },
  { 1027, 13, 36, 26, 4, -36 },
  { 1086, 22, 36, 26, 2, -36 },
  { 1185, 21, 36, 26, 2, -36 },
  { 1280, 22, 36, 26, 2, -36 },
  { 1379, 20, 36, 26, 3, -36 },
  { 1469, 21, 36, 26, 3, -36 },
  { 1564, 21, 36, 26, 2, -36 },
  { 1659, 20, 36, 26, 3, -36 },
  { 1749, 21, 36, 26, 2, -36 },
  { 1844, 8, 28, 13, 3, -28 },
  { 1872, 9, 37, 12, 1, -28 },
  { 1914, 18, 23, 23, 2, -27 },
  { 1966, 19, 15, 25, 3, -24 },
  { 2002, 18, 23, 23, 3, -27 },
  { 2054, 20, 36, 23, 1, -36 },
  { 2144, 35, 46, 39, 2, -35 },
  { 2346, 29, 36, 30, 1, -36 },
  { 2477, 23, 36, 28, 3, -36 },
  { 2581, 25, 36, 29, 2, -36 },
  { 2694, 23, 36, 29, 3, -36 },
  { 2798, 21, 36, 25, 3, -36 },
  { 2893, 20, 36, 24, 3, -36 },
  { 2983, 24, 36, 30, 3, -36 },
  { 3091, 25, 36, 31, 3, -36 },
  { 3204, 7, 36, 14, 3, -36 },
  { 3236, 21, 36, 25, 1, -36 },
  { 3331, 25, 36, 28, 3, -36 },
  { 3444, 20, 36, 24, 3, -36 },
  { 3534, 32, 36, 39, 3, -36 },
  { 3678, 25, 36, 31, 3, -36 },
  { 3791, 25, 36, 31, 3, -36 },
  { 3904, 24, 36, 29, 3, -36 },
  { 4012, 26, 42, 31, 2, -36 },
  { 4149, 24, 36, 28, 3, -36 },
  { 4257, 23, 36, 27, 2, -36 },
  { 4361, 25, 36, 27, 1, -36 },
  { 4474, 23, 36, 29, 3, -36 },
  { 4578, 28, 36, 29, 1, -36 },
  { 4704, 36, 36, 38, 1, -36 },
  { 4866, 26, 36, 28, 1, -36 },
  { 4983, 27, 36, 27, 0, -36 },
  { 5105, 23, 36, 27, 2, -36 },
  { 5209, 9, 50, 13, 3, -42 },
  { 5266, 20, 39, 19, 0, -36 },
  { 5364, 9, 50, 13, 1, -42 },
  { 5421, 17, 18, 20, 1, -36 },
  { 5460, 19, 5, 20, 1, 0 },
  { 5472, 13, 8, 17, 1, -39 },
  { 5485, 20, 27, 24, 2, -27 },
  { 5553, 20, 38, 25, 3, -38 },
  { 5648, 20, 27, 23, 2, -27 },
  { 5716, 20, 38, 25, 2, -38 },
  { 5811, 21, 27, 24, 2, -27 },
  { 5882, 15, 39, 17, 1, -39 },
  { 5956, 21, 37, 26, 2, -27 },
  { 6054, 19, 38, 25, 3, -38 },
  { 6145, 7, 38, 13, 3, -38 },
  { 6179, 11, 48, 12, -1, -38 },
  { 6245, 21, 38, 24, 3, -38 },
  { 6345, 6, 38, 13, 3, -38 },
  { 6374, 32, 27, 38, 3, -27 },
  { 6482, 19, 27, 25, 3, -27 },
  { 6547, 21, 27, 25, 2, -27 },
  { 6618, 20, 37, 25, 3, -27 },
  { 6711, 20, 37, 25, 2, -27 },
  { 6804, 13, 27, 17, 3, -27 },
  { 6848, 19, 27, 23, 2, -27 },
  { 6913, 13, 34, 16, 1, -34 },
  { 6969, 19, 27, 25, 3, -27 },
  { 7034, 21, 27, 23, 1, -27 },
  { 7105, 31, 27, 33, 1, -27 },
  { 7210, 21, 27, 23, 1, -27 },
  { 7281, 21, 37, 22, 1, -27 },
  { 7379, 19, 27, 23, 2, -27 },
  { 7444, 13, 49, 15, 1, -40 },
  { 7524, 5, 43, 13, 4, -36 },
  { 7551, 13, 49, 15, 1, -40 },
  { 7631, 23, 11, 29, 3, -21 },
};

const GFXfont RobotoCondensed_SemiBold51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_SEMIBOLD51PT7B_H_
