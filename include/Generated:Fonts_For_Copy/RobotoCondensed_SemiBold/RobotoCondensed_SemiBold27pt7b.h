#ifndef _ROBOTOCONDENSED_SEMIBOLD27PT7B_H_
#define _ROBOTOCONDENSED_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0xEF, 0xDF, 0x3E,
  0x7C, 0xD9, 0xB3, 0x00, 0x06, 0x60, 0x73, 0x03, 0xB8, 0x19, 0xC0, 0xCC,
  0x06, 0x61, 0xFF, 0xEF, 0xFF, 0x1C, 0xC0, 0xCE, 0x06, 0x61, 0xFF, 0xEF,
  0xFF, 0x0C, 0xC0, 0xE6, 0x07, 0x70, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0x06,
  0x00, 0xC0, 0x18, 0x07, 0x83, 0xFC, 0xFF, 0x9E, 0x7B, 0x87, 0x70, 0xEF,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xF0, 0xFE, 0x1D,
  0xC7, 0xBF, 0xF3, 0xFC, 0x3F, 0x01, 0x80, 0x30, 0x06, 0x00, 0x3C, 0x00,
  0xFC, 0x01, 0x98, 0xC7, 0x31, 0x8E, 0x67, 0x1C, 0xCC, 0x19, 0xB0, 0x3F,
  0x60, 0x3D, 0x80, 0x03, 0x00, 0x0C, 0xE0, 0x3B, 0xE0, 0x6E, 0xE1, 0xD8,
  0xC3, 0x31, 0x8E, 0x63, 0x18, 0xEE, 0x00, 0xF8, 0x00, 0xE0, 0x0F, 0x00,
  0xFE, 0x03, 0xFC, 0x1E, 0x70, 0x71, 0xC1, 0xE7, 0x03, 0xBC, 0x0F, 0xE0,
  0x1F, 0x00, 0xF8, 0xE7, 0xF3, 0x9D, 0xEE, 0xF3, 0xFB, 0x8F, 0xCF, 0x1F,
  0x3C, 0x78, 0x7F, 0xF1, 0xFF, 0xE1, 0xF3, 0xC0, 0xFF, 0xED, 0xB0, 0x04,
  0x71, 0x8E, 0x31, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0x40, 0x83, 0x0E, 0x1C, 0x70,
  0xE3, 0x8E, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCE, 0x38,
  0xE7, 0x1C, 0xE3, 0x08, 0x00, 0x06, 0x00, 0x60, 0x06, 0x04, 0x60, 0x7E,
  0xFF, 0xFF, 0x0F, 0x80, 0xF0, 0x1F, 0x83, 0x9C, 0x38, 0xC1, 0x08, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x39, 0xCE, 0x73, 0xB9, 0xCC,
  0xFF, 0xFF, 0xF8, 0x6F, 0xFE, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x0E, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xF7, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xDC, 0x7B, 0xCF, 0x7F, 0xC7, 0xF0, 0x7C, 0x00, 0x02, 0x3D, 0xFF, 0xFE,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x1F, 0x03, 0xFC, 0x7F, 0xCF, 0x1E, 0xF1, 0xEE, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xFF,
  0x1E, 0x01, 0xC0, 0x78, 0x0E, 0x0F, 0xC1, 0xF0, 0x3F, 0x00, 0xF0, 0x0E,
  0x01, 0xF8, 0x3F, 0x8F, 0x7F, 0xCF, 0xF8, 0x7C, 0x00, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x39, 0xC3, 0x1C,
  0x71, 0xCF, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3F, 0xE7, 0xFC, 0xFF, 0xBC, 0x07, 0x00, 0xE0, 0x1D, 0xE3,
  0xFE, 0x7F, 0xE6, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0xE1, 0xDC, 0x3B, 0xCF,
  0x7F, 0xC7, 0xF8, 0x3C, 0x00, 0x03, 0x80, 0xF8, 0x1F, 0x83, 0xC0, 0x38,
  0x07, 0x00, 0x77, 0x87, 0xFC, 0xFF, 0xEF, 0x9E, 0xF0, 0xEF, 0x0E, 0xF0,
  0xF7, 0x0E, 0x70, 0xE7, 0x9E, 0x3F, 0xC3, 0xFC, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x00, 0x1F, 0x07, 0xF9, 0xFF, 0x3C, 0xF7, 0x1E, 0xE3, 0xDC, 0x7B, 0xCE,
  0x3F, 0xC3, 0xF0, 0xFF, 0x3C, 0xFF, 0x0F, 0xE1, 0xFC, 0x3B, 0x8F, 0x7F,
  0xE7, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xEF, 0x1F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xEE, 0x3D, 0xFF, 0x9F, 0xF1, 0xEE, 0x03, 0x80,
  0x70, 0x3E, 0x1F, 0x83, 0xE0, 0x70, 0x00, 0x6F, 0xFE, 0x00, 0x00, 0x00,
  0x06, 0xFF, 0xE0, 0x77, 0x77, 0x00, 0x00, 0x00, 0x00, 0x77, 0x77, 0x7E,
  0xE4, 0x00, 0x81, 0xC1, 0xE3, 0xF7, 0xE7, 0xC3, 0x81, 0xF0, 0x7E, 0x0F,
  0xC1, 0xE0, 0x70, 0x08, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x70, 0x3E, 0x1F, 0x83, 0xF0, 0x7C, 0x0E,
  0x1F, 0x3F, 0x7E, 0x3C, 0x1C, 0x08, 0x00, 0x3E, 0x1F, 0xEF, 0xFB, 0xCF,
  0xE3, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x1C, 0x00,
  0x00, 0x00, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x3C, 0x3C, 0x0E, 0x01, 0xC3, 0x80, 0x18, 0x60, 0x03, 0x9C, 0x3C, 0x33,
  0x0F, 0xE6, 0x63, 0x98, 0xCC, 0x63, 0x1B, 0x8C, 0x63, 0xF3, 0x8C, 0x7E,
  0x71, 0x8D, 0x8E, 0x31, 0xB9, 0xC6, 0x37, 0x39, 0xC6, 0xE7, 0x39, 0x8C,
  0x7F, 0xF1, 0x87, 0x3C, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x86, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E,
  0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xFF, 0x0F, 0xFC,
  0xFF, 0xEE, 0x1E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8,
  0xFF, 0xEE, 0x1E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1E, 0xFF, 0xEF, 0xFC,
  0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1F,
  0xC0, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x03, 0xF8,
  0x1D, 0xC0, 0xEF, 0x0F, 0x3F, 0xF0, 0xFF, 0x03, 0xF0, 0xFF, 0x0F, 0xF8,
  0xFF, 0xCE, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8,
  0xFF, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0x9F, 0xF3, 0xFE, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xFF, 0xBF, 0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0xF0, 0xF7,
  0x03, 0xB8, 0x1F, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3,
  0xFF, 0x03, 0xB8, 0x1D, 0xE0, 0xEF, 0x07, 0x3F, 0xF8, 0xFF, 0x83, 0xF8,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xC3, 0xF8, 0x77,
  0x9E, 0xFF, 0xCF, 0xF0, 0x78, 0x00, 0xE0, 0xF7, 0x07, 0xB8, 0x79, 0xC7,
  0x8E, 0x3C, 0x73, 0xC3, 0xBC, 0x1D, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1,
  0xFF, 0x0F, 0x78, 0x71, 0xE3, 0x8F, 0x1C, 0x3C, 0xE1, 0xF7, 0x07, 0xB8,
  0x1E, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0xEF, 0xF8, 0x7F, 0xEE, 0x3F, 0xF7, 0x3B, 0xFB, 0x9D,
  0xFC, 0xEE, 0xFE, 0x76, 0x7F, 0x3F, 0x3F, 0x9F, 0x9F, 0xC7, 0xCF, 0xE3,
  0xC7, 0xF1, 0xE3, 0xF8, 0x71, 0xE0, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFD, 0xC7, 0xEE, 0x3F, 0x39, 0xF9, 0xCF,
  0xC7, 0x7E, 0x3B, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8,
  0x1E, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x78, 0x39, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3D,
  0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70,
  0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3D, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x40, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE,
  0x1E, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE1, 0xEF, 0xFE, 0xFF, 0xCF,
  0xF8, 0xE3, 0x8E, 0x3C, 0xE1, 0xCE, 0x1E, 0xE1, 0xEE, 0x0F, 0xE0, 0xF0,
  0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0xFF, 0x07, 0x70, 0x07, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0x7F, 0xF3, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3D, 0xC1,
  0xEF, 0x0F, 0x7F, 0xF1, 0xFF, 0x03, 0xF0, 0x70, 0x1E, 0xF0, 0x3D, 0xE0,
  0x73, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x8F, 0x0E, 0x0E, 0x3C, 0x1C, 0x78,
  0x3C, 0xE0, 0x79, 0xC0, 0x77, 0x80, 0xEE, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0xE1, 0xFC, 0x3C, 0x3B,
  0xC7, 0x87, 0x78, 0xF0, 0xE7, 0x1F, 0x1C, 0xE3, 0xE7, 0x9C, 0xFC, 0xF3,
  0x9F, 0x9C, 0x7B, 0xB3, 0x8F, 0x77, 0x70, 0xEC, 0xEE, 0x1F, 0x9F, 0xC3,
  0xF3, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x03,
  0xC3, 0xC0, 0x78, 0x38, 0x00, 0xF0, 0x7B, 0xC1, 0xE7, 0x8F, 0x1E, 0x3C,
  0x3C, 0xE0, 0xF7, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x83, 0xDE, 0x1E, 0x3C, 0x78, 0xF3, 0xC1,
  0xEF, 0x07, 0x80, 0xF0, 0x3D, 0xE0, 0xF7, 0x87, 0x8E, 0x1E, 0x3C, 0x70,
  0x73, 0xC1, 0xCE, 0x07, 0xB8, 0x0F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0xFF, 0xFE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xFF, 0xFF, 0xC0, 0x1C, 0x0E, 0x0F, 0x07, 0xC3, 0xE3, 0xB1, 0x9C, 0xCE,
  0xE3, 0x71, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE3, 0x87, 0x1F,
  0x07, 0xF1, 0xFF, 0x78, 0xE0, 0x1C, 0x03, 0x87, 0xF3, 0xFE, 0x71, 0xDE,
  0x3B, 0x87, 0x78, 0xEF, 0xFC, 0xFF, 0x8F, 0x78, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xFE, 0x3F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xFF, 0xFF, 0xEF,
  0x78, 0x1F, 0x07, 0xF1, 0xFF, 0x78, 0xEF, 0x1F, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC7, 0xF8, 0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC7, 0x7B, 0xFF, 0x7F, 0xFE, 0x3F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3D, 0xFF,
  0xBF, 0x71, 0xCE, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xFF, 0x1F, 0xE1, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x38, 0x27, 0xFE, 0x7F, 0x87, 0xE0,
  0x0E, 0x7C, 0xFB, 0xC7, 0x8F, 0x3F, 0xFF, 0xFE, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x1E, 0xEF, 0xFD, 0xFF, 0xF8,
  0xFF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0xF7,
  0xFE, 0xFF, 0xC7, 0xB8, 0x07, 0x21, 0xEF, 0xF9, 0xFF, 0x0F, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1E, 0x67, 0xF7, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x70, 0x18, 0xF3, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFF, 0xFB, 0xC0, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x3C, 0xF3,
  0xCF, 0x78, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF3,
  0x8F, 0x3C, 0xF1, 0xCF, 0x1E, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF7, 0x8F, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xC7, 0x8E,
  0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC,
  0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3C, 0xF7, 0x9F, 0xFB, 0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x78, 0x1F, 0x07,
  0xF9, 0xFF, 0x38, 0xFF, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC3, 0xB8, 0xF7, 0xFC, 0x7F, 0x87, 0xC0, 0xF7, 0x9F, 0xFB, 0xFF, 0xF8,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF,
  0xFF, 0xFF, 0xBD, 0xE7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x3E,
  0xEF, 0xFD, 0xFF, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0xC7, 0xF8, 0xF7, 0xFE, 0xFF, 0xCF, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0xF7, 0xFF, 0xFF, 0xEF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x00, 0x1F, 0x1F, 0xE7, 0xFF, 0xC7, 0xF0, 0x3E,
  0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x87, 0xFF, 0xDF, 0xE1, 0xF0,
  0x38, 0x38, 0x38, 0xFE, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x3C, 0x3F, 0x1F, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xB8, 0xF7, 0xFE,
  0xFF, 0xCF, 0x38, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0x9E, 0x39, 0xC3, 0x9C,
  0x39, 0xC3, 0xBC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x71, 0xC7, 0xB8, 0xE3, 0x9C, 0x71, 0xCE, 0x3C, 0xE7, 0xBE,
  0x71, 0xDF, 0x78, 0xED, 0xB8, 0x76, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x07,
  0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x70, 0x78, 0xE7,
  0x9E, 0x39, 0xC3, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF8, 0x1F, 0x83, 0xFC, 0x39, 0xC7, 0x9E, 0x70, 0xE0, 0xF0, 0xE7, 0x0E,
  0x71, 0xE7, 0x9E, 0x39, 0xC3, 0x9C, 0x3B, 0xC3, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x83, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x73,
  0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0xBC, 0xE3, 0xC7, 0x0E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC3, 0x8F, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x8F,
  0x1C, 0xF3, 0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0xE3, 0x00, 0x3C,
  0x3B, 0xF1, 0xDF, 0xCE, 0xCF, 0xEE, 0x3F, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 9, 1, -20 },
  { 16, 13, 19, 14, 1, -19 },
  { 47, 11, 25, 14, 1, -22 },
  { 82, 15, 19, 17, 1, -19 },
  { 118, 14, 19, 15, 1, -19 },
  { 152, 3, 7, 4, 1, -20 },
  { 155, 6, 27, 9, 2, -21 },
  { 176, 6, 27, 9, 1, -21 },
  { 197, 12, 12, 12, 0, -19 },
  { 215, 11, 14, 13, 1, -15 },
  { 235, 5, 8, 6, 0, -3 },
  { 240, 7, 3, 9, 1, -10 },
  { 243, 4, 4, 8, 2, -4 },
  { 245, 9, 21, 9, 0, -19 },
  { 269, 11, 19, 14, 1, -19 },
  { 296, 7, 19, 14, 2, -19 },
  { 313, 12, 19, 14, 1, -19 },
  { 342, 11, 19, 14, 1, -19 },
  { 369, 12, 19, 14, 1, -19 },
  { 398, 11, 19, 14, 1, -19 },
  { 425, 12, 19, 14, 1, -19 },
  { 454, 11, 19, 14, 1, -19 },
  { 481, 11, 19, 14, 1, -19 },
  { 508, 11, 19, 14, 1, -19 },
  { 535, 4, 15, 7, 2, -15 },
  { 543, 4, 20, 7, 1, -15 },
  { 553, 9, 13, 12, 1, -15 },
  { 568, 10, 9, 13, 2, -13 },
  { 580, 9, 13, 12, 2, -15 },
  { 595, 10, 19, 12, 1, -19 },
  { 619, 19, 25, 21, 1, -19 },
  { 679, 16, 19, 16, 0, -19 },
  { 717, 12, 19, 15, 2, -19 },
  { 746, 13, 19, 15, 1, -19 },
  { 777, 12, 19, 15, 2, -19 },
  { 806, 11, 19, 13, 2, -19 },
  { 833, 10, 19, 13, 2, -19 },
  { 857, 13, 19, 16, 1, -19 },
  { 888, 13, 19, 17, 2, -19 },
  { 919, 3, 19, 7, 2, -19 },
  { 927, 11, 19, 13, 1, -19 },
  { 954, 13, 19, 15, 2, -19 },
  { 985, 10, 19, 13, 2, -19 },
  { 1009, 17, 19, 20, 2, -19 },
  { 1050, 13, 19, 17, 2, -19 },
  { 1081, 14, 19, 16, 1, -19 },
  { 1115, 12, 19, 15, 2, -19 },
  { 1144, 14, 22, 16, 1, -19 },
  { 1183, 12, 19, 15, 2, -19 },
  { 1212, 12, 19, 14, 1, -19 },
  { 1241, 13, 19, 15, 1, -19 },
  { 1272, 13, 19, 15, 1, -19 },
  { 1303, 15, 19, 15, 0, -19 },
  { 1339, 19, 19, 20, 1, -19 },
  { 1385, 14, 19, 15, 1, -19 },
  { 1419, 14, 19, 15, 0, -19 },
  { 1453, 12, 19, 14, 1, -19 },
  { 1482, 4, 26, 7, 2, -22 },
  { 1495, 10, 21, 10, 0, -19 },
  { 1522, 5, 26, 7, 0, -22 },
  { 1539, 9, 10, 10, 1, -19 },
  { 1551, 11, 3, 11, 0, 0 },
  { 1556, 6, 4, 9, 1, -20 },
  { 1559, 11, 15, 13, 1, -15 },
  { 1580, 11, 21, 13, 1, -21 },
  { 1609, 11, 15, 12, 1, -15 },
  { 1630, 11, 21, 13, 1, -21 },
  { 1659, 11, 15, 13, 1, -15 },
  { 1680, 7, 21, 9, 1, -21 },
  { 1699, 11, 20, 14, 1, -15 },
  { 1727, 11, 21, 13, 1, -21 },
  { 1756, 4, 21, 7, 1, -21 },
  { 1767, 6, 26, 6, -1, -21 },
  { 1787, 12, 21, 13, 1, -21 },
  { 1819, 3, 21, 7, 2, -21 },
  { 1827, 18, 15, 20, 1, -15 },
  { 1861, 11, 15, 13, 1, -15 },
  { 1882, 11, 15, 13, 1, -15 },
  { 1903, 11, 20, 13, 1, -15 },
  { 1931, 11, 20, 13, 1, -15 },
  { 1959, 7, 15, 9, 1, -15 },
  { 1973, 10, 15, 12, 1, -15 },
  { 1992, 8, 18, 8, 0, -18 },
  { 2010, 11, 15, 13, 1, -15 },
  { 2031, 12, 15, 12, 0, -15 },
  { 2054, 17, 15, 17, 0, -15 },
  { 2086, 12, 15, 12, 0, -15 },
  { 2109, 12, 20, 12, 0, -15 },
  { 2139, 10, 15, 12, 1, -15 },
  { 2158, 6, 26, 8, 1, -21 },
  { 2178, 3, 23, 7, 2, -19 },
  { 2187, 6, 26, 8, 1, -21 },
  { 2207, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_SemiBold27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_SEMIBOLD27PT7B_H_
