#ifndef _IBMPLEXMONO_SEMIBOLD49PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x03, 0x81,
  0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x8F, 0x80, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x07, 0xFF, 0x87, 0xFF, 0x7F, 0xF8,
  0x7F, 0xF7, 0xFF, 0x87, 0xFF, 0x7F, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFF,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0xFF, 0xE1, 0xFF,
  0xCF, 0xFE, 0x1F, 0xFC, 0xFF, 0xE1, 0xFF, 0xCF, 0xFC, 0x1F, 0xFC, 0xFF,
  0xC3, 0xFF, 0xC0, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xF9, 0xE7, 0xF1, 0xFC, 0x78,
  0x78, 0x7E, 0x1E, 0x0C, 0x1F, 0x87, 0x80, 0x07, 0xE1, 0xE0, 0x01, 0xF8,
  0x78, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0xC7, 0x80, 0x07, 0xF9, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xE7, 0xF8, 0x00, 0x78, 0x7E, 0x00, 0x1E, 0x1F, 0x80, 0x07, 0x83, 0xF0,
  0x01, 0xE0, 0xFC, 0x00, 0x78, 0x3F, 0x10, 0x1E, 0x1F, 0x8E, 0x07, 0x87,
  0xE7, 0xE1, 0xE3, 0xFB, 0xFE, 0x79, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xCF,
  0xFF, 0x00, 0x7C, 0x7F, 0xF8, 0x03, 0xE7, 0xC3, 0xE0, 0x3E, 0x3E, 0x0F,
  0x01, 0xF1, 0xE0, 0x78, 0x1F, 0x0F, 0x03, 0xE0, 0xF8, 0x78, 0x1F, 0x0F,
  0x83, 0xC0, 0xF8, 0x7C, 0x1E, 0x07, 0xC7, 0xC0, 0xF0, 0x3C, 0x3E, 0x07,
  0xC1, 0xE3, 0xE0, 0x3E, 0x1F, 0x1F, 0x00, 0xFF, 0xF1, 0xF0, 0x07, 0xFF,
  0x8F, 0x80, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x8F, 0xFE, 0x00, 0xF8, 0xFF, 0xF8,
  0x07, 0xCF, 0xC7, 0xC0, 0x7C, 0x7C, 0x1E, 0x03, 0xE3, 0xC0, 0xF8, 0x3E,
  0x1E, 0x07, 0xC1, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x3C,
  0x0F, 0x8F, 0x81, 0xE0, 0x7C, 0x7C, 0x0F, 0x83, 0xC7, 0xC0, 0x7E, 0x3E,
  0x3E, 0x01, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0x1F, 0x00, 0x1F, 0xF1, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x0C, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xFC, 0x1F, 0xE3, 0xFF, 0xE1,
  0xFE, 0x7F, 0x7F, 0x1F, 0x07, 0xE3, 0xF1, 0xE0, 0xFC, 0x1F, 0x9E, 0x0F,
  0xC1, 0xFF, 0xE0, 0xFC, 0x0F, 0xFE, 0x0F, 0xC0, 0x7F, 0xC0, 0xFC, 0x03,
  0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x07, 0xFF, 0x07, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0x1F, 0xC1, 0xFF,
  0xE0, 0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x04, 0x03, 0xE0, 0x11, 0xE0, 0xF8, 0x3E, 0x7F, 0x3E, 0x3F, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0x1C, 0x01, 0xC0, 0x02,
  0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x78, 0x7F, 0xFC,
  0x3F, 0x1F, 0xFF, 0x0F, 0xC7, 0xFF, 0xC3, 0xF1, 0xFF, 0xF0, 0xFC, 0x7F,
  0xFC, 0x1E, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0x83, 0xFC, 0x1F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0,
  0x07, 0xC0, 0xFC, 0x00, 0xE0, 0x3F, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFC,
  0x1F, 0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3C, 0x00, 0x7F, 0x06,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE3, 0xFC, 0x0F, 0xF0, 0xF8, 0x03, 0xFC, 0x38, 0x00, 0xFE, 0x08, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC4, 0x00, 0x0F, 0xE3, 0x00, 0x07,
  0xF7, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xFB, 0xFE, 0x07, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xC1,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0xFC, 0x01, 0xF1, 0xFF, 0x80, 0xF9, 0xFF, 0xF0, 0x7D, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x8F, 0xC0, 0x1F, 0xE0, 0x40, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x84, 0x00, 0x1F, 0xC3, 0x00, 0x0F, 0xE7, 0xC0, 0x07,
  0xF7, 0xF0, 0x07, 0xF7, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x01, 0xF9, 0xFF, 0xC1, 0xFD, 0xFF, 0xF0, 0xFD, 0xFF,
  0xFC, 0x7E, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F, 0xBF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF,
  0xE0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0xFE, 0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xFC, 0xF8, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFE,
  0x07, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F,
  0xF3, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xBF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xF7, 0xE1, 0xFF, 0xF3, 0xF0, 0x3F, 0xF3, 0xF8, 0x07, 0xE1, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0x80, 0x1F, 0x07, 0xF9, 0xFF,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF1, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0x80, 0x7F, 0x7E, 0x00, 0x7E, 0x1C,
  0x00, 0xFC, 0x08, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFE, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0x9F, 0x01, 0xE3, 0xEF, 0x83, 0xFD, 0xF7, 0x83, 0xFE,
  0xFB, 0xC1, 0xFF, 0xFF, 0xE1, 0xF8, 0x7F, 0xF0, 0xF8, 0x1F, 0xF8, 0x7C,
  0x0F, 0xFC, 0x3E, 0x07, 0xFE, 0x1F, 0x03, 0xFF, 0x0F, 0x81, 0xFF, 0x87,
  0xC0, 0xFF, 0xC3, 0xE0, 0x7F, 0xE1, 0xF0, 0x3F, 0xF0, 0xF8, 0x1F, 0xF8,
  0x7C, 0x0F, 0xFC, 0x3E, 0x07, 0xDE, 0x1F, 0x87, 0xEF, 0x07, 0xFF, 0xF7,
  0xC3, 0xFE, 0xFB, 0xE0, 0xFF, 0x7D, 0xF0, 0x3F, 0x3E, 0x7C, 0x04, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0xFC,
  0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0,
  0x1F, 0x9F, 0x80, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xEF, 0xC0, 0x0F,
  0xDF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0x1F, 0xC0, 0x04,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x1F,
  0xC0, 0x07, 0x87, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x80, 0xFF,
  0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07,
  0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xC1, 0xFE, 0x3F,
  0x80, 0xFF, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3C, 0x7E,
  0x00, 0x20, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x7F, 0x3F,
  0xE0, 0xFF, 0x1F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x9F, 0x07,
  0xFE, 0x1F, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x1C, 0x01, 0xFF, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xE7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x8F, 0xC0,
  0x3F, 0x87, 0xE0, 0x3F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0x7E, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F,
  0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF7, 0xF0,
  0x0F, 0xFB, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80,
  0x7F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xF3, 0xF0, 0x03, 0xF9, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xEF, 0xFF, 0xF9, 0xF7, 0xFF, 0x7C,
  0xFB, 0xFF, 0xBE, 0xF9, 0xFF, 0xCF, 0xFC, 0xFF, 0xE7, 0xFC, 0x7F, 0xF3,
  0xFE, 0x3F, 0xF8, 0xFF, 0x1F, 0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xFF,
  0x0F, 0xC7, 0xFF, 0x87, 0xC3, 0xFF, 0xC1, 0xE1, 0xFF, 0xE0, 0xE0, 0xFF,
  0xF0, 0x70, 0x7F, 0xF8, 0x18, 0x3F, 0xFC, 0x08, 0x1F, 0xFE, 0x04, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xF7, 0xC0, 0xFF, 0xEF, 0x81,
  0xFF, 0xDF, 0x83, 0xFF, 0x9F, 0x07, 0xFF, 0x3F, 0x0F, 0xFE, 0x7E, 0x1F,
  0xFC, 0x7C, 0x3F, 0xF8, 0xFC, 0x7F, 0xF0, 0xF8, 0xFF, 0xE1, 0xF1, 0xFF,
  0xC3, 0xF3, 0xFF, 0x83, 0xE7, 0xFF, 0x07, 0xCF, 0xFE, 0x0F, 0xDF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xDF, 0x80, 0x7F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07,
  0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F,
  0x9F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC,
  0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF9,
  0xFE, 0x07, 0xF8, 0xFE, 0x00, 0x78, 0xFE, 0x00, 0x18, 0x7F, 0x00, 0x08,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE2, 0x00, 0x07, 0xF3,
  0x80, 0x03, 0xFB, 0xF0, 0x03, 0xFB, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xF0, 0x7F, 0x8F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF8, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x9F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C,
  0x3F, 0x83, 0xE7, 0xC3, 0xF8, 0x3E, 0x7C, 0x3F, 0xC7, 0xE7, 0xC3, 0xFC,
  0x7E, 0x7C, 0x3F, 0xC7, 0xE7, 0xC7, 0xBC, 0x7C, 0x7C, 0x7B, 0xC7, 0xC7,
  0xC7, 0xBC, 0x7C, 0x7C, 0x7B, 0xE7, 0xC7, 0xE7, 0x9E, 0x7C, 0x7E, 0x79,
  0xE7, 0xC7, 0xEF, 0x1E, 0x7C, 0x7E, 0xF1, 0xE7, 0xC7, 0xEF, 0x1F, 0x7C,
  0x3E, 0xF1, 0xF7, 0xC3, 0xEF, 0x0F, 0x7C, 0x3E, 0xF0, 0xF7, 0xC3, 0xFF,
  0x0F, 0x7C, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF9,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x38, 0x00, 0x0F, 0x04, 0x00, 0x01, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x08, 0x0F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC1, 0xE0, 0x20, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0xC0,
  0xF0, 0x07, 0xE0, 0x30, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFB, 0xFE, 0xFF, 0xFC, 0xFF, 0x3F, 0xFC, 0x7F, 0x8F,
  0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFE, 0xFF, 0xFC,
  0xFE, 0x7F, 0xF8, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7,
  0xF8, 0x3F, 0xCF, 0xE0, 0x1F, 0x3F, 0x80, 0x38, 0x7E, 0x00, 0x40, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x83, 0xF8, 0x01, 0xC3, 0xF8, 0x07, 0xC7, 0xF8, 0x3F,
  0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x3F,
  0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF, 0x3F, 0x3F, 0xFF, 0xBF,
  0x3F, 0xC1, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x3F, 0xC1, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F,
  0x07, 0xFE, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC,
  0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x10, 0x7E, 0x00, 0x38, 0x7F, 0x00, 0x7C, 0x3F, 0xC1, 0xFE,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xEF, 0xF0, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0x80,
  0x7F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFD, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC1, 0xF8, 0x3F, 0x1F, 0xF8, 0xFC, 0xFF, 0xF3, 0xF7, 0xFF, 0xCF, 0xDF,
  0xFF, 0xBF, 0xC1, 0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xEF, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC3, 0xF0,
  0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x1F, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0xFF, 0x3F, 0x00, 0x3F, 0xDF, 0x80, 0x0F, 0xF0, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x3E, 0x3E, 0x7E, 0x1F, 0xCF, 0xBF, 0xCF, 0xFB, 0xEF, 0xF7, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0x1F, 0xC7, 0xEF, 0x83, 0xF0, 0xFB, 0xE0, 0xF8,
  0x3F, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0xFF, 0xE0,
  0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0xFF,
  0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xFF, 0x83, 0xE0,
  0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xFF, 0x83,
  0xE0, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x3E, 0x0F, 0xFE, 0x0F, 0x83, 0xF0,
  0x00, 0x1F, 0x83, 0xF1, 0xFF, 0x8F, 0xCF, 0xFF, 0x3F, 0x7F, 0xFC, 0xFD,
  0xFF, 0xFB, 0xFC, 0x1F, 0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0xFE, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF,
  0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFE, 0xFF,
  0xFC, 0xFE, 0x7F, 0xF8, 0xFE, 0x3F, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0x0F, 0xFF, 0x3F, 0x1F, 0xFF,
  0x3F, 0x3F, 0xFF, 0xBF, 0x3F, 0xC1, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0xC1, 0xFF, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF,
  0xBF, 0x0F, 0xFF, 0x3F, 0x07, 0xFE, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x7F, 0xE0, 0x7E, 0xE0, 0x00, 0xFD, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE7, 0xF0, 0x1F, 0x1F, 0xC0, 0x0C, 0x3F, 0x00, 0x08,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF9, 0x80, 0x03, 0xF7, 0xC0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF8,
  0x3F, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xBF, 0x8F, 0xFF, 0x7F, 0x0F, 0xFC,
  0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x83,
  0xEF, 0x83, 0xF8, 0x3E, 0xF8, 0x3F, 0x83, 0xEF, 0x83, 0xFC, 0x3E, 0x7C,
  0x3F, 0xC3, 0xE7, 0xC3, 0xBC, 0x3E, 0x7C, 0x3B, 0xC3, 0xE7, 0xC7, 0xBC,
  0x3E, 0x7C, 0x79, 0xC3, 0xC7, 0xC7, 0x9E, 0x7C, 0x7C, 0x79, 0xE7, 0xC7,
  0xC7, 0x1E, 0x7C, 0x3C, 0x71, 0xE7, 0xC3, 0xEF, 0x1E, 0x7C, 0x3E, 0xF0,
  0xE7, 0xC3, 0xEF, 0x0F, 0x78, 0x3E, 0xF0, 0xF7, 0x83, 0xEE, 0x0F, 0x78,
  0x3E, 0xE0, 0xF7, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0xF8,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7,
  0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFE,
  0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xE0, 0x06, 0x07,
  0xF8, 0x03, 0xC7, 0xFE, 0x03, 0xE7, 0xFF, 0x81, 0xF3, 0xFF, 0xE0, 0xFB,
  0xF3, 0xF8, 0xF9, 0xF0, 0xFC, 0x7C, 0xF8, 0x3F, 0xFE, 0xF8, 0x1F, 0xFE,
  0x7C, 0x07, 0xFE, 0x3E, 0x01, 0xFF, 0x07, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 35, 29, 10, -34 },
  { 41, 16, 15, 29, 7, -36 },
  { 71, 28, 34, 29, 1, -34 },
  { 190, 26, 46, 29, 2, -40 },
  { 340, 29, 36, 29, 0, -35 },
  { 471, 28, 36, 29, 1, -35 },
  { 597, 6, 15, 29, 12, -36 },
  { 609, 16, 44, 29, 9, -37 },
  { 697, 16, 44, 29, 4, -37 },
  { 785, 26, 25, 29, 2, -27 },
  { 867, 23, 23, 29, 3, -26 },
  { 934, 11, 15, 29, 9, -8 },
  { 955, 15, 6, 29, 7, -18 },
  { 967, 9, 9, 29, 10, -8 },
  { 978, 22, 44, 29, 4, -37 },
  { 1099, 26, 36, 29, 2, -35 },
  { 1216, 26, 34, 29, 2, -34 },
  { 1327, 25, 35, 29, 2, -35 },
  { 1437, 25, 36, 29, 2, -35 },
  { 1550, 27, 34, 29, 1, -34 },
  { 1665, 25, 35, 29, 2, -34 },
  { 1775, 25, 35, 29, 2, -34 },
  { 1885, 24, 34, 29, 3, -34 },
  { 1987, 25, 36, 29, 2, -35 },
  { 2100, 25, 35, 29, 2, -35 },
  { 2210, 9, 26, 29, 10, -25 },
  { 2240, 11, 32, 29, 9, -25 },
  { 2284, 21, 29, 29, 4, -29 },
  { 2361, 23, 16, 29, 3, -23 },
  { 2407, 21, 29, 29, 4, -29 },
  { 2484, 23, 36, 29, 3, -35 },
  { 2588, 25, 40, 29, 2, -35 },
  { 2713, 28, 34, 29, 1, -34 },
  { 2832, 23, 34, 29, 4, -34 },
  { 2930, 25, 36, 29, 2, -35 },
  { 3043, 23, 34, 29, 4, -34 },
  { 3141, 22, 34, 29, 4, -34 },
  { 3235, 22, 34, 29, 4, -34 },
  { 3329, 24, 36, 29, 2, -35 },
  { 3437, 23, 34, 29, 3, -34 },
  { 3535, 22, 34, 29, 4, -34 },
  { 3629, 23, 35, 29, 2, -34 },
  { 3730, 25, 34, 29, 4, -34 },
  { 3837, 21, 34, 29, 5, -34 },
  { 3927, 25, 34, 29, 2, -34 },
  { 4034, 23, 34, 29, 3, -34 },
  { 4132, 26, 36, 29, 2, -35 },
  { 4249, 23, 34, 29, 4, -34 },
  { 4347, 26, 44, 29, 2, -35 },
  { 4490, 24, 34, 29, 4, -34 },
  { 4592, 25, 36, 29, 2, -35 },
  { 4705, 27, 34, 29, 1, -34 },
  { 4820, 23, 35, 29, 3, -34 },
  { 4921, 28, 34, 29, 1, -34 },
  { 5040, 28, 34, 29, 1, -34 },
  { 5159, 28, 34, 29, 1, -34 },
  { 5278, 29, 34, 29, 0, -34 },
  { 5402, 25, 34, 29, 2, -34 },
  { 5509, 15, 44, 29, 10, -37 },
  { 5592, 22, 44, 29, 4, -37 },
  { 5713, 15, 44, 29, 5, -37 },
  { 5796, 26, 22, 29, 2, -34 },
  { 5868, 23, 5, 29, 3, 4 },
  { 5883, 10, 11, 29, 8, -39 },
  { 5897, 25, 27, 29, 3, -26 },
  { 5982, 24, 37, 29, 3, -36 },
  { 6093, 23, 27, 29, 3, -26 },
  { 6171, 24, 37, 29, 2, -36 },
  { 6282, 24, 27, 29, 3, -26 },
  { 6363, 24, 36, 29, 3, -36 },
  { 6471, 25, 40, 29, 3, -30 },
  { 6596, 22, 36, 29, 4, -36 },
  { 6695, 22, 37, 29, 5, -37 },
  { 6797, 18, 47, 29, 4, -37 },
  { 6903, 25, 36, 29, 4, -36 },
  { 7016, 22, 36, 29, 4, -36 },
  { 7115, 26, 26, 29, 2, -26 },
  { 7200, 22, 26, 29, 4, -26 },
  { 7272, 25, 27, 29, 2, -26 },
  { 7357, 24, 36, 29, 3, -26 },
  { 7465, 24, 36, 29, 2, -26 },
  { 7573, 23, 25, 29, 4, -25 },
  { 7645, 23, 27, 29, 3, -26 },
  { 7723, 24, 34, 29, 2, -34 },
  { 7825, 23, 26, 29, 3, -25 },
  { 7900, 26, 25, 29, 2, -25 },
  { 7982, 28, 25, 29, 1, -25 },
  { 8070, 26, 25, 29, 2, -25 },
  { 8152, 27, 35, 29, 1, -25 },
  { 8271, 22, 25, 29, 4, -25 },
  { 8340, 20, 44, 29, 5, -37 },
  { 8450, 5, 44, 29, 12, -37 },
  { 8478, 20, 44, 29, 5, -37 },
  { 8588, 25, 12, 29, 2, -21 },
};

const GFXfont IBMPlexMono_SemiBold49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_SEMIBOLD49PT7B_H_
