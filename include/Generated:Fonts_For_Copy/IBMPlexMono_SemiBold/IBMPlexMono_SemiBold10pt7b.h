#ifndef _IBMPLEXMONO_SEMIBOLD10PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x3C, 0xFF, 0xF0, 0x28, 0xAE, 0xCC, 0xDD, 0x45, 0x00, 0x11,
  0xE5, 0x94, 0x78, 0x79, 0xDE, 0x10, 0x66, 0xAB, 0x1E, 0x15, 0xD9, 0x80,
  0x71, 0x44, 0x1B, 0xBA, 0x66, 0xC0, 0xFC, 0x6A, 0x49, 0x22, 0x60, 0xC8,
  0x92, 0x4A, 0xC0, 0x32, 0xE7, 0xCC, 0x48, 0x66, 0xF6, 0x60, 0xE8, 0xF0,
  0xF0, 0x11, 0x22, 0x64, 0x48, 0x80, 0x79, 0x2F, 0xFF, 0xCD, 0x27, 0x80,
  0x31, 0x4D, 0x04, 0x10, 0x47, 0xC0, 0x7B, 0x20, 0x86, 0x31, 0x87, 0xC0,
  0x7A, 0x42, 0x60, 0xA7, 0xE0, 0x18, 0xA2, 0x92, 0xCB, 0xF0, 0x80, 0xF4,
  0x3D, 0x21, 0xCB, 0xC0, 0x39, 0x87, 0x92, 0xCD, 0x27, 0x80, 0xF9, 0x12,
  0x26, 0x40, 0x79, 0x24, 0x8C, 0x4B, 0x37, 0x80, 0x79, 0x2C, 0xD2, 0x78,
  0x67, 0x00, 0xF0, 0xF0, 0xF0, 0xE8, 0x17, 0xCC, 0x71, 0xF0, 0xF0, 0x8E,
  0x33, 0xE8, 0xF9, 0x34, 0x06, 0x60, 0x7A, 0x57, 0x5A, 0xBD, 0x06, 0x30,
  0xC7, 0x92, 0x79, 0x2C, 0xC0, 0xF4, 0xA5, 0xC9, 0x4F, 0xC0, 0x39, 0x24,
  0x70, 0x41, 0x33, 0x80, 0xF4, 0xA7, 0x39, 0xCB, 0xC0, 0xF8, 0x8F, 0x88,
  0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x7A, 0x71, 0xBC, 0xA5, 0xE0, 0x99, 0x9F,
  0x99, 0x90, 0xF6, 0x66, 0x66, 0xF0, 0x78, 0x42, 0x10, 0xE5, 0xC0, 0x9D,
  0xA9, 0xCB, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0xCF, 0xFF, 0xFF, 0xEF,
  0x3C, 0xC0, 0x9D, 0xDF, 0xBB, 0x90, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x80,
  0xF4, 0xE7, 0xE8, 0x42, 0x00, 0x79, 0x2C, 0xF3, 0xCD, 0x27, 0x8C, 0x18,
  0xF4, 0xA7, 0xEA, 0x4A, 0x60, 0x79, 0x24, 0x1E, 0x09, 0x3F, 0x80, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x99, 0x99, 0x99, 0xF0, 0xCD, 0x24, 0x92,
  0x78, 0xC3, 0x00, 0x86, 0x1B, 0x7D, 0xFD, 0xE4, 0x80, 0xCD, 0xA3, 0x0C,
  0x31, 0x2C, 0xC0, 0xCD, 0x27, 0x8C, 0x30, 0xC3, 0x00, 0x78, 0x21, 0x0C,
  0x61, 0x0F, 0xC0, 0xF2, 0x49, 0x24, 0xE0, 0x88, 0x44, 0x62, 0x21, 0x10,
  0xE4, 0x92, 0x49, 0xE0, 0x30, 0xC4, 0xB3, 0xF0, 0x90, 0xF4, 0xBD, 0x2F,
  0x80, 0x84, 0x3D, 0x29, 0xCB, 0xC0, 0x79, 0x89, 0x70, 0x08, 0x5E, 0x9C,
  0xA5, 0xE0, 0xF9, 0xF8, 0xF0, 0x3B, 0x3E, 0xC6, 0x33, 0xC0, 0x1F, 0xA5,
  0xE8, 0x7A, 0x3E, 0x88, 0xF9, 0x99, 0x90, 0x23, 0x01, 0xC2, 0x10, 0x9F,
  0x23, 0x0E, 0x22, 0x22, 0x2E, 0x84, 0x27, 0x4E, 0x5A, 0x60, 0xE6, 0x66,
  0x66, 0xF0, 0xAB, 0xDB, 0x6D, 0xB4, 0xF9, 0x99, 0x90, 0x79, 0x2C, 0xD2,
  0x78, 0xF4, 0xA7, 0x2F, 0x42, 0x00, 0x7A, 0x72, 0x97, 0x84, 0x20, 0xDB,
  0x10, 0x8F, 0x00, 0xF9, 0xF9, 0xF0, 0x21, 0x3E, 0x42, 0x10, 0xE0, 0x99,
  0x99, 0xF0, 0xCD, 0x26, 0x8C, 0x30, 0xB6, 0xDB, 0x5E, 0x48, 0xCC, 0xC3,
  0x1E, 0xCC, 0xCD, 0x27, 0x8C, 0x30, 0x86, 0x00, 0xF3, 0x6C, 0xF0, 0x74,
  0x62, 0xC2, 0x64, 0x70, 0xFF, 0xFF, 0xC0, 0xE2, 0x64, 0x34, 0x62, 0xE0,
  0x66, 0x60,
};

const GFXglyph IBMPlexMono_SemiBold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 9, 6, 0, -8 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 6, 7, 6, 0, -7 },
  { 30, 2, 3, 6, 2, -7 },
  { 31, 3, 9, 6, 2, -8 },
  { 35, 3, 9, 6, 1, -8 },
  { 39, 6, 5, 6, 0, -5 },
  { 43, 4, 5, 6, 1, -6 },
  { 46, 2, 3, 6, 2, -2 },
  { 47, 4, 1, 6, 1, -4 },
  { 48, 2, 2, 6, 2, -2 },
  { 49, 4, 9, 6, 1, -8 },
  { 54, 6, 7, 6, 0, -7 },
  { 60, 6, 7, 6, 0, -7 },
  { 66, 6, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 6, 7, 6, 0, -7 },
  { 83, 5, 7, 6, 1, -7 },
  { 88, 6, 7, 6, 0, -7 },
  { 94, 4, 7, 6, 1, -7 },
  { 98, 6, 7, 6, 0, -7 },
  { 104, 6, 7, 6, 0, -7 },
  { 110, 2, 6, 6, 2, -6 },
  { 112, 2, 7, 6, 2, -6 },
  { 114, 4, 6, 6, 1, -6 },
  { 117, 4, 3, 6, 1, -5 },
  { 119, 4, 6, 6, 1, -6 },
  { 122, 4, 7, 6, 1, -7 },
  { 126, 5, 8, 6, 0, -7 },
  { 131, 6, 7, 6, 0, -7 },
  { 137, 5, 7, 6, 1, -7 },
  { 142, 6, 7, 6, 0, -7 },
  { 148, 5, 7, 6, 1, -7 },
  { 153, 4, 7, 6, 1, -7 },
  { 157, 4, 7, 6, 1, -7 },
  { 161, 5, 7, 6, 0, -7 },
  { 166, 4, 7, 6, 1, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 5, 7, 6, 0, -7 },
  { 179, 5, 7, 6, 1, -7 },
  { 184, 4, 7, 6, 1, -7 },
  { 188, 6, 7, 6, 0, -7 },
  { 194, 4, 7, 6, 1, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 5, 7, 6, 1, -7 },
  { 209, 6, 9, 6, 0, -7 },
  { 216, 5, 7, 6, 1, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 6, 7, 6, 0, -7 },
  { 233, 4, 7, 6, 1, -7 },
  { 237, 6, 7, 6, 0, -7 },
  { 243, 6, 7, 6, 0, -7 },
  { 249, 6, 7, 6, 0, -7 },
  { 255, 6, 7, 6, 0, -7 },
  { 261, 6, 7, 6, 0, -7 },
  { 267, 3, 9, 6, 2, -8 },
  { 271, 4, 9, 6, 1, -8 },
  { 276, 3, 9, 6, 1, -8 },
  { 280, 6, 4, 6, 0, -7 },
  { 283, 4, 1, 6, 1, 1 },
  { 284, 2, 2, 6, 2, -8 },
  { 285, 5, 5, 6, 1, -5 },
  { 289, 5, 7, 6, 1, -7 },
  { 294, 4, 5, 6, 1, -5 },
  { 297, 5, 7, 6, 0, -7 },
  { 302, 4, 5, 6, 1, -5 },
  { 305, 5, 7, 6, 1, -7 },
  { 310, 5, 8, 6, 1, -6 },
  { 315, 4, 7, 6, 1, -7 },
  { 319, 5, 8, 6, 1, -8 },
  { 324, 4, 10, 6, 1, -8 },
  { 329, 5, 7, 6, 1, -7 },
  { 334, 4, 7, 6, 1, -7 },
  { 338, 6, 5, 6, 0, -5 },
  { 342, 4, 5, 6, 1, -5 },
  { 345, 6, 5, 6, 0, -5 },
  { 349, 5, 7, 6, 1, -5 },
  { 354, 5, 7, 6, 0, -5 },
  { 359, 5, 5, 6, 1, -5 },
  { 363, 4, 5, 6, 1, -5 },
  { 366, 5, 7, 6, 0, -7 },
  { 371, 4, 5, 6, 1, -5 },
  { 374, 6, 5, 6, 0, -5 },
  { 378, 6, 5, 6, 0, -5 },
  { 382, 6, 5, 6, 0, -5 },
  { 386, 6, 7, 6, 0, -5 },
  { 392, 4, 5, 6, 1, -5 },
  { 395, 4, 9, 6, 1, -8 },
  { 400, 2, 9, 6, 2, -8 },
  { 403, 4, 9, 6, 1, -8 },
  { 408, 6, 2, 6, 0, -4 },
};

const GFXfont IBMPlexMono_SemiBold10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_SEMIBOLD10PT7B_H_
