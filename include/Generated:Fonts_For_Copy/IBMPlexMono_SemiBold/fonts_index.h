#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &IBMPlexMono_SemiBold6pt7b, 6, "IBMPlexMono_SemiBold6pt7b" },
  { &IBMPlexMono_SemiBold7pt7b, 7, "IBMPlexMono_SemiBold7pt7b" },
  { &IBMPlexMono_SemiBold8pt7b, 8, "IBMPlexMono_SemiBold8pt7b" },
  { &IBMPlexMono_SemiBold9pt7b, 9, "IBMPlexMono_SemiBold9pt7b" },
  { &IBMPlexMono_SemiBold10pt7b, 10, "IBMPlexMono_SemiBold10pt7b" },
  { &IBMPlexMono_SemiBold11pt7b, 11, "IBMPlexMono_SemiBold11pt7b" },
  { &IBMPlexMono_SemiBold12pt7b, 12, "IBMPlexMono_SemiBold12pt7b" },
  { &IBMPlexMono_SemiBold13pt7b, 13, "IBMPlexMono_SemiBold13pt7b" },
  { &IBMPlexMono_SemiBold14pt7b, 14, "IBMPlexMono_SemiBold14pt7b" },
  { &IBMPlexMono_SemiBold15pt7b, 15, "IBMPlexMono_SemiBold15pt7b" },
  { &IBMPlexMono_SemiBold16pt7b, 16, "IBMPlexMono_SemiBold16pt7b" },
  { &IBMPlexMono_SemiBold17pt7b, 17, "IBMPlexMono_SemiBold17pt7b" },
  { &IBMPlexMono_SemiBold18pt7b, 18, "IBMPlexMono_SemiBold18pt7b" },
  { &IBMPlexMono_SemiBold19pt7b, 19, "IBMPlexMono_SemiBold19pt7b" },
  { &IBMPlexMono_SemiBold20pt7b, 20, "IBMPlexMono_SemiBold20pt7b" },
  { &IBMPlexMono_SemiBold21pt7b, 21, "IBMPlexMono_SemiBold21pt7b" },
  { &IBMPlexMono_SemiBold22pt7b, 22, "IBMPlexMono_SemiBold22pt7b" },
  { &IBMPlexMono_SemiBold23pt7b, 23, "IBMPlexMono_SemiBold23pt7b" },
  { &IBMPlexMono_SemiBold24pt7b, 24, "IBMPlexMono_SemiBold24pt7b" },
  { &IBMPlexMono_SemiBold25pt7b, 25, "IBMPlexMono_SemiBold25pt7b" },
  { &IBMPlexMono_SemiBold26pt7b, 26, "IBMPlexMono_SemiBold26pt7b" },
  { &IBMPlexMono_SemiBold27pt7b, 27, "IBMPlexMono_SemiBold27pt7b" },
  { &IBMPlexMono_SemiBold28pt7b, 28, "IBMPlexMono_SemiBold28pt7b" },
  { &IBMPlexMono_SemiBold29pt7b, 29, "IBMPlexMono_SemiBold29pt7b" },
  { &IBMPlexMono_SemiBold30pt7b, 30, "IBMPlexMono_SemiBold30pt7b" },
  { &IBMPlexMono_SemiBold31pt7b, 31, "IBMPlexMono_SemiBold31pt7b" },
  { &IBMPlexMono_SemiBold32pt7b, 32, "IBMPlexMono_SemiBold32pt7b" },
  { &IBMPlexMono_SemiBold33pt7b, 33, "IBMPlexMono_SemiBold33pt7b" },
  { &IBMPlexMono_SemiBold34pt7b, 34, "IBMPlexMono_SemiBold34pt7b" },
  { &IBMPlexMono_SemiBold35pt7b, 35, "IBMPlexMono_SemiBold35pt7b" },
  { &IBMPlexMono_SemiBold36pt7b, 36, "IBMPlexMono_SemiBold36pt7b" },
  { &IBMPlexMono_SemiBold37pt7b, 37, "IBMPlexMono_SemiBold37pt7b" },
  { &IBMPlexMono_SemiBold38pt7b, 38, "IBMPlexMono_SemiBold38pt7b" },
  { &IBMPlexMono_SemiBold39pt7b, 39, "IBMPlexMono_SemiBold39pt7b" },
  { &IBMPlexMono_SemiBold40pt7b, 40, "IBMPlexMono_SemiBold40pt7b" },
  { &IBMPlexMono_SemiBold41pt7b, 41, "IBMPlexMono_SemiBold41pt7b" },
  { &IBMPlexMono_SemiBold42pt7b, 42, "IBMPlexMono_SemiBold42pt7b" },
  { &IBMPlexMono_SemiBold43pt7b, 43, "IBMPlexMono_SemiBold43pt7b" },
  { &IBMPlexMono_SemiBold44pt7b, 44, "IBMPlexMono_SemiBold44pt7b" },
  { &IBMPlexMono_SemiBold45pt7b, 45, "IBMPlexMono_SemiBold45pt7b" },
  { &IBMPlexMono_SemiBold46pt7b, 46, "IBMPlexMono_SemiBold46pt7b" },
  { &IBMPlexMono_SemiBold47pt7b, 47, "IBMPlexMono_SemiBold47pt7b" },
  { &IBMPlexMono_SemiBold48pt7b, 48, "IBMPlexMono_SemiBold48pt7b" },
  { &IBMPlexMono_SemiBold49pt7b, 49, "IBMPlexMono_SemiBold49pt7b" },
  { &IBMPlexMono_SemiBold50pt7b, 50, "IBMPlexMono_SemiBold50pt7b" },
  { &IBMPlexMono_SemiBold51pt7b, 51, "IBMPlexMono_SemiBold51pt7b" },
  { &IBMPlexMono_SemiBold52pt7b, 52, "IBMPlexMono_SemiBold52pt7b" },
  { &IBMPlexMono_SemiBold53pt7b, 53, "IBMPlexMono_SemiBold53pt7b" },
  { &IBMPlexMono_SemiBold54pt7b, 54, "IBMPlexMono_SemiBold54pt7b" },
  { &IBMPlexMono_SemiBold55pt7b, 55, "IBMPlexMono_SemiBold55pt7b" },
  { &IBMPlexMono_SemiBold56pt7b, 56, "IBMPlexMono_SemiBold56pt7b" },
  { &IBMPlexMono_SemiBold57pt7b, 57, "IBMPlexMono_SemiBold57pt7b" },
  { &IBMPlexMono_SemiBold58pt7b, 58, "IBMPlexMono_SemiBold58pt7b" },
  { &IBMPlexMono_SemiBold59pt7b, 59, "IBMPlexMono_SemiBold59pt7b" },
  { &IBMPlexMono_SemiBold60pt7b, 60, "IBMPlexMono_SemiBold60pt7b" },
  { &IBMPlexMono_SemiBold61pt7b, 61, "IBMPlexMono_SemiBold61pt7b" },
  { &IBMPlexMono_SemiBold62pt7b, 62, "IBMPlexMono_SemiBold62pt7b" },
  { &IBMPlexMono_SemiBold63pt7b, 63, "IBMPlexMono_SemiBold63pt7b" },
  { &IBMPlexMono_SemiBold64pt7b, 64, "IBMPlexMono_SemiBold64pt7b" },
  { &IBMPlexMono_SemiBold65pt7b, 65, "IBMPlexMono_SemiBold65pt7b" },
  { &IBMPlexMono_SemiBold66pt7b, 66, "IBMPlexMono_SemiBold66pt7b" },
  { &IBMPlexMono_SemiBold67pt7b, 67, "IBMPlexMono_SemiBold67pt7b" },
  { &IBMPlexMono_SemiBold68pt7b, 68, "IBMPlexMono_SemiBold68pt7b" },
  { &IBMPlexMono_SemiBold69pt7b, 69, "IBMPlexMono_SemiBold69pt7b" },
  { &IBMPlexMono_SemiBold70pt7b, 70, "IBMPlexMono_SemiBold70pt7b" },
  { &IBMPlexMono_SemiBold71pt7b, 71, "IBMPlexMono_SemiBold71pt7b" },
  { &IBMPlexMono_SemiBold72pt7b, 72, "IBMPlexMono_SemiBold72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
