#ifndef _IBMPLEXMONO_SEMIBOLD26PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xC6, 0x31, 0x88, 0x00, 0x3F, 0xFF, 0x7B,
  0xC0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x63, 0x0F, 0xC7, 0xDF, 0x9F, 0xBF, 0x3F,
  0x0E, 0x70, 0x1C, 0xE3, 0xF1, 0xF7, 0xE7, 0xEF, 0xCF, 0xC3, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x18, 0xC0, 0x73, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xE7, 0xB7, 0x9C, 0xC4, 0x73, 0x01, 0xEC,
  0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x33, 0xC0, 0xCF, 0x63,
  0x3F, 0xCD, 0xEF, 0xFF, 0x9F, 0xFC, 0x1F, 0xC0, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x3C, 0x06, 0xFC, 0x1D, 0xFC, 0x37, 0x18, 0xEE, 0x31, 0x9C, 0x67,
  0x1F, 0xCC, 0x3F, 0xB8, 0x3C, 0x00, 0x00, 0xF0, 0x3B, 0xF0, 0xE7, 0xF1,
  0xDC, 0x67, 0x38, 0xCE, 0x71, 0xB8, 0x7F, 0x70, 0xFD, 0xC0, 0xF0, 0x0F,
  0x80, 0x3F, 0x80, 0xFF, 0x81, 0xC7, 0x83, 0x84, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x0F, 0x1F, 0x1E, 0x7F, 0x7D, 0xFE, 0xE3, 0x9F, 0xCF, 0x1F, 0x9E,
  0x1E, 0x1C, 0x3E, 0x3F, 0xDC, 0x3F, 0x9C, 0x3E, 0x3C, 0xFF, 0xFF, 0xFF,
  0x07, 0x87, 0x07, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xF0, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x06,
  0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81,
  0xC1, 0xC0, 0xC0, 0xE0, 0xE1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x21,
  0xC2, 0xF7, 0x7B, 0xFF, 0xF3, 0xFF, 0x01, 0xE0, 0x0F, 0xC0, 0x77, 0x83,
  0xCE, 0x0E, 0x1C, 0x50, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x7D, 0xE7, 0xBC, 0xF3, 0x8E, 0x30, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0,
  0xEE, 0x03, 0xB8, 0x0F, 0xE7, 0x3F, 0x9C, 0xFE, 0x73, 0xF8, 0x0E, 0xF0,
  0x39, 0xC0, 0xE7, 0x87, 0x9F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x7B, 0xC3, 0xCF, 0x06, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1,
  0xFF, 0x07, 0x90, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0,
  0x0F, 0xC1, 0xFF, 0x1F, 0xFD, 0xE1, 0xF2, 0x07, 0x80, 0x3C, 0x03, 0xC1,
  0xFC, 0x0F, 0xC0, 0x7F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xB0, 0x3F, 0xC3,
  0xEF, 0xFE, 0x3F, 0xE0, 0xFC, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x86,
  0x0E, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x3F, 0xF1, 0xFF, 0x9F, 0xFC, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xCF, 0x0E, 0xFE, 0x7F, 0xFB, 0xC3, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x98,
  0x1F, 0xE1, 0xEF, 0xFE, 0x3F, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0xBE, 0x1D, 0xFC, 0xFF, 0xFB,
  0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x39, 0xC0, 0xE7, 0x87, 0x9F, 0xFC,
  0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x07,
  0xF0, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x87, 0x0F, 0xF8,
  0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x87,
  0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x7B, 0xFD, 0xCF, 0xFE,
  0x3E, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x0F, 0x81, 0xF8, 0x00,
  0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xBC, 0x7B, 0xEF, 0xBE,
  0x78, 0x00, 0x00, 0x00, 0x07, 0xDE, 0x7B, 0xCF, 0x38, 0xE3, 0x00, 0x00,
  0x20, 0x0C, 0x07, 0x83, 0xF1, 0xF8, 0xFC, 0x3E, 0x07, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x78, 0x07, 0x01, 0xE0, 0xF8, 0x7E, 0x3F,
  0x0F, 0x81, 0xC0, 0x20, 0x00, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x1E, 0xE0,
  0xF0, 0x0E, 0x00, 0xE0, 0x7C, 0x0F, 0x80, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x0F, 0xC0, 0xFF, 0x0F,
  0xFC, 0xF0, 0xF7, 0x03, 0xB1, 0xEF, 0x9F, 0x7C, 0xFF, 0xE7, 0x3F, 0x30,
  0xF9, 0x87, 0xCC, 0x3E, 0x71, 0xF3, 0xFF, 0x9F, 0x6C, 0x7B, 0x70, 0x03,
  0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xEE, 0x01, 0xDE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x78,
  0x38, 0xF0, 0xF0, 0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x9E, 0x07, 0x3C,
  0x0F, 0x70, 0x1F, 0xE0, 0x1C, 0xFF, 0x8F, 0xFE, 0xFF, 0xEE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xEF, 0xFC, 0xFF, 0xCF, 0xFE, 0xE0, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x0F, 0xC0, 0xFF, 0x0F,
  0xFC, 0xF0, 0xF7, 0x83, 0xB8, 0x1B, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x03, 0x3C, 0x1D, 0xE1, 0xE7, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF9, 0xC3, 0xCE, 0x0F, 0x70, 0x3B,
  0x81, 0xDC, 0x0E, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x7B, 0x87, 0xDF, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFE, 0xFF,
  0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07, 0xF8, 0x1B,
  0xC0, 0x1E, 0x00, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE0, 0x7F, 0x03, 0xB8,
  0x1D, 0xE1, 0xEF, 0xFF, 0x3F, 0xB8, 0xF9, 0xC0, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x20, 0x7F, 0x0F, 0x78,
  0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xE0, 0x7B, 0x83, 0xCE, 0x1E, 0x38, 0x78,
  0xE3, 0xC3, 0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3C, 0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0x7B, 0x81,
  0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF9, 0xFF, 0xCF, 0xF6, 0xFF,
  0xBF, 0xFD, 0xF7, 0xE7, 0xBF, 0x39, 0xF8, 0xCF, 0xC6, 0x7E, 0x23, 0xF1,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0xF0, 0x7F, 0x07, 0xF8,
  0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFC, 0x7E, 0xE7, 0xEE, 0x7E, 0x67, 0xE7,
  0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0x0F,
  0xC0, 0xFF, 0x87, 0xFF, 0x1E, 0x1E, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xBC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x39, 0xC1, 0xE7,
  0x87, 0x9F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0xCF, 0xFE, 0xFF, 0xFE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xCE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xC0,
  0xFF, 0x87, 0xFF, 0x1E, 0x1E, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xBC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC1, 0xE7, 0x87,
  0x9F, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x1E, 0xFF, 0xF7, 0xFF, 0x3F, 0xE1, 0xC7, 0x0E, 0x3C,
  0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0xF7, 0x03, 0xC0, 0x0F, 0xC1, 0xFF,
  0x9F, 0xFE, 0xF0, 0xE7, 0x02, 0x38, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7E, 0x00, 0x70, 0x03, 0xB0, 0x1F, 0xC1, 0xFF, 0xFE, 0x3F,
  0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF, 0xFE, 0x7F,
  0xE1, 0xF8, 0xF0, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC0, 0xE3, 0x83, 0xC7,
  0x87, 0x8F, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0x73,
  0x80, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x3C, 0xEE, 0x79, 0xDC,
  0xF3, 0xB9, 0xE7, 0x77, 0xCE, 0xED, 0x99, 0xDB, 0xB3, 0xB7, 0x67, 0x66,
  0xCE, 0xCD, 0x9F, 0x9F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x78, 0x1E,
  0x70, 0x78, 0xF0, 0xF0, 0xE3, 0xC1, 0xE7, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x81, 0xEF, 0x03, 0x8F,
  0x0F, 0x1E, 0x1C, 0x1E, 0x78, 0x1D, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x3D,
  0xE0, 0xF1, 0xE1, 0xE1, 0xC7, 0x83, 0xCF, 0x03, 0x9C, 0x07, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0x70, 0x1C, 0xE0,
  0xE3, 0x83, 0x87, 0x1C, 0x1C, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xD0, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0x9C, 0x73, 0x8C, 0x0F, 0x80, 0xFF,
  0x87, 0xFF, 0x1C, 0x3C, 0x20, 0x70, 0x01, 0xC1, 0xFF, 0x1F, 0xFC, 0x70,
  0x73, 0xC3, 0xC7, 0xFF, 0xDF, 0xDF, 0x3E, 0x3C, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xFF, 0xFE, 0xFE, 0xE7,
  0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x4E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x4F, 0x0F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x79, 0xE7, 0xFF, 0x7F, 0xFB,
  0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xEF, 0x0F, 0x7F,
  0xF9, 0xFF, 0xC7, 0x9E, 0x0F, 0xC1, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0xC1, 0x0F, 0xFE, 0x7F, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x83, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x87, 0x1C, 0x1C, 0x78, 0x71, 0xFF,
  0xC3, 0xFE, 0x07, 0xF0, 0x70, 0x01, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x60,
  0x1F, 0xC0, 0xFF, 0xFF, 0xDF, 0xFE, 0x3F, 0xE0, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0xCE, 0xFE, 0xEF, 0xEF, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xF0, 0x0E, 0x03, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x0F,
  0xFB, 0xFE, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xBF, 0xEF, 0xFB, 0xFC, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFC, 0x3C, 0xE3,
  0xC7, 0x3C, 0x3B, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC3, 0x8F, 0x1C, 0x3C,
  0xE1, 0xE7, 0x07, 0xB8, 0x1E, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEE, 0x73,
  0xF9, 0xEF, 0xFF, 0xB9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7,
  0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1C, 0xE7, 0xCE, 0xFE,
  0xEF, 0xEF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF0, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0xC3, 0xDF, 0xFC, 0x7F,
  0xC0, 0xFC, 0x00, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0F, 0xFF, 0xFE, 0xFE, 0xE7, 0xCE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x79, 0xFF, 0xDF, 0xFE, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7B, 0xC3, 0xDF, 0xFE,
  0x7F, 0xF1, 0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0xFE, 0x7F, 0xF7, 0xFF, 0xFE, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xC1,
  0xFF, 0x9F, 0xFE, 0xF0, 0x47, 0x80, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0x00,
  0x79, 0x83, 0xFF, 0xFC, 0xFF, 0xE1, 0xFC, 0x00, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFF, 0xF7, 0xEF, 0x3C, 0xF0, 0xF0, 0x3D,
  0xC0, 0xE7, 0x07, 0x9E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0xCE, 0x07, 0x38,
  0x1D, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0xE3, 0x86, 0xC7,
  0x9D, 0x8F, 0x3B, 0x9E, 0x77, 0x3C, 0xEE, 0xD9, 0xDD, 0xB3, 0x3B, 0x36,
  0x76, 0x6C, 0x6C, 0xD8, 0xD9, 0xF1, 0xE3, 0xE3, 0xC7, 0xC0, 0xF0, 0x39,
  0xE1, 0xC3, 0xCF, 0x07, 0x78, 0x1F, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0x77, 0x83, 0x8F, 0x1E, 0x1E, 0xF0, 0x3C, 0xE0, 0x3F, 0xC0,
  0xE7, 0x03, 0x9E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0xCE, 0x07, 0x38, 0x1D,
  0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE1, 0xFC, 0x3F, 0x86, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0xF3, 0xFC, 0x7E, 0x0F, 0xF0, 0x0E, 0x00, 0xE0, 0x18, 0x07,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xC3, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xE3, 0xFC, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x3F, 0x81, 0xF0,
  0xFE, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x71,
  0xFE, 0x3F, 0xC7, 0xF0, 0x1C, 0x18, 0xF8, 0x77, 0xF1, 0x99, 0xEE, 0xE3,
  0xFB, 0x8F, 0xCE, 0x0E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 18, 16, 5, -18 },
  { 13, 8, 8, 16, 4, -19 },
  { 21, 15, 18, 16, 0, -18 },
  { 55, 14, 24, 16, 1, -21 },
  { 97, 15, 18, 16, 0, -18 },
  { 131, 15, 18, 16, 0, -18 },
  { 165, 3, 8, 16, 6, -19 },
  { 168, 9, 24, 16, 5, -20 },
  { 195, 9, 24, 16, 2, -20 },
  { 222, 14, 13, 16, 1, -14 },
  { 245, 12, 13, 16, 2, -14 },
  { 265, 6, 8, 16, 5, -4 },
  { 271, 8, 3, 16, 4, -9 },
  { 274, 5, 5, 16, 5, -5 },
  { 278, 12, 24, 16, 2, -20 },
  { 314, 14, 18, 16, 1, -18 },
  { 346, 14, 18, 16, 1, -18 },
  { 378, 13, 18, 16, 1, -18 },
  { 408, 13, 18, 16, 1, -18 },
  { 438, 14, 18, 16, 1, -18 },
  { 470, 13, 18, 16, 1, -18 },
  { 500, 14, 18, 16, 1, -18 },
  { 532, 13, 18, 16, 1, -18 },
  { 562, 14, 18, 16, 1, -18 },
  { 594, 13, 18, 16, 1, -18 },
  { 624, 5, 14, 16, 5, -14 },
  { 633, 6, 18, 16, 5, -14 },
  { 647, 11, 15, 16, 2, -15 },
  { 668, 12, 8, 16, 2, -12 },
  { 680, 11, 15, 16, 2, -15 },
  { 701, 12, 18, 16, 2, -18 },
  { 728, 13, 21, 16, 1, -18 },
  { 763, 15, 18, 16, 0, -18 },
  { 797, 12, 18, 16, 2, -18 },
  { 824, 13, 18, 16, 1, -18 },
  { 854, 13, 18, 16, 2, -18 },
  { 884, 12, 18, 16, 2, -18 },
  { 911, 12, 18, 16, 2, -18 },
  { 938, 13, 18, 16, 1, -18 },
  { 968, 12, 18, 16, 2, -18 },
  { 995, 12, 18, 16, 2, -18 },
  { 1022, 12, 18, 16, 1, -18 },
  { 1049, 14, 18, 16, 2, -18 },
  { 1081, 11, 18, 16, 3, -18 },
  { 1106, 13, 18, 16, 1, -18 },
  { 1136, 12, 18, 16, 2, -18 },
  { 1163, 14, 18, 16, 1, -18 },
  { 1195, 12, 18, 16, 2, -18 },
  { 1222, 14, 23, 16, 1, -18 },
  { 1263, 13, 18, 16, 2, -18 },
  { 1293, 13, 18, 16, 1, -18 },
  { 1323, 14, 18, 16, 1, -18 },
  { 1355, 12, 18, 16, 2, -18 },
  { 1382, 15, 18, 16, 0, -18 },
  { 1416, 15, 18, 16, 0, -18 },
  { 1450, 15, 18, 16, 0, -18 },
  { 1484, 15, 18, 16, 0, -18 },
  { 1518, 13, 18, 16, 1, -18 },
  { 1548, 8, 24, 16, 5, -20 },
  { 1572, 12, 24, 16, 2, -20 },
  { 1608, 9, 24, 16, 2, -20 },
  { 1635, 14, 12, 16, 1, -18 },
  { 1656, 12, 3, 16, 2, 2 },
  { 1661, 5, 6, 16, 4, -21 },
  { 1665, 14, 13, 16, 1, -13 },
  { 1688, 12, 19, 16, 2, -19 },
  { 1717, 12, 13, 16, 2, -13 },
  { 1737, 13, 19, 16, 1, -19 },
  { 1768, 13, 13, 16, 1, -13 },
  { 1790, 12, 19, 16, 2, -19 },
  { 1819, 14, 21, 16, 1, -16 },
  { 1856, 12, 19, 16, 2, -19 },
  { 1885, 11, 19, 16, 3, -19 },
  { 1912, 10, 24, 16, 2, -19 },
  { 1942, 13, 19, 16, 2, -19 },
  { 1973, 12, 19, 16, 2, -19 },
  { 2002, 14, 13, 16, 1, -13 },
  { 2025, 12, 13, 16, 2, -13 },
  { 2045, 13, 13, 16, 1, -13 },
  { 2067, 12, 18, 16, 2, -13 },
  { 2094, 13, 18, 16, 1, -13 },
  { 2124, 13, 13, 16, 2, -13 },
  { 2146, 13, 13, 16, 1, -13 },
  { 2168, 13, 18, 16, 1, -18 },
  { 2198, 12, 13, 16, 2, -13 },
  { 2218, 14, 13, 16, 1, -13 },
  { 2241, 15, 13, 16, 0, -13 },
  { 2266, 14, 13, 16, 1, -13 },
  { 2289, 14, 18, 16, 1, -13 },
  { 2321, 12, 13, 16, 2, -13 },
  { 2341, 11, 24, 16, 2, -20 },
  { 2374, 3, 24, 16, 6, -20 },
  { 2383, 11, 24, 16, 2, -20 },
  { 2416, 14, 7, 16, 1, -11 },
};

const GFXfont IBMPlexMono_SemiBold26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_SEMIBOLD26PT7B_H_
