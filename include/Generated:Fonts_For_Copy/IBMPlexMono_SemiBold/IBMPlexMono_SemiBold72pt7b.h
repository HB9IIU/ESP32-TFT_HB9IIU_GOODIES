#ifndef _IBMPLEXMONO_SEMIBOLD72PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold72pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0x87, 0xF0,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0x3F, 0x3F,
  0xF8, 0x3F, 0xF0, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xF0, 0x3E, 0x07, 0xFE,
  0x0F, 0xC0, 0x70, 0x1F, 0xF0, 0x3F, 0x00, 0x80, 0x7F, 0xC0, 0xFC, 0x00,
  0x01, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x3F, 0x00, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x00,
  0x03, 0xFF, 0x8F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xFF, 0xC0, 0x00, 0x0F,
  0xC3, 0xFF, 0x80, 0x00, 0x3F, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F,
  0x01, 0xFF, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x10, 0x03, 0xF0, 0x1F, 0xE0,
  0xE0, 0x0F, 0xC0, 0xFF, 0x87, 0xC0, 0x3F, 0x03, 0xFE, 0x3F, 0x80, 0xFC,
  0x1F, 0xF9, 0xFF, 0x83, 0xF0, 0xFF, 0xCF, 0xFF, 0xCF, 0xCF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0x80,
  0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0x03, 0xFF,
  0xFF, 0x83, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xC3, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0x80,
  0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xE1,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0x81, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x40, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFC, 0xFF, 0x83, 0xFF, 0xC3, 0xFE, 0x3F, 0xF0, 0xFE, 0x01, 0xFF, 0x07,
  0xFE, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x8F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF3,
  0xF8, 0x07, 0xF8, 0x03, 0xFE, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xBF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x30, 0xF8, 0x03, 0xFC, 0x03,
  0xE1, 0xFE, 0x07, 0xF8, 0x1F, 0xC3, 0xFF, 0x0F, 0xF1, 0xFF, 0x8F, 0xFF,
  0xDF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC1,
  0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x03, 0xE0,
  0x3F, 0xEF, 0xF8, 0x1F, 0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF,
  0x83, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F,
  0xF9, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x01,
  0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xC0,
  0x00, 0x3F, 0xF0, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x00,
  0x7F, 0xE0, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x40, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x81, 0x00, 0x00,
  0x0F, 0xFC, 0x1C, 0x00, 0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x03, 0xFF, 0x1F,
  0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFF, 0xF0,
  0x03, 0xF8, 0x7F, 0xFF, 0x80, 0x3F, 0x8F, 0xFF, 0xFE, 0x03, 0xF9, 0xFF,
  0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xFF, 0x83, 0xFB, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF,
  0xE7, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x02, 0x00, 0x00, 0x3F, 0xF0, 0x60, 0x00,
  0x03, 0xFF, 0x1F, 0x00, 0x00, 0x7F, 0xE3, 0xF8, 0x00, 0x07, 0xFE, 0x7F,
  0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFC, 0x07, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0xE3, 0xFF, 0xFC, 0x03, 0xFE, 0x3F,
  0xFF, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xFF, 0xFF, 0x0F,
  0xFB, 0xFF, 0xFF, 0xFC, 0x7F, 0xDF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F,
  0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x7F, 0xEF, 0xF0, 0x00, 0x0F, 0xFD, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF,
  0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xFC, 0xFF,
  0x80, 0x7F, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xFC, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF9, 0xFF, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x1F,
  0xF0, 0x78, 0x00, 0x0F, 0xFC, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0x87, 0xF7, 0xF8, 0x07, 0xFC, 0x7F, 0x7F, 0x00, 0xFF, 0xE7, 0xF7, 0xF0,
  0x1F, 0xFF, 0x7F, 0x7F, 0x01, 0xFF, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFF,
  0x7F, 0x03, 0xFE, 0x1F, 0xF7, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x07, 0xF8,
  0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xF0,
  0x7F, 0x00, 0x7F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x7F,
  0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0x07, 0xF0,
  0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xF0,
  0x7F, 0x00, 0x7F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0x00, 0x7F,
  0x7F, 0x07, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0x80, 0xFF, 0x7F, 0x03, 0xFE,
  0x1F, 0xF7, 0xF0, 0x3F, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xF7, 0xF7, 0xF0,
  0x1F, 0xFF, 0x7F, 0x7F, 0x00, 0xFF, 0xE7, 0xF3, 0xF8, 0x07, 0xFC, 0x7F,
  0x3F, 0x80, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xF8, 0xFF,
  0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF,
  0xCF, 0xF8, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x80, 0x0F, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xEF,
  0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x01, 0xC0, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1C, 0x07, 0xFE, 0x00, 0x01,
  0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xE3,
  0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x0F,
  0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xFC, 0xFF,
  0xC0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x3F, 0x87, 0xFE, 0x00, 0x01, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00,
  0x1F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF,
  0x80, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0xFF, 0xFF,
  0xDF, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F,
  0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x07,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x07,
  0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF3, 0xFF, 0x00, 0x0F, 0xFF, 0x8F,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF,
  0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xBF, 0xC3, 0xFB, 0xFF, 0xFC, 0xFE,
  0x1F, 0xDF, 0xFF, 0xE7, 0xF9, 0xFC, 0xFF, 0xFF, 0x3F, 0xCF, 0xE7, 0xFF,
  0xF8, 0xFE, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0xF8,
  0x07, 0xFF, 0xFC, 0x03, 0x80, 0x3F, 0xFF, 0xE0, 0x1C, 0x01, 0xFF, 0xFF,
  0x00, 0x60, 0x0F, 0xFF, 0xF8, 0x02, 0x00, 0x7F, 0xFF, 0xC0, 0x10, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFD, 0xFE, 0x01, 0xFF, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF,
  0xCF, 0xF0, 0x1F, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0xF1, 0xFE, 0x07, 0xFF,
  0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0xC1, 0xFE, 0x1F,
  0xFF, 0xE0, 0x7F, 0x8F, 0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0xF8, 0x1F, 0xE3,
  0xFF, 0xFC, 0x07, 0xF9, 0xFF, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0x01, 0xFE,
  0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF, 0xE0, 0x1F,
  0xEF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x83,
  0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFE, 0xFF,
  0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00,
  0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F,
  0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x7F,
  0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xE0, 0x00,
  0xFF, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x80, 0x07, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x07,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x00,
  0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07, 0xFE, 0xFF,
  0x80, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x07,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xDF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x01, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x7F, 0xE0, 0x00, 0x0E, 0x03,
  0xFE, 0x00, 0x00, 0x20, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x30, 0x00, 0x00, 0x7F, 0xE3, 0xC0, 0x00, 0x03, 0xFE, 0x3F, 0x00, 0x00,
  0x3F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xFD, 0xFF,
  0xF8, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xF3,
  0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xFC, 0x07, 0xF9, 0xFE, 0x03,
  0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0x81, 0xFE, 0x7F, 0x80, 0xFF, 0xC0,
  0xFF, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x3F, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xFE, 0x0F, 0xF1, 0xFE, 0x0F,
  0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xDF, 0x83, 0xF8, 0x7F, 0x87, 0xEF, 0xC1,
  0xFC, 0x3F, 0xC3, 0xF7, 0xE0, 0xFE, 0x1F, 0xE1, 0xFB, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFC, 0xFC, 0x3F, 0x87, 0xF8, 0x7C, 0x7E, 0x1F, 0xC3, 0xFC, 0x7E,
  0x3F, 0x1F, 0xE1, 0xFE, 0x3F, 0x1F, 0x8F, 0xF0, 0xFF, 0x1F, 0x8F, 0xC7,
  0xF8, 0x7F, 0x8F, 0xC7, 0xF3, 0xFC, 0x3F, 0xC7, 0xE1, 0xF9, 0xFE, 0x0F,
  0xE3, 0xF0, 0xFC, 0xFF, 0x07, 0xF3, 0xF0, 0x7E, 0x7F, 0x83, 0xF9, 0xF8,
  0x3F, 0x3F, 0xC1, 0xFC, 0xFC, 0x1F, 0x9F, 0xC0, 0xFE, 0x7E, 0x0F, 0xEF,
  0xE0, 0x7F, 0xBF, 0x03, 0xF7, 0xF0, 0x3F, 0xDF, 0x81, 0xFB, 0xF8, 0x1F,
  0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x8F, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x07,
  0xFD, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x3C, 0x03, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x07,
  0xFF, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0x00, 0xFF, 0xC0, 0x04,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xDF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0x83,
  0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF0, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF,
  0x0F, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0x7F, 0xFF, 0xFE, 0x3F, 0xEF, 0x03,
  0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x1F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xEF, 0x03, 0xFF, 0xE7, 0xFD,
  0xFF, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF, 0xC3,
  0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0x87, 0xFE, 0x00, 0x07, 0x81, 0xFF, 0x00, 0x01, 0x80, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0xC0, 0x7F, 0xE0, 0x00, 0x7C, 0x0F, 0xFC, 0x00,
  0x1F, 0xC3, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0x87, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xF3, 0xFE,
  0x3F, 0xFF, 0xFF, 0x7F, 0xCF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x01,
  0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF,
  0xFF, 0x3F, 0xE1, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x81,
  0xFF, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x04, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x7F, 0xE0, 0x00, 0x7C,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC0, 0x00, 0x0F, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0xFC, 0x3F, 0xF1, 0xFF, 0xFF, 0x1F,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xE7, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xCF, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0xE0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0x80, 0x03, 0xFF,
  0x8F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xF8, 0x00,
  0x0F, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x1F, 0x87, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0x8F, 0xFC, 0x3F, 0xF9,
  0xFC, 0xFF, 0xE3, 0xFF, 0xEF, 0xE7, 0xFF, 0x9F, 0xFF, 0x7F, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xFF,
  0x03, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0x00,
  0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x80,
  0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0x8F, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xC7, 0xFF,
  0xFE, 0x0F, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xEF,
  0xFF, 0xFF, 0xC7, 0xFD, 0xE0, 0x7F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0x9F,
  0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xE7,
  0xFD, 0xE0, 0x7F, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0x1F, 0xF3, 0xFF, 0xFF,
  0xE3, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFF,
  0x1F, 0xF0, 0xFF, 0xFF, 0xF3, 0xFE, 0x1F, 0xFF, 0xFE, 0x7F, 0xC7, 0xFF,
  0xFF, 0xEF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xE7,
  0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF9,
  0xFF, 0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xE7,
  0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0xEF, 0x80, 0x00,
  0x07, 0xFD, 0x80, 0x00, 0x00, 0xFF, 0xA0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x00,
  0xC0, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x10, 0x00, 0x01,
  0xFF, 0x0E, 0x00, 0x00, 0x7F, 0xCF, 0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xC3,
  0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xFE, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xFC, 0x07, 0xFB, 0xF8, 0x07,
  0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFF, 0x80,
  0xFE, 0x7F, 0x81, 0xFF, 0xC0, 0x7F, 0x3F, 0xC0, 0xFF, 0xF0, 0x3F, 0x9F,
  0xE0, 0x7D, 0xF8, 0x1F, 0xCF, 0xF0, 0x3E, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0x7E, 0x07, 0xF1, 0xFC, 0x1F, 0x9F, 0x07, 0xF0, 0xFE, 0x0F, 0xCF, 0x83,
  0xF8, 0x7F, 0x07, 0xC7, 0xC1, 0xFC, 0x3F, 0x83, 0xE3, 0xF0, 0xFE, 0x1F,
  0xC1, 0xF1, 0xF8, 0x7F, 0x0F, 0xF0, 0xF8, 0xFC, 0x3F, 0x83, 0xF8, 0xFC,
  0x7E, 0x1F, 0xC1, 0xFC, 0x7E, 0x1F, 0x0F, 0xE0, 0xFE, 0x3E, 0x0F, 0x87,
  0xE0, 0x7F, 0x1F, 0x07, 0xE7, 0xF0, 0x3F, 0x8F, 0x83, 0xF3, 0xF8, 0x1F,
  0xC7, 0xC1, 0xF9, 0xFC, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x07, 0xF3, 0xF0,
  0x3E, 0x7F, 0x01, 0xFD, 0xF0, 0x1F, 0x3F, 0x80, 0xFE, 0xF8, 0x0F, 0xDF,
  0xC0, 0x7F, 0x7C, 0x07, 0xEF, 0xC0, 0x3F, 0xBE, 0x03, 0xF7, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0xC3,
  0xFF, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xF8,
  0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0xF0, 0x00, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xF1, 0xFF, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0xFC,
  0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0xFF, 0x80, 0xFE, 0x3F,
  0x83, 0xFE, 0x0F, 0xF3, 0xF8, 0x0F, 0xF8, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF,
  0xF8, 0xFE, 0x01, 0xFF, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xFC, 0x7F, 0x00,
  0x1F, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0xC0,
  0x0E, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 13, 51, 43, 15, -50 },
  { 84, 23, 22, 43, 10, -53 },
  { 148, 41, 50, 43, 1, -50 },
  { 405, 38, 66, 43, 3, -58 },
  { 719, 43, 52, 43, 0, -51 },
  { 999, 42, 52, 43, 1, -51 },
  { 1272, 9, 22, 43, 17, -53 },
  { 1297, 24, 65, 43, 13, -55 },
  { 1492, 24, 65, 43, 6, -55 },
  { 1687, 39, 36, 43, 2, -40 },
  { 1863, 35, 35, 43, 4, -39 },
  { 2017, 16, 23, 43, 13, -12 },
  { 2063, 23, 8, 43, 10, -25 },
  { 2086, 14, 13, 43, 15, -12 },
  { 2109, 32, 65, 43, 6, -55 },
  { 2369, 38, 52, 43, 3, -51 },
  { 2616, 38, 50, 43, 3, -50 },
  { 2854, 37, 51, 43, 3, -51 },
  { 3090, 37, 52, 43, 2, -51 },
  { 3331, 39, 50, 43, 2, -50 },
  { 3575, 36, 51, 43, 4, -50 },
  { 3805, 37, 51, 43, 3, -50 },
  { 4041, 35, 50, 43, 4, -50 },
  { 4260, 37, 52, 43, 3, -51 },
  { 4501, 37, 51, 43, 3, -51 },
  { 4737, 14, 39, 43, 15, -38 },
  { 4806, 16, 49, 43, 13, -38 },
  { 4904, 31, 43, 43, 6, -43 },
  { 5071, 35, 22, 43, 4, -33 },
  { 5168, 31, 43, 43, 6, -43 },
  { 5335, 33, 52, 43, 5, -51 },
  { 5550, 36, 59, 43, 3, -51 },
  { 5816, 41, 50, 43, 1, -50 },
  { 6073, 34, 50, 43, 6, -50 },
  { 6286, 36, 52, 43, 4, -51 },
  { 6520, 35, 50, 43, 5, -50 },
  { 6739, 32, 50, 43, 6, -50 },
  { 6939, 33, 50, 43, 6, -50 },
  { 7146, 36, 52, 43, 3, -51 },
  { 7380, 33, 50, 43, 5, -50 },
  { 7587, 32, 50, 43, 6, -50 },
  { 7787, 32, 51, 43, 4, -50 },
  { 7991, 38, 50, 43, 5, -50 },
  { 8229, 32, 50, 43, 7, -50 },
  { 8429, 37, 50, 43, 3, -50 },
  { 8661, 33, 50, 43, 5, -50 },
  { 8868, 38, 52, 43, 3, -51 },
  { 9115, 34, 50, 43, 6, -50 },
  { 9328, 38, 65, 43, 3, -51 },
  { 9637, 35, 50, 43, 6, -50 },
  { 9856, 37, 52, 43, 3, -51 },
  { 10097, 39, 50, 43, 2, -50 },
  { 10341, 35, 51, 43, 4, -50 },
  { 10565, 41, 50, 43, 1, -50 },
  { 10822, 41, 50, 43, 1, -50 },
  { 11079, 41, 50, 43, 1, -50 },
  { 11336, 42, 50, 43, 1, -50 },
  { 11599, 37, 50, 43, 3, -50 },
  { 11831, 22, 65, 43, 14, -55 },
  { 12010, 32, 65, 43, 6, -55 },
  { 12270, 22, 65, 43, 7, -55 },
  { 12449, 39, 32, 43, 2, -50 },
  { 12605, 35, 8, 43, 4, 5 },
  { 12640, 14, 16, 43, 12, -57 },
  { 12668, 37, 39, 43, 4, -38 },
  { 12849, 35, 54, 43, 5, -53 },
  { 13086, 34, 39, 43, 5, -38 },
  { 13252, 35, 54, 43, 3, -53 },
  { 13489, 35, 39, 43, 4, -38 },
  { 13660, 35, 53, 43, 5, -53 },
  { 13892, 37, 59, 43, 4, -44 },
  { 14165, 33, 53, 43, 5, -53 },
  { 14384, 33, 54, 43, 7, -54 },
  { 14607, 26, 68, 43, 7, -54 },
  { 14828, 36, 53, 43, 6, -53 },
  { 15067, 33, 53, 43, 5, -53 },
  { 15286, 37, 38, 43, 3, -38 },
  { 15462, 33, 38, 43, 5, -38 },
  { 15619, 37, 39, 43, 3, -38 },
  { 15800, 35, 52, 43, 5, -38 },
  { 16028, 35, 52, 43, 3, -38 },
  { 16256, 35, 37, 43, 5, -37 },
  { 16418, 34, 39, 43, 4, -38 },
  { 16584, 35, 50, 43, 3, -50 },
  { 16803, 33, 38, 43, 5, -37 },
  { 16960, 37, 37, 43, 3, -37 },
  { 17132, 41, 37, 43, 1, -37 },
  { 17322, 39, 37, 43, 2, -37 },
  { 17503, 39, 51, 43, 2, -37 },
  { 17752, 33, 37, 43, 5, -37 },
  { 17905, 29, 65, 43, 7, -55 },
  { 18141, 8, 65, 43, 18, -55 },
  { 18206, 29, 65, 43, 7, -55 },
  { 18442, 37, 17, 43, 3, -31 },
};

const GFXfont IBMPlexMono_SemiBold72pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold72pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold72pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _IBMPLEXMONO_SEMIBOLD72PT7B_H_
