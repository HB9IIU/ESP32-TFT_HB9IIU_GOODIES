#ifndef _IBMPLEXMONO_SEMIBOLD28PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x79, 0xCE, 0x73, 0x98, 0x40, 0x00, 0x0E, 0xFF,
  0xFE, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0x80, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x38, 0x7F, 0x3F, 0x7F, 0x3F, 0x7E, 0x3F, 0x0E, 0x38, 0x0E, 0x30, 0xFE,
  0x7E, 0xFE, 0x7E, 0xFE, 0x7E, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7F,
  0x03, 0xFF, 0x8F, 0xFF, 0x9E, 0xEF, 0x39, 0xC4, 0x73, 0x80, 0xE7, 0x01,
  0xEE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xCF, 0x03,
  0x9E, 0x07, 0x3D, 0x8E, 0x7F, 0xDD, 0xE7, 0xFF, 0xC7, 0xFF, 0x03, 0xF8,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x03, 0xBF, 0x83, 0x9F, 0xE1,
  0x9C, 0x71, 0xCE, 0x38, 0xC7, 0x1C, 0xE3, 0x8E, 0x70, 0xFF, 0x70, 0x7F,
  0x38, 0x0F, 0x20, 0x00, 0x0F, 0x01, 0xCF, 0xC0, 0xEF, 0xF0, 0xE7, 0x18,
  0x73, 0x0C, 0x71, 0x86, 0x38, 0xE7, 0x38, 0x7F, 0x9C, 0x1F, 0x9C, 0x07,
  0x80, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0x8F, 0x03, 0x82, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x1F, 0x0F, 0x8F, 0x8F, 0xE7,
  0xCF, 0x7B, 0x87, 0x1D, 0xC3, 0x8F, 0xE3, 0xC3, 0xE0, 0xE0, 0xF0, 0x78,
  0x7C, 0x3F, 0xEF, 0x0F, 0xE3, 0x83, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xC3, 0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81,
  0xC0, 0xF0, 0xF8, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x07,
  0x39, 0xDF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x7B,
  0xC1, 0xE3, 0x83, 0x87, 0x83, 0x06, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x3D, 0xF7, 0x9E, 0x79, 0xCF, 0x38, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x83, 0xDE, 0x03,
  0xBC, 0x07, 0x78, 0x0F, 0xF3, 0x9F, 0xE7, 0x3F, 0xCE, 0x7F, 0x9C, 0xFF,
  0x01, 0xFE, 0x03, 0x9C, 0x07, 0x3C, 0x1E, 0x78, 0x7C, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xEF, 0x07, 0xDE,
  0x1F, 0x3C, 0x1C, 0x78, 0x30, 0xF0, 0x21, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x7F,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E,
  0xF0, 0x3C, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1F, 0x30,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF2, 0x03, 0xD8, 0x0F, 0xF8, 0x7D, 0xFF, 0xE3,
  0xFF, 0x03, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77,
  0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xC1, 0xC3,
  0x83, 0x8E, 0x07, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x39, 0xF0, 0x77, 0xF8, 0xFF, 0xF9,
  0xE1, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC8, 0x07, 0x18, 0x1E, 0xF8,
  0x7C, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0xF0, 0x7F, 0xF8,
  0xEF, 0xFB, 0xE1, 0xF7, 0xC1, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xB8,
  0x1E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x3B, 0x83, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xC1, 0xE7, 0x03, 0xCE, 0x03, 0x9C, 0x0F, 0x1C, 0x3C, 0x1F, 0xF0, 0x1F,
  0xC0, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0x78, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC3, 0xEF, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xF0,
  0x3C, 0xF0, 0xF9, 0xFF, 0x71, 0xFF, 0xE1, 0xF3, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x00, 0x77, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xC0, 0x39, 0xF7, 0xDF, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xDF, 0x79, 0xE7, 0x9C, 0xF3, 0x8E, 0x00, 0x00,
  0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x03, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x70, 0x0F, 0x03, 0xF0, 0xFC, 0x3F, 0x0F,
  0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xFD, 0xE1,
  0xEE, 0x07, 0x90, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xF0, 0x7F, 0x03, 0xE0,
  0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8E, 0x0F, 0x70, 0x1D,
  0xC0, 0x76, 0x1C, 0xF8, 0xFB, 0xE3, 0xFF, 0x9C, 0x7E, 0x70, 0xF9, 0xC3,
  0xE7, 0x0F, 0x9C, 0x7E, 0x7F, 0xD8, 0xFB, 0x61, 0xCD, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x0E, 0x78,
  0x0E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x38, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F,
  0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x1E, 0xFF, 0xE7, 0xFE, 0x3F, 0xFD, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x81, 0xCF, 0x03, 0xDC, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x07, 0x3C, 0x0F, 0x3C, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x03, 0xBC,
  0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78,
  0x3D, 0xC0, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDE, 0x0F, 0x7C, 0x7C, 0xFF, 0x73,
  0xFD, 0xC3, 0xC7, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0xC1, 0xFE, 0x0F, 0x78,
  0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x80, 0xF0, 0x3D, 0xE0, 0xF3, 0xC3, 0xE7,
  0x87, 0x8F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFF,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xBE, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0x79, 0xE0, 0xF3, 0xC0, 0xF7, 0x81, 0xF0, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xBB,
  0xFE, 0xEF, 0xF9, 0xF7, 0xE7, 0xDF, 0xDE, 0x7F, 0x39, 0xFC, 0xE7, 0xF3,
  0x1F, 0xC4, 0x7F, 0x11, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xB8,
  0xFD, 0xC7, 0xEE, 0x3F, 0x39, 0xF9, 0xCF, 0xCE, 0x7E, 0x3B, 0xF1, 0xDF,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xF0, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0x78,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0x9C, 0x07, 0x3C, 0x1E, 0x7C, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00,
  0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03,
  0xFC, 0x0E, 0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07,
  0x78, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0x3C, 0x1E, 0x7C, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0E,
  0xF0, 0x7B, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0, 0xF3, 0xC3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0x0F, 0xE0, 0x7F,
  0xE3, 0xFF, 0xDF, 0x0F, 0x78, 0x09, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7F,
  0xC0, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xD8,
  0x0F, 0xF8, 0x7D, 0xFF, 0xE3, 0xFF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF8, 0xFB, 0xFF, 0x9F, 0xF8, 0x3F, 0x80, 0xF8, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x78, 0x0F, 0x78, 0x0F,
  0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0xF0,
  0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x71, 0xC7, 0x73,
  0xC7, 0x73, 0xE7, 0x73, 0xE7, 0x73, 0x67, 0x73, 0x67, 0x73, 0x67, 0x77,
  0x66, 0x77, 0x76, 0x76, 0x7E, 0x36, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x78, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C, 0x1E,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xBC, 0x07, 0x9E,
  0x07, 0x87, 0x83, 0xC3, 0xC3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x1E, 0xF0,
  0x0F, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0xFF,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xEF, 0x03, 0x8E, 0x0F,
  0x1E, 0x1C, 0x1C, 0x78, 0x3C, 0xE0, 0x3B, 0xC0, 0x7B, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x67, 0x3C, 0xE3, 0x88, 0x1F, 0x81, 0xFF, 0x8F,
  0xFF, 0x3C, 0x3C, 0x40, 0xF0, 0x01, 0xC3, 0xFF, 0x1F, 0xFC, 0xF0, 0x73,
  0x83, 0xCF, 0x0F, 0x3F, 0xFF, 0xFF, 0x7C, 0xF8, 0xF0, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF0, 0xFF,
  0xF3, 0xFF, 0xEF, 0x0F, 0xBC, 0x1E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFC,
  0x0E, 0xF0, 0x7B, 0xC3, 0xEF, 0xFF, 0xBF, 0xFC, 0xF3, 0xC0, 0x0F, 0xC1,
  0xFF, 0x1F, 0xFC, 0xF0, 0xFF, 0x02, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x81, 0x1E, 0x1E, 0xFF, 0xE3, 0xFE, 0x07, 0xE0, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xCF, 0x3F,
  0xBD, 0xFF, 0xF7, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x0F, 0x81,
  0xFF, 0x1F, 0xFD, 0xE1, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x3C, 0x08, 0xFF, 0xF3, 0xFF, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x1E, 0x1E, 0x3C, 0x1C, 0x78,
  0x38, 0xF0, 0xF0, 0xFF, 0xE0, 0xFF, 0x81, 0xFC, 0x06, 0x00, 0x1C, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFD, 0xC0, 0x3F, 0x80, 0xF7, 0xFF, 0xEF,
  0xFF, 0x87, 0xFC, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x78, 0xF7, 0xF7, 0xFF, 0xBE, 0x3F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0x80, 0x07, 0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0x81, 0xF0, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0xFF, 0xBF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xFF, 0xBF, 0xEF, 0xF0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x1F, 0xF0, 0xF3, 0xC7, 0x8F, 0x3C, 0x3D, 0xE0, 0xFF, 0x03, 0xFE,
  0x0F, 0xFC, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0x3C, 0x1E, 0xF0,
  0x3C, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xEE, 0x39, 0xDE, 0xFB, 0xFD, 0xFF, 0x1C, 0xFE, 0x38, 0xFC, 0x71, 0xF8,
  0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38,
  0xFC, 0x71, 0xC0, 0xF3, 0xC7, 0xBF, 0xBF, 0xFD, 0xF1, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3C, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1F, 0x70, 0x3F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x87, 0xCF, 0xFE, 0x1F,
  0xF0, 0x3F, 0x00, 0xF3, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x3E, 0xF0, 0x7B,
  0xC0, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x0F, 0xBF, 0xFE,
  0xFF, 0xF3, 0xCF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x87, 0xDF, 0xFF, 0x3F,
  0xBC, 0x7C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xC3, 0xA0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x9F, 0xFF, 0xE0, 0x4F, 0x00, 0x7F, 0xC1,
  0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x03, 0xD8, 0x1F, 0xFF, 0xE7, 0xFE, 0x0F,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xFF, 0xF7, 0xF7, 0x9F, 0x3C, 0xF0,
  0x1E, 0xE0, 0x39, 0xE0, 0xF3, 0xC1, 0xC3, 0x83, 0x87, 0x8F, 0x0F, 0x1C,
  0x0E, 0x38, 0x1E, 0xF0, 0x1D, 0xC0, 0x3B, 0x80, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xE1, 0xC7, 0x71, 0xC7, 0x73, 0xE7, 0x73, 0xE7, 0x73, 0x67,
  0x73, 0x67, 0x73, 0x67, 0x77, 0x66, 0x37, 0x76, 0x36, 0x7E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0xF8, 0x3E, 0xF0, 0x70, 0xF1, 0xE0,
  0xF7, 0x80, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3D,
  0xE0, 0x73, 0xC1, 0xE3, 0xC7, 0x83, 0xDE, 0x07, 0xC0, 0xF0, 0x1F, 0xE0,
  0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x0F, 0x1C, 0x0E, 0x38,
  0x1E, 0xF0, 0x1D, 0xC0, 0x3B, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE3,
  0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x1C, 0x7F, 0x8F, 0x81, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xE3, 0xFC, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x0F, 0xF0,
  0x3E, 0x3F, 0xC7, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x0E, 0x3F, 0xC7, 0xF8, 0xFE, 0x00, 0x1E, 0x0E, 0x7E, 0x1D, 0xFE, 0x73,
  0xBC, 0xEE, 0x3F, 0xDC, 0x3F, 0x38, 0x3C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 9, 9, 17, 4, -21 },
  { 25, 16, 20, 17, 0, -20 },
  { 65, 15, 26, 17, 1, -23 },
  { 114, 17, 20, 17, 0, -20 },
  { 157, 17, 20, 17, 0, -20 },
  { 200, 3, 9, 17, 7, -21 },
  { 204, 10, 25, 17, 5, -21 },
  { 236, 10, 25, 17, 2, -21 },
  { 268, 15, 14, 17, 1, -15 },
  { 295, 13, 13, 17, 2, -15 },
  { 317, 6, 9, 17, 5, -5 },
  { 324, 9, 3, 17, 4, -10 },
  { 328, 5, 5, 17, 6, -5 },
  { 332, 13, 25, 17, 2, -21 },
  { 373, 15, 20, 17, 1, -20 },
  { 411, 15, 20, 17, 1, -20 },
  { 449, 14, 20, 17, 1, -20 },
  { 484, 14, 20, 17, 1, -20 },
  { 519, 15, 20, 17, 1, -20 },
  { 557, 15, 20, 17, 1, -20 },
  { 595, 15, 20, 17, 1, -20 },
  { 633, 13, 20, 17, 2, -20 },
  { 666, 15, 20, 17, 1, -20 },
  { 704, 15, 20, 17, 1, -20 },
  { 742, 5, 15, 17, 6, -15 },
  { 752, 6, 19, 17, 5, -15 },
  { 767, 12, 17, 17, 2, -17 },
  { 793, 13, 9, 17, 2, -13 },
  { 808, 12, 17, 17, 2, -17 },
  { 834, 13, 20, 17, 2, -20 },
  { 867, 14, 23, 17, 1, -20 },
  { 908, 16, 20, 17, 0, -20 },
  { 948, 13, 20, 17, 2, -20 },
  { 981, 15, 20, 17, 1, -20 },
  { 1019, 14, 20, 17, 2, -20 },
  { 1054, 13, 20, 17, 2, -20 },
  { 1087, 13, 20, 17, 2, -20 },
  { 1120, 14, 20, 17, 1, -20 },
  { 1155, 13, 20, 17, 2, -20 },
  { 1188, 13, 20, 17, 2, -20 },
  { 1221, 13, 20, 17, 1, -20 },
  { 1254, 15, 20, 17, 2, -20 },
  { 1292, 12, 20, 17, 3, -20 },
  { 1322, 14, 20, 17, 1, -20 },
  { 1357, 13, 20, 17, 2, -20 },
  { 1390, 15, 20, 17, 1, -20 },
  { 1428, 14, 20, 17, 2, -20 },
  { 1463, 15, 25, 17, 1, -20 },
  { 1510, 14, 20, 17, 2, -20 },
  { 1545, 14, 20, 17, 1, -20 },
  { 1580, 15, 20, 17, 1, -20 },
  { 1618, 13, 20, 17, 2, -20 },
  { 1651, 16, 20, 17, 0, -20 },
  { 1691, 16, 20, 17, 0, -20 },
  { 1731, 16, 20, 17, 0, -20 },
  { 1771, 17, 20, 17, 0, -20 },
  { 1814, 14, 20, 17, 1, -20 },
  { 1849, 9, 25, 17, 5, -21 },
  { 1878, 13, 25, 17, 2, -21 },
  { 1919, 8, 25, 17, 3, -21 },
  { 1944, 15, 12, 17, 1, -20 },
  { 1967, 13, 3, 17, 2, 2 },
  { 1972, 5, 6, 17, 5, -22 },
  { 1976, 14, 14, 17, 2, -14 },
  { 2001, 14, 21, 17, 2, -21 },
  { 2038, 13, 14, 17, 2, -14 },
  { 2061, 14, 21, 17, 1, -21 },
  { 2098, 13, 14, 17, 2, -14 },
  { 2121, 13, 21, 17, 2, -21 },
  { 2156, 15, 23, 17, 1, -17 },
  { 2200, 13, 21, 17, 2, -21 },
  { 2235, 13, 21, 17, 3, -21 },
  { 2270, 10, 27, 17, 3, -21 },
  { 2304, 14, 21, 17, 2, -21 },
  { 2341, 13, 21, 17, 2, -21 },
  { 2376, 15, 14, 17, 1, -14 },
  { 2403, 13, 14, 17, 2, -14 },
  { 2426, 14, 14, 17, 1, -14 },
  { 2451, 14, 20, 17, 2, -14 },
  { 2486, 14, 20, 17, 1, -14 },
  { 2521, 14, 14, 17, 2, -14 },
  { 2546, 13, 14, 17, 2, -14 },
  { 2569, 14, 20, 17, 1, -20 },
  { 2604, 13, 14, 17, 2, -14 },
  { 2627, 15, 14, 17, 1, -14 },
  { 2654, 16, 14, 17, 0, -14 },
  { 2682, 15, 14, 17, 1, -14 },
  { 2709, 15, 20, 17, 1, -14 },
  { 2747, 13, 14, 17, 2, -14 },
  { 2770, 11, 25, 17, 3, -21 },
  { 2805, 3, 25, 17, 7, -21 },
  { 2815, 11, 25, 17, 3, -21 },
  { 2850, 15, 7, 17, 1, -12 },
};

const GFXfont IBMPlexMono_SemiBold28pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold28pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold28pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _IBMPLEXMONO_SEMIBOLD28PT7B_H_
