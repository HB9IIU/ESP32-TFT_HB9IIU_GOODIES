#ifndef _IBMPLEXMONO_SEMIBOLD36PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x79, 0xE7, 0x9C, 0x30, 0xC3,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0x78, 0xF1, 0xFF, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1,
  0xF0, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x1E, 0x07, 0xF8, 0xFF, 0x3F, 0xC7,
  0xF9, 0xFE, 0x3F, 0xCF, 0xF1, 0xFE, 0x07, 0x0E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x83, 0xFE, 0x3F, 0xDF, 0xF1, 0xFE, 0xFF, 0x8F, 0xF7, 0xF8, 0xFF,
  0x83, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38,
  0x70, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3E, 0x77, 0xCF, 0x8E, 0x31, 0xF1, 0xC4, 0x3E, 0x38, 0x07,
  0xC7, 0x00, 0x7E, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x39, 0xF0, 0x07, 0x1E, 0x00, 0xE3, 0xC4,
  0x1C, 0x79, 0xC3, 0x9F, 0x7E, 0x77, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x79, 0xFE, 0x03, 0xDF, 0xF8, 0x3C, 0xF3, 0xC1,
  0xC7, 0x0E, 0x1E, 0x78, 0x70, 0xE3, 0xC3, 0xCF, 0x1E, 0x1C, 0x70, 0x70,
  0xE7, 0x83, 0xCF, 0x78, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x7C,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x73, 0x8F, 0x07, 0xBC, 0x38, 0x79,
  0xC1, 0xC3, 0x8E, 0x0E, 0x3C, 0x70, 0x71, 0xC3, 0xC3, 0x9E, 0x0E, 0x3C,
  0xE0, 0x7F, 0xCF, 0x01, 0xFE, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xC1, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xF1,
  0xF8, 0x3F, 0x3F, 0xC3, 0xF7, 0xFE, 0x3F, 0xFB, 0xF7, 0x8F, 0x1F, 0x78,
  0xF0, 0xFF, 0x8F, 0x07, 0xF0, 0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0xF8, 0x3F,
  0x8F, 0xFF, 0x7C, 0x7F, 0xF7, 0xC3, 0xFE, 0x3E, 0x0F, 0x81, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0xE1, 0xE1, 0x9F, 0xBD, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0x7C, 0x03, 0xC7, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0x00, 0x80, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF0,
  0x78, 0x3C, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0xFF,
  0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xFC, 0xF8, 0x0F, 0x9F,
  0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x78, 0xFF, 0x8F, 0x1F, 0xF1, 0xE3, 0xFE, 0x3C, 0x7F, 0xC0, 0x1F, 0x78,
  0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xE0, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0x30, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x03, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFC, 0x3F, 0xBE,
  0x03, 0xEF, 0x00, 0xF8, 0x40, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0x70, 0x0F, 0x84,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0xC0, 0x0F, 0xBC, 0x03, 0xEF, 0xE0, 0xFC, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F,
  0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0xF8, 0x1E, 0xFF, 0x87, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7C, 0x1F, 0x8E, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF3, 0x00, 0x7D, 0xE0, 0x3E, 0xFC, 0x1F, 0x9F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0xF8, 0x1E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE,
  0xFE, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0x7E, 0x1F, 0x9F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x7C,
  0xF0, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE,
  0xFC, 0x1F, 0xBE, 0x01, 0xEF, 0x80, 0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x9F,
  0x07, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0xCF, 0xC1,
  0xFB, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x1F, 0xDF, 0xFF, 0xE7, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC,
  0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D,
  0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xE0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFE, 0xF0,
  0xFF, 0xBE, 0x07, 0xE7, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x9F, 0xFF, 0xFF, 0xFD, 0xF9, 0xE0, 0x1E, 0x1F, 0x9F, 0xCF, 0xE7, 0xF1,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x7E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC1, 0xF7, 0xC0, 0x7C,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x3B, 0xC3, 0xCF, 0xF1,
  0xFB, 0xF8, 0x7F, 0xFE, 0x3C, 0x7F, 0x8F, 0x0F, 0xE3, 0xC3, 0xF8, 0xF0,
  0xFE, 0x3C, 0x3F, 0x8F, 0x0F, 0xE3, 0xC3, 0xF8, 0xF0, 0xFE, 0x3C, 0x3F,
  0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3E, 0xF7, 0x80, 0x01, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00, 0x3C,
  0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x1F, 0xF8, 0x00, 0xF8, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1F,
  0x78, 0x1F, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xC0,
  0x7D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x1F, 0x9F, 0x01,
  0xF7, 0xC0, 0x7F, 0xE0, 0x1C, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xC7, 0x80, 0x7D, 0xF0, 0x1F, 0x7E, 0x1F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x03, 0xF7, 0x80, 0xFB, 0xC0, 0x7D, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07,
  0xDE, 0x03, 0xEF, 0x03, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0x0F, 0x8F, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x0C,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xF7, 0x83, 0xFD, 0xF0, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xF7, 0xC0,
  0x3D, 0xF8, 0x1F, 0x3F, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xBC, 0x3F, 0xCF,
  0x07, 0xE3, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x10, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0xF0, 0x0F, 0xFC, 0x03, 0xEF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x7E,
  0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF3, 0xF0, 0x3C, 0xF8, 0x0F,
  0x7C, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF3,
  0xE0, 0xF8, 0xFC, 0x3C, 0x1F, 0x0F, 0x07, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F,
  0x3C, 0x07, 0xCF, 0x00, 0xFB, 0xC0, 0x3F, 0xF0, 0x07, 0xC0, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFC, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFF, 0x3F, 0x3F, 0xCF, 0xCF,
  0xF3, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x0F, 0xF0, 0xC3, 0xFC,
  0x20, 0xFF, 0x08, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xEF, 0x0F, 0xF7,
  0x87, 0xF9, 0xE3, 0xFC, 0xF1, 0xFE, 0x78, 0xFF, 0x1E, 0x7F, 0x8F, 0x3F,
  0xC3, 0xDF, 0xE1, 0xEF, 0xF0, 0xF7, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0x80,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC,
  0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3,
  0xF0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0xF8, 0x0F, 0x9F, 0x00, 0xF3, 0xE0,
  0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xE0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0x7D, 0xF0,
  0x3F, 0xF8, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F,
  0xFF, 0xE3, 0xE0, 0x7E, 0xF8, 0x03, 0x1F, 0x00, 0x43, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0xC0,
  0x0F, 0xBC, 0x01, 0xF7, 0xE0, 0xFD, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xEF,
  0x81, 0xF7, 0xE1, 0xFB, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF8,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0,
  0x0F, 0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0xF9, 0xE0, 0x07, 0xBE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0xF0, 0xFF, 0x1F, 0x0E,
  0xF1, 0xF8, 0xEF, 0x1F, 0x9E, 0xF1, 0xF9, 0xEF, 0x1F, 0x9E, 0xF1, 0xB9,
  0xE7, 0x3B, 0x9E, 0x7B, 0xBD, 0xE7, 0xB9, 0xDE, 0x7B, 0x9D, 0xE7, 0xB9,
  0xDE, 0x7F, 0x1D, 0xE7, 0xF1, 0xDE, 0x7F, 0x1F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x0F, 0xC0, 0x7E, 0x01, 0xF9, 0xF0, 0x0F,
  0x8F, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x81,
  0xF0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xCF, 0x80, 0x3E, 0xFC, 0x01,
  0xF8, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x07, 0xE1,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7B, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0xC0, 0x78, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0xF0, 0x1F, 0x1E, 0x01, 0xE7, 0x80, 0x3E, 0xF0,
  0x03, 0xDC, 0x00, 0x78, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x10, 0xE3, 0xE3, 0xC3, 0xC7, 0xC7, 0x84, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x78, 0x3F, 0x0C, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE0,
  0x3C, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xFF, 0x7F, 0xEF,
  0xCF, 0xF1, 0xF1, 0xF8, 0x3C, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0xFC, 0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFE, 0x1F, 0xBE, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xE1, 0xFB, 0xFF, 0xFE, 0xFB,
  0xFF, 0x3E, 0x7F, 0x8F, 0x8F, 0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0xC7, 0xFF, 0xE7, 0xE0, 0xFB, 0xE0, 0x39, 0xE0, 0x10, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x43, 0xE0, 0x39,
  0xF8, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x0F, 0x87, 0x9F, 0xF3, 0xDF, 0xFD, 0xEF, 0xFE,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7E,
  0xFF, 0xEF, 0x7F, 0xF7, 0x9F, 0xF3, 0xC3, 0xE1, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x9E, 0x03, 0xEF, 0x80,
  0x7B, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x87, 0xE0, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x03, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0xF8,
  0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E, 0x0F, 0x83, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9C, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0x81,
  0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE,
  0xF7, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF,
  0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xBC, 0x0F, 0xCF,
  0x07, 0xE3, 0xC3, 0xF0, 0xF0, 0xF8, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xDF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xDF, 0x03, 0xE7, 0xE0, 0xF0, 0xF8,
  0x3C, 0x1F, 0x0F, 0x07, 0xE3, 0xC0, 0xFC, 0xF0, 0x1F, 0x3C, 0x07, 0xEF,
  0x00, 0xFC, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xC3, 0x9E, 0xF8,
  0xFB, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0x9F, 0x1F, 0xE1, 0xE3, 0xFC, 0x3C,
  0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x78,
  0xFF, 0x0F, 0x1F, 0xE1, 0xE3, 0xFC, 0x3C, 0x7F, 0x87, 0x8F, 0xF0, 0xF1,
  0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0x80, 0xF1, 0xF0, 0xF3, 0xFC, 0xF7, 0xFE,
  0xF7, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0xBE, 0x03, 0xEF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x03, 0xE7, 0xE1, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0xF8, 0xFC, 0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE,
  0xFE, 0x1F, 0xBE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xE1,
  0xFB, 0xFF, 0xFE, 0xFB, 0xFF, 0x3E, 0x7F, 0x8F, 0x8F, 0xC3, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x87, 0x9F, 0xF3, 0xDF, 0xFD, 0xEF, 0xFE, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x7E, 0xFF, 0xEF,
  0x7F, 0xF7, 0x9F, 0xF3, 0xC3, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xFF, 0x87,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF0, 0xFA, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF,
  0x3F, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xC0, 0xE3, 0xE0, 0x11, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xF9, 0x00, 0x3D, 0xE0, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x7F, 0xDF, 0x3F, 0xDF, 0x1F, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x7C, 0x1F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0xCF, 0x00,
  0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x3E,
  0x1E, 0xF1, 0xF8, 0xF7, 0x8F, 0xC7, 0xBC, 0x7E, 0x39, 0xE3, 0x71, 0xCF,
  0x1B, 0x8E, 0x39, 0xCC, 0x71, 0xCE, 0x67, 0x8E, 0x73, 0xBC, 0x73, 0x9D,
  0xE3, 0xD8, 0xEF, 0x1E, 0xC7, 0x70, 0xFE, 0x3B, 0x87, 0xF0, 0xDC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0xF8,
  0xFC, 0x3E, 0x0F, 0x87, 0x80, 0xF9, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7B, 0xE0, 0x1F, 0x7E, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x3E, 0x0F, 0xCF,
  0x80, 0xFB, 0xF0, 0x0F, 0x80, 0xF8, 0x01, 0xF7, 0x80, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x3C, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFE,
  0x0F, 0xFC, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC0, 0x0F, 0x80, 0xC3, 0xF8, 0x3C, 0xFF, 0x87, 0x9F,
  0xF8, 0xF7, 0x9F, 0x3C, 0xF1, 0xFF, 0x9C, 0x1F, 0xE3, 0x81, 0xFC, 0xF0,
  0x1E, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 25, 22, 8, -25 },
  { 20, 12, 11, 22, 5, -27 },
  { 37, 21, 25, 22, 0, -25 },
  { 103, 19, 33, 22, 1, -29 },
  { 182, 21, 25, 22, 0, -25 },
  { 248, 20, 25, 22, 1, -25 },
  { 311, 4, 11, 22, 9, -27 },
  { 317, 12, 32, 22, 7, -27 },
  { 365, 12, 32, 22, 3, -27 },
  { 413, 19, 18, 22, 1, -20 },
  { 456, 17, 18, 22, 2, -20 },
  { 495, 9, 11, 22, 6, -6 },
  { 508, 11, 4, 22, 5, -13 },
  { 514, 7, 7, 22, 7, -6 },
  { 521, 16, 32, 22, 3, -27 },
  { 585, 19, 25, 22, 1, -25 },
  { 645, 20, 25, 22, 1, -25 },
  { 708, 18, 25, 22, 2, -25 },
  { 765, 19, 25, 22, 1, -25 },
  { 825, 20, 25, 22, 1, -25 },
  { 888, 18, 25, 22, 2, -25 },
  { 945, 18, 25, 22, 2, -25 },
  { 1002, 18, 25, 22, 2, -25 },
  { 1059, 18, 25, 22, 2, -25 },
  { 1116, 19, 25, 22, 1, -25 },
  { 1176, 7, 20, 22, 7, -19 },
  { 1194, 9, 24, 22, 6, -19 },
  { 1221, 16, 21, 22, 3, -21 },
  { 1263, 17, 12, 22, 2, -17 },
  { 1289, 16, 21, 22, 3, -21 },
  { 1331, 17, 25, 22, 2, -25 },
  { 1385, 18, 29, 22, 2, -25 },
  { 1451, 21, 25, 22, 0, -25 },
  { 1517, 17, 25, 22, 3, -25 },
  { 1571, 18, 25, 22, 2, -25 },
  { 1628, 17, 25, 22, 3, -25 },
  { 1682, 16, 25, 22, 3, -25 },
  { 1732, 16, 25, 22, 3, -25 },
  { 1782, 18, 25, 22, 1, -25 },
  { 1839, 17, 25, 22, 2, -25 },
  { 1893, 16, 25, 22, 3, -25 },
  { 1943, 16, 25, 22, 2, -25 },
  { 1993, 18, 25, 22, 3, -25 },
  { 2050, 15, 25, 22, 4, -25 },
  { 2097, 18, 25, 22, 2, -25 },
  { 2154, 17, 25, 22, 2, -25 },
  { 2208, 19, 25, 22, 1, -25 },
  { 2268, 17, 25, 22, 3, -25 },
  { 2322, 19, 32, 22, 1, -25 },
  { 2398, 17, 25, 22, 3, -25 },
  { 2452, 19, 25, 22, 1, -25 },
  { 2512, 20, 25, 22, 1, -25 },
  { 2575, 17, 25, 22, 2, -25 },
  { 2629, 20, 25, 22, 1, -25 },
  { 2692, 20, 25, 22, 1, -25 },
  { 2755, 21, 25, 22, 0, -25 },
  { 2821, 21, 25, 22, 0, -25 },
  { 2887, 18, 25, 22, 2, -25 },
  { 2944, 11, 32, 22, 7, -27 },
  { 2988, 16, 32, 22, 3, -27 },
  { 3052, 12, 32, 22, 3, -27 },
  { 3100, 19, 16, 22, 1, -25 },
  { 3138, 17, 4, 22, 2, 3 },
  { 3147, 7, 8, 22, 6, -29 },
  { 3154, 18, 19, 22, 2, -19 },
  { 3197, 18, 27, 22, 2, -27 },
  { 3258, 17, 19, 22, 2, -19 },
  { 3299, 17, 27, 22, 2, -27 },
  { 3357, 18, 19, 22, 2, -19 },
  { 3400, 18, 27, 22, 2, -27 },
  { 3461, 19, 29, 22, 2, -22 },
  { 3530, 16, 27, 22, 3, -27 },
  { 3584, 16, 28, 22, 4, -28 },
  { 3640, 13, 35, 22, 3, -28 },
  { 3697, 18, 27, 22, 3, -27 },
  { 3758, 16, 27, 22, 3, -27 },
  { 3812, 19, 19, 22, 1, -19 },
  { 3858, 16, 19, 22, 3, -19 },
  { 3896, 18, 19, 22, 2, -19 },
  { 3939, 18, 26, 22, 2, -19 },
  { 3998, 17, 26, 22, 2, -19 },
  { 4054, 17, 19, 22, 3, -19 },
  { 4095, 17, 19, 22, 2, -19 },
  { 4136, 18, 25, 22, 1, -25 },
  { 4193, 16, 19, 22, 3, -19 },
  { 4231, 19, 19, 22, 1, -19 },
  { 4277, 21, 19, 22, 0, -19 },
  { 4327, 19, 19, 22, 1, -19 },
  { 4373, 20, 26, 22, 1, -19 },
  { 4438, 16, 19, 22, 3, -19 },
  { 4476, 15, 32, 22, 3, -27 },
  { 4536, 4, 32, 22, 9, -27 },
  { 4552, 15, 32, 22, 3, -27 },
  { 4612, 19, 9, 22, 1, -16 },
};

const GFXfont IBMPlexMono_SemiBold36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_SEMIBOLD36PT7B_H_
