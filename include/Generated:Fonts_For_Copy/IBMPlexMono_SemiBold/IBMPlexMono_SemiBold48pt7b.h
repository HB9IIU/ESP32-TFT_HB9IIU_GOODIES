#ifndef _IBMPLEXMONO_SEMIBOLD48PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x8F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x8F, 0x80, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0x0F, 0xFD, 0xFF, 0xC1, 0xFF, 0xBF,
  0xF8, 0x7F, 0xF7, 0xFF, 0x0F, 0xFE, 0xFF, 0xE1, 0xFF, 0xC0, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x0F, 0xFE, 0x1F, 0xF9, 0xFF, 0xC3, 0xFF,
  0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x1F, 0xFC, 0xFF, 0xC3, 0xFF, 0x80, 0xF8,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xE7, 0xBF, 0x8F, 0xE3, 0xC7, 0x87, 0xE1, 0xE0, 0x83, 0xF0, 0xF0,
  0x01, 0xF8, 0x78, 0x00, 0xFC, 0x3C, 0x00, 0x7E, 0x1E, 0x00, 0x3F, 0x8F,
  0x00, 0x1F, 0xE7, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x7F, 0x80, 0x07, 0x8F, 0xE0, 0x03, 0xC3, 0xF0, 0x01, 0xE1, 0xF8,
  0x00, 0xF0, 0xFC, 0x00, 0x78, 0x7E, 0x20, 0x3C, 0x3F, 0x38, 0x1E, 0x1F,
  0xBF, 0x0F, 0x1F, 0xBF, 0xE7, 0xBF, 0xDF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x3F, 0xFC, 0x03,
  0xE3, 0xFF, 0xC0, 0x3E, 0x7C, 0x3E, 0x07, 0xC7, 0x83, 0xE0, 0x7C, 0x78,
  0x1E, 0x0F, 0x87, 0x81, 0xE0, 0xF8, 0x78, 0x1E, 0x1F, 0x07, 0x81, 0xE1,
  0xF0, 0x78, 0x1E, 0x3E, 0x07, 0x81, 0xE3, 0xE0, 0x78, 0x3E, 0x7C, 0x07,
  0xC3, 0xE7, 0xC0, 0x3F, 0xFC, 0x78, 0x03, 0xFF, 0xC8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x01, 0xF9, 0xFF, 0xE0, 0x1F, 0x3E, 0x3E, 0x03, 0xE3, 0xC1, 0xF0, 0x3E,
  0x3C, 0x0F, 0x07, 0xC7, 0xC0, 0xF0, 0x7C, 0x7C, 0x0F, 0x0F, 0x87, 0xC0,
  0xF0, 0xF8, 0x7C, 0x0F, 0x1F, 0x03, 0xC0, 0xF1, 0xF0, 0x3C, 0x1F, 0x3E,
  0x03, 0xE3, 0xE3, 0xE0, 0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0xC7, 0x80, 0x0F,
  0xF8, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x87,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x06, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x07,
  0xF8, 0x3F, 0xE3, 0xFF, 0x87, 0xFC, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0x1F,
  0xF7, 0xE7, 0xF3, 0xE1, 0xF8, 0x7E, 0x7C, 0x3F, 0x07, 0xEF, 0x87, 0xE0,
  0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF,
  0xCF, 0xC1, 0xFF, 0xF9, 0xFC, 0x1F, 0xFE, 0x1F, 0xC1, 0xFF, 0x81, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x01, 0x00, 0xF8, 0x0C, 0xF0, 0x7C, 0x1E, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03,
  0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3C, 0x01, 0xC0, 0x04, 0x00, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0xF0, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x7E, 0x1F, 0xFE, 0x3F, 0x0F, 0xFF,
  0x0F, 0x87, 0xFF, 0x87, 0x83, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x07, 0x01, 0xF8, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x83, 0xFE, 0x7F, 0x00,
  0xFE, 0xFE, 0x00, 0xFE, 0x3C, 0x00, 0x7E, 0x0C, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0x7C, 0x01, 0xFC, 0x1C, 0x00, 0xFE, 0x04,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x84, 0x00, 0x1F, 0xC3, 0x00, 0x0F, 0xE7, 0xC0,
  0x07, 0xF7, 0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE1, 0xFC, 0x01, 0xF1, 0xFF, 0x80, 0xF9,
  0xFF, 0xE0, 0x7D, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0x8F,
  0xC0, 0x3F, 0xC0, 0x40, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x84, 0x00, 0x1F,
  0xC3, 0x00, 0x0F, 0xC7, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF7, 0xFC, 0x0F,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x01, 0xF9, 0xFF,
  0x81, 0xF9, 0xFF, 0xF0, 0xFD, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xE0,
  0xFF, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xF1,
  0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xFB,
  0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFC, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0xC7,
  0xF0, 0x07, 0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xE7, 0xF0, 0x07, 0xF3, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC3, 0xFE, 0x0F, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00,
  0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xFF, 0xDF, 0x8F, 0xFF, 0xEF, 0xC3, 0xFF,
  0xEF, 0xE0, 0xFF, 0xE7, 0xE0, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0x7F,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0x00, 0x1F, 0x0F, 0xF1, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF,
  0x9F, 0xF3, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF9, 0xFC, 0x1F, 0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0x1C, 0x01,
  0xFC, 0x20, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0x3E, 0x3E, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x0F, 0x9F, 0x78, 0x1F,
  0xCF, 0x78, 0x3F, 0xEF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7E, 0x3F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x78,
  0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x78,
  0x0F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0x78, 0x7F, 0x7F, 0x7C, 0x3F,
  0xEF, 0x7C, 0x3F, 0xCF, 0x7C, 0x1F, 0xCF, 0x3E, 0x02, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xFC,
  0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0x3F, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7,
  0xE0, 0x1F, 0xCF, 0xC0, 0x1F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xEF, 0xC0, 0x3F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xBF,
  0x80, 0x0E, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x0E, 0x0F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xE3, 0xF8,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x07, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC1,
  0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7E, 0x00,
  0x38, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0xC1,
  0xFF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x07, 0xFE,
  0x3F, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x10, 0x03, 0xFF,
  0xE0, 0x0F, 0xDF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFE, 0x1F, 0xE3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0x7E, 0x00, 0xFF, 0x9F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFB,
  0xE3, 0xFF, 0xFF, 0xF1, 0xEF, 0xFF, 0x7C, 0xF7, 0xFF, 0xBE, 0xFB, 0xFF,
  0xDF, 0x79, 0xFF, 0xE7, 0xFC, 0xFF, 0xF3, 0xFE, 0x7F, 0xF8, 0xFE, 0x3F,
  0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x8F, 0xFF, 0x0F, 0x87, 0xFF, 0x87, 0xC3,
  0xFF, 0xC3, 0xC1, 0xFF, 0xE0, 0xE0, 0xFF, 0xF0, 0x70, 0x7F, 0xF8, 0x30,
  0x3F, 0xFC, 0x08, 0x1F, 0xFE, 0x04, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0x9F,
  0x0F, 0xFF, 0x3E, 0x1F, 0xFE, 0x7E, 0x3F, 0xFC, 0x7C, 0x7F, 0xF8, 0xF8,
  0xFF, 0xF1, 0xF9, 0xFF, 0xE1, 0xF3, 0xFF, 0xC3, 0xE7, 0xFF, 0x87, 0xEF,
  0xFF, 0x07, 0xDF, 0xFE, 0x0F, 0xBF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFC,
  0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF,
  0x00, 0x7F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00,
  0x7F, 0x7E, 0x01, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFE, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1,
  0xFE, 0x07, 0xF1, 0xFC, 0x00, 0xF0, 0xFE, 0x00, 0x30, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x84, 0x00, 0x0F, 0xC7, 0x00, 0x0F, 0xE7,
  0xE0, 0x07, 0xF7, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x1F, 0xCF, 0xF0, 0x7F, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xFC, 0x3F, 0x87, 0xDF,
  0x87, 0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8,
  0x7C, 0xF8, 0x7F, 0x0F, 0x9F, 0x1F, 0xF1, 0xF3, 0xE3, 0xDE, 0x3E, 0x7C,
  0x7B, 0xC7, 0xCF, 0x8F, 0x78, 0xF9, 0xF1, 0xEF, 0x1F, 0x3E, 0x39, 0xE3,
  0xE7, 0xCF, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F, 0x3C, 0x7B, 0xE3, 0xF7,
  0x8F, 0x7C, 0x7E, 0xF1, 0xEF, 0x87, 0xDE, 0x3D, 0xF0, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xF0,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xE3, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x1E, 0x3F, 0x1F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x83, 0xC1, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFE, 0x07, 0xF8, 0x3C, 0x03, 0xF8, 0x18, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFE, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x06, 0xFF,
  0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0xFF, 0x7F, 0xFC, 0x7F, 0x3F, 0xF8, 0x3F,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFC, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFF, 0x83, 0xFC, 0xFD, 0xFF, 0xFC, 0xFC, 0xFF, 0xF8, 0xFC, 0xFF, 0xF0,
  0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0x9F,
  0xC0, 0x3E, 0x3F, 0x00, 0x38, 0x7E, 0x00, 0x40, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x81, 0xF8, 0x01,
  0xC3, 0xF8, 0x07, 0xE3, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x7F, 0xC7, 0xE3, 0xFF,
  0xCF, 0xC7, 0xFF, 0xDF, 0x9F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFE, 0xFE, 0x01,
  0xFD, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0xC0, 0x3F, 0xBF, 0xE0, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFE, 0xFC, 0x7F,
  0xFD, 0xF8, 0x7F, 0xE3, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0,
  0x7F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x83, 0xF0, 0x03, 0x87, 0xF8, 0x1F, 0x87, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x1F, 0xEF, 0xF0, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF1, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xCF, 0xFC, 0x7E,
  0xFF, 0xF3, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x9F,
  0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFC,
  0x3F, 0x80, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0xFD,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x3C, 0x7C, 0xFC, 0x7F, 0x3E, 0xFF, 0x3F, 0xDF,
  0x7F, 0xBF, 0xEF, 0xFF, 0xDF, 0xFF, 0xE3, 0xF8, 0xFF, 0xE0, 0xF8, 0x3F,
  0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83,
  0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8,
  0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F,
  0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0,
  0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x07,
  0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80,
  0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFD, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F,
  0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF0, 0xFC, 0xFF,
  0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0x83, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFF, 0x83, 0xFC, 0xFD, 0xFF, 0xFC, 0xFC, 0xFF, 0xF8, 0xFC, 0xFF,
  0xF0, 0xFC, 0x7F, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x7E, 0x0F, 0xF8, 0xFC, 0x7F, 0xF9, 0xF8, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF,
  0xEF, 0xF8, 0x3F, 0xDF, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x07, 0xF7, 0xFC, 0x1F, 0xE7, 0xFF,
  0xFF, 0xC7, 0xFF, 0xDF, 0x8F, 0xFF, 0xBF, 0x0F, 0xFC, 0x7E, 0x07, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xE0, 0x7E, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFE, 0x07, 0xE7, 0xE0, 0x07, 0x1F, 0x80,
  0x08, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF1, 0x00, 0x0F, 0xDE, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0, 0x7F,
  0x7F, 0x83, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xEF, 0xC7, 0xFF, 0x3F, 0x0F,
  0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x1F, 0x03, 0xFF, 0x07, 0xF0, 0x7F, 0xE0, 0xFE, 0x0F, 0xFC, 0x1F,
  0xC1, 0xFF, 0x83, 0xF8, 0x3F, 0xF0, 0x7F, 0x07, 0xBE, 0x0F, 0xE0, 0xF3,
  0xE1, 0xDE, 0x3E, 0x7C, 0x7B, 0xC7, 0xCF, 0x8F, 0x78, 0xF9, 0xF1, 0xEF,
  0x1F, 0x3E, 0x39, 0xE3, 0xE7, 0xC7, 0x1C, 0x7C, 0xF8, 0xE3, 0x8F, 0x0F,
  0x3C, 0x79, 0xE1, 0xE7, 0x8F, 0x3C, 0x3C, 0xF1, 0xE7, 0x87, 0xDC, 0x3D,
  0xF0, 0xFB, 0x87, 0xBE, 0x1F, 0x70, 0x77, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xFC, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F,
  0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0xFE,
  0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x0E, 0x07, 0xF8, 0x07, 0xC7, 0xFE,
  0x03, 0xE7, 0xFF, 0x81, 0xE3, 0xFF, 0xC1, 0xF3, 0xE3, 0xF0, 0xF9, 0xF0,
  0xFC, 0xFC, 0xF0, 0x7F, 0xFC, 0xF8, 0x1F, 0xFE, 0x7C, 0x07, 0xFE, 0x3E,
  0x01, 0xFE, 0x06, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 9, 35, 29, 10, -34 },
  { 41, 15, 15, 29, 7, -36 },
  { 70, 27, 34, 29, 1, -34 },
  { 185, 25, 45, 29, 2, -39 },
  { 326, 28, 35, 29, 0, -34 },
  { 449, 27, 35, 29, 1, -34 },
  { 568, 5, 15, 29, 12, -36 },
  { 578, 16, 43, 29, 9, -36 },
  { 664, 16, 43, 29, 4, -36 },
  { 750, 25, 24, 29, 2, -26 },
  { 825, 23, 23, 29, 3, -26 },
  { 892, 11, 15, 29, 9, -8 },
  { 913, 15, 5, 29, 7, -17 },
  { 923, 9, 9, 29, 10, -8 },
  { 934, 21, 43, 29, 4, -36 },
  { 1047, 25, 35, 29, 2, -34 },
  { 1157, 25, 34, 29, 2, -34 },
  { 1264, 24, 34, 29, 2, -34 },
  { 1366, 25, 35, 29, 1, -34 },
  { 1476, 26, 34, 29, 1, -34 },
  { 1587, 25, 35, 29, 2, -34 },
  { 1697, 25, 35, 29, 2, -34 },
  { 1807, 23, 34, 29, 3, -34 },
  { 1905, 25, 35, 29, 2, -34 },
  { 2015, 25, 34, 29, 2, -34 },
  { 2122, 9, 26, 29, 10, -25 },
  { 2152, 11, 32, 29, 9, -25 },
  { 2196, 21, 28, 29, 4, -29 },
  { 2270, 23, 15, 29, 3, -22 },
  { 2314, 21, 28, 29, 4, -29 },
  { 2388, 22, 35, 29, 3, -34 },
  { 2485, 24, 39, 29, 2, -34 },
  { 2602, 27, 34, 29, 1, -34 },
  { 2717, 23, 34, 29, 4, -34 },
  { 2815, 25, 35, 29, 2, -34 },
  { 2925, 24, 34, 29, 3, -34 },
  { 3027, 21, 34, 29, 4, -34 },
  { 3117, 22, 34, 29, 4, -34 },
  { 3211, 24, 35, 29, 2, -34 },
  { 3316, 23, 34, 29, 3, -34 },
  { 3414, 21, 34, 29, 4, -34 },
  { 3504, 22, 35, 29, 2, -34 },
  { 3601, 26, 34, 29, 3, -34 },
  { 3712, 21, 34, 29, 5, -34 },
  { 3802, 25, 34, 29, 2, -34 },
  { 3909, 23, 34, 29, 3, -34 },
  { 4007, 25, 35, 29, 2, -34 },
  { 4117, 23, 34, 29, 4, -34 },
  { 4215, 25, 43, 29, 2, -34 },
  { 4350, 23, 34, 29, 4, -34 },
  { 4448, 25, 35, 29, 2, -34 },
  { 4558, 27, 34, 29, 1, -34 },
  { 4673, 23, 35, 29, 3, -34 },
  { 4774, 27, 34, 29, 1, -34 },
  { 4889, 27, 34, 29, 1, -34 },
  { 5004, 27, 34, 29, 1, -34 },
  { 5119, 28, 34, 29, 0, -34 },
  { 5238, 25, 34, 29, 2, -34 },
  { 5345, 15, 43, 29, 9, -36 },
  { 5426, 21, 43, 29, 4, -36 },
  { 5539, 14, 43, 29, 5, -36 },
  { 5615, 25, 21, 29, 2, -34 },
  { 5681, 23, 5, 29, 3, 4 },
  { 5696, 9, 11, 29, 8, -39 },
  { 5709, 24, 26, 29, 3, -25 },
  { 5787, 24, 37, 29, 3, -36 },
  { 5898, 23, 26, 29, 3, -25 },
  { 5973, 23, 37, 29, 2, -36 },
  { 6080, 23, 26, 29, 3, -25 },
  { 6155, 24, 36, 29, 3, -36 },
  { 6263, 25, 39, 29, 3, -29 },
  { 6385, 21, 36, 29, 4, -36 },
  { 6480, 22, 36, 29, 5, -36 },
  { 6579, 18, 46, 29, 4, -36 },
  { 6683, 24, 36, 29, 4, -36 },
  { 6791, 22, 36, 29, 3, -36 },
  { 6890, 25, 25, 29, 2, -25 },
  { 6969, 21, 25, 29, 4, -25 },
  { 7035, 25, 26, 29, 2, -25 },
  { 7117, 24, 35, 29, 3, -25 },
  { 7222, 23, 35, 29, 2, -25 },
  { 7323, 23, 25, 29, 4, -25 },
  { 7395, 22, 26, 29, 3, -25 },
  { 7467, 23, 34, 29, 2, -34 },
  { 7565, 22, 26, 29, 3, -25 },
  { 7637, 25, 25, 29, 2, -25 },
  { 7716, 27, 25, 29, 1, -25 },
  { 7801, 25, 25, 29, 2, -25 },
  { 7880, 26, 35, 29, 1, -25 },
  { 7994, 22, 25, 29, 3, -25 },
  { 8063, 19, 43, 29, 5, -36 },
  { 8166, 5, 43, 29, 12, -36 },
  { 8193, 19, 43, 29, 5, -36 },
  { 8296, 25, 12, 29, 2, -21 },
};

const GFXfont IBMPlexMono_SemiBold48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_SEMIBOLD48PT7B_H_
