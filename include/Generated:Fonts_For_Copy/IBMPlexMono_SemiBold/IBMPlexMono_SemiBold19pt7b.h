#ifndef _IBMPLEXMONO_SEMIBOLD19PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xD2, 0x03, 0xFE, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x0C,
  0xC1, 0xB0, 0x36, 0x0C, 0xC7, 0x9E, 0xF3, 0xC6, 0x67, 0xDE, 0xFB, 0xC6,
  0x60, 0xCC, 0x19, 0x83, 0x60, 0x0C, 0x03, 0x03, 0xF1, 0xFE, 0xED, 0xB3,
  0x0E, 0xC1, 0xF0, 0x3F, 0x83, 0xE0, 0xDE, 0x37, 0xED, 0xBF, 0xE3, 0xE0,
  0x30, 0x0C, 0x00, 0x78, 0x6F, 0x9B, 0x33, 0x66, 0xCC, 0xD8, 0xFC, 0x1E,
  0x70, 0x1F, 0x1E, 0x66, 0xCC, 0xD9, 0xB1, 0xFC, 0x1C, 0x1E, 0x07, 0xE1,
  0xCE, 0x38, 0x03, 0x00, 0x71, 0xCF, 0x3B, 0x74, 0xE6, 0x9C, 0x73, 0x8E,
  0x3F, 0xE3, 0xCE, 0xFF, 0xF0, 0x0E, 0x30, 0xC1, 0x86, 0x0C, 0x18, 0x30,
  0xE0, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x0C, 0x0E, 0xE1, 0xC3, 0x06, 0x18,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x63, 0x1C, 0xE0, 0x0C, 0x03, 0x08,
  0xCB, 0xBE, 0xFF, 0xC7, 0x03, 0xE0, 0xDC, 0x63, 0x88, 0x80, 0x0C, 0x06,
  0x03, 0x01, 0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x7B, 0x9C,
  0xC6, 0x60, 0xFF, 0xF0, 0xEF, 0xE0, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0xE0, 0x00, 0x3E, 0x1F, 0xCE, 0x3B, 0x06, 0xC1, 0xF3, 0x7C, 0xDF, 0x37,
  0xC1, 0xF0, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x1E, 0x0F, 0x87, 0xE3, 0xB8,
  0xCE, 0x13, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE1, 0xFF, 0x7F, 0xC0,
  0x3E, 0x3F, 0xB8, 0xE8, 0x70, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x1F, 0xFF, 0xF8, 0x3E, 0x3F, 0xF8, 0xE8, 0x70, 0x38, 0xF8, 0x7C, 0x07,
  0x01, 0xA0, 0xF8, 0xFF, 0xE3, 0xE0, 0x07, 0x03, 0xC1, 0xB0, 0x6C, 0x33,
  0x18, 0xC6, 0x33, 0x0C, 0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F,
  0x9F, 0xE6, 0x01, 0x80, 0x6F, 0x17, 0xEE, 0x38, 0x07, 0x01, 0xD0, 0x6E,
  0x39, 0xFC, 0x3E, 0x00, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0x6F, 0x3F, 0xEE,
  0x3B, 0x87, 0xC1, 0xF8, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0xFF, 0xFF, 0xF0,
  0x78, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x80,
  0x3E, 0x1F, 0xEE, 0x3B, 0x86, 0x63, 0x8F, 0xC7, 0xF3, 0x8E, 0xC1, 0xF0,
  0x7E, 0x39, 0xFE, 0x3E, 0x00, 0x3E, 0x1F, 0xCE, 0x3B, 0x06, 0xC1, 0xF0,
  0x7E, 0x39, 0xFE, 0x3F, 0x80, 0xC0, 0x60, 0x38, 0x78, 0x00, 0xEF, 0xE0,
  0x00, 0x0E, 0xFE, 0x73, 0xDC, 0x00, 0x00, 0x0F, 0x73, 0x98, 0xCC, 0x00,
  0x01, 0x07, 0x1E, 0x78, 0xF0, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0x3E, 0x3F, 0xB8, 0xE8, 0x70, 0x38, 0xF8,
  0x70, 0x30, 0x00, 0x00, 0x07, 0x03, 0x81, 0xC0, 0x3E, 0x3F, 0x98, 0x78,
  0x3C, 0xEE, 0xFF, 0x67, 0xB1, 0xD8, 0xEF, 0xF3, 0xB8, 0x06, 0x03, 0xF8,
  0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0D, 0x81, 0xB8, 0x73, 0x0E, 0x61, 0x8E,
  0x3F, 0xCF, 0xF9, 0xC3, 0x30, 0x7E, 0x0E, 0xFE, 0xFF, 0xC7, 0xC7, 0xC7,
  0xFE, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0x1E, 0x1F, 0xE7, 0x3B,
  0x87, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x77, 0x39, 0xFE, 0x1E,
  0x00, 0xFE, 0x3F, 0xCE, 0x3B, 0x86, 0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1,
  0xB8, 0x6E, 0x3B, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x3F, 0x98, 0xFC,
  0x3C, 0x06, 0x03, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0xEF, 0xF3, 0xD8, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x18, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x1F, 0xFF, 0xF8, 0x3F, 0x9F, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xE1, 0xF8, 0xCF, 0xE3, 0xE0, 0xE1, 0xF8, 0xEE, 0x73,
  0x98, 0xEE, 0x3F, 0x0F, 0xE3, 0xF8, 0xE7, 0x38, 0xCE, 0x3B, 0x86, 0xE1,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xE1, 0xF1, 0xFC, 0xFE, 0xFD, 0xFE, 0xEF, 0x77, 0x9B, 0xC9,
  0xE4, 0xF0, 0x78, 0x3C, 0x18, 0xF1, 0xF8, 0xFC, 0x7F, 0x3D, 0x9E, 0xCF,
  0x37, 0x9B, 0xCF, 0xE3, 0xF1, 0xF8, 0xFC, 0x38, 0x3E, 0x1F, 0xCE, 0x3B,
  0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x39, 0xFC, 0x3E,
  0x00, 0xFE, 0x7F, 0xB0, 0xD8, 0x7C, 0x3E, 0x1B, 0xFD, 0xFC, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x00, 0x3E, 0x1F, 0xCE, 0x3B, 0x86, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x6E, 0x39, 0xFC, 0x3E, 0x03, 0x00, 0xC0, 0x3E,
  0x07, 0x80, 0xFE, 0x7F, 0xB0, 0xD8, 0x7C, 0x3E, 0x1B, 0xFD, 0xFC, 0xCC,
  0x67, 0x31, 0x98, 0xEC, 0x38, 0x3F, 0x3F, 0xF8, 0x7C, 0x0E, 0x03, 0xE1,
  0xFC, 0x0F, 0x01, 0xC0, 0xF8, 0xFF, 0xF3, 0xE0, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0xEF, 0xE3, 0xE0, 0xE0, 0xEC, 0x1D, 0xC3, 0x38, 0x63, 0x1C,
  0x63, 0x8E, 0x61, 0xCC, 0x1B, 0x83, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0xE0,
  0x7C, 0x0D, 0x81, 0xB7, 0x36, 0xE6, 0xDC, 0xDA, 0xDB, 0x5B, 0x6B, 0x4F,
  0x79, 0xE7, 0x3C, 0xE7, 0x9C, 0x70, 0xEE, 0x38, 0xE6, 0x0D, 0xC1, 0xF0,
  0x1E, 0x03, 0x80, 0xF8, 0x1B, 0x87, 0x70, 0xC7, 0x38, 0xEE, 0x0E, 0xE0,
  0xEE, 0x19, 0xC7, 0x1C, 0xC3, 0xB8, 0x36, 0x07, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x60, 0x70,
  0x70, 0x70, 0x38, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0xFF, 0xFC, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xE0, 0x30, 0x1C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x01, 0x80, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0x1C, 0x07, 0x83, 0x60, 0xDC, 0x63,
  0x18, 0xEC, 0x1B, 0x07, 0xFF, 0xFF, 0xC0, 0x4E, 0x72, 0x3E, 0x1F, 0xCE,
  0x30, 0x0E, 0x3F, 0xBF, 0xEE, 0x3B, 0x8E, 0xFF, 0xDE, 0x70, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEE, 0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1B,
  0x8E, 0xFF, 0xBB, 0xC0, 0x1E, 0x3F, 0x98, 0x7C, 0x0E, 0x07, 0x03, 0x80,
  0xE3, 0x7F, 0x8F, 0x00, 0x01, 0x80, 0xC0, 0x60, 0x33, 0x9B, 0xEF, 0x8F,
  0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x77, 0xD9, 0xCC, 0x3E, 0x3F, 0x98, 0xFC,
  0x3F, 0xFF, 0xFF, 0x80, 0xC2, 0x7F, 0x9F, 0x00, 0x0F, 0x87, 0xC7, 0x03,
  0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC,
  0x01, 0xC0, 0xF3, 0xE1, 0xFC, 0x63, 0xB8, 0xE6, 0x39, 0xFC, 0x3E, 0x10,
  0x07, 0xF9, 0xFF, 0xC0, 0xF0, 0x7F, 0xF9, 0xFC, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0xF7, 0xFF, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0C,
  0x1C, 0x0E, 0x07, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x0C, 0x1C, 0x30, 0x00, 0x1F, 0xBF, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0D, 0xFB, 0xE0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE3, 0xF9, 0xCE, 0xE3, 0xB0, 0xFC, 0x3F, 0x8E, 0x73,
  0x8C, 0xE3, 0xB8, 0x70, 0xFC, 0x7E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0xDB, 0xBE, 0xFC, 0xCF,
  0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x30, 0xEF, 0x7F, 0xF8,
  0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xC0, 0x3E, 0x3F, 0xB8,
  0xFC, 0x3C, 0x1E, 0x0F, 0x87, 0xC7, 0x7F, 0x1F, 0x00, 0xEF, 0x3F, 0xEE,
  0x3B, 0x86, 0xE1, 0xF8, 0x7E, 0x1B, 0x8E, 0xFF, 0xBB, 0xCE, 0x03, 0x80,
  0xE0, 0x38, 0x00, 0x39, 0xBE, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC7,
  0x7D, 0x9C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xF9, 0xFE, 0xF1, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xBF, 0xE0, 0x3F, 0x3F, 0xD8, 0x4C,
  0x07, 0xE1, 0xFC, 0x0E, 0x87, 0xFF, 0x9F, 0x00, 0x18, 0x0C, 0x06, 0x1F,
  0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0x7D, 0x9C, 0xC0, 0xC1,
  0xF8, 0x66, 0x39, 0x8C, 0x73, 0x0C, 0xC3, 0x60, 0xF8, 0x1E, 0x07, 0x00,
  0xC6, 0x79, 0xCD, 0xB9, 0xB5, 0x36, 0xB6, 0xD6, 0x9A, 0xD3, 0xCE, 0x79,
  0xCF, 0x38, 0xE1, 0xDC, 0xC3, 0x70, 0xF8, 0x1C, 0x07, 0x83, 0xE1, 0xDC,
  0x63, 0xB8, 0x70, 0xC1, 0xF8, 0x66, 0x39, 0x8C, 0x73, 0x0D, 0xC3, 0x60,
  0x78, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0xF8, 0x3C, 0x00, 0x7F, 0xBF, 0xC0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0x3F, 0x30,
  0x30, 0x18, 0x08, 0x1C, 0xF8, 0xF8, 0x1C, 0x0C, 0x18, 0x30, 0x30, 0x30,
  0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0xF8, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x3F, 0x1F, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0xF8, 0xF8,
  0x70, 0xDE, 0x2C, 0xDB, 0x3E, 0xC7, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 6, 6, 11, 3, -14 },
  { 11, 11, 13, 11, 0, -13 },
  { 29, 10, 17, 11, 1, -15 },
  { 51, 11, 13, 11, 0, -13 },
  { 69, 11, 13, 11, 0, -13 },
  { 87, 2, 6, 11, 5, -14 },
  { 89, 7, 17, 11, 3, -14 },
  { 104, 6, 17, 11, 2, -14 },
  { 117, 10, 10, 11, 1, -10 },
  { 130, 9, 10, 11, 1, -11 },
  { 142, 5, 6, 11, 3, -3 },
  { 146, 6, 2, 11, 3, -7 },
  { 148, 4, 3, 11, 4, -3 },
  { 150, 9, 17, 11, 1, -14 },
  { 170, 10, 13, 11, 1, -13 },
  { 187, 10, 13, 11, 1, -13 },
  { 204, 9, 13, 11, 1, -13 },
  { 219, 9, 13, 11, 1, -13 },
  { 234, 10, 13, 11, 1, -13 },
  { 251, 10, 13, 11, 1, -13 },
  { 268, 10, 13, 11, 1, -13 },
  { 285, 9, 13, 11, 1, -13 },
  { 300, 10, 13, 11, 1, -13 },
  { 317, 10, 13, 11, 1, -13 },
  { 334, 4, 10, 11, 4, -10 },
  { 339, 5, 13, 11, 3, -10 },
  { 348, 8, 11, 11, 2, -11 },
  { 359, 9, 6, 11, 1, -9 },
  { 366, 8, 11, 11, 2, -11 },
  { 377, 9, 13, 11, 1, -13 },
  { 392, 9, 15, 11, 1, -13 },
  { 409, 11, 13, 11, 0, -13 },
  { 427, 8, 13, 11, 2, -13 },
  { 440, 10, 13, 11, 1, -13 },
  { 457, 10, 13, 11, 1, -13 },
  { 474, 8, 13, 11, 2, -13 },
  { 487, 8, 13, 11, 2, -13 },
  { 500, 9, 13, 11, 1, -13 },
  { 515, 9, 13, 11, 1, -13 },
  { 530, 9, 13, 11, 1, -13 },
  { 545, 9, 13, 11, 1, -13 },
  { 560, 10, 13, 11, 1, -13 },
  { 577, 8, 13, 11, 2, -13 },
  { 590, 9, 13, 11, 1, -13 },
  { 605, 9, 13, 11, 1, -13 },
  { 620, 10, 13, 11, 1, -13 },
  { 637, 9, 13, 11, 2, -13 },
  { 652, 10, 17, 11, 1, -13 },
  { 674, 9, 13, 11, 2, -13 },
  { 689, 9, 13, 11, 1, -13 },
  { 704, 11, 13, 11, 0, -13 },
  { 722, 9, 13, 11, 1, -13 },
  { 737, 11, 13, 11, 0, -13 },
  { 755, 11, 13, 11, 0, -13 },
  { 773, 11, 13, 11, 0, -13 },
  { 791, 11, 13, 11, 0, -13 },
  { 809, 9, 13, 11, 1, -13 },
  { 824, 6, 17, 11, 4, -14 },
  { 837, 9, 17, 11, 1, -14 },
  { 857, 6, 17, 11, 2, -14 },
  { 870, 10, 8, 11, 1, -13 },
  { 880, 9, 2, 11, 1, 2 },
  { 883, 4, 4, 11, 3, -15 },
  { 885, 10, 10, 11, 1, -10 },
  { 898, 10, 14, 11, 1, -14 },
  { 916, 9, 10, 11, 1, -10 },
  { 928, 9, 14, 11, 1, -14 },
  { 944, 9, 10, 11, 1, -10 },
  { 956, 9, 14, 11, 1, -14 },
  { 972, 10, 16, 11, 1, -12 },
  { 992, 9, 14, 11, 1, -14 },
  { 1008, 9, 15, 11, 2, -15 },
  { 1025, 7, 19, 11, 2, -15 },
  { 1042, 10, 14, 11, 1, -14 },
  { 1060, 9, 14, 11, 1, -14 },
  { 1076, 10, 10, 11, 1, -10 },
  { 1089, 9, 10, 11, 1, -10 },
  { 1101, 9, 10, 11, 1, -10 },
  { 1113, 10, 14, 11, 1, -10 },
  { 1131, 9, 14, 11, 1, -10 },
  { 1147, 10, 10, 11, 1, -10 },
  { 1160, 9, 10, 11, 1, -10 },
  { 1172, 9, 13, 11, 1, -13 },
  { 1187, 9, 10, 11, 1, -10 },
  { 1199, 10, 10, 11, 1, -10 },
  { 1212, 11, 10, 11, 0, -10 },
  { 1226, 10, 10, 11, 1, -10 },
  { 1239, 10, 14, 11, 1, -10 },
  { 1257, 9, 10, 11, 1, -10 },
  { 1269, 8, 17, 11, 2, -14 },
  { 1286, 2, 17, 11, 5, -14 },
  { 1291, 8, 17, 11, 2, -14 },
  { 1308, 10, 5, 11, 1, -8 },
};

const GFXfont IBMPlexMono_SemiBold19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_SEMIBOLD19PT7B_H_
