#ifndef _IBMPLEXMONO_SEMIBOLD27PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x79, 0xCC, 0x63, 0x18, 0x00, 0x03, 0xDE, 0xFF,
  0xBC, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0x03, 0x9C,
  0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x7F, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0xFE, 0x7E, 0xFC, 0x7E,
  0xFC, 0x7E, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0xF8, 0x3F, 0xF9, 0xFF, 0xF7, 0xBB,
  0x9C, 0xE4, 0x73, 0x81, 0xCE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xE0, 0x3B, 0xC0, 0xE7, 0x03, 0x9D, 0x8E, 0x7F, 0xBB, 0xFF, 0xFE, 0x3F,
  0xF0, 0x3F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x3E, 0x07, 0x7F, 0x06,
  0x7F, 0x0E, 0xE3, 0x1C, 0xE3, 0x9C, 0xE3, 0xB8, 0xE3, 0xB8, 0x7F, 0x70,
  0x7F, 0x00, 0x3E, 0x3C, 0x00, 0x7E, 0x0E, 0xFE, 0x0C, 0xC7, 0x1C, 0xC7,
  0x18, 0xC7, 0x38, 0xC7, 0x70, 0xFE, 0x70, 0x7E, 0xE0, 0x3C, 0x07, 0x80,
  0x1F, 0xE0, 0x3F, 0xF0, 0x3C, 0x70, 0x38, 0x40, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x1F, 0x3F, 0x1F, 0x7F, 0x9F, 0x73, 0xD8, 0x71, 0xF8,
  0xF0, 0xF8, 0xF0, 0x78, 0x78, 0x78, 0x7F, 0xFC, 0x3F, 0x9E, 0x1F, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0x87, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0xF0,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x20, 0xE2, 0xF3, 0xBF, 0xFF, 0xF7,
  0xFF, 0x83, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xCE, 0x0F, 0x1C, 0x38, 0x78,
  0x41, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x7D, 0xE7, 0x9C, 0x73, 0xCE, 0x38, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3B,
  0xC0, 0xFF, 0x01, 0xFC, 0xC7, 0xF7, 0x9F, 0xDE, 0x7F, 0x31, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0x70, 0x79, 0xC3, 0xC7, 0x06,
  0x1C, 0x10, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x1E, 0x1E, 0xF0, 0x78, 0x80, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1E, 0x20, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x0F,
  0xF0, 0x3F, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x38, 0x80, 0xF6, 0x03, 0xFC,
  0x1E, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x3B, 0xC1, 0xCF, 0x07, 0x3C, 0x38, 0xF1, 0xC3,
  0xC7, 0x0F, 0x38, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x9C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x3E, 0x1D, 0xFC, 0x7F, 0xF9, 0xE1, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x80, 0xF3, 0x03, 0xFE, 0x1E, 0x7F, 0xF8, 0xFF,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0xBE, 0x1D, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0xDE, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0x70, 0x39, 0xC0, 0xF7, 0x03, 0x9E,
  0x1E, 0x3F, 0xF0, 0x3F, 0x03, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFE, 0x1F, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3D, 0xE1, 0xF7, 0xFF, 0xCF, 0xEE, 0x1F, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x00, 0xF7, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3D, 0xFF, 0xFF, 0xC0, 0x79, 0xF7, 0xDF, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x79, 0xE7, 0x1C, 0xF3, 0x8E, 0x00, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0x00, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x00,
  0xF0, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x1F,
  0x83, 0xFE, 0x7F, 0xEF, 0x0F, 0xE0, 0xF2, 0x0F, 0x00, 0xF0, 0x1E, 0x0F,
  0xE0, 0xF8, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0E, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70,
  0x19, 0x80, 0x7E, 0x1D, 0xF8, 0xFF, 0xE7, 0xFF, 0x9C, 0x7E, 0x71, 0xF9,
  0xC7, 0xE7, 0x1F, 0x9C, 0x7E, 0x7F, 0xD8, 0xFF, 0x73, 0xDD, 0xC0, 0x03,
  0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E,
  0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0x3F, 0xFD, 0xE1, 0xEF, 0x07, 0x78, 0x3B, 0xC1, 0xDE, 0x1E, 0xFF, 0xE7,
  0xFE, 0x3F, 0xFD, 0xE0, 0xEF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF,
  0xF7, 0xFF, 0x3F, 0xF0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1E, 0x78,
  0x3D, 0xC0, 0x67, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x67, 0x83, 0xDF, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0,
  0x7C, 0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xDC, 0x1E, 0xFF, 0xE7, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xC0, 0x7F,
  0x83, 0xFF, 0x1E, 0x1E, 0x78, 0x39, 0xC0, 0xDF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0xF7, 0x83, 0xDE,
  0x1F, 0x3F, 0xFC, 0xFE, 0xF0, 0xF3, 0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x88, 0x3F, 0xC1, 0xCF, 0x1E, 0x7F, 0xF1, 0xFF, 0x03, 0xE0,
  0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x78,
  0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3E, 0xF0, 0xF3, 0xC3, 0xC7,
  0x8F, 0x0F, 0x3C, 0x3C, 0xF0, 0x7B, 0xC1, 0xEF, 0x03, 0xC0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0xFF,
  0xB3, 0x7E, 0xED, 0xFB, 0xF7, 0xE7, 0x9F, 0x9E, 0x7E, 0x39, 0xF8, 0xC7,
  0xE3, 0x1F, 0x84, 0x7E, 0x21, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xC0, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEE, 0x7E,
  0xE7, 0xEE, 0x7E, 0x77, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E,
  0x1E, 0x70, 0x3B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x3F, 0xF8,
  0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x0F,
  0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7,
  0x03, 0xDE, 0x1E, 0x3F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0xFF, 0xC7, 0xFF, 0x3F, 0xFD, 0xE1, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF,
  0x8F, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x1C, 0xF0, 0xF7, 0x83, 0xFC, 0x1E,
  0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0xDE, 0x0E, 0x70, 0x11, 0xC0, 0x07, 0x80,
  0x1F, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF6, 0x03, 0xFE, 0x1E, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0x81, 0xDE, 0x1E,
  0x7F, 0xF3, 0xFF, 0x07, 0xE0, 0xF0, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0x1E,
  0x38, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF0, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x70, 0x07, 0x73, 0xC6, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x73,
  0xEE, 0x73, 0xEE, 0x77, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x76,
  0x7E, 0x3E, 0x7E, 0x3E, 0x7E, 0x3E, 0x3E, 0x3C, 0x3C, 0x78, 0x1F, 0x3C,
  0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1E,
  0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x78, 0x0E,
  0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0x00, 0xFC,
  0x07, 0xF8, 0x1C, 0xE0, 0xF3, 0xC3, 0x87, 0x1E, 0x1E, 0x70, 0x3B, 0xC0,
  0xFE, 0x01, 0xD8, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x33, 0xC7, 0x8E,
  0x1C, 0x60, 0x1F, 0x83, 0xFE, 0x3F, 0xF9, 0xC3, 0xC4, 0x0F, 0x00, 0x78,
  0xFF, 0xDF, 0xFE, 0xE0, 0xF7, 0x07, 0xB8, 0x7D, 0xFE, 0xFF, 0xF7, 0x9E,
  0x1C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F,
  0x1D, 0xFC, 0xEF, 0xF7, 0x87, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0xF7, 0x7F, 0xBB, 0xF9, 0xCF, 0x80, 0x0F, 0x83,
  0xFE, 0x7F, 0xF7, 0x8F, 0xF0, 0x4E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x06, 0x78, 0xF7, 0xFF, 0x3F, 0xE0, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x7C, 0xE7, 0xF7, 0x7F, 0xFB, 0xC3, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x78, 0x7B, 0xFF,
  0xCF, 0xEE, 0x3E, 0x70, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x70,
  0x39, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x01, 0xC0, 0x07, 0x83, 0x0F,
  0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E, 0x00,
  0xF0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xFF, 0xBF, 0xFD,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x7F, 0x03, 0xFF, 0x07,
  0xFF, 0x1E, 0x1E, 0x38, 0x1C, 0x78, 0x78, 0xFF, 0xE0, 0xFF, 0xC0, 0xFE,
  0x03, 0x00, 0x0E, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0xC0, 0x3F,
  0xC0, 0x7B, 0xFF, 0xE7, 0xFF, 0x83, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0xCE, 0xFE, 0xEF, 0xFF, 0x0F, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3D, 0xFF, 0x7F, 0x9F, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xBC, 0x3C, 0xF1, 0xE3, 0xCF,
  0x0F, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x3C, 0x3C, 0x78, 0xF1,
  0xE3, 0xC3, 0xCF, 0x07, 0xBC, 0x1F, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEE, 0x3B, 0xBD, 0xFF, 0xFF, 0xF9, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39,
  0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E,
  0x70, 0xE3, 0xCE, 0xFE, 0xEF, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x1E, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3D, 0xC0, 0xF7, 0x87, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x00, 0xE7,
  0xC7, 0x7F, 0x3B, 0xFD, 0xE1, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xFC, 0x3D, 0xDF, 0xEE, 0xFE, 0x73, 0xE3, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFE, 0xF0,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xDE, 0x1E,
  0xFF, 0xF3, 0xFB, 0x8F, 0x9C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0xFE, 0x7F, 0xF7, 0xFF, 0xBE, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8,
  0x0F, 0xE1, 0xFF, 0x8F, 0xFE, 0xF0, 0x67, 0x80, 0x3F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x03, 0xF8, 0x01, 0xDC, 0x1F, 0xFF, 0xF3, 0xFF, 0x07, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0xF7,
  0x7F, 0x73, 0xE7, 0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9E, 0x0E, 0x38, 0x78,
  0xE1, 0xC3, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x7B, 0x80, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1E, 0x00, 0xE3, 0xC7, 0x63, 0xC7, 0x73, 0xC7, 0x73, 0xC6,
  0x73, 0xC6, 0x73, 0x6E, 0x73, 0x6E, 0x76, 0x6E, 0x76, 0x6E, 0x36, 0x6E,
  0x36, 0x6E, 0x36, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0xF8, 0x3D, 0xE1, 0xE3,
  0xC7, 0x07, 0xB8, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0xC0,
  0x7F, 0x83, 0xCF, 0x0E, 0x1C, 0x78, 0x7B, 0xC0, 0xF0, 0xF0, 0x1F, 0xC0,
  0xF7, 0x03, 0x9E, 0x0E, 0x38, 0x78, 0xF1, 0xC3, 0xCF, 0x07, 0x38, 0x1E,
  0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x3C, 0x7F, 0x0F, 0x81, 0xFC, 0x03,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xF8,
  0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0xE0,
  0x18, 0x07, 0x00, 0xF0, 0x0F, 0xF0, 0x7E, 0x3F, 0xCF, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0x87, 0xF0, 0xFC, 0x00,
  0x1C, 0x0C, 0xF8, 0x77, 0xF1, 0xDD, 0xE6, 0xE3, 0xFB, 0x87, 0xEE, 0x0F,
  0x00,
};

const GFXglyph IBMPlexMono_SemiBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 19, 16, 6, -19 },
  { 13, 9, 8, 16, 4, -20 },
  { 22, 16, 19, 16, 0, -19 },
  { 60, 14, 25, 16, 1, -22 },
  { 104, 16, 19, 16, 0, -19 },
  { 142, 16, 19, 16, 0, -19 },
  { 180, 3, 8, 16, 7, -20 },
  { 183, 9, 25, 16, 5, -21 },
  { 212, 9, 25, 16, 2, -21 },
  { 241, 14, 14, 16, 1, -15 },
  { 266, 13, 13, 16, 2, -15 },
  { 288, 6, 8, 16, 5, -4 },
  { 294, 8, 3, 16, 4, -10 },
  { 297, 5, 5, 16, 6, -5 },
  { 301, 12, 25, 16, 2, -21 },
  { 339, 14, 19, 16, 1, -19 },
  { 373, 14, 19, 16, 1, -19 },
  { 407, 14, 19, 16, 1, -19 },
  { 441, 14, 19, 16, 1, -19 },
  { 475, 14, 19, 16, 1, -19 },
  { 509, 14, 19, 16, 1, -19 },
  { 543, 14, 19, 16, 1, -19 },
  { 577, 14, 19, 16, 1, -19 },
  { 611, 14, 19, 16, 1, -19 },
  { 645, 14, 19, 16, 1, -19 },
  { 679, 5, 15, 16, 6, -15 },
  { 689, 6, 19, 16, 5, -15 },
  { 704, 12, 16, 16, 2, -16 },
  { 728, 13, 9, 16, 2, -13 },
  { 743, 12, 16, 16, 2, -16 },
  { 767, 12, 19, 16, 2, -19 },
  { 796, 14, 22, 16, 1, -19 },
  { 835, 16, 19, 16, 0, -19 },
  { 873, 13, 19, 16, 2, -19 },
  { 904, 14, 19, 16, 1, -19 },
  { 938, 13, 19, 16, 2, -19 },
  { 969, 12, 19, 16, 2, -19 },
  { 998, 13, 19, 16, 2, -19 },
  { 1029, 14, 19, 16, 1, -19 },
  { 1063, 12, 19, 16, 2, -19 },
  { 1092, 12, 19, 16, 2, -19 },
  { 1121, 13, 19, 16, 1, -19 },
  { 1152, 14, 19, 16, 2, -19 },
  { 1186, 12, 19, 16, 3, -19 },
  { 1215, 14, 19, 16, 1, -19 },
  { 1249, 12, 19, 16, 2, -19 },
  { 1278, 14, 19, 16, 1, -19 },
  { 1312, 13, 19, 16, 2, -19 },
  { 1343, 14, 24, 16, 1, -19 },
  { 1385, 13, 19, 16, 2, -19 },
  { 1416, 14, 19, 16, 1, -19 },
  { 1450, 15, 19, 16, 1, -19 },
  { 1486, 13, 19, 16, 2, -19 },
  { 1517, 16, 19, 16, 0, -19 },
  { 1555, 16, 19, 16, 0, -19 },
  { 1593, 16, 19, 16, 0, -19 },
  { 1631, 16, 19, 16, 0, -19 },
  { 1669, 14, 19, 16, 1, -19 },
  { 1703, 9, 25, 16, 5, -21 },
  { 1732, 12, 25, 16, 2, -21 },
  { 1770, 8, 25, 16, 3, -21 },
  { 1795, 14, 12, 16, 1, -19 },
  { 1816, 13, 3, 16, 2, 2 },
  { 1821, 6, 6, 16, 4, -22 },
  { 1826, 13, 14, 16, 2, -14 },
  { 1849, 13, 20, 16, 2, -20 },
  { 1882, 12, 14, 16, 2, -14 },
  { 1903, 13, 20, 16, 1, -20 },
  { 1936, 14, 14, 16, 1, -14 },
  { 1961, 13, 20, 16, 2, -20 },
  { 1994, 15, 22, 16, 1, -17 },
  { 2036, 12, 20, 16, 2, -20 },
  { 2066, 12, 21, 16, 3, -21 },
  { 2098, 10, 26, 16, 2, -21 },
  { 2131, 14, 20, 16, 2, -20 },
  { 2166, 12, 20, 16, 2, -20 },
  { 2196, 14, 14, 16, 1, -14 },
  { 2221, 12, 14, 16, 2, -14 },
  { 2242, 14, 14, 16, 1, -14 },
  { 2267, 13, 19, 16, 2, -14 },
  { 2298, 13, 19, 16, 1, -14 },
  { 2329, 13, 14, 16, 2, -14 },
  { 2352, 13, 14, 16, 1, -14 },
  { 2375, 13, 19, 16, 1, -19 },
  { 2406, 12, 14, 16, 2, -14 },
  { 2427, 14, 14, 16, 1, -14 },
  { 2452, 16, 14, 16, 0, -14 },
  { 2480, 14, 14, 16, 1, -14 },
  { 2505, 14, 19, 16, 1, -14 },
  { 2539, 12, 14, 16, 2, -14 },
  { 2560, 11, 25, 16, 3, -21 },
  { 2595, 3, 25, 16, 7, -21 },
  { 2605, 11, 25, 16, 3, -21 },
  { 2640, 14, 7, 16, 1, -12 },
};

const GFXfont IBMPlexMono_SemiBold27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_SEMIBOLD27PT7B_H_
