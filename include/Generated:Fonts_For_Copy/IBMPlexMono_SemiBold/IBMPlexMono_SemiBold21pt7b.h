#ifndef _IBMPLEXMONO_SEMIBOLD21PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x76, 0x62, 0x20, 0x07, 0xFF, 0x70, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xF3, 0x80, 0x0E, 0xE0, 0xCC, 0x0C, 0xC0, 0xCC, 0x7C, 0xF7,
  0xCF, 0x1D, 0xC1, 0x98, 0x19, 0x8F, 0x9F, 0xF9, 0xF1, 0x98, 0x3B, 0x83,
  0x30, 0x33, 0x00, 0x0E, 0x01, 0xC0, 0x7E, 0x3F, 0xE6, 0x4F, 0xC8, 0x39,
  0x07, 0x20, 0x7E, 0x07, 0xF0, 0x1F, 0x02, 0x70, 0x4E, 0x89, 0xF9, 0x37,
  0xFE, 0x3F, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x37, 0xC3, 0xC6, 0x6C, 0x6E,
  0xC6, 0xCC, 0x78, 0x7C, 0x03, 0x9E, 0x03, 0xF1, 0xB3, 0x1B, 0x33, 0x33,
  0x73, 0x36, 0x3F, 0xE1, 0xE0, 0x1F, 0x03, 0xF8, 0x31, 0x83, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x03, 0xC7, 0x7E, 0x76, 0x7C, 0xE3, 0xCE, 0x1C, 0x71,
  0xC7, 0xEE, 0x3C, 0x70, 0xFF, 0xFF, 0xF8, 0x0E, 0x30, 0xC3, 0x86, 0x1C,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x38,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC1, 0x83, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xC1,
  0x83, 0x0C, 0x38, 0xE3, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x76, 0x6F, 0xFE,
  0x7F, 0x07, 0x81, 0xF8, 0x33, 0x8E, 0x38, 0x84, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7B, 0xB9,
  0xCE, 0x60, 0xFF, 0xFC, 0x7F, 0xF7, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x70, 0x30, 0x00, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0xD9,
  0xFB, 0xBF, 0x77, 0xEC, 0xFC, 0x1F, 0x83, 0xF0, 0x67, 0x1C, 0xFF, 0x07,
  0xC0, 0x1F, 0x07, 0xE1, 0xDC, 0x3B, 0x8E, 0x70, 0x8E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xDF, 0xF8, 0x1F, 0x0F,
  0xF3, 0x87, 0x30, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0F, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0x1F, 0xEE, 0x1D, 0x07,
  0x01, 0xC0, 0x71, 0xF0, 0x7E, 0x01, 0xC0, 0x70, 0x0D, 0x07, 0xE1, 0xFF,
  0xE3, 0xF0, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0xC1, 0xB8, 0x77, 0x0C, 0xE3,
  0x1C, 0xE3, 0x98, 0x73, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x7F,
  0xCF, 0xF9, 0x80, 0x30, 0x06, 0x00, 0xDE, 0x1F, 0xF3, 0x8E, 0x00, 0xE0,
  0x1C, 0x03, 0xA0, 0x6E, 0x1C, 0xFF, 0x0F, 0xC0, 0x07, 0x83, 0xC0, 0x70,
  0x1C, 0x07, 0x00, 0xDE, 0x3F, 0xF7, 0x8E, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x67, 0x1C, 0xFF, 0x07, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xE1, 0xC0,
  0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x03, 0xC0,
  0x3F, 0x0F, 0xF9, 0xC7, 0x70, 0x6E, 0x0C, 0xE3, 0x8F, 0xC1, 0xFC, 0xF1,
  0xDC, 0x1F, 0x83, 0xF0, 0x7F, 0x1C, 0xFF, 0x87, 0xC0, 0x1F, 0x0F, 0xF1,
  0xC7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x8E, 0x7E, 0xC7, 0xB8, 0x06,
  0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x00, 0x7F, 0xF7, 0x00, 0x07, 0xFF, 0x70,
  0x77, 0xBC, 0xE0, 0x00, 0x00, 0x7B, 0xB9, 0xCE, 0x60, 0x00, 0x81, 0xC3,
  0xE7, 0xCF, 0x87, 0x03, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xE0, 0x10, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07,
  0x80, 0xF0, 0x1C, 0x0E, 0x1E, 0x3C, 0x7C, 0x38, 0x10, 0x00, 0x1F, 0x1F,
  0xE7, 0x1F, 0x87, 0x01, 0xC0, 0xE0, 0xF8, 0x30, 0x0C, 0x00, 0x00, 0x00,
  0x70, 0x1E, 0x07, 0x81, 0xC0, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xC7, 0xF3,
  0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x3F, 0xC7, 0xD8, 0x07, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0x00, 0xF8, 0x0F, 0x81, 0xD8, 0x1D, 0x81, 0x9C,
  0x19, 0xC3, 0x8C, 0x38, 0xE3, 0xFE, 0x3F, 0xE7, 0x06, 0x70, 0x76, 0x07,
  0xE0, 0x70, 0xFE, 0x3F, 0xCC, 0x3B, 0x0E, 0xC3, 0xB0, 0xEF, 0xE3, 0xFC,
  0xC3, 0xB0, 0x6C, 0x1F, 0x07, 0xC3, 0xBF, 0xEF, 0xE0, 0x1F, 0x07, 0xF9,
  0xC7, 0x30, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x77, 0x1C, 0x7F, 0x87, 0xC0, 0xFE, 0x3F, 0xCC, 0x3B, 0x0E, 0xC1,
  0xB0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1B, 0x0E, 0xC3, 0xBF, 0xCF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F,
  0x0F, 0xE7, 0x1F, 0x87, 0xE0, 0x38, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x3E,
  0x0F, 0x83, 0x71, 0xDF, 0xB3, 0xCC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x3F, 0xCF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x86, 0xE3, 0x9F, 0xE3,
  0xE0, 0xC1, 0xD8, 0x73, 0x1C, 0x63, 0x8C, 0xE1, 0xB8, 0x37, 0x07, 0xE0,
  0xFE, 0x1D, 0xC3, 0x1C, 0x61, 0xCC, 0x39, 0x83, 0xB0, 0x78, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0xFF, 0xFE, 0xE1, 0xFE, 0x3F, 0xC7, 0xF9, 0xFD, 0xBF, 0xB7, 0xF7,
  0xBE, 0x77, 0xCC, 0xF9, 0x9F, 0x13, 0xE4, 0x7C, 0x0F, 0x81, 0xF0, 0x38,
  0xF0, 0xFC, 0x3F, 0x8F, 0xE3, 0xF8, 0xFF, 0x3E, 0xCF, 0xB3, 0xE6, 0xF9,
  0xBE, 0x6F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1C, 0x1F, 0x0F, 0xF1, 0xC7, 0x70,
  0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x67,
  0x1C, 0xFF, 0x07, 0xC0, 0xFF, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C,
  0x3B, 0xFE, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F,
  0x0F, 0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x67, 0x1C, 0xFF, 0x07, 0xC0, 0x70, 0x0E, 0x01, 0xF8,
  0x1F, 0x00, 0xFF, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x3B, 0xFE,
  0xFE, 0x33, 0x8C, 0x73, 0x1C, 0xC3, 0xB0, 0xEC, 0x1C, 0x1F, 0x0F, 0xF9,
  0xC3, 0x70, 0x4E, 0x01, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xC0, 0x1C, 0x03,
  0xA0, 0x6E, 0x1D, 0xFF, 0x0F, 0xC0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0x71, 0xDF, 0xE3, 0xF0, 0xE0, 0x77,
  0x07, 0x70, 0x77, 0x06, 0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x8C, 0x19, 0xC1,
  0xDC, 0x1D, 0x81, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xE0, 0x3E, 0x03,
  0x60, 0x36, 0x73, 0x67, 0x36, 0x73, 0x67, 0x36, 0xD3, 0x6D, 0x76, 0xDF,
  0x6D, 0xF6, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0xE0, 0x70, 0x77, 0x0E, 0x38,
  0xE1, 0xDC, 0x1D, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF8, 0x1D,
  0xC3, 0x9C, 0x38, 0xE7, 0x0E, 0xE0, 0x70, 0xE0, 0x77, 0x07, 0x70, 0xE3,
  0x8E, 0x39, 0xC1, 0xDC, 0x1D, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xF8, 0xC0, 0x70, 0x18, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xF8, 0x0E,
  0x03, 0xC0, 0x7C, 0x1D, 0x83, 0x38, 0xE3, 0x18, 0x77, 0x06, 0xC0, 0xE0,
  0xFF, 0xFF, 0xF0, 0x27, 0x1C, 0x61, 0x80, 0x3F, 0x0F, 0xF3, 0x8E, 0x00,
  0xE0, 0x1C, 0x7F, 0x9F, 0xF7, 0x0E, 0xE1, 0xCF, 0xFC, 0xF3, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xCF, 0x3B, 0xF7, 0x8E, 0xE0, 0xDC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0D, 0xE3, 0xBB, 0xF7, 0x3C, 0x1F, 0x0F, 0xE7,
  0x1D, 0x84, 0xE0, 0x38, 0x0E, 0x01, 0x84, 0x71, 0xCF, 0xF1, 0xF0, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0x77, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xFC, 0x77, 0xFC, 0xF7, 0x1F, 0x0F, 0xE7, 0x1F, 0x83,
  0xFF, 0xFF, 0xFE, 0x03, 0x82, 0x71, 0xCF, 0xE1, 0xF0, 0x07, 0xE1, 0xFC,
  0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x1F, 0xF3, 0xFE, 0x00, 0xE0, 0x3C, 0x7C, 0x3F,
  0xC7, 0x1C, 0xC3, 0x9C, 0x73, 0xFC, 0x3F, 0x0C, 0x01, 0x80, 0x3F, 0xE3,
  0xFF, 0x81, 0xF8, 0x3F, 0xFF, 0x3F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x73, 0x7D, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0x0C, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x0E, 0x0F, 0x0E,
  0x00, 0x00, 0xFE, 0xFE, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0xFE, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFC, 0x73, 0x38, 0xDC, 0x3F, 0x0F, 0xC3, 0xB8, 0xC7, 0x31, 0xCC, 0x3B,
  0x07, 0xFC, 0x7E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0xD9, 0xDF, 0xFF, 0x3B, 0xE6,
  0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0x80, 0xCE,
  0x6F, 0xB8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xE0,
  0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0x71,
  0xCF, 0xF0, 0x7C, 0x00, 0xE7, 0x9D, 0xFB, 0xC7, 0x70, 0x6E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x06, 0xF1, 0xDD, 0xFB, 0x9E, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x00, 0x3D, 0xDF, 0xFF, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xF1,
  0xDF, 0xF3, 0xDC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xF9, 0xFE, 0xF3, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x3F, 0xEF, 0xF8, 0x1F, 0x1F,
  0xF7, 0x09, 0x80, 0x7F, 0x0F, 0xE0, 0xFC, 0x07, 0x61, 0xFF, 0xE3, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0xF0, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDF, 0xF3, 0xDC, 0xE0, 0xFC, 0x19,
  0x87, 0x38, 0xE7, 0x18, 0x67, 0x0E, 0xE1, 0xD8, 0x1F, 0x03, 0xC0, 0x38,
  0x00, 0xE7, 0x3E, 0x73, 0x67, 0x36, 0x53, 0x6D, 0x36, 0xD3, 0x6D, 0xE6,
  0x9E, 0x69, 0xE7, 0x9E, 0x38, 0xE0, 0xE1, 0xEE, 0x38, 0xEE, 0x1F, 0x81,
  0xE0, 0x1C, 0x07, 0xC1, 0xF8, 0x33, 0x8E, 0x3B, 0x87, 0x80, 0xE0, 0xFC,
  0x19, 0x87, 0x38, 0xE7, 0x18, 0x67, 0x0E, 0xC0, 0xD8, 0x1F, 0x03, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0xF0, 0x1E, 0x00, 0xFF, 0xFF, 0xC1, 0xE1, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0x8F, 0xCE, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x18, 0xFC, 0x7C, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x0F, 0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC,
  0x7E, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0xC0, 0x70, 0x1F, 0x8F, 0xCE, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x7E, 0x3E, 0x00, 0x38, 0x6F, 0x8F,
  0x3B, 0x63, 0xEC, 0x38,
};

const GFXglyph IBMPlexMono_SemiBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 15, 13, 4, -15 },
  { 9, 7, 7, 13, 3, -16 },
  { 16, 12, 15, 13, 0, -15 },
  { 39, 11, 19, 13, 1, -17 },
  { 66, 12, 15, 13, 0, -15 },
  { 89, 12, 15, 13, 0, -15 },
  { 112, 3, 7, 13, 5, -16 },
  { 115, 7, 19, 13, 4, -16 },
  { 132, 7, 19, 13, 2, -16 },
  { 149, 11, 11, 13, 1, -12 },
  { 165, 10, 10, 13, 1, -11 },
  { 178, 5, 6, 13, 4, -3 },
  { 182, 7, 2, 13, 3, -7 },
  { 184, 4, 4, 13, 4, -4 },
  { 186, 9, 19, 13, 2, -16 },
  { 208, 11, 15, 13, 1, -15 },
  { 229, 11, 15, 13, 1, -15 },
  { 250, 11, 15, 13, 1, -15 },
  { 271, 10, 15, 13, 1, -15 },
  { 290, 11, 15, 13, 1, -15 },
  { 311, 11, 15, 13, 1, -15 },
  { 332, 11, 15, 13, 1, -15 },
  { 353, 10, 15, 13, 1, -15 },
  { 372, 11, 15, 13, 1, -15 },
  { 393, 11, 15, 13, 1, -15 },
  { 414, 4, 11, 13, 4, -11 },
  { 420, 5, 14, 13, 4, -11 },
  { 429, 9, 12, 13, 2, -12 },
  { 443, 10, 7, 13, 1, -10 },
  { 452, 9, 12, 13, 2, -12 },
  { 466, 10, 15, 13, 1, -15 },
  { 485, 10, 17, 13, 1, -15 },
  { 507, 12, 15, 13, 0, -15 },
  { 530, 10, 15, 13, 2, -15 },
  { 549, 11, 15, 13, 1, -15 },
  { 570, 10, 15, 13, 2, -15 },
  { 589, 9, 15, 13, 2, -15 },
  { 606, 9, 15, 13, 2, -15 },
  { 623, 10, 15, 13, 1, -15 },
  { 642, 10, 15, 13, 1, -15 },
  { 661, 9, 15, 13, 2, -15 },
  { 678, 10, 15, 13, 1, -15 },
  { 697, 11, 15, 13, 2, -15 },
  { 718, 9, 15, 13, 2, -15 },
  { 735, 11, 15, 13, 1, -15 },
  { 756, 10, 15, 13, 1, -15 },
  { 775, 11, 15, 13, 1, -15 },
  { 796, 10, 15, 13, 2, -15 },
  { 815, 11, 19, 13, 1, -15 },
  { 842, 10, 15, 13, 2, -15 },
  { 861, 11, 15, 13, 1, -15 },
  { 882, 11, 15, 13, 1, -15 },
  { 903, 10, 15, 13, 1, -15 },
  { 922, 12, 15, 13, 0, -15 },
  { 945, 12, 15, 13, 0, -15 },
  { 968, 12, 15, 13, 0, -15 },
  { 991, 12, 15, 13, 0, -15 },
  { 1014, 11, 15, 13, 1, -15 },
  { 1035, 7, 19, 13, 4, -16 },
  { 1052, 9, 19, 13, 2, -16 },
  { 1074, 7, 19, 13, 2, -16 },
  { 1091, 11, 9, 13, 1, -15 },
  { 1104, 10, 2, 13, 1, 2 },
  { 1107, 5, 5, 13, 3, -17 },
  { 1111, 11, 11, 13, 1, -11 },
  { 1127, 11, 16, 13, 1, -16 },
  { 1149, 10, 11, 13, 1, -11 },
  { 1163, 10, 16, 13, 1, -16 },
  { 1183, 10, 11, 13, 1, -11 },
  { 1197, 11, 16, 13, 1, -16 },
  { 1219, 11, 17, 13, 1, -13 },
  { 1243, 9, 16, 13, 2, -16 },
  { 1261, 10, 16, 13, 2, -16 },
  { 1281, 8, 20, 13, 2, -16 },
  { 1301, 10, 16, 13, 2, -16 },
  { 1321, 9, 16, 13, 2, -16 },
  { 1339, 11, 11, 13, 1, -11 },
  { 1355, 9, 11, 13, 2, -11 },
  { 1368, 11, 11, 13, 1, -11 },
  { 1384, 11, 15, 13, 1, -11 },
  { 1405, 10, 15, 13, 1, -11 },
  { 1424, 10, 11, 13, 2, -11 },
  { 1438, 10, 11, 13, 1, -11 },
  { 1452, 10, 15, 13, 1, -15 },
  { 1471, 10, 11, 13, 1, -11 },
  { 1485, 11, 11, 13, 1, -11 },
  { 1501, 12, 11, 13, 0, -11 },
  { 1518, 11, 11, 13, 1, -11 },
  { 1534, 11, 15, 13, 1, -11 },
  { 1555, 9, 11, 13, 2, -11 },
  { 1568, 9, 19, 13, 2, -16 },
  { 1590, 2, 19, 13, 5, -16 },
  { 1595, 9, 19, 13, 2, -16 },
  { 1617, 11, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_SemiBold21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_SEMIBOLD21PT7B_H_
