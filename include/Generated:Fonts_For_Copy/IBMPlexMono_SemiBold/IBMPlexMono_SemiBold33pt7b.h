#ifndef _IBMPLEXMONO_SEMIBOLD33PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold33pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x0C, 0x30, 0xC0,
  0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xF0, 0x01, 0xE7, 0x80, 0x38,
  0xF0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xE3,
  0xC1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0x1E, 0x38, 0x03, 0x8F,
  0x00, 0x71, 0xE1, 0xFE, 0x3F, 0xBF, 0xC7, 0xF7, 0xF8, 0xFE, 0x0F, 0x3C,
  0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70,
  0x07, 0x9E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x1F, 0xE0,
  0x1F, 0xFF, 0x0F, 0xFF, 0xE3, 0xCE, 0xF1, 0xE3, 0x88, 0x78, 0xE0, 0x1E,
  0x38, 0x07, 0x8E, 0x01, 0xF3, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0xEF, 0x80, 0x39, 0xE0, 0x0E, 0x7C, 0x03, 0x8F,
  0x20, 0xE7, 0x8C, 0x39, 0xE7, 0xCE, 0xFB, 0xFF, 0xFC, 0x3F, 0xFE, 0x01,
  0xFE, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0xF3,
  0xF8, 0x1E, 0x7F, 0xC1, 0xC7, 0x1C, 0x3C, 0xF1, 0xC3, 0x8E, 0x1E, 0x78,
  0xE1, 0xE7, 0x0F, 0x1C, 0xF0, 0x71, 0xCE, 0x07, 0xFD, 0xE0, 0x3F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0xC0, 0x7B, 0xFE, 0x07, 0x38, 0xE0, 0xE7,
  0x0E, 0x0E, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE3, 0x83, 0x8E, 0x78,
  0x3F, 0xE7, 0x01, 0xFC, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x1E, 0x3E, 0x03, 0x83, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3F, 0x1F, 0xC7, 0xE7,
  0xFC, 0xFD, 0xE7, 0x9E, 0x3C, 0x7B, 0x87, 0x87, 0xF0, 0xF0, 0x7E, 0x1E,
  0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x3F, 0x87, 0xFE, 0xF8, 0x7F, 0x8F, 0x07,
  0xE0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0xF0, 0x3C, 0x07,
  0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x41, 0xE0, 0x9E, 0x79, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x3C,
  0x07, 0x8F, 0x83, 0xE1, 0xF0, 0x70, 0x30, 0x08, 0x08, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x1E, 0x78, 0xF1,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8,
  0x7C, 0x7C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07,
  0xBE, 0x79, 0xFF, 0x9E, 0x7F, 0xE7, 0x9F, 0xF9, 0xE7, 0xFE, 0x01, 0xFF,
  0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF0, 0xF8,
  0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x83,
  0xE3, 0xE0, 0x30, 0xF8, 0x08, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0xF8, 0x7E, 0xF0, 0x3E, 0x70, 0x1E,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE3, 0x80, 0xF0, 0x80, 0x78, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x98, 0x07,
  0xDE, 0x03, 0xFF, 0x83, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xDE, 0x00, 0xF7,
  0x80, 0x79, 0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x71, 0xF0, 0x77, 0xFC, 0x77,
  0xFE, 0x7C, 0x3F, 0x90, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x20, 0x0F, 0x70, 0x1F, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x79, 0xF0, 0xF7, 0xFC, 0xF7, 0xFE, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0xC7, 0xC3, 0xE7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E,
  0xF0, 0x0F, 0x3C, 0x0F, 0x1F, 0x0F, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0xE3, 0xE0, 0xF9, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDE,
  0x03, 0xEF, 0x83, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0xC0, 0xF3, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xDF, 0x03, 0xEF, 0xC3, 0xF3,
  0xFF, 0x78, 0xFF, 0x7C, 0x3F, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xDF, 0xBE, 0x7C, 0xF9, 0xE3, 0xCF, 0x1E, 0x38, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC0,
  0xFC, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0xC0, 0xFC, 0x03, 0xC0,
  0x0E, 0x00, 0x20, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xE3, 0xFF,
  0x03, 0xE6, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x01, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0x80, 0x73, 0xC0,
  0x3D, 0xC0, 0x0E, 0xE0, 0xE7, 0x71, 0xFB, 0xB8, 0xFF, 0xDC, 0x71, 0xEE,
  0x78, 0x7F, 0x3C, 0x3F, 0x9E, 0x1F, 0xCF, 0x0E, 0xE7, 0x87, 0x73, 0xC3,
  0xB8, 0xFF, 0xDC, 0x7E, 0xEE, 0x1F, 0x77, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78,
  0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC7, 0x80, 0xF8, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3E,
  0xF0, 0x07, 0xFE, 0x00, 0x78, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0x83,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xFF, 0x9E, 0x07, 0xBC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x3F, 0x78, 0x1F, 0x78,
  0x0F, 0xF8, 0x08, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x08, 0x78,
  0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8,
  0x1E, 0xF8, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3, 0xE0, 0x7D, 0xE0,
  0x10, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBE, 0x03,
  0xDF, 0x03, 0xE7, 0xC3, 0xF3, 0xFF, 0x78, 0xFF, 0x3C, 0x1F, 0x1E, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x7B,
  0xC0, 0xF7, 0xC3, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0xBE, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F,
  0x8F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xCF, 0x83, 0xE1, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xEF,
  0x80, 0xFC, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xEE, 0x77,
  0xEE, 0x77, 0xEF, 0xE7, 0xE7, 0xE7, 0xE7, 0xEF, 0xE3, 0xCF, 0xE3, 0xCF,
  0xE3, 0xCF, 0xE1, 0x8F, 0xE1, 0x8F, 0xE1, 0x0F, 0xE1, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xF7, 0x0F,
  0xF7, 0x8F, 0xF7, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0xCF,
  0xF1, 0xEF, 0xF0, 0xEF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF8, 0x7C, 0x7C, 0x0F, 0x1E, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1E,
  0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xC0,
  0xF0, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF8, 0x7C, 0x7C, 0x0F, 0x1E, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1E,
  0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xC0,
  0xF0, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xF1, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8,
  0xF0, 0x78, 0xF0, 0x7C, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F, 0x03, 0xF8,
  0x0F, 0xFF, 0x0F, 0xFF, 0xE7, 0xC1, 0xE7, 0xC0, 0x63, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x90, 0x03,
  0xDC, 0x03, 0xFF, 0x83, 0xE7, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7D, 0xE0, 0x1E, 0x78, 0x07,
  0x9F, 0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF3,
  0xF3, 0xFC, 0xFC, 0xFF, 0x3F, 0x3F, 0xCF, 0xCE, 0xF3, 0x73, 0x9C, 0xCC,
  0xE7, 0x73, 0xB9, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0xCE, 0xE7, 0x63, 0xB9,
  0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF8, 0x7C, 0x03, 0xE7,
  0xC0, 0x78, 0xF8, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x1F, 0x3E, 0x01,
  0xE7, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xF0, 0x0F,
  0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xC3, 0xC0, 0x7C, 0xF8,
  0x07, 0xBE, 0x00, 0xF8, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3,
  0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF9, 0xF0,
  0x07, 0x9E, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0x78,
  0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x1E, 0xF0, 0x07, 0x9C, 0x00, 0xF2, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xF1, 0xE1, 0xE1, 0xC3, 0xC3, 0x00,
  0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0x0F, 0x82, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x3E, 0x0F, 0x9E,
  0x07, 0xCF, 0x03, 0xE7, 0xC3, 0xF3, 0xFF, 0x7E, 0xFF, 0xBF, 0x1F, 0x0F,
  0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9,
  0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x0C, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x08, 0x78, 0x0C, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x1F, 0x9F, 0x1F, 0xEF, 0x9F, 0xFF, 0xDF, 0x87, 0xEF, 0x81,
  0xF7, 0x80, 0xFB, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBC,
  0x07, 0xDE, 0x03, 0xEF, 0x81, 0xF7, 0xE1, 0xF9, 0xFF, 0xFC, 0x7F, 0xBE,
  0x1F, 0x1F, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x04, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xE1, 0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x87, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xE7, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFE, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x78, 0xFB, 0xFD, 0xF7, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3F, 0xF0, 0x7C,
  0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0xFB, 0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0x7C,
  0xF0, 0x7C, 0xF0, 0x3E, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0x8F, 0x3D, 0xF7, 0xEF, 0xFD, 0xFB, 0xC7, 0x8E,
  0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC,
  0x78, 0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xC0, 0xF8, 0xF1, 0xF7, 0xFB, 0xEF, 0xFF,
  0xE1, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1E, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0xF8, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0xF9, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFC, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3E, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF0, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x0F, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xFB, 0xC0,
  0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF,
  0x01, 0xF7, 0xC0, 0xFB, 0xF0, 0xFC, 0xFF, 0xFE, 0x3F, 0xDF, 0x0F, 0x8F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xEF, 0xE0, 0xF4, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E,
  0x78, 0x0C, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7E, 0x00, 0x1E, 0x60, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xEF, 0x87, 0xDF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E, 0xF8, 0x07, 0xDE, 0x01,
  0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF0,
  0xF0, 0xEE, 0x1E, 0x1D, 0xC3, 0xC3, 0xB8, 0xF8, 0x77, 0x1F, 0x9E, 0xF3,
  0xF3, 0xDE, 0x6E, 0x7B, 0xCC, 0xCE, 0x39, 0x99, 0xC7, 0x73, 0x38, 0xEE,
  0x77, 0x1D, 0xCE, 0xE3, 0xB1, 0xDC, 0x76, 0x3B, 0x8F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0x80, 0xFC, 0x0F, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x7C,
  0xF8, 0x0F, 0x3C, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3D, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x83,
  0xC1, 0xF1, 0xF0, 0x3E, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xDE, 0x01, 0xE7,
  0x80, 0x79, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1D, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC3, 0xFE, 0x0F, 0xE0, 0x3F,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0x03,
  0x9F, 0xC1, 0xCF, 0xF0, 0xEF, 0x38, 0x77, 0x1E, 0x7B, 0x87, 0xFB, 0xC1,
  0xF8, 0xC0, 0x78,
};

const GFXglyph IBMPlexMono_SemiBold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 23, 20, 7, -23 },
  { 19, 10, 10, 20, 5, -24 },
  { 32, 19, 23, 20, 0, -23 },
  { 87, 18, 29, 20, 1, -26 },
  { 153, 20, 23, 20, 0, -23 },
  { 211, 19, 23, 20, 1, -23 },
  { 266, 4, 10, 20, 8, -24 },
  { 271, 11, 30, 20, 6, -25 },
  { 313, 11, 30, 20, 3, -25 },
  { 355, 18, 17, 20, 1, -18 },
  { 394, 16, 15, 20, 2, -18 },
  { 424, 7, 10, 20, 6, -5 },
  { 433, 10, 4, 20, 5, -12 },
  { 438, 6, 6, 20, 7, -6 },
  { 443, 14, 30, 20, 3, -25 },
  { 496, 18, 23, 20, 1, -23 },
  { 548, 18, 23, 20, 1, -23 },
  { 600, 16, 23, 20, 2, -23 },
  { 646, 17, 23, 20, 1, -23 },
  { 695, 18, 23, 20, 1, -23 },
  { 747, 16, 23, 20, 2, -23 },
  { 793, 16, 23, 20, 2, -23 },
  { 839, 16, 23, 20, 2, -23 },
  { 885, 17, 23, 20, 1, -23 },
  { 934, 17, 23, 20, 1, -23 },
  { 983, 6, 18, 20, 7, -18 },
  { 997, 7, 23, 20, 6, -18 },
  { 1018, 14, 20, 20, 3, -20 },
  { 1053, 16, 10, 20, 2, -15 },
  { 1073, 14, 20, 20, 3, -20 },
  { 1108, 15, 23, 20, 2, -23 },
  { 1152, 17, 27, 20, 1, -23 },
  { 1210, 19, 23, 20, 0, -23 },
  { 1265, 15, 23, 20, 3, -23 },
  { 1309, 16, 23, 20, 2, -23 },
  { 1355, 16, 23, 20, 2, -23 },
  { 1401, 14, 23, 20, 3, -23 },
  { 1442, 15, 23, 20, 3, -23 },
  { 1486, 17, 23, 20, 1, -23 },
  { 1535, 16, 23, 20, 2, -23 },
  { 1581, 14, 23, 20, 3, -23 },
  { 1622, 15, 23, 20, 2, -23 },
  { 1666, 18, 23, 20, 2, -23 },
  { 1718, 15, 23, 20, 3, -23 },
  { 1762, 16, 23, 20, 2, -23 },
  { 1808, 16, 23, 20, 2, -23 },
  { 1854, 18, 23, 20, 1, -23 },
  { 1906, 15, 23, 20, 3, -23 },
  { 1950, 18, 29, 20, 1, -23 },
  { 2016, 16, 23, 20, 3, -23 },
  { 2062, 17, 23, 20, 1, -23 },
  { 2111, 18, 23, 20, 1, -23 },
  { 2163, 16, 23, 20, 2, -23 },
  { 2209, 18, 23, 20, 1, -23 },
  { 2261, 18, 23, 20, 1, -23 },
  { 2313, 19, 23, 20, 0, -23 },
  { 2368, 20, 23, 20, 0, -23 },
  { 2426, 16, 23, 20, 2, -23 },
  { 2472, 11, 30, 20, 6, -25 },
  { 2514, 14, 30, 20, 3, -25 },
  { 2567, 10, 30, 20, 3, -25 },
  { 2605, 18, 15, 20, 1, -23 },
  { 2639, 16, 3, 20, 2, 3 },
  { 2645, 7, 7, 20, 5, -26 },
  { 2652, 17, 17, 20, 2, -17 },
  { 2689, 16, 24, 20, 2, -24 },
  { 2737, 16, 17, 20, 2, -17 },
  { 2771, 17, 24, 20, 1, -24 },
  { 2822, 16, 17, 20, 2, -17 },
  { 2856, 16, 24, 20, 2, -24 },
  { 2904, 17, 27, 20, 2, -20 },
  { 2962, 15, 24, 20, 2, -24 },
  { 3007, 15, 25, 20, 3, -25 },
  { 3054, 12, 32, 20, 3, -25 },
  { 3102, 16, 24, 20, 3, -24 },
  { 3150, 15, 24, 20, 2, -24 },
  { 3195, 18, 17, 20, 1, -17 },
  { 3234, 15, 17, 20, 2, -17 },
  { 3266, 16, 17, 20, 2, -17 },
  { 3300, 16, 24, 20, 2, -17 },
  { 3348, 17, 24, 20, 1, -17 },
  { 3399, 17, 17, 20, 2, -17 },
  { 3436, 16, 17, 20, 2, -17 },
  { 3470, 16, 23, 20, 1, -23 },
  { 3516, 15, 17, 20, 2, -17 },
  { 3548, 18, 17, 20, 1, -17 },
  { 3587, 19, 17, 20, 0, -17 },
  { 3628, 18, 17, 20, 1, -17 },
  { 3667, 18, 24, 20, 1, -17 },
  { 3721, 15, 17, 20, 2, -17 },
  { 3753, 14, 30, 20, 3, -25 },
  { 3806, 4, 30, 20, 8, -25 },
  { 3821, 14, 30, 20, 3, -25 },
  { 3874, 17, 8, 20, 1, -14 },
};

const GFXfont IBMPlexMono_SemiBold33pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold33pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold33pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _IBMPLEXMONO_SEMIBOLD33PT7B_H_
