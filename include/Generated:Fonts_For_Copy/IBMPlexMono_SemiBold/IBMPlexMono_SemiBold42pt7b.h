#ifndef _IBMPLEXMONO_SEMIBOLD42PT7B_H_
#define _IBMPLEXMONO_SEMIBOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-SemiBold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_SemiBold42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE3,
  0xC7, 0x0E, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0x80, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xF8, 0x7F, 0xE7,
  0xFC, 0x3F, 0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x7F, 0xE1, 0xFF, 0x3F, 0xF0, 0xFF,
  0x9F, 0xF8, 0x7F, 0xCF, 0xFC, 0x7F, 0xE0, 0x3E, 0x3E, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0x7B, 0xF1, 0xF1, 0xE3, 0x87,
  0xC7, 0x84, 0x3F, 0x1E, 0x00, 0xFC, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xE7,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xE7, 0xE0, 0x07, 0x8F, 0x80,
  0x1E, 0x3F, 0x00, 0x78, 0x7C, 0x81, 0xE3, 0xF3, 0x07, 0x8F, 0x9E, 0x1E,
  0x3E, 0xFE, 0x7B, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0xC0, 0x0F, 0x8F, 0xF0, 0x07, 0x8F, 0xFC, 0x07, 0xCF,
  0xFF, 0x03, 0xC7, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xC1, 0xE1, 0xE1,
  0xE0, 0x70, 0xF0, 0x70, 0x78, 0xF0, 0x3C, 0x3C, 0x78, 0x1E, 0x1E, 0x78,
  0x0F, 0xFF, 0x7C, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xF7, 0xFF, 0x80, 0xF3,
  0xE3, 0xC0, 0xF9, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x7C, 0x78, 0x3C, 0x3C,
  0x3C, 0x1E, 0x3C, 0x1E, 0x0F, 0x1E, 0x0F, 0x8F, 0x1E, 0x07, 0xFF, 0x8F,
  0x01, 0xFF, 0x8F, 0x00, 0x7F, 0x8F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0xC0,
  0x3E, 0x07, 0x80, 0x3E, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0xFE, 0x1F, 0xF0, 0xFE, 0x3F, 0xF0, 0xFE, 0x7C, 0xF8, 0xFE,
  0xFC, 0xFC, 0xF0, 0xF8, 0x7E, 0xF0, 0xF8, 0x3F, 0xF0, 0xF8, 0x1F, 0xE0,
  0xF8, 0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x1F, 0xF0,
  0x7F, 0xFD, 0xF8, 0x3F, 0xF8, 0xFC, 0x1F, 0xF8, 0x7E, 0x07, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x08, 0x0F, 0x81, 0x1E, 0x1F, 0x0F,
  0x3F, 0xBE, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xF7, 0xE0, 0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0xC0, 0x78,
  0x0F, 0x00, 0x20, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0x9F, 0xDF, 0xCF, 0xE7,
  0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE1,
  0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x1C, 0x3F, 0xF8, 0xF8, 0xFF, 0xE3, 0xE3,
  0xFF, 0x8F, 0x8F, 0xFE, 0x3E, 0x3F, 0xF8, 0x70, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xC0,
  0x1F, 0x1F, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0xFC, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0x03, 0xE0,
  0x08, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC7, 0xF0, 0xFE, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xC7, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x07, 0xF8, 0x78, 0x07, 0xE0,
  0xC0, 0x1F, 0x82, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x20, 0x03, 0xF3, 0x80, 0x0F, 0xDF, 0x00,
  0x7E, 0xFF, 0x03, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3C,
  0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0xF9, 0xFF, 0x87, 0xDF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFC, 0x1F, 0xCF, 0x80, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x88, 0x00,
  0xFC, 0xE0, 0x07, 0xEF, 0x80, 0x7E, 0xFF, 0x07, 0xF3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x8F,
  0xC0, 0xF9, 0xFF, 0x87, 0xDF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xDF,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F,
  0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0x3F, 0x00, 0xF9, 0xF0, 0x07,
  0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x7C, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xFC,
  0x7F, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x7F, 0x07, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F,
  0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFD,
  0xFC, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFD, 0xF0, 0xFF, 0xCF, 0x81, 0xF8,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7C, 0x3E, 0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xBF, 0x9F,
  0xCF, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03,
  0xF0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x07,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF,
  0xE0, 0xFD, 0xF8, 0x0F, 0xDE, 0x01, 0xF8, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F,
  0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x0F, 0x78, 0x3E, 0x7F, 0xC3,
  0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFF, 0xFF, 0x0F, 0x0F, 0xF8, 0xF8, 0x3F,
  0xC7, 0xC1, 0xFE, 0x3C, 0x0F, 0xF1, 0xE0, 0x7F, 0x8F, 0x03, 0xFC, 0x78,
  0x1F, 0xE3, 0xE0, 0xFF, 0x0F, 0x0F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFD, 0xFE,
  0x0F, 0xEF, 0x78, 0x3E, 0x7B, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03,
  0xEF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xCF, 0xC0, 0x07, 0xC7, 0xC0, 0x07,
  0xC7, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x0F,
  0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF,
  0xC0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF8, 0x3F, 0x1F, 0x80,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0x83, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x08, 0x3F, 0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x83, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0xF8, 0x1F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF,
  0x80, 0x7E, 0xF8, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3F, 0xFC, 0x01,
  0x87, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF8,
  0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x87, 0xF9, 0xFF, 0xF7, 0xC7, 0xFF, 0x3E,
  0x1F, 0xF1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x70, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xF8, 0x0F, 0xE3,
  0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF,
  0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xEF, 0xFF,
  0xCF, 0x7F, 0xDE, 0xF3, 0xFE, 0xFF, 0x9F, 0xF3, 0xFD, 0xFF, 0x9F, 0xCF,
  0xFC, 0xFE, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xC3,
  0x87, 0xFE, 0x1C, 0x3F, 0xF0, 0x61, 0xFF, 0x82, 0x0F, 0xFC, 0x10, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xEF, 0x07, 0xFD, 0xF0, 0xFF,
  0xBE, 0x1F, 0xF3, 0xE3, 0xFE, 0x7C, 0x7F, 0xC7, 0x8F, 0xF8, 0xF9, 0xFF,
  0x1F, 0x3F, 0xE1, 0xE7, 0xFC, 0x3E, 0xFF, 0x87, 0xDF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x3F,
  0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x80, 0xFC, 0x3F, 0x07,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7E, 0xFC,
  0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0,
  0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x80, 0xFC, 0x3F, 0x07, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80,
  0x3E, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF,
  0xC0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0x81, 0xF8, 0xFC,
  0x01, 0xC3, 0xE0, 0x02, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x40, 0x01, 0xF1, 0x80, 0x0F,
  0xCF, 0x00, 0x3F, 0x7F, 0x03, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xFC, 0x03, 0xEF, 0xC0, 0x7E, 0x7E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F,
  0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x7C,
  0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x03, 0xE0,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F,
  0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7E, 0x3F, 0xF0, 0xFC, 0x7F, 0xE3,
  0xF8, 0xFB, 0xC7, 0xF1, 0xF7, 0x8F, 0xE3, 0xEF, 0x1D, 0xC7, 0xDE, 0x3B,
  0xCF, 0x3C, 0x77, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0xCE, 0x79, 0xF7, 0x9C,
  0xF3, 0xEE, 0x39, 0xE7, 0xDC, 0x7B, 0xCF, 0xB8, 0xF7, 0x9F, 0xF1, 0xEF,
  0x3F, 0xE3, 0xDE, 0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x0F, 0xF1,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x03, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xFC,
  0x7E, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xBF, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07,
  0xC0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x70, 0x00, 0x70,
  0x20, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x04, 0x03, 0xFC,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0,
  0xE0, 0x1F, 0x81, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x87,
  0xFF, 0xFF, 0xCF, 0xFE, 0x7F, 0x1F, 0xF1, 0xFC, 0x3F, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x87, 0xE0,
  0xF8, 0xFF, 0x8F, 0x9F, 0xFC, 0xFB, 0xFF, 0xEF, 0xE0, 0xFE, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xEF, 0xBF, 0xFE, 0xF9, 0xFF, 0xCF,
  0x8F, 0xF8, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xE7, 0xF0, 0x7E, 0xFC, 0x07, 0x9F, 0x00, 0x47, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x0C, 0x7E, 0x03, 0xCF, 0xE0, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x1F, 0x1F,
  0xF9, 0xF3, 0xFF, 0xDF, 0x3F, 0xFD, 0xF7, 0xF0, 0x7F, 0x7E, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xF7, 0xE0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xDF, 0x3F, 0xFD, 0xF1, 0xFF,
  0x9F, 0x07, 0xE1, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x08, 0x7E, 0x00,
  0xE1, 0xFC, 0x1F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x3E, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFD, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x8F, 0xC3, 0xF3, 0xFE, 0x7E, 0xFF, 0xEF, 0xFF, 0xFD, 0xFC, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xEF, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF3, 0xC1, 0xE3, 0xDF, 0x8F, 0xCF, 0x7F, 0x7F, 0xBF, 0xFD, 0xFE,
  0xF8, 0xFC, 0xFB, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0,
  0xF8, 0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8,
  0x7F, 0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F,
  0xC3, 0xE1, 0xFF, 0x0F, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8, 0x7F, 0xC3,
  0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0xF3, 0xF7, 0xFF, 0x7F, 0xFF, 0xEF,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7F, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0x80,
  0x3E, 0x7E, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xF8, 0x7E, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF,
  0xCF, 0xBF, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0xFE, 0xFB, 0xFF, 0xEF, 0x9F, 0xFC, 0xF8, 0xFF, 0x8F, 0x87, 0xE0,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE1, 0xF1, 0xFF,
  0x9F, 0x3F, 0xFD, 0xF3, 0xFF, 0xDF, 0x7F, 0x07, 0xF7, 0xE0, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0x7E, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFD, 0xF3, 0xFF, 0xDF, 0x1F, 0xF9,
  0xF0, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xF0, 0x3E, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x03, 0xE3, 0xE0, 0x0C,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF1, 0x00,
  0x1F, 0x38, 0x01, 0xF7, 0xE0, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xC1, 0xFD,
  0xFF, 0xEF, 0x9F, 0xFD, 0xF1, 0xFF, 0x3E, 0x1F, 0x87, 0xC0, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7E, 0x01, 0xF0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xF0,
  0x7C, 0x1F, 0xF0, 0x7C, 0x1E, 0xF0, 0x7E, 0x1E, 0xF0, 0x7E, 0x1E, 0xF8,
  0xFE, 0x1E, 0xF8, 0xFE, 0x1E, 0xF8, 0xEE, 0x1E, 0x78, 0xEE, 0x1E, 0x78,
  0xEF, 0x3E, 0x78, 0xEF, 0x3C, 0x78, 0xE7, 0x3C, 0x79, 0xE7, 0x3C, 0x79,
  0xC7, 0x3C, 0x79, 0xC7, 0x3C, 0x7D, 0xC7, 0xBC, 0x3D, 0xC7, 0xBC, 0x3D,
  0xC7, 0xBC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xFB,
  0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0,
  0x03, 0xF7, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7E,
  0xF8, 0x00, 0xF9, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0x87,
  0xE0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0x70, 0xFE, 0x03, 0xCF, 0xF8, 0x1E, 0xFF, 0xE0, 0xF7, 0x8F, 0x8F,
  0xFC, 0x7E, 0x7B, 0xC1, 0xFF, 0xDE, 0x07, 0xFC, 0xF0, 0x1F, 0xC3, 0x80,
  0x7C, 0x00,
};

const GFXglyph IBMPlexMono_SemiBold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 13, 13, 25, 6, -31 },
  { 49, 25, 29, 25, 0, -29 },
  { 140, 22, 37, 25, 2, -33 },
  { 242, 25, 29, 25, 0, -29 },
  { 333, 24, 29, 25, 1, -29 },
  { 420, 5, 13, 25, 10, -31 },
  { 429, 14, 38, 25, 8, -32 },
  { 496, 15, 38, 25, 3, -32 },
  { 568, 23, 21, 25, 1, -23 },
  { 629, 20, 20, 25, 3, -23 },
  { 679, 9, 13, 25, 8, -7 },
  { 694, 13, 5, 25, 6, -15 },
  { 703, 8, 8, 25, 9, -7 },
  { 711, 19, 38, 25, 3, -32 },
  { 802, 22, 29, 25, 2, -29 },
  { 882, 22, 29, 25, 2, -29 },
  { 962, 21, 29, 25, 2, -29 },
  { 1039, 22, 29, 25, 1, -29 },
  { 1119, 23, 29, 25, 1, -29 },
  { 1203, 21, 29, 25, 2, -29 },
  { 1280, 21, 29, 25, 2, -29 },
  { 1357, 21, 29, 25, 2, -29 },
  { 1434, 21, 29, 25, 2, -29 },
  { 1511, 21, 29, 25, 2, -29 },
  { 1588, 8, 23, 25, 9, -22 },
  { 1611, 9, 28, 25, 8, -22 },
  { 1643, 18, 25, 25, 4, -25 },
  { 1700, 20, 13, 25, 3, -19 },
  { 1733, 18, 25, 25, 4, -25 },
  { 1790, 19, 29, 25, 3, -29 },
  { 1859, 21, 34, 25, 2, -29 },
  { 1949, 24, 29, 25, 1, -29 },
  { 2036, 20, 29, 25, 3, -29 },
  { 2109, 21, 29, 25, 2, -29 },
  { 2186, 20, 29, 25, 3, -29 },
  { 2259, 19, 29, 25, 3, -29 },
  { 2328, 20, 29, 25, 3, -29 },
  { 2401, 21, 29, 25, 2, -29 },
  { 2478, 19, 29, 25, 3, -29 },
  { 2547, 19, 29, 25, 3, -29 },
  { 2616, 19, 29, 25, 2, -29 },
  { 2685, 22, 29, 25, 3, -29 },
  { 2765, 19, 29, 25, 4, -29 },
  { 2834, 21, 29, 25, 2, -29 },
  { 2911, 19, 29, 25, 3, -29 },
  { 2980, 22, 29, 25, 2, -29 },
  { 3060, 20, 29, 25, 3, -29 },
  { 3133, 22, 36, 25, 2, -29 },
  { 3232, 21, 29, 25, 3, -29 },
  { 3309, 22, 29, 25, 1, -29 },
  { 3389, 23, 29, 25, 1, -29 },
  { 3473, 20, 29, 25, 3, -29 },
  { 3546, 23, 29, 25, 1, -29 },
  { 3630, 23, 29, 25, 1, -29 },
  { 3714, 24, 29, 25, 1, -29 },
  { 3801, 25, 29, 25, 0, -29 },
  { 3892, 21, 29, 25, 2, -29 },
  { 3969, 13, 38, 25, 8, -32 },
  { 4031, 19, 38, 25, 3, -32 },
  { 4122, 13, 38, 25, 4, -32 },
  { 4184, 23, 19, 25, 1, -29 },
  { 4239, 20, 4, 25, 3, 4 },
  { 4249, 8, 9, 25, 7, -33 },
  { 4258, 22, 22, 25, 2, -22 },
  { 4319, 20, 31, 25, 3, -31 },
  { 4397, 19, 22, 25, 3, -22 },
  { 4450, 20, 31, 25, 2, -31 },
  { 4528, 21, 22, 25, 2, -22 },
  { 4586, 20, 31, 25, 3, -31 },
  { 4664, 22, 33, 25, 2, -25 },
  { 4755, 19, 31, 25, 3, -31 },
  { 4829, 19, 31, 25, 4, -31 },
  { 4903, 15, 39, 25, 4, -31 },
  { 4977, 22, 31, 25, 3, -31 },
  { 5063, 19, 31, 25, 3, -31 },
  { 5137, 22, 22, 25, 2, -22 },
  { 5198, 19, 22, 25, 3, -22 },
  { 5251, 21, 22, 25, 2, -22 },
  { 5309, 20, 30, 25, 3, -22 },
  { 5384, 20, 30, 25, 2, -22 },
  { 5459, 21, 22, 25, 3, -22 },
  { 5517, 20, 22, 25, 2, -22 },
  { 5572, 20, 29, 25, 2, -29 },
  { 5645, 19, 22, 25, 3, -22 },
  { 5698, 22, 22, 25, 2, -22 },
  { 5759, 24, 22, 25, 1, -22 },
  { 5825, 23, 22, 25, 1, -22 },
  { 5889, 23, 30, 25, 1, -22 },
  { 5976, 19, 22, 25, 3, -22 },
  { 6029, 17, 38, 25, 4, -32 },
  { 6110, 5, 38, 25, 10, -32 },
  { 6134, 17, 38, 25, 4, -32 },
  { 6215, 21, 10, 25, 2, -18 },
};

const GFXfont IBMPlexMono_SemiBold42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_SemiBold42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_SemiBold42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_SEMIBOLD42PT7B_H_
