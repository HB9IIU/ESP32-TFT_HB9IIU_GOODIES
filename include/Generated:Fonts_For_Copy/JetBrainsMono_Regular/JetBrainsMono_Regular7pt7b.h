#ifndef _JETBRAINSMONO_REGULAR7PT7B_H_
#define _JETBRAINSMONO_REGULAR7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x5F, 0x6F, 0xA0, 0x25, 0x46, 0xB6, 0x20, 0xDE, 0x27,
  0xB0, 0x64, 0x5A, 0x70, 0xC0, 0x6A, 0xA4, 0x95, 0x58, 0x2F, 0x60, 0x2F,
  0x20, 0xE0, 0xC0, 0x80, 0x29, 0x29, 0x20, 0xF7, 0xDC, 0xC9, 0x2E, 0x69,
  0x24, 0x70, 0x72, 0x59, 0x60, 0x52, 0xF2, 0xDA, 0x9C, 0x24, 0x79, 0x60,
  0xE5, 0x28, 0xF7, 0x5C, 0x79, 0x72, 0x40, 0x90, 0xC1, 0x80, 0x71, 0x10,
  0xFC, 0x8F, 0x40, 0xDE, 0x80, 0x7B, 0xDD, 0xB6, 0x26, 0x66, 0x90, 0xD7,
  0x5C, 0xF2, 0x5C, 0xD6, 0xDC, 0xF3, 0x4E, 0xF3, 0xC8, 0xF3, 0xDC, 0xB7,
  0xDA, 0xD5, 0xC0, 0x24, 0xD6, 0xBB, 0x6A, 0x92, 0x4E, 0xBF, 0xDA, 0xB6,
  0xFA, 0xD6, 0xDC, 0xF7, 0x48, 0xF6, 0xDC, 0xC0, 0xF7, 0x6A, 0x74, 0x69,
  0x60, 0xF2, 0x22, 0x20, 0xB6, 0xDC, 0x95, 0x66, 0x20, 0xBB, 0xF7, 0x60,
  0xD6, 0x26, 0x90, 0x96, 0x62, 0x20, 0xE9, 0x4E, 0xEA, 0xAC, 0x92, 0x24,
  0x88, 0xD5, 0x5C, 0x5A, 0x80, 0xF0, 0xC0, 0x61, 0xF7, 0x9A, 0xDC, 0xD6,
  0x70, 0x3E, 0xDE, 0xDE, 0x70, 0x3F, 0x44, 0x40, 0xF6, 0xFE, 0x9A, 0xDA,
  0x59, 0x2E, 0x75, 0x70, 0x97, 0x6A, 0xC4, 0x44, 0x30, 0xFB, 0xBB, 0xD6,
  0xD0, 0xD6, 0xE0, 0xD6, 0xE8, 0xF6, 0xF2, 0xD6, 0x40, 0xF1, 0xF0, 0x4F,
  0x44, 0x30, 0xB6, 0xE0, 0x95, 0x62, 0xBB, 0x76, 0xD6, 0x6D, 0x96, 0x62,
  0x40, 0xEA, 0x70, 0x69, 0x44, 0x98, 0xFE, 0x92, 0x39, 0x20, 0xF0,
};

const GFXglyph JetBrainsMono_Regular7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 5, 4, 2, -5 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 4, 7, 4, 0, -6 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 4, 2, -5 },
  { 17, 2, 7, 4, 1, -6 },
  { 19, 2, 7, 4, 1, -6 },
  { 21, 4, 3, 4, 0, -4 },
  { 23, 4, 3, 4, 0, -4 },
  { 25, 2, 2, 4, 1, -1 },
  { 26, 2, 1, 4, 1, -3 },
  { 27, 1, 1, 4, 2, -1 },
  { 28, 3, 7, 4, 1, -6 },
  { 31, 3, 5, 4, 1, -5 },
  { 33, 3, 5, 4, 1, -5 },
  { 35, 4, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 1, -5 },
  { 43, 3, 5, 4, 1, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 3, 5, 4, 1, -5 },
  { 50, 3, 5, 4, 1, -5 },
  { 52, 4, 5, 4, 0, -5 },
  { 55, 1, 4, 4, 2, -4 },
  { 56, 2, 5, 4, 1, -4 },
  { 58, 3, 4, 4, 1, -4 },
  { 60, 3, 2, 4, 1, -3 },
  { 61, 3, 4, 4, 1, -4 },
  { 63, 2, 5, 4, 1, -5 },
  { 65, 4, 6, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 3, 5, 4, 1, -5 },
  { 73, 3, 5, 4, 1, -5 },
  { 75, 3, 5, 4, 1, -5 },
  { 77, 3, 5, 4, 1, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 3, 5, 4, 1, -5 },
  { 83, 3, 5, 4, 1, -5 },
  { 85, 2, 5, 4, 1, -5 },
  { 87, 3, 5, 4, 0, -5 },
  { 89, 3, 5, 4, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 3, 5, 4, 1, -5 },
  { 95, 3, 5, 4, 1, -5 },
  { 97, 3, 5, 4, 1, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 3, 6, 4, 1, -5 },
  { 104, 3, 5, 4, 1, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 3, 5, 4, 1, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 3, 5, 4, 1, -5 },
  { 128, 2, 7, 4, 1, -6 },
  { 130, 3, 7, 4, 1, -6 },
  { 133, 2, 7, 4, 1, -6 },
  { 135, 3, 3, 4, 1, -5 },
  { 137, 4, 1, 4, 0, 0 },
  { 138, 2, 1, 4, 1, -6 },
  { 139, 4, 4, 4, 0, -4 },
  { 141, 3, 5, 4, 1, -5 },
  { 143, 3, 4, 4, 1, -4 },
  { 145, 3, 5, 4, 1, -5 },
  { 147, 3, 4, 4, 1, -4 },
  { 149, 4, 5, 4, 0, -5 },
  { 152, 3, 5, 4, 1, -4 },
  { 154, 3, 5, 4, 1, -5 },
  { 156, 3, 5, 4, 1, -5 },
  { 158, 2, 6, 4, 1, -5 },
  { 160, 3, 5, 4, 1, -5 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 4, 4, 4, 0, -4 },
  { 167, 3, 4, 4, 1, -4 },
  { 169, 3, 4, 4, 1, -4 },
  { 171, 3, 5, 4, 1, -4 },
  { 173, 3, 5, 4, 1, -4 },
  { 175, 3, 4, 4, 1, -4 },
  { 177, 3, 4, 4, 1, -4 },
  { 179, 4, 5, 4, 0, -5 },
  { 182, 3, 4, 4, 1, -4 },
  { 184, 4, 4, 4, 0, -4 },
  { 186, 4, 4, 4, 0, -4 },
  { 188, 4, 4, 4, 0, -4 },
  { 190, 4, 5, 4, 0, -4 },
  { 193, 3, 4, 4, 1, -4 },
  { 195, 3, 7, 4, 1, -6 },
  { 198, 1, 7, 4, 2, -6 },
  { 199, 3, 7, 4, 1, -6 },
  { 202, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_Regular7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_REGULAR7PT7B_H_
