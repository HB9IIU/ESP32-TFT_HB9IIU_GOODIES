#ifndef _JETBRAINSMONO_REGULAR49PT7B_H_
#define _JETBRAINSMONO_REGULAR49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x3F, 0xFF, 0xFF, 0xFB, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xBC, 0x1F,
  0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE,
  0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x01, 0xE0,
  0x03, 0x80, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01,
  0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x07, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0xF0, 0x1E, 0x00,
  0x38, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C,
  0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xC0, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x1E, 0x01, 0xC0,
  0x07, 0x80, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x9C, 0x7C, 0x7C, 0x70, 0xF9, 0xE1,
  0xC3, 0xE7, 0x87, 0x07, 0x9E, 0x1C, 0x1E, 0x78, 0x70, 0x01, 0xE1, 0xC0,
  0x07, 0x87, 0x00, 0x1F, 0x1C, 0x00, 0x7E, 0x70, 0x00, 0xFD, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x71, 0xF8, 0x01, 0xC3, 0xE0, 0x07, 0x07,
  0x80, 0x1C, 0x1F, 0x00, 0x70, 0x7C, 0x01, 0xC1, 0xFF, 0x07, 0x07, 0xFC,
  0x1C, 0x1F, 0xF8, 0x70, 0x7F, 0xE1, 0xC3, 0xE7, 0xE7, 0x1F, 0x9F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xF3, 0xFE, 0x00, 0x1E,
  0x7F, 0xF0, 0x01, 0xCF, 0x8F, 0x80, 0x38, 0xF0, 0x78, 0x07, 0x8F, 0x03,
  0x80, 0xF0, 0xE0, 0x38, 0x0E, 0x0E, 0x03, 0x81, 0xE0, 0xE0, 0x38, 0x3C,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0x38, 0x78, 0x0F, 0x07, 0x8F, 0x00, 0xF8,
  0x78, 0xE0, 0x07, 0xFF, 0x1E, 0x00, 0x7F, 0xF3, 0xC0, 0x01, 0xFC, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x7F, 0x00, 0x03, 0x8F, 0xFC, 0x00, 0x79,
  0xFF, 0xE0, 0x0F, 0x1E, 0x3E, 0x00, 0xE3, 0xC0, 0xE0, 0x1C, 0x3C, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x03, 0xC0, 0xF0, 0xF0,
  0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xF1, 0xC0, 0x3C, 0x0E, 0x3C, 0x03, 0xE1,
  0xE7, 0x80, 0x1F, 0xFE, 0x70, 0x00, 0xFF, 0xCF, 0x00, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x1F,
  0x03, 0xEF, 0x07, 0xC1, 0xE7, 0x83, 0xE1, 0xF3, 0xC0, 0xF8, 0xF1, 0xE0,
  0x3E, 0xF8, 0xF0, 0x0F, 0xF8, 0x78, 0x07, 0xF8, 0x3C, 0x01, 0xFC, 0x1E,
  0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x83, 0xE0, 0x1F, 0xE1,
  0xF0, 0x1F, 0xF0, 0x7F, 0x7F, 0x7C, 0x3F, 0xFF, 0x1F, 0x0F, 0xFF, 0x07,
  0xC1, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x39, 0xC0, 0x00, 0x06, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x80,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xF0, 0x3F, 0x80,
  0xFC, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x01, 0x80, 0x78, 0x04, 0x78, 0x1C, 0x0F, 0xBF,
  0xC7, 0x0F, 0xEF, 0xF9, 0xCF, 0xFD, 0xFF, 0xB7, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x07,
  0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x01, 0xE0,
  0x03, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x3F, 0x3E, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x0E, 0x0F, 0xF0,
  0xF8, 0x7F, 0x87, 0xE3, 0xFC, 0x3F, 0x1F, 0xE1, 0xF0, 0xFF, 0x07, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0xC0, 0x3E, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x01, 0xFC, 0xF8, 0x0F, 0xE3, 0xE0, 0x3E,
  0x0F, 0x80, 0xF0, 0x3E, 0x03, 0x80, 0xF8, 0x08, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F,
  0x80, 0x7E, 0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x80, 0x3C, 0x7F,
  0xC1, 0xEF, 0xFF, 0x0F, 0x7F, 0xFC, 0x7F, 0xCF, 0xF3, 0xF0, 0x0F, 0x9F,
  0x00, 0x3E, 0xF8, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0xC0, 0x3E,
  0x3F, 0xDF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xCF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x7F, 0x8F, 0xF1, 0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x80,
  0x0F, 0x9F, 0x80, 0x1F, 0x1F, 0x80, 0x7C, 0x1F, 0xEF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x3F, 0x3E,
  0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xE7, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C,
  0x1F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0,
  0x1F, 0xBF, 0x81, 0xF0, 0x7E, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0xC0, 0x3E, 0x3F, 0xDF,
  0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F, 0x87,
  0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF, 0x80, 0x7F, 0xBE,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7E, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01,
  0xFC, 0x1F, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1C, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F,
  0xEF, 0xE0, 0x3E, 0x3F, 0xF0, 0x3E, 0x07, 0xF8, 0x1E, 0x03, 0xFC, 0x0F,
  0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x3F, 0x81, 0xE0, 0x1F, 0xC0,
  0xF0, 0x0F, 0xE0, 0x78, 0x07, 0xF0, 0x3C, 0x03, 0xF8, 0x1E, 0x03, 0xFC,
  0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x7F, 0x81, 0xF0, 0x7F,
  0xC0, 0x7F, 0xEF, 0xE0, 0x1F, 0xF7, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x7C,
  0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83,
  0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03,
  0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0x00, 0xFE, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00,
  0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x1F, 0x78, 0x00, 0xF3, 0xC0, 0x1F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xE0, 0x3F, 0xCF, 0x00, 0x3E, 0x78,
  0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0,
  0x07, 0xDE, 0x00, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xF0, 0x3F, 0x3E, 0x00, 0xFD, 0xE0, 0x03, 0xEF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x03,
  0xEF, 0xC0, 0x3E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xF0, 0x1F, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xF0, 0x3F, 0x3E, 0x00, 0xFD, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0,
  0x3E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0x80, 0x7E,
  0x3F, 0xEF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7C, 0xF0, 0x01,
  0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0,
  0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F,
  0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00,
  0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F,
  0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xDF, 0xB8, 0x0F,
  0x7E, 0xF0, 0x3F, 0xFB, 0xC0, 0xEF, 0xE7, 0x07, 0xBF, 0x9C, 0x1E, 0xFE,
  0x78, 0x73, 0xF8, 0xE3, 0xCF, 0xF3, 0x8F, 0x3F, 0xCF, 0x38, 0xFF, 0x1C,
  0xE3, 0xFC, 0x77, 0x8F, 0xF1, 0xFC, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC7,
  0xFC, 0x3E, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xDE, 0x01, 0xFE, 0xF0, 0x0F, 0xF7, 0x80, 0x7F, 0x9E,
  0x03, 0xFE, 0xF0, 0x1F, 0xF7, 0x80, 0xFF, 0x9E, 0x07, 0xFC, 0xF0, 0x3F,
  0xE7, 0x81, 0xFF, 0x1E, 0x0F, 0xF8, 0xF0, 0x7F, 0xC3, 0x83, 0xFE, 0x1E,
  0x1F, 0xF0, 0xF0, 0xFF, 0x83, 0xC7, 0xFC, 0x1E, 0x3F, 0xE0, 0xF1, 0xFF,
  0x03, 0xCF, 0xF8, 0x1E, 0x7F, 0xC0, 0xF3, 0xFE, 0x03, 0xDF, 0xF0, 0x1E,
  0xFF, 0x80, 0xF7, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x3F, 0x3E,
  0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x07, 0xF3, 0xC0,
  0x07, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x03, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7E,
  0x03, 0xF1, 0xF0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x80, 0xFC, 0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xF0, 0x0F, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0xBC,
  0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0xBC, 0x00, 0x7C,
  0xF0, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xFC, 0xF0, 0x01, 0xF3, 0xC0,
  0x07, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3F, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0x80, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x9F, 0x80, 0x7E, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7,
  0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0xDF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x0F,
  0xBC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE3, 0xC0, 0x01,
  0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF0,
  0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00,
  0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0xF0, 0x0F, 0x01, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x07,
  0xBC, 0x0F, 0x80, 0xF7, 0x81, 0xF8, 0x1E, 0xF0, 0x3F, 0x03, 0xDE, 0x06,
  0xE0, 0xF3, 0xC0, 0xDC, 0x1E, 0x78, 0x3B, 0x83, 0xCF, 0x07, 0x70, 0x79,
  0xE0, 0xE6, 0x0F, 0x1E, 0x1C, 0xC1, 0xE3, 0xC3, 0x9C, 0x3C, 0x78, 0x73,
  0x87, 0x8F, 0x0E, 0x70, 0xF1, 0xE1, 0x8E, 0x1C, 0x3C, 0x71, 0xC7, 0x87,
  0x8E, 0x38, 0xF0, 0xF1, 0xC7, 0x1E, 0x1E, 0x38, 0x63, 0xC1, 0xE7, 0x0C,
  0x78, 0x3C, 0xE1, 0xCF, 0x07, 0x9C, 0x39, 0xE0, 0xF3, 0x07, 0x38, 0x1E,
  0xE0, 0xE7, 0x03, 0xDC, 0x1D, 0xE0, 0x7B, 0x83, 0xBC, 0x0F, 0x70, 0x77,
  0x81, 0xEE, 0x06, 0xF0, 0x1D, 0xC0, 0xDE, 0x03, 0xB8, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xDF, 0x00, 0x03, 0xE7, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x78,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x03, 0xC0,
  0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x03, 0xC0, 0xE0, 0x1C,
  0x07, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x03, 0xFC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF,
  0x07, 0xFB, 0xFE, 0x3F, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0x00, 0x0F,
  0x78, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x1F, 0xDF, 0xC0, 0xEF, 0x3F, 0xFF,
  0xBC, 0x7F, 0xFC, 0xF0, 0xFF, 0xC3, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x1F, 0xE0, 0xF3, 0xFF, 0x8F, 0x7F,
  0xFC, 0xFF, 0x9F, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3E, 0xFF, 0x9F, 0xEF, 0x7F, 0xFC, 0xF3, 0xFF, 0x8F, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE7,
  0xE0, 0x1F, 0x3E, 0x00, 0x7D, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D, 0xF8,
  0x07, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x3F, 0xC3, 0xC7, 0xFF, 0x9E, 0x7F, 0xFC, 0xF3, 0xFD, 0xF7, 0xBF, 0x01,
  0xBD, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0xC0, 0x7F,
  0x3F, 0xCF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xBE, 0x0F, 0xF1, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0xC7, 0xE0, 0x1F,
  0x3E, 0x00, 0x79, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x07, 0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xC7,
  0xF0, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF8, 0xF8, 0xFF, 0xF7, 0xCF,
  0xFF, 0xFE, 0x7F, 0xBF, 0xF7, 0xE0, 0x3F, 0xBE, 0x00, 0xFD, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xE0,
  0x3F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0xDF, 0x07, 0xF8, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x1F, 0xE0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC, 0xFF,
  0x9F, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x0F, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0,
  0x0F, 0x8F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C,
  0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x01,
  0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3E,
  0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF3,
  0xF1, 0xF9, 0xEF, 0xE7, 0xFB, 0xDF, 0xEF, 0xF7, 0xC3, 0xF1, 0xFF, 0x83,
  0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38,
  0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81,
  0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F,
  0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE,
  0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0,
  0x70, 0x3F, 0xC0, 0xE0, 0x78, 0xF1, 0xFE, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF,
  0xCF, 0xF9, 0xFE, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xE0, 0x3F, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x79, 0xF8,
  0x0F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0xF1, 0xFF, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF, 0xCF, 0xF9, 0xFE, 0xFC, 0x03,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xEF, 0xF9, 0xFE,
  0xF7, 0xFF, 0xCF, 0x3F, 0xF8, 0xF1, 0xFF, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0xF8, 0xFF, 0xF7, 0xCF,
  0xFF, 0xBE, 0x7F, 0xBF, 0xF7, 0xE0, 0x3F, 0xBE, 0x00, 0xFD, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0xBE, 0x00, 0xFD, 0xF8, 0x0D, 0xE7, 0xF9, 0xEF, 0x3F, 0xFE, 0x78,
  0xFF, 0xF7, 0xC1, 0xFE, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0xFF, 0x07, 0xDF, 0xFE, 0x3E, 0xFF,
  0xF9, 0xFF, 0x9F, 0xEF, 0xE0, 0x1F, 0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE7, 0xE0, 0x1F, 0xBE, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xF0, 0x03, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE,
  0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0xFF, 0xC0, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C,
  0x3E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0,
  0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0xF0, 0x1E, 0x03, 0xFC, 0x0F, 0x80, 0xEF, 0x03, 0xE0, 0x3B, 0xC0, 0xF8,
  0x1E, 0xF0, 0x3F, 0x07, 0x9C, 0x0D, 0xC1, 0xE7, 0x83, 0x70, 0x79, 0xE1,
  0xDC, 0x1C, 0x78, 0x77, 0x07, 0x1E, 0x1C, 0xC1, 0xC7, 0x87, 0x30, 0xF0,
  0xE1, 0x8E, 0x3C, 0x38, 0x63, 0x8F, 0x0F, 0x38, 0xE3, 0x83, 0xCE, 0x38,
  0xE0, 0xF3, 0x86, 0x38, 0x3C, 0xE1, 0x8E, 0x07, 0x30, 0x77, 0x81, 0xCC,
  0x1D, 0xE0, 0x73, 0x07, 0x70, 0x1F, 0xC1, 0xDC, 0x07, 0xF0, 0x77, 0x01,
  0xFC, 0x0D, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x1E, 0x7F, 0xC0, 0x3D, 0xFF, 0xC0, 0x7B, 0xEF, 0xC0, 0xFF, 0x87,
  0xC1, 0xFE, 0x07, 0xC7, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFE, 0xF0, 0x07,
  0xF9, 0xE0, 0x03, 0x80,
};

const GFXglyph JetBrainsMono_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 36, 29, 11, -36 },
  { 33, 15, 15, 29, 7, -36 },
  { 62, 26, 36, 29, 2, -36 },
  { 179, 22, 50, 29, 4, -43 },
  { 317, 28, 36, 29, 1, -36 },
  { 443, 25, 36, 29, 3, -36 },
  { 556, 5, 15, 29, 12, -36 },
  { 566, 15, 47, 29, 9, -41 },
  { 655, 14, 47, 29, 6, -41 },
  { 738, 26, 25, 29, 2, -30 },
  { 820, 23, 23, 29, 3, -28 },
  { 887, 10, 15, 29, 8, -7 },
  { 906, 16, 4, 29, 7, -18 },
  { 914, 8, 8, 29, 11, -8 },
  { 922, 22, 46, 29, 4, -41 },
  { 1049, 21, 36, 29, 4, -36 },
  { 1144, 22, 36, 29, 4, -36 },
  { 1243, 22, 36, 29, 4, -36 },
  { 1342, 22, 36, 29, 3, -36 },
  { 1441, 21, 36, 29, 4, -36 },
  { 1536, 21, 36, 29, 4, -36 },
  { 1631, 23, 36, 29, 3, -36 },
  { 1735, 22, 36, 29, 4, -36 },
  { 1834, 21, 36, 29, 4, -36 },
  { 1929, 23, 36, 29, 3, -36 },
  { 2033, 8, 27, 29, 11, -27 },
  { 2060, 11, 35, 29, 8, -27 },
  { 2109, 21, 26, 29, 4, -29 },
  { 2178, 21, 16, 29, 4, -24 },
  { 2220, 21, 26, 29, 4, -29 },
  { 2289, 17, 36, 29, 7, -36 },
  { 2366, 25, 45, 29, 2, -36 },
  { 2507, 25, 36, 29, 2, -36 },
  { 2620, 21, 36, 29, 5, -36 },
  { 2715, 21, 36, 29, 4, -36 },
  { 2810, 20, 36, 29, 5, -36 },
  { 2900, 20, 36, 29, 5, -36 },
  { 2990, 21, 36, 29, 5, -36 },
  { 3085, 21, 36, 29, 4, -36 },
  { 3180, 20, 36, 29, 5, -36 },
  { 3270, 19, 36, 29, 5, -36 },
  { 3356, 22, 36, 29, 2, -36 },
  { 3455, 22, 36, 29, 5, -36 },
  { 3554, 20, 36, 29, 6, -36 },
  { 3644, 22, 36, 29, 4, -36 },
  { 3743, 21, 36, 29, 4, -36 },
  { 3838, 21, 36, 29, 4, -36 },
  { 3933, 22, 36, 29, 5, -36 },
  { 4032, 22, 45, 29, 4, -36 },
  { 4156, 22, 36, 29, 5, -36 },
  { 4255, 22, 36, 29, 4, -36 },
  { 4354, 24, 36, 29, 3, -36 },
  { 4462, 21, 36, 29, 4, -36 },
  { 4557, 25, 36, 29, 2, -36 },
  { 4670, 27, 36, 29, 1, -36 },
  { 4792, 25, 36, 29, 2, -36 },
  { 4905, 26, 36, 29, 2, -36 },
  { 5022, 21, 36, 29, 4, -36 },
  { 5117, 12, 46, 29, 10, -41 },
  { 5186, 22, 46, 29, 4, -41 },
  { 5313, 12, 46, 29, 7, -41 },
  { 5382, 21, 19, 29, 4, -36 },
  { 5432, 23, 4, 29, 3, 1 },
  { 5444, 10, 6, 29, 9, -38 },
  { 5452, 22, 27, 29, 3, -27 },
  { 5527, 20, 36, 29, 5, -36 },
  { 5617, 21, 27, 29, 4, -27 },
  { 5688, 21, 36, 29, 4, -36 },
  { 5783, 21, 27, 29, 4, -27 },
  { 5854, 23, 36, 29, 3, -36 },
  { 5958, 21, 36, 29, 4, -27 },
  { 6053, 20, 36, 29, 5, -36 },
  { 6143, 23, 38, 29, 4, -38 },
  { 6253, 18, 47, 29, 4, -38 },
  { 6359, 22, 36, 29, 5, -36 },
  { 6458, 26, 36, 29, 1, -36 },
  { 6575, 23, 27, 29, 3, -27 },
  { 6653, 20, 27, 29, 5, -27 },
  { 6721, 21, 27, 29, 4, -27 },
  { 6792, 20, 36, 29, 5, -27 },
  { 6882, 21, 36, 29, 4, -27 },
  { 6977, 21, 27, 29, 5, -27 },
  { 7048, 21, 27, 29, 4, -27 },
  { 7119, 22, 35, 29, 3, -35 },
  { 7216, 21, 27, 29, 4, -27 },
  { 7287, 24, 27, 29, 3, -27 },
  { 7368, 26, 27, 29, 2, -27 },
  { 7456, 25, 27, 29, 2, -27 },
  { 7541, 24, 36, 29, 3, -27 },
  { 7649, 21, 27, 29, 4, -27 },
  { 7720, 21, 46, 29, 4, -41 },
  { 7841, 5, 46, 29, 12, -41 },
  { 7870, 21, 46, 29, 4, -41 },
  { 7991, 23, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_Regular49pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular49pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _JETBRAINSMONO_REGULAR49PT7B_H_
