#ifndef _JETBRAINSMONO_REGULAR36PT7B_H_
#define _JETBRAINSMONO_REGULAR36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x30, 0xC0, 0x00, 0x00, 0x07, 0xBF, 0xF9, 0xE0, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC3,
  0x80, 0x01, 0x81, 0xC0, 0x70, 0x30, 0x0E, 0x06, 0x01, 0xC1, 0xC0, 0x30,
  0x38, 0x06, 0x07, 0x00, 0xC0, 0xC1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xE0,
  0xE0, 0x18, 0x1C, 0x03, 0x03, 0x00, 0xE0, 0x60, 0x1C, 0x0C, 0x03, 0x83,
  0x80, 0x60, 0x70, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x30, 0x38, 0x06, 0x06, 0x01, 0xC0, 0xC0, 0x38, 0x18,
  0x07, 0x07, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7D, 0xBE, 0x71, 0x9E, 0xF1, 0x8E, 0xF1,
  0x8F, 0xF1, 0x80, 0xF1, 0x80, 0x71, 0x80, 0x79, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0x9E, 0x01, 0x8F, 0x01,
  0x8F, 0x01, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x8F, 0xF1, 0x9E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x3F, 0x80, 0x3B, 0xFE, 0x03, 0x9C, 0x70, 0x18, 0xC1,
  0xC1, 0xC6, 0x0E, 0x1C, 0x30, 0x71, 0xC1, 0x83, 0x8C, 0x0C, 0x1C, 0xE0,
  0x71, 0xCE, 0x03, 0xFE, 0x60, 0x0F, 0xE7, 0x00, 0x08, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x19, 0xFE, 0x01, 0xCF, 0xF0,
  0x1C, 0xE1, 0xC0, 0xC7, 0x0E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0E,
  0x1C, 0x70, 0x70, 0xE7, 0x03, 0xCF, 0x30, 0x0F, 0xF7, 0x80, 0x3F, 0x00,
  0x01, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xF1, 0xF0, 0x38, 0x1C, 0x1E,
  0x07, 0x87, 0x81, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x38, 0x1F, 0xCF, 0x0E,
  0xE1, 0xE7, 0xB8, 0x39, 0xCE, 0x07, 0xF3, 0x81, 0xF8, 0xE0, 0x3E, 0x38,
  0x07, 0x0E, 0x03, 0xE3, 0xC1, 0xFC, 0x7F, 0xF7, 0x9F, 0xF8, 0xE1, 0xFC,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0xF0, 0x7C, 0x3E, 0x1E,
  0x0F, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF8, 0x1F, 0x03, 0xC0,
  0x30, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x0F, 0x87, 0xE0, 0xF8, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0xC1, 0xC0, 0x9E, 0x18, 0xFF, 0xF3, 0x3F, 0x7F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x0F, 0x38, 0x01, 0xC7, 0x80,
  0x78, 0x78, 0x1E, 0x07, 0x81, 0x80, 0xE0, 0x10, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1F,
  0x3E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x23, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C, 0x3C,
  0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x87,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0E, 0x78, 0x1E, 0x7E, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7D, 0xE0, 0xF9, 0xE0, 0xE1, 0xE0, 0xC1, 0xE0,
  0x81, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C, 0x7C, 0xF0, 0x1E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xFC, 0x07, 0xBF, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x73, 0x80, 0xEF, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x77, 0xF0, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x1E,
  0x70, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x7E, 0x07, 0xFF, 0xC3, 0xF3, 0xF3, 0xC0, 0x79, 0xE0, 0x1E, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0xC0,
  0x3C, 0xF0, 0x3C, 0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C, 0x3C, 0x70, 0x1E,
  0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x38, 0x3C,
  0x3E, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3C, 0x7C, 0x78, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E,
  0x78, 0x1E, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x07, 0xFC,
  0x07, 0xFF, 0x87, 0xC7, 0xE7, 0x80, 0xF3, 0xC0, 0x3D, 0xC0, 0x0E, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0x7B,
  0xE0, 0x78, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xDE, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0x1E, 0x3F, 0x3F,
  0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xE0, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xE1, 0xFE,
  0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF0, 0x3C, 0x78, 0x03, 0x9C, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xDF, 0x87,
  0xFB, 0xE1, 0xC3, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1,
  0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E,
  0x1E, 0x3F, 0x83, 0xFB, 0xE0, 0x7C, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8F, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xE0, 0x1C, 0x70, 0x07,
  0x1C, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xF0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1E, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7E, 0x7C,
  0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xF3, 0xFF, 0xF7, 0x81, 0xEF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xFC, 0x0F, 0x7F, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x9F,
  0xFF, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7E, 0x7C,
  0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF8, 0x1E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF0, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xC7,
  0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x3C, 0x38,
  0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xC3, 0x81, 0xE1, 0xE0, 0xF0,
  0x70, 0x78, 0x3C, 0x3C, 0x0E, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x80, 0xF3,
  0xC0, 0x39, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xC0, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1B, 0xD8, 0x3B, 0xDC, 0x3F, 0xDC, 0x37, 0xCC, 0x37,
  0xCC, 0x77, 0xEE, 0x77, 0xE6, 0x67, 0xE6, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7,
  0xE3, 0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFD,
  0xC1, 0xFB, 0x83, 0xF7, 0x07, 0xE7, 0x0F, 0xCE, 0x1F, 0x8C, 0x3F, 0x1C,
  0x7E, 0x38, 0xFC, 0x31, 0xF8, 0x73, 0xF0, 0xE7, 0xE0, 0xEF, 0xC1, 0xDF,
  0x83, 0xBF, 0x03, 0xFE, 0x07, 0xFC, 0x0E, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xF3, 0xE3, 0xE7, 0x81,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xBC, 0x0F,
  0x7F, 0xFC, 0x7F, 0xF0, 0x3F, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9E, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3,
  0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x00, 0x01, 0x80, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C, 0x7C, 0x70, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0x78, 0x1E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9E, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x1D, 0xE0,
  0x0E, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x07, 0xCF, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0x81, 0xE1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xE0, 0x1C, 0xF0,
  0x0F, 0x78, 0x03, 0xC0, 0x03, 0x80, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E,
  0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0xEE, 0x01, 0xDE, 0x07, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0xE0, 0x03,
  0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x9E, 0x01, 0xC3,
  0x80, 0x70, 0xE0, 0x1C, 0x38, 0x0F, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x1E, 0x07, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x38,
  0x03, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xE0, 0xF0, 0x7E,
  0x0F, 0x07, 0xE0, 0xF0, 0xEE, 0x0F, 0x0E, 0xE0, 0xF0, 0xE7, 0x1F, 0x0E,
  0x71, 0xB0, 0xE7, 0x1B, 0x0E, 0x71, 0x98, 0xE7, 0x19, 0x8E, 0x71, 0x98,
  0xC7, 0x19, 0x9C, 0x71, 0x99, 0xC7, 0x39, 0x9C, 0x33, 0x19, 0xC3, 0xB1,
  0x9C, 0x3B, 0x19, 0xC3, 0xB0, 0xDC, 0x3B, 0x0D, 0xC3, 0xB0, 0xD8, 0x3B,
  0x0D, 0x83, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF8, 0x78, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0E, 0x0F, 0x03, 0xC1,
  0xE0, 0x70, 0x1E, 0x1E, 0x01, 0xC3, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xBC, 0x00, 0xF3, 0x80, 0x1C, 0x78, 0x07,
  0x87, 0x80, 0xE0, 0xF0, 0x38, 0x0F, 0x0F, 0x00, 0xE1, 0xC0, 0x1E, 0x78,
  0x01, 0xDE, 0x00, 0x3C, 0xF0, 0x00, 0xEE, 0x00, 0x3C, 0xE0, 0x07, 0x1C,
  0x01, 0xE1, 0xC0, 0x38, 0x38, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x78, 0x0F,
  0x0E, 0x00, 0xE3, 0xC0, 0x1E, 0x70, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x0C, 0x70,
  0x1C, 0x30, 0x1C, 0x38, 0x38, 0x18, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E,
  0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0xF0, 0xE0, 0xE1, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x0F,
  0x38, 0x07, 0x40, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0x70, 0x0F, 0x7C, 0x3F, 0x3F, 0xF7, 0x1F, 0xE7, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xF8,
  0xFF, 0xFC, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF8, 0x1E, 0xFF, 0xFC, 0xFF, 0xFC, 0xF3, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x7F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC3, 0xF3, 0x9F, 0xF7, 0x7F, 0xFE, 0xF0, 0x7F, 0xC0,
  0x7F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDE, 0x07, 0xBF,
  0x7F, 0x3F, 0xEE, 0x3F, 0x9C, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78,
  0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x0E, 0x78, 0x1E, 0x7E, 0x7C, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0xCE, 0x7F, 0xDD, 0xFF, 0xFB, 0xC1,
  0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBE, 0x1F, 0x3F,
  0xEE, 0x3F, 0xDC, 0x1C, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x3F, 0x1F, 0xFC, 0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xFC, 0x7B, 0xFC, 0xFF, 0xFD, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1C, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xDF, 0xFC, 0xFF,
  0xC7, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F,
  0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0x87,
  0x81, 0xE3, 0xC0, 0x79, 0xE0, 0x1C, 0xF0, 0x0F, 0x78, 0x03, 0xC0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFC, 0xE7, 0x9E, 0x77, 0xDF, 0xBE, 0xF9, 0xFE, 0x38, 0x7E, 0x1C, 0x3F,
  0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70,
  0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1,
  0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x70, 0xF3, 0xF1, 0xEF, 0xF3,
  0xFF, 0xF7, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x70, 0x0F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x78, 0x1E, 0x7F, 0xFC, 0x3F, 0xF8,
  0x0F, 0xF0, 0xF3, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC, 0xF8, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xE8, 0x1E,
  0xEF, 0xFC, 0xF7, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xCE, 0x7F, 0xDD, 0xFF, 0xFB,
  0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0x78, 0x1E, 0xFD, 0xFC, 0xFF, 0xB8, 0xFE, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0xE7, 0xF1, 0xDF, 0xF3, 0xBF,
  0xF7, 0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0x70, 0x0F, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xB8,
  0x0F, 0x78, 0x1E, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xE0, 0x03, 0xFC,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0xF0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x81, 0xE1, 0xC0, 0x38, 0x70,
  0x0E, 0x3C, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xE0, 0xE0, 0x7C, 0x1E, 0x1D, 0x83,
  0xC3, 0xB8, 0x78, 0x77, 0x0F, 0x0E, 0xE3, 0x61, 0x9C, 0x6C, 0x33, 0x8C,
  0x86, 0x31, 0x99, 0xC6, 0x33, 0x38, 0xE6, 0x67, 0x1D, 0x8C, 0xC3, 0xB1,
  0x98, 0x76, 0x33, 0x06, 0xC3, 0xE0, 0xD8, 0x7C, 0x1B, 0x0F, 0x83, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0xF0, 0xF0, 0x78, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0x73, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0x78, 0x03,
  0xCE, 0x00, 0xE3, 0xC0, 0x78, 0x78, 0x3C, 0x0E, 0x0E, 0x03, 0xC7, 0x80,
  0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x79, 0xE0, 0x1C,
  0x38, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x1E, 0x03,
  0x87, 0x00, 0xE3, 0xC0, 0x3C, 0xE0, 0x07, 0x38, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x3F, 0x03, 0xBF,
  0xC1, 0xDC, 0xF0, 0xFE, 0x3C, 0x7E, 0x0F, 0xFF, 0x03, 0xFB, 0x80, 0xF8,
};

const GFXglyph JetBrainsMono_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 11, 11, 22, 5, -26 },
  { 37, 19, 26, 22, 1, -26 },
  { 99, 16, 36, 22, 3, -31 },
  { 171, 21, 26, 22, 0, -26 },
  { 240, 18, 27, 22, 2, -27 },
  { 301, 3, 11, 22, 9, -26 },
  { 306, 10, 34, 22, 7, -30 },
  { 349, 11, 34, 22, 4, -30 },
  { 396, 19, 19, 22, 1, -22 },
  { 442, 17, 17, 22, 2, -20 },
  { 479, 8, 11, 22, 6, -5 },
  { 490, 12, 3, 22, 5, -13 },
  { 495, 6, 6, 22, 8, -6 },
  { 500, 16, 34, 22, 3, -30 },
  { 568, 16, 27, 22, 3, -27 },
  { 622, 16, 26, 22, 3, -26 },
  { 674, 16, 27, 22, 3, -27 },
  { 728, 15, 26, 22, 3, -26 },
  { 777, 15, 26, 22, 3, -26 },
  { 826, 16, 26, 22, 3, -26 },
  { 878, 17, 26, 22, 2, -26 },
  { 934, 16, 26, 22, 3, -26 },
  { 986, 16, 27, 22, 3, -27 },
  { 1040, 17, 27, 22, 2, -27 },
  { 1098, 6, 20, 22, 8, -20 },
  { 1113, 8, 26, 22, 6, -20 },
  { 1139, 16, 19, 22, 3, -21 },
  { 1177, 16, 12, 22, 3, -18 },
  { 1201, 16, 19, 22, 3, -21 },
  { 1239, 13, 26, 22, 5, -26 },
  { 1282, 18, 33, 22, 2, -27 },
  { 1357, 18, 26, 22, 2, -26 },
  { 1416, 16, 26, 22, 3, -26 },
  { 1468, 16, 27, 22, 3, -27 },
  { 1522, 15, 26, 22, 3, -26 },
  { 1571, 15, 26, 22, 4, -26 },
  { 1620, 16, 26, 22, 3, -26 },
  { 1672, 16, 27, 22, 3, -27 },
  { 1726, 15, 26, 22, 3, -26 },
  { 1775, 14, 26, 22, 4, -26 },
  { 1821, 16, 26, 22, 2, -26 },
  { 1873, 17, 26, 22, 3, -26 },
  { 1929, 15, 26, 22, 4, -26 },
  { 1978, 16, 26, 22, 3, -26 },
  { 2030, 15, 26, 22, 3, -26 },
  { 2079, 15, 27, 22, 3, -27 },
  { 2130, 17, 26, 22, 3, -26 },
  { 2186, 16, 33, 22, 3, -27 },
  { 2252, 17, 26, 22, 3, -26 },
  { 2308, 16, 27, 22, 3, -27 },
  { 2362, 18, 26, 22, 2, -26 },
  { 2421, 15, 26, 22, 3, -26 },
  { 2470, 18, 26, 22, 2, -26 },
  { 2529, 20, 26, 22, 1, -26 },
  { 2594, 19, 26, 22, 1, -26 },
  { 2656, 19, 26, 22, 1, -26 },
  { 2718, 16, 26, 22, 3, -26 },
  { 2770, 9, 34, 22, 7, -30 },
  { 2809, 16, 34, 22, 3, -30 },
  { 2877, 9, 34, 22, 5, -30 },
  { 2916, 16, 14, 22, 3, -26 },
  { 2944, 17, 3, 22, 2, 1 },
  { 2951, 7, 5, 22, 7, -28 },
  { 2956, 16, 20, 22, 2, -20 },
  { 2996, 16, 26, 22, 3, -26 },
  { 3048, 16, 20, 22, 3, -20 },
  { 3088, 15, 26, 22, 3, -26 },
  { 3137, 16, 20, 22, 3, -20 },
  { 3177, 17, 26, 22, 2, -26 },
  { 3233, 15, 26, 22, 3, -20 },
  { 3282, 15, 26, 22, 3, -26 },
  { 3331, 17, 28, 22, 3, -28 },
  { 3391, 13, 34, 22, 3, -28 },
  { 3447, 17, 26, 22, 3, -26 },
  { 3503, 19, 26, 22, 1, -26 },
  { 3565, 17, 20, 22, 2, -20 },
  { 3608, 15, 20, 22, 3, -20 },
  { 3646, 16, 20, 22, 3, -20 },
  { 3686, 16, 26, 22, 3, -20 },
  { 3738, 15, 26, 22, 3, -20 },
  { 3787, 15, 20, 22, 4, -20 },
  { 3825, 16, 20, 22, 3, -20 },
  { 3865, 17, 25, 22, 2, -25 },
  { 3919, 15, 20, 22, 3, -20 },
  { 3957, 18, 20, 22, 2, -20 },
  { 4002, 19, 20, 22, 1, -20 },
  { 4050, 18, 20, 22, 2, -20 },
  { 4095, 18, 26, 22, 2, -20 },
  { 4154, 15, 20, 22, 3, -20 },
  { 4192, 16, 34, 22, 3, -30 },
  { 4260, 3, 34, 22, 9, -30 },
  { 4273, 16, 34, 22, 3, -30 },
  { 4341, 17, 7, 22, 2, -16 },
};

const GFXfont JetBrainsMono_Regular36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_REGULAR36PT7B_H_
