#ifndef _JETBRAINSMONO_REGULAR35PT7B_H_
#define _JETBRAINSMONO_REGULAR35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x3F, 0x07, 0x60, 0xEC, 0x19, 0x83, 0x00, 0x01, 0x81,
  0x80, 0x70, 0x70, 0x0E, 0x0E, 0x01, 0x81, 0xC0, 0x30, 0x30, 0x06, 0x06,
  0x01, 0xC0, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x18, 0x18,
  0x03, 0x03, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x03, 0x80, 0x60, 0x60,
  0x0C, 0x0C, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x0E, 0x0E, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x06, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x06, 0x07, 0x00,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7E, 0x03, 0xFF, 0x0F,
  0xFF, 0x3C, 0xDE, 0x71, 0x9F, 0xE3, 0x1F, 0x86, 0x3F, 0x0C, 0x0F, 0x18,
  0x0E, 0x30, 0x1F, 0x60, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0,
  0x0D, 0xE0, 0x19, 0xE0, 0x31, 0xC0, 0x63, 0xF0, 0xC7, 0xE1, 0x8F, 0xC3,
  0x1F, 0xC6, 0x7B, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x39, 0xFC, 0x03, 0x9F,
  0xF0, 0x18, 0xE3, 0x81, 0x86, 0x0C, 0x1C, 0x30, 0x61, 0xC1, 0x83, 0x0C,
  0x0C, 0x18, 0xE0, 0x61, 0xCE, 0x03, 0xDE, 0x60, 0x0F, 0xE7, 0x00, 0x3E,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x84, 0x00, 0x19, 0xFC,
  0x01, 0xDF, 0xF0, 0x1C, 0xE3, 0x80, 0xC6, 0x0C, 0x0E, 0x30, 0x60, 0xE1,
  0x83, 0x06, 0x0C, 0x18, 0x60, 0x60, 0xC7, 0x03, 0x8E, 0x70, 0x0F, 0xF7,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xF0, 0xF0,
  0x78, 0x1C, 0x1C, 0x07, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x38,
  0x3B, 0x87, 0x1E, 0xE1, 0xE7, 0x38, 0x3F, 0x8E, 0x07, 0xE3, 0x80, 0xF0,
  0xE0, 0x3C, 0x38, 0x0F, 0x8F, 0x07, 0xE1, 0xFF, 0xDC, 0x7F, 0xE7, 0x8F,
  0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x3C, 0x1F, 0x87,
  0xC1, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x00, 0x60, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x81, 0xF0, 0x7C, 0x3F, 0x07,
  0x80, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0xE1, 0xC3, 0x9F, 0x39, 0xF7, 0xFA, 0xFF, 0x1F, 0xFF,
  0x00, 0x1C, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0xC0, 0x0E, 0x38,
  0x03, 0xC7, 0x80, 0xF0, 0x78, 0x0C, 0x06, 0x00, 0x80, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3E,
  0x78, 0xF1, 0xE7, 0x8F, 0x1C, 0x38, 0xE1, 0xC3, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x1C, 0x7E, 0x7C, 0xFC, 0xF9, 0xF8, 0xE3,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x03, 0xDC, 0x07, 0x3F, 0x7E, 0x3F, 0xF8, 0x1F, 0xC0, 0x03, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0xF9, 0xC0, 0xF1, 0xC0, 0xE1, 0xC0, 0x81,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x3F, 0xE1, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x78, 0x1E,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0xF3, 0x81, 0xEF, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xF3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE7, 0xC1, 0xDF, 0xE3, 0xFF, 0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xDC, 0x07, 0x3F, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x3C, 0x07, 0xFF, 0x83, 0xFF, 0xE3,
  0xE0, 0xF9, 0xE0, 0x3C, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x39, 0xE0, 0x3C, 0x7E, 0xFC, 0x1F,
  0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0x70,
  0x1C, 0xF0, 0x78, 0xF1, 0xE0, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x0F, 0xBE,
  0x3C, 0x1E, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xBF, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xE0, 0x07,
  0xFC, 0x0F, 0xFF, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1D,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x80,
  0xF1, 0xF1, 0xF8, 0x7F, 0xB8, 0x1F, 0xBC, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x27, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xF0, 0x18, 0x7C, 0xF9, 0xF3, 0xE3, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3E, 0x78, 0xF1, 0xC7,
  0x8E, 0x1C, 0x78, 0xE1, 0xC0, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0x80, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x78, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x01, 0x80, 0x02,
  0x00, 0x00, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xE3, 0xFC, 0x3F,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0,
  0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x1E, 0x7C, 0x0F, 0xDF, 0x07, 0x9F, 0xC1, 0xC3, 0xF0, 0xE0,
  0x7C, 0x38, 0x1F, 0x0E, 0x07, 0xC3, 0x81, 0xF0, 0xE0, 0x7C, 0x38, 0x1F,
  0x0E, 0x07, 0xC1, 0xC3, 0xF0, 0x70, 0xFC, 0x1F, 0xDF, 0x01, 0xE7, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x6C, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x70, 0x78, 0x3C, 0x38, 0x0E, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0x01, 0xE7,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xC0, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1E, 0xE0,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF,
  0xF8, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xF3, 0xC1,
  0xE7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDE, 0x07,
  0x3F, 0xFE, 0x3F, 0xF8, 0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xE7,
  0x07, 0xEE, 0x03, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xB8,
  0x0F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xF3, 0xC1, 0xE7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x03, 0xDE, 0x07, 0x3F, 0x7E, 0x3F, 0xF8, 0x1F, 0xE0, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC,
  0x07, 0xBF, 0x7E, 0x3F, 0xF8, 0x3F, 0xE0, 0xE0, 0x07, 0x70, 0x07, 0xB8,
  0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0,
  0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0x87, 0x81, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1E, 0x1C,
  0x07, 0x0E, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x0F,
  0x70, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFD,
  0x83, 0xFB, 0x06, 0xF7, 0x1D, 0xEE, 0x3B, 0xCC, 0x67, 0x9D, 0xCF, 0x3B,
  0x9F, 0x36, 0x7E, 0x7C, 0xFC, 0xF9, 0xF8, 0xE3, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFB, 0x83, 0xF7, 0x07, 0xEE, 0x0F, 0xCE, 0x1F,
  0x9C, 0x3F, 0x18, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0x63, 0xF0, 0xE7, 0xE1,
  0xCF, 0xC1, 0x9F, 0x83, 0xBF, 0x07, 0x7E, 0x07, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDE,
  0x0F, 0x3F, 0x7E, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xE0, 0x3E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0x3F, 0x7E, 0x3F, 0xF8, 0x1F, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0xFF, 0xFC, 0xE0, 0x7C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0,
  0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE7, 0x01,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xBF, 0xFE,
  0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDC, 0x0F, 0x3F, 0x7E, 0x3F, 0xF8, 0x1F,
  0xC0, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x39, 0xE0, 0x1C, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0F, 0x03,
  0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x78, 0x70, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0xE0, 0xFC,
  0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x58, 0x7E, 0x1B, 0x0F, 0xC3, 0x61, 0xDC,
  0x6C, 0x33, 0x8D, 0x8E, 0x71, 0xB1, 0xCE, 0x36, 0x39, 0xC6, 0xC7, 0x38,
  0xC8, 0xE7, 0x31, 0x9C, 0xE6, 0x33, 0x9C, 0xC6, 0x61, 0x98, 0xCC, 0x3B,
  0x19, 0x87, 0x63, 0x70, 0xEC, 0x6E, 0x1D, 0x8D, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x70,
  0x01, 0xCF, 0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x03, 0xC1, 0xE0, 0x70, 0x1C,
  0x1C, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x80, 0x1C, 0x70, 0x07, 0x07, 0x00, 0xE0,
  0xF0, 0x38, 0x0E, 0x0F, 0x01, 0xE1, 0xC0, 0x1C, 0x78, 0x03, 0xDE, 0x00,
  0x3C, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x01, 0x8C, 0x07, 0x1C, 0x0E,
  0x38, 0x38, 0x38, 0x70, 0x71, 0xC0, 0x73, 0x80, 0xE6, 0x00, 0xDC, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x38, 0x1C, 0x0F,
  0x00, 0x80, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x1E, 0x38, 0x0E, 0x70, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x1F, 0xFF, 0x3F, 0xFF, 0x78, 0x07,
  0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x7C, 0x37,
  0x3F, 0xF7, 0x1F, 0xE7, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x60, 0x73, 0xF8, 0xEF, 0xF9, 0xD8, 0xFB, 0xC0,
  0x7F, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0x77,
  0x7E, 0xEF, 0xF9, 0xCF, 0xE0, 0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x03, 0xF8, 0x07, 0x78,
  0x1E, 0xFD, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xC3, 0x8F, 0xE7, 0x3F, 0xEE,
  0xF8, 0xDF, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x03,
  0xDC, 0x0F, 0xBF, 0x77, 0x3F, 0xEE, 0x3F, 0x9C, 0x01, 0x00, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x07, 0x70, 0x1E, 0xF8, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0x9C, 0xFF, 0xBB,
  0xE3, 0x77, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x17,
  0x7F, 0xEE, 0x7F, 0x9C, 0x1E, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x20, 0x73, 0xF8, 0xEF, 0xF9,
  0xD8, 0x7B, 0xC0, 0x77, 0x80, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1C, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x73, 0xFF, 0x9F, 0xF8, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x1E, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x0F, 0x0E, 0x07, 0x07,
  0x07, 0x83, 0x87, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x70, 0xF0, 0x38, 0x3C,
  0x1C, 0x0E, 0x0E, 0x07, 0x87, 0x01, 0xE3, 0x80, 0x71, 0xC0, 0x3C, 0xE0,
  0x0F, 0x70, 0x07, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x02, 0x08, 0x77, 0xDF, 0x3F, 0xEF, 0xDE, 0x38, 0xEE,
  0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1,
  0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3,
  0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x70, 0x00, 0x81,
  0xCF, 0xE3, 0xBF, 0xE7, 0x63, 0xEF, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70,
  0x01, 0x00, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x01, 0xDE, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x70, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0,
  0x7F, 0x00, 0x00, 0x81, 0xCF, 0xE3, 0xBF, 0xE7, 0x63, 0xEF, 0x01, 0xFE,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x1D, 0xDD, 0xFB,
  0xBF, 0xE7, 0x3F, 0x8E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0x9C, 0xFF, 0xBB, 0xE3, 0x77, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0x70, 0x3E, 0xFD,
  0xDC, 0xFF, 0xB8, 0xFE, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x01, 0x81, 0xCF, 0xE3, 0xBF, 0xE7, 0xC3, 0xEF,
  0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0xFF, 0xF3,
  0xC1, 0xE7, 0x01, 0xEE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x07,
  0xF0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x07, 0xBC, 0x1E, 0x7E, 0xFC, 0x7F, 0xF0, 0x3F, 0x80, 0xE0, 0x03,
  0xF8, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x70, 0xE0,
  0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1D, 0x83, 0x83, 0x38, 0xD8,
  0x67, 0x1B, 0x1C, 0xE3, 0x63, 0x9C, 0x6C, 0x73, 0x8D, 0x8E, 0x31, 0xB1,
  0x86, 0x63, 0x30, 0xEC, 0x66, 0x1D, 0x8D, 0xC3, 0xB1, 0xB8, 0x76, 0x36,
  0x06, 0xC6, 0xC0, 0xD0, 0x58, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x00, 0xF0, 0x07, 0xBC, 0x07, 0x8F, 0x07, 0x83, 0x83, 0x81, 0xE3, 0xC0,
  0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xEE, 0x00, 0xF7, 0x80, 0x71, 0xC0, 0x70, 0x70, 0x78, 0x3C, 0x78,
  0x0F, 0x38, 0x03, 0xBC, 0x01, 0xE0, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x01,
  0xCF, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1E,
  0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x7F, 0xC0, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0xFE, 0x07,
  0xFC, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x3F,
  0x80, 0x7E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xBF, 0x81, 0xDF, 0xE0, 0xFC,
  0x38, 0x7E, 0x1F, 0xF7, 0x07, 0xFB, 0x81, 0xF8,
};

const GFXglyph JetBrainsMono_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 11, 11, 21, 5, -26 },
  { 34, 19, 26, 21, 1, -26 },
  { 96, 15, 35, 21, 3, -30 },
  { 162, 21, 26, 21, 0, -26 },
  { 231, 18, 26, 21, 2, -26 },
  { 290, 3, 11, 21, 9, -26 },
  { 295, 11, 33, 21, 6, -29 },
  { 341, 11, 33, 21, 4, -29 },
  { 387, 19, 18, 21, 1, -21 },
  { 430, 17, 17, 21, 2, -20 },
  { 467, 7, 11, 21, 6, -5 },
  { 477, 11, 3, 21, 5, -13 },
  { 482, 5, 5, 21, 8, -5 },
  { 486, 15, 33, 21, 3, -29 },
  { 548, 15, 26, 21, 3, -26 },
  { 597, 16, 26, 21, 3, -26 },
  { 649, 15, 26, 21, 3, -26 },
  { 698, 16, 26, 21, 2, -26 },
  { 750, 15, 26, 21, 3, -26 },
  { 799, 15, 26, 21, 3, -26 },
  { 848, 17, 26, 21, 2, -26 },
  { 904, 16, 26, 21, 3, -26 },
  { 956, 15, 26, 21, 3, -26 },
  { 1005, 17, 26, 21, 2, -26 },
  { 1061, 5, 20, 21, 8, -20 },
  { 1074, 7, 26, 21, 6, -20 },
  { 1097, 15, 19, 21, 3, -21 },
  { 1133, 15, 11, 21, 3, -17 },
  { 1154, 15, 19, 21, 3, -21 },
  { 1190, 12, 26, 21, 5, -26 },
  { 1229, 18, 32, 21, 2, -26 },
  { 1301, 17, 26, 21, 2, -26 },
  { 1357, 16, 26, 21, 3, -26 },
  { 1409, 15, 26, 21, 3, -26 },
  { 1458, 15, 26, 21, 3, -26 },
  { 1507, 15, 26, 21, 3, -26 },
  { 1556, 15, 26, 21, 3, -26 },
  { 1605, 15, 26, 21, 3, -26 },
  { 1654, 15, 26, 21, 3, -26 },
  { 1703, 13, 26, 21, 4, -26 },
  { 1746, 15, 26, 21, 2, -26 },
  { 1795, 17, 26, 21, 3, -26 },
  { 1851, 15, 26, 21, 4, -26 },
  { 1900, 15, 26, 21, 3, -26 },
  { 1949, 15, 26, 21, 3, -26 },
  { 1998, 15, 26, 21, 3, -26 },
  { 2047, 16, 26, 21, 3, -26 },
  { 2099, 15, 32, 21, 3, -26 },
  { 2159, 16, 26, 21, 3, -26 },
  { 2211, 15, 26, 21, 3, -26 },
  { 2260, 17, 26, 21, 2, -26 },
  { 2316, 15, 26, 21, 3, -26 },
  { 2365, 17, 26, 21, 2, -26 },
  { 2421, 19, 26, 21, 1, -26 },
  { 2483, 19, 26, 21, 1, -26 },
  { 2545, 19, 26, 21, 1, -26 },
  { 2607, 15, 26, 21, 3, -26 },
  { 2656, 9, 33, 21, 7, -29 },
  { 2694, 15, 33, 21, 3, -29 },
  { 2756, 9, 33, 21, 5, -29 },
  { 2794, 15, 14, 21, 3, -26 },
  { 2821, 17, 3, 21, 2, 1 },
  { 2828, 8, 4, 21, 6, -27 },
  { 2832, 16, 20, 21, 2, -20 },
  { 2872, 15, 26, 21, 3, -26 },
  { 2921, 15, 20, 21, 3, -20 },
  { 2959, 15, 26, 21, 3, -26 },
  { 3008, 15, 20, 21, 3, -20 },
  { 3046, 17, 26, 21, 2, -26 },
  { 3102, 15, 26, 21, 3, -20 },
  { 3151, 15, 26, 21, 3, -26 },
  { 3200, 16, 27, 21, 3, -27 },
  { 3254, 13, 33, 21, 3, -27 },
  { 3308, 17, 26, 21, 3, -26 },
  { 3364, 18, 26, 21, 1, -26 },
  { 3423, 17, 20, 21, 2, -20 },
  { 3466, 15, 20, 21, 3, -20 },
  { 3504, 15, 20, 21, 3, -20 },
  { 3542, 15, 26, 21, 3, -20 },
  { 3591, 15, 26, 21, 3, -20 },
  { 3640, 15, 20, 21, 4, -20 },
  { 3678, 15, 20, 21, 3, -20 },
  { 3716, 16, 25, 21, 2, -25 },
  { 3766, 15, 19, 21, 3, -19 },
  { 3802, 17, 19, 21, 2, -19 },
  { 3843, 19, 19, 21, 1, -19 },
  { 3889, 17, 19, 21, 2, -19 },
  { 3930, 17, 25, 21, 2, -19 },
  { 3984, 15, 19, 21, 3, -19 },
  { 4020, 15, 33, 21, 3, -29 },
  { 4082, 3, 33, 21, 9, -29 },
  { 4095, 15, 33, 21, 3, -29 },
  { 4157, 17, 7, 21, 2, -16 },
};

const GFXfont JetBrainsMono_Regular35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_REGULAR35PT7B_H_
