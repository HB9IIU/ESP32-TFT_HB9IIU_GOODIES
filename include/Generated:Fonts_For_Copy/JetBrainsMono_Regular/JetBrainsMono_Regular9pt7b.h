#ifndef _JETBRAINSMONO_REGULAR9PT7B_H_
#define _JETBRAINSMONO_REGULAR9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x5E, 0xAF, 0xA9, 0x40, 0x46, 0xDC, 0xE5,
  0xDE, 0x40, 0x4D, 0x6C, 0xC3, 0xAE, 0x60, 0x22, 0x90, 0xCA, 0xC9, 0xA0,
  0xE0, 0x5A, 0xAA, 0x40, 0x88, 0x92, 0x4A, 0x80, 0x27, 0xC8, 0xA0, 0x44,
  0xF4, 0x70, 0xE0, 0x80, 0x32, 0x24, 0x44, 0x88, 0x69, 0x9D, 0x99, 0xE0,
  0x4C, 0x44, 0x44, 0xF0, 0x69, 0x12, 0x48, 0xF0, 0xE2, 0x46, 0x19, 0xE0,
  0x22, 0x49, 0x9F, 0x10, 0xE8, 0x8E, 0x11, 0xE0, 0x24, 0x8E, 0x99, 0xE0,
  0xF9, 0x22, 0x24, 0x40, 0x69, 0x96, 0x99, 0xE0, 0x69, 0x99, 0x62, 0x40,
  0x88, 0x8C, 0x3C, 0xC3, 0xFF, 0xC2, 0x3C, 0xC4, 0x94, 0x10, 0x32, 0x67,
  0x5A, 0xD6, 0x48, 0x30, 0x21, 0x94, 0xA7, 0x26, 0x20, 0xE9, 0x9E, 0x99,
  0xE0, 0x69, 0x88, 0x89, 0xE0, 0xCA, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88,
  0xF0, 0xF8, 0x8E, 0x88, 0x80, 0x69, 0x88, 0xB9, 0xE0, 0x99, 0x9F, 0x99,
  0x90, 0xE9, 0x24, 0xB8, 0x31, 0x11, 0x19, 0x70, 0x9A, 0xAC, 0xAA, 0x90,
  0x88, 0x88, 0x88, 0xF0, 0x9B, 0xBD, 0x99, 0x90, 0x99, 0xDD, 0xDB, 0xB0,
  0x69, 0x99, 0x99, 0xE0, 0xE9, 0x9F, 0x88, 0x80, 0x69, 0x99, 0x99, 0xE2,
  0x10, 0xE9, 0x9E, 0xAA, 0x90, 0x69, 0x8E, 0x19, 0xE0, 0xF9, 0x08, 0x42,
  0x10, 0x80, 0x99, 0x99, 0x99, 0xE0, 0x8A, 0x52, 0xA5, 0x18, 0x80, 0xAD,
  0x6B, 0x55, 0xAD, 0x40, 0x8A, 0x8C, 0x43, 0x2B, 0x20, 0x8A, 0x54, 0x62,
  0x10, 0x80, 0xF2, 0x24, 0x48, 0xF0, 0xEA, 0xAB, 0x88, 0x44, 0x42, 0x21,
  0xE4, 0x92, 0x4F, 0x46, 0xA9, 0xF0, 0xC0, 0xE1, 0xF9, 0xF0, 0x88, 0xE9,
  0x99, 0xE0, 0xE9, 0x89, 0xE0, 0x11, 0xF9, 0x99, 0xF0, 0xE9, 0xF9, 0xE0,
  0x34, 0xF4, 0x44, 0x40, 0xF9, 0x9B, 0x51, 0xE0, 0x88, 0xE9, 0x99, 0x90,
  0x40, 0xC4, 0x44, 0xF0, 0x23, 0x92, 0x49, 0xC0, 0x88, 0x9A, 0xCA, 0x90,
  0xE1, 0x08, 0x42, 0x10, 0xE0, 0xFD, 0xDD, 0xD0, 0xE9, 0x99, 0x90, 0xE9,
  0x99, 0xE0, 0xE9, 0x99, 0xE8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xE9, 0x88,
  0x80, 0xE9, 0x61, 0xE0, 0x27, 0xC8, 0x42, 0x1C, 0x99, 0x99, 0xE0, 0xCA,
  0x54, 0x62, 0x00, 0xAD, 0x56, 0xB5, 0x00, 0x4A, 0x88, 0xAC, 0x80, 0xCA,
  0x94, 0x62, 0x10, 0x80, 0xE2, 0x48, 0xF0, 0x34, 0x2C, 0x22, 0x43, 0xFF,
  0xC4, 0x47, 0x44, 0x4C, 0xDA,
};

const GFXglyph JetBrainsMono_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 7, 5, 2, -7 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 5, 7, 5, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 3, 5, 2, -7 },
  { 25, 2, 9, 5, 2, -8 },
  { 28, 3, 9, 5, 1, -8 },
  { 32, 5, 4, 5, 0, -5 },
  { 35, 4, 4, 5, 1, -5 },
  { 37, 2, 2, 5, 1, -1 },
  { 38, 3, 1, 5, 1, -3 },
  { 39, 1, 1, 5, 2, -1 },
  { 40, 4, 8, 5, 1, -7 },
  { 44, 4, 7, 5, 1, -7 },
  { 48, 4, 7, 5, 1, -7 },
  { 52, 4, 7, 5, 1, -7 },
  { 56, 4, 7, 5, 1, -7 },
  { 60, 4, 7, 5, 1, -7 },
  { 64, 4, 7, 5, 1, -7 },
  { 68, 4, 7, 5, 1, -7 },
  { 72, 4, 7, 5, 1, -7 },
  { 76, 4, 7, 5, 1, -7 },
  { 80, 4, 7, 5, 1, -7 },
  { 84, 1, 5, 5, 2, -5 },
  { 85, 1, 6, 5, 2, -5 },
  { 86, 4, 4, 5, 1, -5 },
  { 88, 4, 2, 5, 1, -4 },
  { 89, 4, 4, 5, 1, -5 },
  { 91, 3, 7, 5, 1, -7 },
  { 94, 5, 9, 5, 0, -7 },
  { 100, 5, 7, 5, 0, -7 },
  { 105, 4, 7, 5, 1, -7 },
  { 109, 4, 7, 5, 1, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 4, 7, 5, 1, -7 },
  { 121, 4, 7, 5, 1, -7 },
  { 125, 4, 7, 5, 1, -7 },
  { 129, 4, 7, 5, 1, -7 },
  { 133, 3, 7, 5, 1, -7 },
  { 136, 4, 7, 5, 0, -7 },
  { 140, 4, 7, 5, 1, -7 },
  { 144, 4, 7, 5, 1, -7 },
  { 148, 4, 7, 5, 1, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 4, 7, 5, 1, -7 },
  { 160, 4, 7, 5, 1, -7 },
  { 164, 4, 9, 5, 1, -7 },
  { 169, 4, 7, 5, 1, -7 },
  { 173, 4, 7, 5, 1, -7 },
  { 177, 5, 7, 5, 0, -7 },
  { 182, 4, 7, 5, 1, -7 },
  { 186, 5, 7, 5, 0, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 5, 7, 5, 0, -7 },
  { 206, 4, 7, 5, 1, -7 },
  { 210, 2, 8, 5, 2, -7 },
  { 212, 4, 8, 5, 1, -7 },
  { 216, 3, 8, 5, 1, -7 },
  { 219, 4, 4, 5, 1, -7 },
  { 221, 4, 1, 5, 1, 0 },
  { 222, 2, 1, 5, 2, -7 },
  { 223, 4, 5, 5, 1, -5 },
  { 226, 4, 7, 5, 1, -7 },
  { 230, 4, 5, 5, 1, -5 },
  { 233, 4, 7, 5, 1, -7 },
  { 237, 4, 5, 5, 1, -5 },
  { 240, 4, 7, 5, 1, -7 },
  { 244, 4, 7, 5, 1, -5 },
  { 248, 4, 7, 5, 1, -7 },
  { 252, 4, 7, 5, 1, -7 },
  { 256, 3, 9, 5, 1, -7 },
  { 260, 4, 7, 5, 1, -7 },
  { 264, 5, 7, 5, 0, -7 },
  { 269, 4, 5, 5, 1, -5 },
  { 272, 4, 5, 5, 1, -5 },
  { 275, 4, 5, 5, 1, -5 },
  { 278, 4, 7, 5, 1, -5 },
  { 282, 4, 7, 5, 1, -5 },
  { 286, 4, 5, 5, 1, -5 },
  { 289, 4, 5, 5, 1, -5 },
  { 292, 5, 6, 5, 0, -6 },
  { 296, 4, 5, 5, 1, -5 },
  { 299, 5, 5, 5, 0, -5 },
  { 303, 5, 5, 5, 0, -5 },
  { 307, 5, 5, 5, 0, -5 },
  { 311, 5, 7, 5, 0, -5 },
  { 316, 4, 5, 5, 1, -5 },
  { 319, 4, 8, 5, 1, -7 },
  { 323, 1, 8, 5, 2, -7 },
  { 324, 4, 8, 5, 1, -7 },
  { 328, 4, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_Regular9pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular9pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _JETBRAINSMONO_REGULAR9PT7B_H_
