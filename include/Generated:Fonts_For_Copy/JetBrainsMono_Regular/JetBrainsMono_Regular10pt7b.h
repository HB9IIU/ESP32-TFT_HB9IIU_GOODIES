#ifndef _JETBRAINSMONO_REGULAR10PT7B_H_
#define _JETBRAINSMONO_REGULAR10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xEA, 0x8C, 0x99, 0x90, 0x28, 0xA5, 0xD2, 0xF9, 0x45, 0x00, 0x22,
  0xFB, 0xA7, 0x3B, 0xF2, 0xEE, 0xAF, 0x08, 0x3D, 0x59, 0xC0, 0xF4, 0x21,
  0x9B, 0x4B, 0xE0, 0xE0, 0x72, 0x49, 0x24, 0x60, 0xC4, 0x92, 0x49, 0xC0,
  0x22, 0x97, 0x8C, 0x48, 0x44, 0xF4, 0x40, 0xEA, 0xF0, 0xB0, 0x11, 0x22,
  0x44, 0x48, 0x80, 0xF9, 0x9F, 0x99, 0xF0, 0xEA, 0x22, 0x22, 0xF0, 0xF9,
  0x12, 0x6C, 0xF0, 0xF2, 0x61, 0x19, 0xF0, 0x34, 0x49, 0xF1, 0x10, 0xF8,
  0xE9, 0x19, 0xF0, 0x24, 0xE9, 0x99, 0xF0, 0xF9, 0x12, 0x24, 0x40, 0xF9,
  0x96, 0x99, 0xF0, 0xF9, 0x9F, 0x22, 0x40, 0xB0, 0x30, 0xB0, 0xEA, 0x16,
  0x8C, 0x30, 0xF0, 0xF0, 0x86, 0x13, 0xC0, 0xE1, 0x16, 0x40, 0x40, 0x7A,
  0x19, 0xE9, 0xA6, 0xB9, 0x10, 0x30, 0x30, 0xC3, 0x12, 0x79, 0x2C, 0xC0,
  0xF9, 0x9F, 0x99, 0xF0, 0xF9, 0x88, 0x89, 0xF0, 0xF9, 0x99, 0x99, 0xE0,
  0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0xF9, 0x8B, 0x99, 0xF0,
  0x99, 0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0x38, 0x42, 0x10, 0xC5,
  0xC0, 0x9C, 0xA9, 0xCA, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0x9F, 0xFF,
  0x99, 0x90, 0x9D, 0xDB, 0xBB, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF4, 0xE5,
  0xE8, 0x42, 0x00, 0xF9, 0x99, 0x99, 0xF2, 0x10, 0xF9, 0x9F, 0xA9, 0x90,
  0xF9, 0x87, 0x19, 0xF0, 0xF4, 0x44, 0x44, 0x40, 0x99, 0x99, 0x99, 0xF0,
  0xCD, 0x24, 0x92, 0x30, 0xC3, 0x00, 0xB6, 0xDB, 0x5E, 0x79, 0x24, 0x80,
  0x49, 0x43, 0x0C, 0x31, 0x2C, 0xC0, 0xCD, 0x23, 0x0C, 0x20, 0x82, 0x00,
  0xF1, 0x24, 0x48, 0xF0, 0xF2, 0x49, 0x24, 0xE0, 0x88, 0x44, 0x22, 0x21,
  0x10, 0xE4, 0x92, 0x49, 0xE0, 0x66, 0x99, 0xF0, 0x90, 0x69, 0x1F, 0x9F,
  0x8E, 0x99, 0x99, 0xF0, 0x69, 0x88, 0x9F, 0x17, 0x99, 0x99, 0xF0, 0x69,
  0x9E, 0x8F, 0x74, 0xF4, 0x44, 0x40, 0x79, 0x99, 0x97, 0x16, 0x8E, 0x99,
  0x99, 0x90, 0x61, 0x38, 0x42, 0x10, 0x9F, 0x32, 0xE2, 0x22, 0x22, 0x2C,
  0x84, 0x65, 0x4E, 0x4A, 0x60, 0xE0, 0x82, 0x08, 0x20, 0x81, 0xC0, 0xDF,
  0xDD, 0xDD, 0xE9, 0x99, 0x99, 0x69, 0x99, 0x9F, 0xE9, 0x99, 0x9F, 0x88,
  0x79, 0x99, 0x9F, 0x11, 0xAD, 0x98, 0x88, 0x69, 0x87, 0x1F, 0x4F, 0x44,
  0x44, 0x70, 0x99, 0x99, 0x9F, 0x99, 0x99, 0x66, 0xA6, 0xD7, 0x9E, 0x49,
  0x20, 0x49, 0x23, 0x0C, 0x33, 0x30, 0x99, 0x96, 0x62, 0x44, 0xF1, 0x24,
  0x8F, 0x32, 0x22, 0xC2, 0x22, 0x30, 0xFF, 0x80, 0xC4, 0x44, 0x34, 0x44,
  0xC0, 0x9F, 0x10,
};

const GFXglyph JetBrainsMono_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 4, 3, 6, 1, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 4, 10, 6, 1, -9 },
  { 16, 6, 7, 6, 0, -7 },
  { 22, 5, 7, 6, 1, -7 },
  { 27, 1, 3, 6, 2, -7 },
  { 28, 3, 9, 6, 2, -8 },
  { 32, 3, 9, 6, 1, -8 },
  { 36, 6, 5, 6, 0, -6 },
  { 40, 4, 5, 6, 1, -6 },
  { 43, 2, 4, 6, 2, -2 },
  { 44, 4, 1, 6, 1, -4 },
  { 45, 2, 2, 6, 2, -2 },
  { 46, 4, 9, 6, 1, -8 },
  { 51, 4, 7, 6, 1, -7 },
  { 55, 4, 7, 6, 1, -7 },
  { 59, 4, 7, 6, 1, -7 },
  { 63, 4, 7, 6, 1, -7 },
  { 67, 4, 7, 6, 1, -7 },
  { 71, 4, 7, 6, 1, -7 },
  { 75, 4, 7, 6, 1, -7 },
  { 79, 4, 7, 6, 1, -7 },
  { 83, 4, 7, 6, 1, -7 },
  { 87, 4, 7, 6, 1, -7 },
  { 91, 2, 6, 6, 2, -6 },
  { 93, 2, 8, 6, 2, -6 },
  { 95, 4, 5, 6, 1, -6 },
  { 98, 4, 3, 6, 1, -5 },
  { 100, 4, 5, 6, 1, -6 },
  { 103, 4, 7, 6, 1, -7 },
  { 107, 6, 9, 6, 0, -7 },
  { 114, 6, 7, 6, 0, -7 },
  { 120, 4, 7, 6, 1, -7 },
  { 124, 4, 7, 6, 1, -7 },
  { 128, 4, 7, 6, 1, -7 },
  { 132, 4, 7, 6, 1, -7 },
  { 136, 4, 7, 6, 1, -7 },
  { 140, 4, 7, 6, 1, -7 },
  { 144, 4, 7, 6, 1, -7 },
  { 148, 4, 7, 6, 1, -7 },
  { 152, 5, 7, 6, 0, -7 },
  { 157, 5, 7, 6, 1, -7 },
  { 162, 4, 7, 6, 1, -7 },
  { 166, 4, 7, 6, 1, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 4, 7, 6, 1, -7 },
  { 178, 5, 7, 6, 1, -7 },
  { 183, 4, 9, 6, 1, -7 },
  { 188, 4, 7, 6, 1, -7 },
  { 192, 4, 7, 6, 1, -7 },
  { 196, 4, 7, 6, 1, -7 },
  { 200, 4, 7, 6, 1, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 7, 6, 0, -7 },
  { 216, 6, 7, 6, 0, -7 },
  { 222, 6, 7, 6, 0, -7 },
  { 228, 4, 7, 6, 1, -7 },
  { 232, 3, 9, 6, 2, -8 },
  { 236, 4, 9, 6, 1, -8 },
  { 241, 3, 9, 6, 1, -8 },
  { 245, 4, 4, 6, 1, -7 },
  { 247, 4, 1, 6, 1, 0 },
  { 248, 2, 2, 6, 2, -8 },
  { 249, 4, 6, 6, 1, -6 },
  { 252, 4, 7, 6, 1, -7 },
  { 256, 4, 6, 6, 1, -6 },
  { 259, 4, 7, 6, 1, -7 },
  { 263, 4, 6, 6, 1, -6 },
  { 266, 4, 7, 6, 1, -7 },
  { 270, 4, 8, 6, 1, -6 },
  { 274, 4, 7, 6, 1, -7 },
  { 278, 5, 8, 6, 1, -8 },
  { 283, 4, 10, 6, 1, -8 },
  { 288, 5, 7, 6, 1, -7 },
  { 293, 6, 7, 6, 0, -7 },
  { 299, 4, 6, 6, 1, -6 },
  { 302, 4, 6, 6, 1, -6 },
  { 305, 4, 6, 6, 1, -6 },
  { 308, 4, 8, 6, 1, -6 },
  { 312, 4, 8, 6, 1, -6 },
  { 316, 4, 6, 6, 1, -6 },
  { 319, 4, 6, 6, 1, -6 },
  { 322, 4, 7, 6, 1, -7 },
  { 326, 4, 6, 6, 1, -6 },
  { 329, 4, 6, 6, 1, -6 },
  { 332, 6, 6, 6, 0, -6 },
  { 337, 6, 6, 6, 0, -6 },
  { 342, 4, 8, 6, 1, -6 },
  { 346, 4, 6, 6, 1, -6 },
  { 349, 4, 9, 6, 1, -8 },
  { 354, 1, 9, 6, 3, -8 },
  { 356, 4, 9, 6, 1, -8 },
  { 361, 4, 3, 6, 1, -5 },
};

const GFXfont JetBrainsMono_Regular10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_REGULAR10PT7B_H_
