#ifndef _JETBRAINSMONO_REGULAR21PT7B_H_
#define _JETBRAINSMONO_REGULAR21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0x48, 0x01, 0xF8, 0xCF, 0x3C, 0xF1, 0xC7, 0x10,
  0x18, 0xC3, 0x18, 0x62, 0x08, 0x4F, 0xFE, 0x63, 0x0C, 0x61, 0x88, 0x21,
  0x1F, 0xFB, 0xFF, 0x31, 0x86, 0x30, 0x84, 0x10, 0x80, 0x08, 0x04, 0x02,
  0x0F, 0xEE, 0xB6, 0x4F, 0x27, 0x90, 0xE8, 0x3C, 0x0F, 0x81, 0xE0, 0x98,
  0x4E, 0x27, 0x93, 0xFF, 0x3F, 0x02, 0x01, 0x00, 0x80, 0x7C, 0x3C, 0xC2,
  0xC4, 0x4C, 0x4C, 0xCD, 0x87, 0xD0, 0x33, 0x00, 0x60, 0x04, 0xE0, 0xDF,
  0x1B, 0x11, 0x31, 0x33, 0x16, 0x1B, 0xC1, 0xE0, 0x0C, 0x07, 0xE1, 0x8C,
  0x30, 0xC6, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x78, 0x79, 0x9B, 0x1B, 0x61,
  0xCC, 0x31, 0x87, 0x1F, 0xB3, 0xE7, 0xFF, 0xF0, 0x04, 0x33, 0x9C, 0x63,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0xC3, 0xC3, 0x04,
  0x81, 0xC1, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x06, 0x0C, 0x31, 0xC7, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x42,
  0x2F, 0x5E, 0xFF, 0x03, 0x00, 0xD0, 0x33, 0x0E, 0x30, 0x86, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x39, 0x9C, 0xC6, 0x70, 0xFF, 0xFC, 0xFF, 0x80, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x60, 0x60, 0x30, 0x00, 0x08, 0x3F, 0x38, 0xD8, 0x3C, 0x1E,
  0x0F, 0x07, 0xB3, 0xDD, 0xE4, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xDC, 0x7C,
  0x3C, 0x3E, 0x33, 0x11, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x08, 0x3F, 0x38, 0xD8, 0x38, 0x18, 0x0C,
  0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0x7F,
  0x80, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x30,
  0x0F, 0x03, 0x61, 0x9F, 0xE3, 0xF0, 0x07, 0x03, 0x03, 0x03, 0x03, 0x81,
  0x81, 0x87, 0xC3, 0xC1, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0xFF,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD, 0x87, 0x01, 0x80, 0xC0, 0x60,
  0x3C, 0x1F, 0xB8, 0xF8, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x86,
  0xF9, 0xC7, 0x60, 0xF0, 0x3C, 0x0D, 0x03, 0x60, 0xDE, 0xE1, 0xF0, 0xFF,
  0xE0, 0xF0, 0x78, 0x20, 0x30, 0x18, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x03,
  0x01, 0x81, 0xC0, 0xC0, 0x18, 0x3F, 0x38, 0xD8, 0x3C, 0x1E, 0x19, 0x8C,
  0x7C, 0x3E, 0x31, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0xDC, 0xFC, 0x04, 0x0F,
  0xC7, 0x19, 0x83, 0xC0, 0xF0, 0x34, 0x0D, 0x83, 0x73, 0xCF, 0xE0, 0x30,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0xDF, 0x80, 0x00, 0x1F, 0xF0, 0x67,
  0x70, 0x00, 0x00, 0x07, 0x66, 0xCC, 0xC0, 0x00, 0x80, 0xC1, 0xC3, 0x87,
  0x06, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x10, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x80, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x06,
  0x1E, 0x3C, 0x78, 0x30, 0x10, 0x00, 0xF8, 0x3C, 0x18, 0x30, 0x60, 0xC3,
  0xBE, 0x60, 0xC1, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x04, 0x07, 0xF1, 0x83,
  0x20, 0x2C, 0x07, 0x80, 0xF1, 0xFE, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0xE6,
  0x3C, 0xC7, 0x9D, 0xF1, 0xDE, 0x00, 0xC0, 0x0C, 0x00, 0xF8, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x68, 0x0D, 0x81, 0xB0, 0x26, 0x0C, 0x41, 0x8C, 0x31,
  0x8F, 0xF1, 0xFE, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x18, 0xFE, 0x63, 0xB0,
  0x78, 0x3C, 0x1E, 0x1B, 0xF9, 0xFE, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0xFB, 0xF8, 0x08, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x1E, 0x0D, 0xDC, 0x7C, 0xFE, 0x63, 0xB0, 0xD8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x37, 0xFB,
  0xF0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x08,
  0x3F, 0xB8, 0xD8, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xCF, 0xE7, 0xF0, 0x78,
  0x3C, 0x1E, 0x0D, 0xDC, 0x7C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x06, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x0F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x78, 0x3C, 0x1B, 0xBC, 0xF8, 0xC1, 0xF0, 0x6C, 0x33, 0x0C, 0xC6,
  0x33, 0x8F, 0xC3, 0xF0, 0xCC, 0x31, 0x8C, 0x63, 0x0C, 0xC3, 0xB0, 0x6C,
  0x1C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xC3, 0xF1, 0xF8, 0xB4, 0xDB, 0x7D,
  0xAE, 0x77, 0x3B, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0xE1,
  0xF0, 0xF8, 0x7E, 0x3F, 0x1E, 0x8F, 0x67, 0x93, 0xCD, 0xE6, 0xF1, 0x78,
  0xFC, 0x7E, 0x1F, 0x0E, 0x08, 0x3F, 0x38, 0xD8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1D, 0xDC, 0x7C, 0xFF, 0x30,
  0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x6C, 0x1B, 0xFC, 0xFC, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x08, 0x3F, 0x38, 0xD8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1D, 0xDC, 0x7C, 0x06,
  0x03, 0x80, 0xC0, 0x30, 0xFF, 0x61, 0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0xFE, 0xCC, 0x63, 0x31, 0x98, 0x6C, 0x36, 0x0F, 0x06, 0x08, 0x3F, 0xB8,
  0xD8, 0x3C, 0x1E, 0x03, 0x80, 0xF0, 0x3E, 0x03, 0x80, 0x60, 0x38, 0x1E,
  0x0F, 0xDC, 0xFC, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x33, 0xB8, 0xF8, 0xC0, 0xE8, 0x19, 0x83, 0x30, 0x66, 0x18, 0x43, 0x0C,
  0x61, 0x8C, 0x33, 0x02, 0x60, 0x6C, 0x0D, 0x01, 0xA0, 0x1C, 0x03, 0x80,
  0x8C, 0x79, 0xCF, 0x39, 0xE5, 0x3C, 0xA7, 0x94, 0xB2, 0x96, 0xD2, 0x52,
  0xCA, 0x59, 0x4F, 0x39, 0xE7, 0x1C, 0xE3, 0x1C, 0x60, 0xE0, 0xEC, 0x38,
  0xC6, 0x19, 0x81, 0xB0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x60, 0xCC,
  0x18, 0xC6, 0x18, 0xC1, 0xB0, 0x38, 0xC0, 0x6C, 0x19, 0x83, 0x18, 0xC3,
  0x18, 0x36, 0x06, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xFF, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x38, 0x18, 0x18, 0x0C, 0x0C, 0x07, 0xFF, 0xFE, 0xFE, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3E, 0xC0, 0x60, 0x18, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFE, 0x1C, 0x0A, 0x0D, 0x04, 0xC6, 0x22,
  0x1B, 0x05, 0x83, 0xFF, 0xC0, 0xE7, 0x0E, 0x0F, 0xE6, 0x19, 0x83, 0x00,
  0xC7, 0xF7, 0xFD, 0x83, 0xC0, 0xF0, 0x76, 0x3C, 0xFB, 0xC0, 0x60, 0x30,
  0x19, 0x8F, 0xF7, 0x1B, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0xBB, 0x78, 0x1C, 0x3F, 0xB8, 0xD8, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC1,
  0xE0, 0xDD, 0xC7, 0xC0, 0x01, 0x80, 0xC0, 0x67, 0x37, 0xDE, 0x1F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3F, 0xBD, 0xF6, 0x1C, 0x3F, 0xB0,
  0xD8, 0x3C, 0x1F, 0xFF, 0xFF, 0x80, 0xC0, 0x60, 0xD9, 0xC7, 0xC0, 0x0F,
  0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x39, 0xBE, 0xF0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xF3, 0xDF, 0x60, 0x30, 0x18, 0x1D, 0xFC, 0xFC,
  0xC0, 0x60, 0x30, 0x1B, 0x8F, 0xF7, 0x1B, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x06, 0x1C, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF,
  0xFF, 0x06, 0x07, 0x00, 0x00, 0xFE, 0xFE, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0xFC, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x07, 0xC1, 0xB0, 0xCC, 0x63, 0x18, 0xFC, 0x3F, 0x0C, 0x63, 0x18,
  0xC3, 0x30, 0x6C, 0x1C, 0xF8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x1F, 0xC1,
  0xF8, 0xD9, 0xBF, 0xFC, 0xCF, 0x13, 0xC4, 0xF1, 0x3C, 0x4F, 0x13, 0xC4,
  0xF1, 0x3C, 0x4F, 0x13, 0xDC, 0x7F, 0xB8, 0xD8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1C, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xDF, 0xC7, 0xC0, 0xCE, 0x7F, 0xB8, 0xD8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFD, 0xDB, 0xCC, 0x06, 0x03,
  0x01, 0x80, 0x39, 0xBE, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xFD, 0xEF, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0xCE, 0x6F, 0xB8, 0x78,
  0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x3C, 0x3F,
  0xB0, 0x78, 0x0C, 0x03, 0xE0, 0xFC, 0x07, 0x01, 0xE0, 0xFF, 0xEF, 0xE0,
  0x18, 0x06, 0x01, 0x83, 0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x03, 0xF0, 0x7C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0x9D, 0xC7, 0xC0, 0xC0, 0x50, 0x36,
  0x0D, 0x82, 0x21, 0x8C, 0x63, 0x10, 0x4C, 0x1B, 0x06, 0x80, 0xE0, 0x38,
  0x8C, 0x79, 0x8F, 0x39, 0xE5, 0x2C, 0xA4, 0x94, 0x96, 0xB2, 0x96, 0x72,
  0xCE, 0x71, 0xC6, 0x38, 0xC0, 0xE0, 0xCC, 0x38, 0xC6, 0x19, 0x81, 0xB0,
  0x1C, 0x03, 0x80, 0xF0, 0x3B, 0x06, 0x31, 0x87, 0x70, 0x70, 0xC0, 0xD8,
  0x36, 0x0D, 0x86, 0x31, 0x8C, 0x61, 0xB0, 0x6C, 0x1A, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0xFF, 0x7F, 0x80, 0xC0, 0xE0, 0xE0,
  0x60, 0x60, 0x60, 0x60, 0x70, 0x3F, 0xFF, 0xF0, 0x07, 0x87, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x78, 0x07, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x07, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x1C, 0x07, 0xC6, 0x02,
  0x01, 0x00, 0x80, 0x60, 0x30, 0x18, 0x18, 0x3C, 0x00, 0x30, 0x1E, 0x3C,
  0xCF, 0x1F, 0xC3, 0x80,
};

const GFXglyph JetBrainsMono_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 6, 13, 3, -15 },
  { 12, 11, 15, 13, 1, -15 },
  { 33, 9, 21, 13, 2, -18 },
  { 57, 12, 15, 13, 0, -15 },
  { 80, 11, 16, 13, 1, -16 },
  { 102, 2, 6, 13, 5, -15 },
  { 104, 6, 21, 13, 4, -18 },
  { 120, 7, 21, 13, 2, -18 },
  { 139, 11, 11, 13, 1, -13 },
  { 155, 10, 10, 13, 1, -12 },
  { 168, 5, 6, 13, 3, -3 },
  { 172, 7, 2, 13, 3, -8 },
  { 174, 3, 3, 13, 5, -3 },
  { 176, 9, 19, 13, 2, -17 },
  { 198, 9, 16, 13, 2, -16 },
  { 216, 9, 15, 13, 2, -15 },
  { 233, 9, 16, 13, 2, -16 },
  { 251, 10, 15, 13, 1, -15 },
  { 270, 9, 15, 13, 2, -15 },
  { 287, 9, 15, 13, 2, -15 },
  { 304, 10, 15, 13, 1, -15 },
  { 323, 9, 15, 13, 2, -15 },
  { 340, 9, 16, 13, 2, -16 },
  { 358, 10, 16, 13, 1, -16 },
  { 378, 3, 12, 13, 5, -12 },
  { 383, 4, 15, 13, 4, -12 },
  { 391, 9, 12, 13, 2, -13 },
  { 405, 9, 6, 13, 2, -10 },
  { 412, 9, 12, 13, 2, -13 },
  { 426, 7, 15, 13, 3, -15 },
  { 440, 11, 20, 13, 1, -16 },
  { 468, 11, 15, 13, 1, -15 },
  { 489, 9, 15, 13, 2, -15 },
  { 506, 9, 16, 13, 2, -16 },
  { 524, 9, 15, 13, 2, -15 },
  { 541, 9, 15, 13, 2, -15 },
  { 558, 9, 15, 13, 2, -15 },
  { 575, 9, 16, 13, 2, -16 },
  { 593, 9, 15, 13, 2, -15 },
  { 610, 8, 15, 13, 2, -15 },
  { 625, 9, 15, 13, 1, -15 },
  { 642, 10, 15, 13, 2, -15 },
  { 661, 9, 15, 13, 2, -15 },
  { 678, 9, 15, 13, 2, -15 },
  { 695, 9, 15, 13, 2, -15 },
  { 712, 9, 16, 13, 2, -16 },
  { 730, 10, 15, 13, 2, -15 },
  { 749, 9, 20, 13, 2, -16 },
  { 772, 9, 15, 13, 2, -15 },
  { 789, 9, 16, 13, 2, -16 },
  { 807, 10, 15, 13, 1, -15 },
  { 826, 9, 15, 13, 2, -15 },
  { 843, 11, 15, 13, 1, -15 },
  { 864, 11, 15, 13, 1, -15 },
  { 885, 11, 15, 13, 1, -15 },
  { 906, 11, 15, 13, 1, -15 },
  { 927, 9, 15, 13, 2, -15 },
  { 944, 5, 19, 13, 4, -17 },
  { 956, 9, 19, 13, 2, -17 },
  { 978, 5, 19, 13, 3, -17 },
  { 990, 9, 8, 13, 2, -15 },
  { 999, 10, 1, 13, 1, 1 },
  { 1001, 4, 2, 13, 4, -16 },
  { 1002, 10, 12, 13, 1, -12 },
  { 1017, 9, 15, 13, 2, -15 },
  { 1034, 9, 12, 13, 2, -12 },
  { 1048, 9, 15, 13, 2, -15 },
  { 1065, 9, 12, 13, 2, -12 },
  { 1079, 10, 15, 13, 1, -15 },
  { 1098, 9, 16, 13, 2, -12 },
  { 1116, 9, 15, 13, 2, -15 },
  { 1133, 10, 16, 13, 2, -16 },
  { 1153, 8, 20, 13, 2, -16 },
  { 1173, 10, 15, 13, 2, -15 },
  { 1192, 11, 15, 13, 1, -15 },
  { 1213, 10, 12, 13, 1, -12 },
  { 1228, 9, 12, 13, 2, -12 },
  { 1242, 9, 12, 13, 2, -12 },
  { 1256, 9, 16, 13, 2, -12 },
  { 1274, 9, 16, 13, 2, -12 },
  { 1292, 9, 12, 13, 2, -12 },
  { 1306, 9, 12, 13, 2, -12 },
  { 1320, 10, 15, 13, 1, -15 },
  { 1339, 9, 12, 13, 2, -12 },
  { 1353, 10, 12, 13, 1, -12 },
  { 1368, 11, 12, 13, 1, -12 },
  { 1385, 11, 12, 13, 1, -12 },
  { 1402, 10, 16, 13, 1, -12 },
  { 1422, 9, 12, 13, 2, -12 },
  { 1436, 9, 19, 13, 2, -17 },
  { 1458, 2, 19, 13, 5, -17 },
  { 1463, 9, 19, 13, 2, -17 },
  { 1485, 10, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_Regular21pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular21pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular21pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _JETBRAINSMONO_REGULAR21PT7B_H_
