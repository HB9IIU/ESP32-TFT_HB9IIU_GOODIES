#ifndef _JETBRAINSMONO_REGULAR50PT7B_H_
#define _JETBRAINSMONO_REGULAR50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFE, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x70,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00,
  0xF0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x78,
  0x01, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x3C, 0x03, 0x80, 0x0F,
  0x00, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x80,
  0x1E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x0F,
  0x00, 0x1C, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x01,
  0xE0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xF0,
  0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xCE, 0xFE, 0x7E, 0x38, 0xF9, 0xF0,
  0xE1, 0xE7, 0x83, 0x87, 0xDE, 0x0E, 0x1F, 0x78, 0x38, 0x7D, 0xE0, 0xE0,
  0x07, 0x83, 0x80, 0x1F, 0x0E, 0x00, 0x7E, 0x38, 0x00, 0xFC, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xE7, 0xE0, 0x03, 0x87,
  0xC0, 0x0E, 0x1F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xFF, 0x03, 0x83, 0xFC,
  0x0E, 0x0F, 0xF0, 0x38, 0x3F, 0xE0, 0xE1, 0xFF, 0xC3, 0x87, 0xDF, 0x8E,
  0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x73,
  0xFE, 0x00, 0x0F, 0x7F, 0xF0, 0x01, 0xE7, 0xFF, 0x80, 0x1C, 0xF0, 0x78,
  0x03, 0xCF, 0x03, 0xC0, 0x78, 0xF0, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0xF0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x3C, 0x38, 0x0F, 0x03,
  0xC7, 0x80, 0xF0, 0x78, 0xF0, 0x0F, 0xDF, 0x8E, 0x00, 0x7F, 0xF1, 0xE0,
  0x03, 0xFE, 0x3C, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x04, 0x00, 0x03, 0xC7,
  0xF8, 0x00, 0x38, 0xFF, 0xC0, 0x07, 0x9F, 0xFE, 0x00, 0xF1, 0xE1, 0xF0,
  0x0E, 0x3C, 0x0F, 0x01, 0xE3, 0xC0, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0x0F,
  0x1C, 0x01, 0xC0, 0xF3, 0xC0, 0x1F, 0x1F, 0x78, 0x01, 0xFF, 0xE7, 0x00,
  0x0F, 0xFC, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x9F, 0x01, 0xFF, 0x8F, 0x80, 0xF7,
  0x83, 0xE0, 0xFB, 0xC0, 0xF8, 0xF9, 0xE0, 0x3E, 0x7C, 0xF0, 0x1F, 0x7C,
  0x78, 0x07, 0xFC, 0x3C, 0x01, 0xFE, 0x1E, 0x00, 0xFE, 0x0F, 0x00, 0x3F,
  0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0xE1, 0xF0, 0x0F, 0xF0, 0xFC, 0x0F,
  0xFC, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0xC7, 0x87, 0xFF, 0x83, 0xE0, 0xFF,
  0x80, 0xF8, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF7, 0xBD, 0xEF, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x3C,
  0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x01, 0x00, 0x78, 0x02, 0x70, 0x1E, 0x03, 0x9F, 0x87, 0x87, 0xEF,
  0xF8, 0xC7, 0xFF, 0xFF, 0x33, 0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x00, 0x38,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x03, 0xF1, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x78, 0x3F, 0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F,
  0x0F, 0xF0, 0x78, 0x3F, 0xC0, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x7E, 0x01,
  0xF8, 0xFF, 0x3F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xF7, 0xC0, 0x1F, 0x8F, 0x80, 0x7E,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xC0, 0x7C, 0x03, 0x00, 0xF8, 0x04, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x7F, 0x03, 0xF1, 0xF0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF1, 0xFC, 0x07, 0x9F, 0xFC, 0x1E, 0xFF, 0xF8, 0x7B, 0xFF, 0xF1, 0xFC,
  0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80,
  0x07, 0x9F, 0x00, 0x3E, 0x7E, 0x01, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x8E, 0x00, 0x1F, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x79, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0xCF, 0xE0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x78, 0x00, 0x7B, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xDF, 0x00, 0x3E, 0x7E, 0x01, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0x7C, 0x07, 0xFE, 0xF8, 0x01, 0xFD, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x07, 0x83, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0x0F, 0xFC, 0x0F, 0x81,
  0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x3C, 0x03, 0xFC, 0x0F,
  0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x3C, 0x03, 0xFC,
  0x0F, 0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x3C, 0x03,
  0xFC, 0x0F, 0x81, 0xFF, 0x01, 0xF0, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFB, 0xFC, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xF9, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xC0,
  0x0F, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0, 0x03,
  0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x1E, 0x3C, 0x01, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0xF0, 0x07, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F,
  0xBC, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00,
  0x7E, 0xF0, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0x83, 0xF1, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00,
  0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x78, 0x03, 0xF3, 0xC0, 0x0F, 0xDE, 0x00, 0x3E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x7C,
  0xF0, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x83, 0xF1, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x3E, 0x01,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F,
  0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3F, 0x01, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00,
  0x0F, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x03, 0xE0, 0x1E,
  0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xE0,
  0x1F, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0xF9, 0xE0, 0x01,
  0xF3, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xB8, 0x07, 0x7E, 0xF0, 0x3D, 0xFB, 0xC0, 0xF7, 0xE7, 0x03,
  0xDF, 0x9E, 0x0E, 0x7F, 0x78, 0x79, 0xFC, 0xE1, 0xEF, 0xF3, 0xC7, 0x3F,
  0xCF, 0x3C, 0xFF, 0x1C, 0xF3, 0xFC, 0x7B, 0x8F, 0xF1, 0xEE, 0x3F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0, 0x7C, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0x78,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xEF, 0x01, 0xFF, 0xBC, 0x07,
  0xFE, 0xF0, 0x1F, 0xF9, 0xE0, 0x7F, 0xE7, 0x81, 0xFF, 0x8F, 0x07, 0xFE,
  0x3C, 0x1F, 0xF8, 0xF0, 0x7F, 0xE1, 0xE1, 0xFF, 0x87, 0x87, 0xFE, 0x1E,
  0x1F, 0xF8, 0x3C, 0x7F, 0xE0, 0xF1, 0xFF, 0x83, 0xC7, 0xFE, 0x07, 0x9F,
  0xF8, 0x1E, 0x7F, 0xE0, 0x79, 0xFF, 0x80, 0xF7, 0xFE, 0x03, 0xDF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7B, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1E,
  0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xE0, 0x07,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07,
  0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F, 0x00, 0x3E,
  0x7E, 0x01, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0xBE, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xC0, 0x0F, 0xCF, 0x00, 0x0F, 0xBC, 0x00,
  0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0,
  0x03, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x1F, 0x03,
  0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xFC, 0xF0, 0x01, 0xF3, 0xC0, 0x07,
  0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x01, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF9, 0xF8,
  0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01,
  0xF7, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0x7E, 0x01, 0xF9, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0x3E, 0x01, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0xFF, 0x80,
  0xF8, 0x0F, 0xF8, 0x0F, 0x81, 0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81,
  0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x78,
  0x1D, 0x81, 0xE7, 0x81, 0x98, 0x1E, 0x7C, 0x19, 0xC1, 0xE3, 0xC3, 0x9C,
  0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC3,
  0xC3, 0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x0C, 0x3C, 0x3C, 0x30,
  0xE3, 0xC3, 0xC7, 0x0E, 0x3C, 0x1E, 0x70, 0xE3, 0x81, 0xE7, 0x0E, 0x78,
  0x1E, 0x70, 0xE7, 0x81, 0xE7, 0x0E, 0x78, 0x1E, 0x70, 0xE7, 0x81, 0xE7,
  0x0E, 0x78, 0x1E, 0x60, 0x67, 0x81, 0xEE, 0x07, 0x78, 0x1E, 0xE0, 0x77,
  0x00, 0xEE, 0x07, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xCF, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00,
  0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF9, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xC0, 0x07,
  0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xC0, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xBE, 0x00, 0x7F, 0x7F, 0x03, 0xFE, 0x7F, 0xFF, 0x7C, 0x7F, 0xFC, 0xF8,
  0x3F, 0xF1, 0xF0, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87, 0xF0, 0x3C, 0x7F, 0xE1, 0xE7,
  0xFF, 0x8F, 0x7F, 0xFE, 0x7F, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x3E,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x3E, 0xFC, 0x03, 0xF7, 0xBE, 0xFF, 0x3D,
  0xFF, 0xF1, 0xE7, 0xFF, 0x8F, 0x1F, 0xF0, 0x00, 0x08, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF9,
  0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0xC3, 0xC3, 0xFF, 0x1E, 0x3F,
  0xFC, 0xF3, 0xFF, 0xF7, 0x9F, 0x81, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3D, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x01, 0xF9, 0xFE, 0xFB, 0xC7,
  0xFF, 0xDE, 0x1F, 0xFC, 0xF0, 0x7F, 0xC7, 0x80, 0x20, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF1,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0x8F, 0x80, 0x3E, 0x3F, 0xC7, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x78,
  0x7F, 0xF3, 0xC7, 0xFF, 0xDE, 0x7F, 0xFE, 0xF3, 0xF0, 0x3F, 0xBF, 0x00,
  0xFD, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x81, 0xFC, 0xFF, 0xFD, 0xE3, 0xFF, 0xEF,
  0x0F, 0xFE, 0x78, 0x1F, 0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x87,
  0xF0, 0x3C, 0xFF, 0xE1, 0xEF, 0xFF, 0x8F, 0x7F, 0xFE, 0x7F, 0x03, 0xF3,
  0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xF7,
  0x80, 0x07, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x78,
  0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0x81,
  0xF8, 0x0F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFC,
  0x0F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF8, 0x78, 0x01, 0xF0,
  0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0xE0, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xF1, 0xE0, 0xF8, 0xF3,
  0xF1, 0xFC, 0xF7, 0xFB, 0xFE, 0xF7, 0xFB, 0x7E, 0xF8, 0x7C, 0x1E, 0xF8,
  0x3C, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0xFE, 0x07, 0x9F,
  0xFC, 0x3D, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xE0, 0x7E, 0x7E, 0x01, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF1,
  0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0x8F, 0x80, 0x7C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0xF0, 0xFE, 0x07, 0x8F, 0xFC, 0x3D, 0xFF, 0xF1, 0xEF,
  0xFF, 0xCF, 0xE0, 0x7F, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7B, 0xE0, 0x07, 0xDF, 0xC0, 0x7E, 0xF7, 0xDF, 0xE7, 0xBF, 0xFE, 0x3C,
  0xFF, 0xF1, 0xE3, 0xFE, 0x0F, 0x01, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xE3, 0xC7, 0xFF,
  0x9E, 0x7F, 0xFE, 0xF3, 0xF0, 0x3F, 0xBF, 0x00, 0xFD, 0xF0, 0x03, 0xEF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x3F, 0xDF, 0x78, 0xFF,
  0xFB, 0xC3, 0xFF, 0x9E, 0x0F, 0xF8, 0xF0, 0x04, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0xFE, 0x07, 0x9F, 0xFC,
  0x3D, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xE0, 0x7E, 0x7E, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x01, 0xF9, 0xF0,
  0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x80, 0x3E, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80,
  0x7C, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0x81, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0,
  0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xDC, 0x0F, 0xC0, 0xE7, 0x83,
  0xF0, 0x39, 0xE0, 0xCC, 0x1E, 0x78, 0x33, 0x07, 0x9E, 0x1C, 0xE1, 0xE7,
  0x87, 0x38, 0x78, 0xE1, 0xCE, 0x1C, 0x38, 0x73, 0x87, 0x0F, 0x18, 0xE1,
  0xC3, 0xC6, 0x18, 0xF0, 0xF3, 0x87, 0x3C, 0x3C, 0xE1, 0xCF, 0x0F, 0x38,
  0x73, 0x81, 0xCE, 0x1C, 0xE0, 0x73, 0x87, 0x38, 0x1E, 0xC0, 0xDE, 0x07,
  0xB0, 0x37, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF3, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x03, 0xE7, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0x1F, 0xE0, 0x1F, 0x3F, 0xF0, 0x1F, 0x7F, 0xF8,
  0x1F, 0x78, 0xFC, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3F, 0x3E, 0xF8, 0x1F,
  0xFE, 0xF8, 0x0F, 0xFC, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x40,
};

const GFXglyph JetBrainsMono_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 37, 30, 11, -37 },
  { 38, 16, 16, 30, 7, -37 },
  { 70, 26, 37, 30, 2, -37 },
  { 191, 22, 51, 30, 4, -44 },
  { 332, 28, 37, 30, 1, -37 },
  { 462, 25, 38, 30, 3, -37 },
  { 581, 5, 16, 30, 12, -37 },
  { 591, 15, 48, 30, 9, -42 },
  { 681, 15, 48, 30, 6, -42 },
  { 771, 26, 26, 30, 2, -31 },
  { 856, 24, 23, 30, 3, -28 },
  { 925, 11, 16, 30, 8, -8 },
  { 947, 16, 5, 30, 7, -19 },
  { 957, 8, 9, 30, 11, -8 },
  { 966, 22, 48, 30, 4, -42 },
  { 1098, 22, 38, 30, 4, -37 },
  { 1203, 23, 37, 30, 4, -37 },
  { 1310, 22, 37, 30, 4, -37 },
  { 1412, 23, 38, 30, 3, -37 },
  { 1522, 21, 37, 30, 4, -37 },
  { 1620, 22, 38, 30, 4, -37 },
  { 1725, 24, 38, 30, 3, -37 },
  { 1839, 23, 37, 30, 4, -37 },
  { 1946, 22, 38, 30, 4, -37 },
  { 2051, 24, 37, 30, 3, -37 },
  { 2162, 8, 29, 30, 11, -28 },
  { 2191, 11, 36, 30, 8, -28 },
  { 2241, 22, 27, 30, 4, -30 },
  { 2316, 22, 17, 30, 4, -25 },
  { 2363, 22, 27, 30, 4, -30 },
  { 2438, 18, 37, 30, 7, -37 },
  { 2522, 26, 46, 30, 2, -37 },
  { 2672, 26, 37, 30, 2, -37 },
  { 2793, 22, 37, 30, 5, -37 },
  { 2895, 22, 38, 30, 4, -37 },
  { 3000, 21, 37, 30, 5, -37 },
  { 3098, 21, 37, 30, 5, -37 },
  { 3196, 21, 37, 30, 5, -37 },
  { 3294, 22, 38, 30, 4, -37 },
  { 3399, 20, 37, 30, 5, -37 },
  { 3492, 20, 37, 30, 5, -37 },
  { 3585, 23, 38, 30, 2, -37 },
  { 3695, 23, 37, 30, 5, -37 },
  { 3802, 21, 37, 30, 6, -37 },
  { 3900, 22, 37, 30, 4, -37 },
  { 4002, 22, 37, 30, 4, -37 },
  { 4104, 22, 38, 30, 4, -37 },
  { 4209, 23, 37, 30, 5, -37 },
  { 4316, 22, 46, 30, 4, -37 },
  { 4443, 22, 37, 30, 5, -37 },
  { 4545, 22, 38, 30, 4, -37 },
  { 4650, 24, 37, 30, 3, -37 },
  { 4761, 22, 38, 30, 4, -37 },
  { 4866, 26, 37, 30, 2, -37 },
  { 4987, 28, 37, 30, 1, -37 },
  { 5117, 26, 37, 30, 2, -37 },
  { 5238, 26, 37, 30, 2, -37 },
  { 5359, 22, 37, 30, 4, -37 },
  { 5461, 13, 48, 30, 10, -42 },
  { 5539, 22, 48, 30, 4, -42 },
  { 5671, 13, 48, 30, 7, -42 },
  { 5749, 22, 20, 30, 4, -37 },
  { 5804, 24, 4, 30, 3, 1 },
  { 5816, 11, 7, 30, 9, -39 },
  { 5826, 23, 29, 30, 3, -28 },
  { 5910, 21, 38, 30, 5, -37 },
  { 6010, 22, 29, 30, 4, -28 },
  { 6090, 21, 38, 30, 4, -37 },
  { 6190, 22, 29, 30, 4, -28 },
  { 6270, 24, 37, 30, 3, -37 },
  { 6381, 21, 37, 30, 4, -28 },
  { 6479, 21, 37, 30, 5, -37 },
  { 6577, 24, 39, 30, 4, -39 },
  { 6694, 19, 48, 30, 4, -39 },
  { 6808, 23, 37, 30, 5, -37 },
  { 6915, 27, 37, 30, 1, -37 },
  { 7040, 24, 28, 30, 3, -28 },
  { 7124, 21, 28, 30, 5, -28 },
  { 7198, 22, 28, 30, 4, -28 },
  { 7275, 21, 37, 30, 5, -28 },
  { 7373, 21, 37, 30, 4, -28 },
  { 7471, 21, 28, 30, 6, -28 },
  { 7545, 22, 28, 30, 4, -28 },
  { 7622, 23, 35, 30, 3, -35 },
  { 7723, 22, 29, 30, 4, -28 },
  { 7803, 24, 28, 30, 3, -28 },
  { 7887, 26, 28, 30, 2, -28 },
  { 7978, 26, 28, 30, 2, -28 },
  { 8069, 24, 37, 30, 3, -28 },
  { 8180, 22, 28, 30, 4, -28 },
  { 8257, 22, 48, 30, 4, -42 },
  { 8389, 4, 48, 30, 13, -42 },
  { 8413, 22, 48, 30, 4, -42 },
  { 8545, 24, 11, 30, 3, -23 },
};

const GFXfont JetBrainsMono_Regular50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_REGULAR50PT7B_H_
