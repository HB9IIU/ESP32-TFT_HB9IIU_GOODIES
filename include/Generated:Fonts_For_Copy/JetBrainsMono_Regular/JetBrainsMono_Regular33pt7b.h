#ifndef _JETBRAINSMONO_REGULAR33PT7B_H_
#define _JETBRAINSMONO_REGULAR33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEE, 0x73, 0x8C, 0x63, 0x18, 0xC6, 0x30,
  0x00, 0x07, 0x3F, 0xEF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x30, 0x70,
  0x1C, 0x18, 0x07, 0x06, 0x01, 0x81, 0x80, 0x60, 0x61, 0xFF, 0xFF, 0x7F,
  0xFF, 0xC3, 0x83, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x0C, 0x1C, 0x03, 0x07,
  0x01, 0xC1, 0x83, 0xFF, 0xFC, 0xFF, 0xFF, 0x06, 0x06, 0x01, 0x83, 0x80,
  0x60, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x01, 0xFE, 0x07, 0xFE,
  0x1E, 0xDE, 0x79, 0x9E, 0xE3, 0x1D, 0xC6, 0x3B, 0x8C, 0x07, 0x18, 0x0F,
  0x30, 0x0F, 0x60, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0C,
  0xF0, 0x18, 0xE0, 0x31, 0xC0, 0x63, 0xF0, 0xC7, 0x71, 0x8E, 0xE3, 0x3C,
  0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x3F, 0x00, 0xEF, 0xF0, 0x19, 0xC6, 0x07, 0x30, 0xE1,
  0xC6, 0x1C, 0x30, 0xC3, 0x8E, 0x18, 0x73, 0x83, 0x0E, 0x60, 0x7B, 0x98,
  0x07, 0xF7, 0x00, 0x78, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x8F,
  0x00, 0x67, 0xF0, 0x1D, 0xE7, 0x03, 0x38, 0x60, 0xC7, 0x0C, 0x38, 0xE1,
  0x86, 0x1C, 0x31, 0x83, 0x86, 0x70, 0x71, 0xDC, 0x07, 0xF7, 0x00, 0x7C,
  0x1F, 0xE0, 0x1F, 0xF8, 0x0E, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F,
  0xE0, 0x0F, 0x70, 0x7F, 0x1C, 0x3B, 0x8F, 0x39, 0xC3, 0xDC, 0xE0, 0xFC,
  0x70, 0x3C, 0x38, 0x1E, 0x1C, 0x0F, 0x0E, 0x0F, 0xC7, 0xCF, 0x71, 0xFF,
  0x3C, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x70, 0x7C, 0x3E,
  0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0x80,
  0x38, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x7C, 0x3E,
  0x0E, 0x02, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x40, 0xC0, 0x9C, 0x30, 0xEF, 0xCC, 0xF9, 0xFF, 0xFF, 0x0F, 0xFC, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1C, 0xC0, 0x0F, 0x38, 0x03, 0x8F, 0x01, 0xE1,
  0xE0, 0x70, 0x38, 0x08, 0x08, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x1E, 0x38, 0x71, 0xC0, 0xFF,
  0xFF, 0xF0, 0x7B, 0xEF, 0xFF, 0x78, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0xBC, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x71,
  0xF9, 0xE7, 0xE7, 0x9F, 0x8C, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3D, 0xE3, 0xE3, 0xFF, 0x07, 0xF8, 0x07,
  0x80, 0x3F, 0x00, 0xFE, 0x03, 0xDC, 0x0F, 0x38, 0x18, 0x70, 0x20, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0,
  0xF1, 0xF3, 0x80, 0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xC0,
  0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0xF7, 0x01, 0xCF, 0x8F, 0x8F, 0xFE,
  0x07, 0xF0, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x81, 0xDE, 0x07, 0x70,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE3, 0xC3,
  0xBF, 0xCF, 0xFF, 0xBE, 0x0E, 0xF0, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xF8, 0x07, 0xF0, 0x39, 0xE3, 0xE3, 0xFF,
  0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3D, 0xF0, 0x3F, 0xF8,
  0x7F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3E, 0x7C, 0x1F, 0xF8,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1F,
  0xE0, 0xFF, 0xC7, 0x87, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0E, 0x70, 0x38, 0xE3, 0xC1, 0xFE, 0x03, 0xE0, 0x1F, 0xE1, 0xE3, 0xC7,
  0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3D,
  0xF3, 0xE7, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x7C, 0x78,
  0x1E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xDC, 0x0F, 0xB8, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x7B, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC7, 0xBF, 0xFD, 0xE0, 0x3C, 0xFD, 0xF9, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x1E, 0x78, 0xF1, 0xC3,
  0x8E, 0x1C, 0x38, 0x00, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x70,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x02,
  0x00, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE1, 0xFE, 0x1F, 0xC1, 0xF0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0, 0x79, 0xF0, 0x7E, 0xF8,
  0x78, 0xFC, 0x38, 0x3E, 0x1C, 0x1F, 0x0E, 0x0F, 0x87, 0x07, 0xC3, 0x83,
  0xE1, 0xC1, 0xF0, 0xE0, 0xF8, 0x70, 0x7C, 0x38, 0x7E, 0x0F, 0xFB, 0x03,
  0xED, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x1C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x18, 0x38, 0x1C,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8,
  0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x81, 0xEF,
  0xFF, 0x3F, 0xF8, 0xFF, 0xFB, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xEF, 0xFF, 0x3F, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x3D, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x38,
  0x1E, 0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE3, 0xFF, 0x8F,
  0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x3D, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xC0,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x81, 0xE7, 0xCF, 0x87, 0xFE, 0x07, 0xF8,
  0xE0, 0x0F, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38,
  0x3C, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC,
  0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xE7,
  0x01, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x6F,
  0x61, 0xBD, 0xCE, 0xF7, 0x33, 0xCC, 0xCF, 0x37, 0x3C, 0xF8, 0xF1, 0xE7,
  0xC7, 0x9F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0xC1, 0xFB, 0x87, 0xEE,
  0x1F, 0x98, 0x7E, 0x71, 0xF9, 0xC7, 0xE3, 0x1F, 0x8E, 0x7E, 0x39, 0xF8,
  0x67, 0xE1, 0xDF, 0x83, 0x7E, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x0F, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0xBC, 0x0E, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x39, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0xFF, 0xE1, 0xFF,
  0xF3, 0xFF, 0xF7, 0x00, 0xEE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0xBC,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3D, 0xF3, 0xE3, 0xFF, 0x07, 0xF8,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0xFF,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F,
  0xF8, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE1, 0xC0, 0xE3, 0x81, 0xC7, 0x03,
  0xCE, 0x03, 0x9C, 0x07, 0xB8, 0x07, 0x70, 0x0F, 0x0F, 0xF0, 0x3F, 0xF0,
  0xF0, 0xF3, 0xC0, 0xF7, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x3B, 0x80, 0x77, 0x01, 0xEF,
  0xCF, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x39, 0xF3, 0xE3, 0xFF, 0x07, 0xF8, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xE1,
  0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xB8, 0x78,
  0x66, 0x16, 0x19, 0x8C, 0x8E, 0x73, 0x23, 0x9C, 0xCC, 0xE7, 0x33, 0x39,
  0xCC, 0xCE, 0x73, 0x33, 0x9C, 0xCC, 0xC7, 0x23, 0x30, 0xD8, 0xCC, 0x36,
  0x13, 0x0D, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0x83, 0xE1, 0xE0, 0x70, 0x78, 0x70, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0xC3,
  0x81, 0xC1, 0xE1, 0xE0, 0x70, 0xE0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x0E, 0x07, 0x87, 0x03, 0x81, 0xC3,
  0xC0, 0xF1, 0xC0, 0x39, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xDC, 0x00,
  0xE7, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0x38, 0x70, 0x0E, 0x3C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0x70, 0x1C, 0xC0, 0x73, 0x81, 0x86, 0x0E, 0x1C, 0x30,
  0x31, 0xC0, 0xE6, 0x03, 0xB8, 0x07, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF3, 0xC0,
  0xF7, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xFF, 0x3F, 0xFE, 0xFF, 0xFD,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xBC, 0x1F, 0x7F,
  0xEE, 0x3F, 0x9C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x7E, 0x3B, 0xFC, 0xF8, 0x7B, 0xC0, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x3F, 0xF1, 0xEE, 0xFF, 0x39, 0xF8, 0x1F, 0xE0, 0xFF,
  0xC7, 0x87, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xDF,
  0x3E, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x73, 0xF9, 0xDF, 0xF7, 0x78, 0x7F, 0xC0, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3D, 0xE3, 0xF7, 0xFD, 0xC7, 0xE7, 0x1F,
  0xE0, 0xFF, 0xC7, 0x87, 0xBC, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x7F,
  0x03, 0xDE, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x3F, 0x9D, 0xFF, 0x77, 0x87,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xC1, 0xF7, 0xFD, 0xCF, 0xF7, 0x0F,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0xFE, 0x3B, 0xFC, 0xF8, 0x7B, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x03, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x0F, 0x01,
  0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x07, 0xF0, 0x0E, 0xE0,
  0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x07, 0x0E, 0x1E, 0x1F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x83, 0xC7, 0x03, 0x8E, 0x03, 0x9C,
  0x07, 0xB8, 0x07, 0x70, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xEF, 0x3C, 0xFF, 0xFE,
  0xE3, 0xCE, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87,
  0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87,
  0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xEF, 0xE3, 0xBF, 0xCF,
  0x87, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x70, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0xBC, 0x0E, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0x9F, 0x3E, 0x3F, 0xF0, 0x7F, 0x80,
  0xE7, 0xE3, 0xBF, 0xEF, 0x87, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x03, 0xFF, 0x1E, 0xEF, 0xF3, 0x9F, 0x8E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x3F, 0x9D, 0xFF, 0x77, 0x87, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0xDE, 0x3F, 0x7F, 0xDC,
  0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0xEF, 0xE3, 0xFF, 0xCF, 0x87, 0xB8, 0x0E, 0xE0, 0x3B, 0x80, 0x7E, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0xE7,
  0x87, 0xBC, 0x07, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x01, 0xDE, 0x1F,
  0x7F, 0xF8, 0x7F, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0xF7, 0x03, 0x9F, 0x3E, 0x3F, 0xF0, 0x7F, 0x00, 0xE0, 0x07, 0xE0, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x18,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xE1, 0xC1, 0xF8, 0x78,
  0x66, 0x1E, 0x19, 0x87, 0x86, 0x61, 0xE3, 0x9C, 0x58, 0xE7, 0x32, 0x39,
  0xCC, 0xCC, 0x33, 0x33, 0x0C, 0xCC, 0xC3, 0x33, 0x30, 0xC8, 0xDC, 0x3E,
  0x37, 0x0F, 0x85, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x07,
  0x80, 0xF0, 0x0F, 0x78, 0x1E, 0x38, 0x1C, 0x1C, 0x38, 0x1E, 0x78, 0x0E,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E,
  0xF0, 0x1E, 0x70, 0x1C, 0x38, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x0E, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x07,
  0xF0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xFC,
  0x03, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0xFF, 0x07, 0xC0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0xFE, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x3E,
  0x07, 0x7F, 0x07, 0xF7, 0x87, 0xE3, 0xC7, 0xE1, 0xFE, 0xE0, 0xFE, 0xE0,
  0x38,
};

const GFXglyph JetBrainsMono_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 24, 20, 7, -24 },
  { 16, 10, 10, 20, 5, -24 },
  { 29, 18, 24, 20, 1, -24 },
  { 83, 15, 34, 20, 2, -29 },
  { 147, 19, 24, 20, 0, -24 },
  { 204, 17, 24, 20, 2, -24 },
  { 255, 3, 10, 20, 8, -24 },
  { 259, 10, 32, 20, 6, -28 },
  { 299, 10, 32, 20, 4, -28 },
  { 339, 18, 17, 20, 1, -20 },
  { 378, 16, 16, 20, 2, -19 },
  { 410, 7, 10, 20, 5, -5 },
  { 419, 10, 2, 20, 5, -12 },
  { 422, 6, 5, 20, 7, -5 },
  { 426, 15, 31, 20, 2, -27 },
  { 485, 14, 24, 20, 3, -24 },
  { 527, 15, 24, 20, 3, -24 },
  { 572, 15, 24, 20, 2, -24 },
  { 617, 15, 24, 20, 2, -24 },
  { 662, 14, 24, 20, 3, -24 },
  { 704, 14, 24, 20, 3, -24 },
  { 746, 16, 24, 20, 2, -24 },
  { 794, 15, 24, 20, 3, -24 },
  { 839, 14, 24, 20, 3, -24 },
  { 881, 16, 24, 20, 2, -24 },
  { 929, 6, 18, 20, 7, -18 },
  { 943, 7, 23, 20, 6, -18 },
  { 964, 14, 18, 20, 3, -20 },
  { 996, 14, 10, 20, 3, -16 },
  { 1014, 14, 18, 20, 3, -20 },
  { 1046, 12, 24, 20, 4, -24 },
  { 1082, 17, 30, 20, 1, -24 },
  { 1146, 16, 24, 20, 2, -24 },
  { 1194, 14, 24, 20, 3, -24 },
  { 1236, 14, 24, 20, 3, -24 },
  { 1278, 14, 24, 20, 3, -24 },
  { 1320, 14, 24, 20, 3, -24 },
  { 1362, 14, 24, 20, 3, -24 },
  { 1404, 14, 24, 20, 3, -24 },
  { 1446, 14, 24, 20, 3, -24 },
  { 1488, 13, 24, 20, 3, -24 },
  { 1527, 15, 24, 20, 1, -24 },
  { 1572, 15, 24, 20, 3, -24 },
  { 1617, 14, 24, 20, 4, -24 },
  { 1659, 14, 24, 20, 3, -24 },
  { 1701, 14, 24, 20, 3, -24 },
  { 1743, 14, 24, 20, 3, -24 },
  { 1785, 15, 24, 20, 3, -24 },
  { 1830, 14, 30, 20, 3, -24 },
  { 1883, 15, 24, 20, 3, -24 },
  { 1928, 15, 24, 20, 2, -24 },
  { 1973, 16, 24, 20, 2, -24 },
  { 2021, 14, 24, 20, 3, -24 },
  { 2063, 16, 24, 20, 2, -24 },
  { 2111, 18, 24, 20, 1, -24 },
  { 2165, 17, 24, 20, 1, -24 },
  { 2216, 18, 24, 20, 1, -24 },
  { 2270, 14, 24, 20, 3, -24 },
  { 2312, 8, 31, 20, 7, -27 },
  { 2343, 15, 31, 20, 2, -27 },
  { 2402, 8, 31, 20, 5, -27 },
  { 2433, 14, 13, 20, 3, -24 },
  { 2456, 16, 2, 20, 2, 1 },
  { 2460, 7, 5, 20, 6, -26 },
  { 2465, 15, 18, 20, 2, -18 },
  { 2499, 14, 24, 20, 3, -24 },
  { 2541, 14, 18, 20, 3, -18 },
  { 2573, 14, 24, 20, 3, -24 },
  { 2615, 14, 18, 20, 3, -18 },
  { 2647, 16, 24, 20, 2, -24 },
  { 2695, 14, 24, 20, 3, -18 },
  { 2737, 14, 24, 20, 3, -24 },
  { 2779, 15, 26, 20, 3, -26 },
  { 2828, 12, 32, 20, 3, -26 },
  { 2876, 15, 24, 20, 3, -24 },
  { 2921, 17, 24, 20, 1, -24 },
  { 2972, 16, 18, 20, 2, -18 },
  { 3008, 14, 18, 20, 3, -18 },
  { 3040, 14, 18, 20, 3, -18 },
  { 3072, 14, 24, 20, 3, -18 },
  { 3114, 14, 24, 20, 3, -18 },
  { 3156, 14, 18, 20, 4, -18 },
  { 3188, 14, 18, 20, 3, -18 },
  { 3220, 15, 23, 20, 2, -23 },
  { 3264, 14, 18, 20, 3, -18 },
  { 3296, 16, 18, 20, 2, -18 },
  { 3332, 18, 18, 20, 1, -18 },
  { 3373, 16, 18, 20, 2, -18 },
  { 3409, 16, 24, 20, 2, -18 },
  { 3457, 14, 18, 20, 3, -18 },
  { 3489, 14, 31, 20, 3, -27 },
  { 3544, 3, 31, 20, 8, -27 },
  { 3556, 14, 31, 20, 3, -27 },
  { 3611, 16, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_Regular33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_REGULAR33PT7B_H_
