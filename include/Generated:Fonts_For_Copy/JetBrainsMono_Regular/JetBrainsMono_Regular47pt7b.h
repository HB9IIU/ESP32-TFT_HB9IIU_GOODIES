#ifndef _JETBRAINSMONO_REGULAR47PT7B_H_
#define _JETBRAINSMONO_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xBF, 0xFF, 0xFD, 0xF8, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0x70, 0x3D, 0xC0, 0xF0, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x78,
  0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x38, 0x07,
  0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x0E, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF3,
  0xBF, 0x0F, 0x8E, 0x3E, 0x3C, 0x38, 0xF9, 0xF0, 0xE1, 0xE7, 0xC3, 0x87,
  0x9F, 0x0E, 0x00, 0x7C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xE3, 0x80, 0x0F,
  0x8E, 0x00, 0x1F, 0xB8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xBF, 0x00, 0x0E, 0x7E,
  0x00, 0x38, 0xF8, 0x00, 0xE1, 0xF0, 0x03, 0x87, 0xC0, 0x0E, 0x0F, 0xF8,
  0x38, 0x3F, 0xE0, 0xE1, 0xF7, 0x83, 0x87, 0xDF, 0x0E, 0x1E, 0x7E, 0x38,
  0xF8, 0xFE, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x00, 0x27, 0xF8,
  0x00, 0x79, 0xFF, 0x80, 0x0E, 0x7F, 0xF8, 0x03, 0xCF, 0x07, 0x00, 0xF1,
  0xC0, 0xF0, 0x1C, 0x38, 0x1E, 0x07, 0x87, 0x03, 0xC1, 0xE0, 0xE0, 0x78,
  0x38, 0x1C, 0x0F, 0x0F, 0x03, 0x81, 0xE3, 0xC0, 0x78, 0x3C, 0x70, 0x0F,
  0x0F, 0x1E, 0x00, 0xFF, 0xE7, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0xFE, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x0C, 0x00, 0x03, 0x8F, 0xF0, 0x00, 0xE3, 0xFF, 0x00, 0x3C, 0xFF,
  0xF0, 0x0F, 0x1E, 0x1E, 0x01, 0xC7, 0x81, 0xC0, 0x78, 0xF0, 0x38, 0x1E,
  0x1E, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x78, 0x1C, 0x3C, 0x0F, 0x03,
  0x87, 0x00, 0xE0, 0x71, 0xE0, 0x1E, 0x1E, 0x78, 0x03, 0xFF, 0xCE, 0x00,
  0x3F, 0xF3, 0xC0, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3E, 0x07, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0xFD, 0xF0, 0x1E, 0xF0, 0xF0, 0x3E, 0xF0, 0xF8, 0x3C, 0xF0, 0x7C, 0x78,
  0xF0, 0x3E, 0x78, 0xF0, 0x1E, 0xF0, 0xF0, 0x1F, 0xF0, 0xF0, 0x0F, 0xE0,
  0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xE0, 0xF0, 0x0F, 0xF0,
  0xF8, 0x1F, 0xF0, 0xFE, 0x7F, 0xF8, 0x7F, 0xFE, 0x7C, 0x3F, 0xFC, 0x3E,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xC0, 0x0F, 0x00, 0x04, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x03,
  0xF0, 0x07, 0x80, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0xC0, 0x78, 0x0C, 0xF8, 0x3C, 0x1F, 0x7F, 0x8E,
  0x3F, 0xBF, 0xE6, 0x7F, 0xE7, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x0C, 0x00, 0xC0, 0x02, 0x00, 0x40,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0x0F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x0F, 0x0F, 0xF0,
  0x60, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0x7C, 0x03, 0xE3, 0xF0, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0x78, 0x03,
  0xF3, 0xC0, 0x7E, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xC0, 0x3C,
  0x04, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7,
  0xC0, 0x0F, 0x9E, 0x00, 0x3E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F,
  0x3F, 0x00, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x78,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x81, 0x00, 0x79, 0xFF, 0x07,
  0xBF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7C, 0x03, 0xE7, 0xC0, 0x1F,
  0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7F, 0x1F, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7D, 0xFE, 0x01, 0xEF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0x87, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xF8, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x78,
  0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7,
  0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x0F, 0x80, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3E, 0x07,
  0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0x7C,
  0x03, 0xF7, 0xF8, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x03, 0xF0, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xF8,
  0x07, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFD, 0xE0, 0x0F, 0xCF,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x1F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xE0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83,
  0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x70,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xC7, 0xF0, 0x1F,
  0xE7, 0xF0, 0x1F, 0xF7, 0xF0, 0x3E, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x78,
  0x0F, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78,
  0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x78,
  0x07, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3F,
  0xF7, 0xF0, 0x1F, 0xF7, 0xF0, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xE7,
  0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x7C, 0x3E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x3E, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07,
  0xBE, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x03, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3E, 0x01, 0xF9,
  0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0x7C, 0x01, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x87, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE3, 0xF9, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0x87, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0x07,
  0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0xBF, 0x00, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xF7, 0x00, 0xFF, 0xF8,
  0x07, 0x7F, 0xE0, 0x3B, 0xF7, 0x03, 0xDF, 0xB8, 0x1D, 0xFD, 0xE0, 0xEF,
  0xE7, 0x0F, 0x7F, 0x38, 0x73, 0xF9, 0xE3, 0x9F, 0xC7, 0x3C, 0xFE, 0x39,
  0xE7, 0xF1, 0xEE, 0x3F, 0x8F, 0x71, 0xFC, 0x3F, 0x8F, 0xF1, 0xF8, 0x7F,
  0x8F, 0xC3, 0xFC, 0x3E, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xF7, 0x00, 0xFF, 0x78, 0x0F, 0xF7, 0x80, 0xFF, 0x38, 0x0F, 0xF3, 0xC0,
  0xFF, 0x3C, 0x0F, 0xF1, 0xC0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x78, 0xFF, 0x07, 0x8F, 0xF0,
  0x38, 0xFF, 0x03, 0xCF, 0xF0, 0x3C, 0xFF, 0x01, 0xCF, 0xF0, 0x1E, 0xFF,
  0x01, 0xEF, 0xF0, 0x0E, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x07, 0xE7, 0xC0,
  0x3E, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xF7, 0x80,
  0x1E, 0x7C, 0x03, 0xE3, 0xF9, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0,
  0x7E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0xF9, 0xF0, 0x0F, 0x87, 0xF3, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x03,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3E, 0x0F, 0x80,
  0xF8, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x9F, 0x00,
  0x1E, 0x7C, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0,
  0x01, 0xE7, 0xE0, 0x0F, 0x8F, 0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3F, 0x9F, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xF0, 0x1F, 0x03, 0xFC, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3D, 0xE0,
  0x7C, 0x0F, 0x78, 0x3F, 0x03, 0x9E, 0x0F, 0xC0, 0xE7, 0x83, 0xB0, 0x79,
  0xE0, 0xEC, 0x1E, 0x78, 0x3B, 0x07, 0x9E, 0x0C, 0xE1, 0xE7, 0x83, 0x38,
  0x78, 0xE0, 0xCE, 0x1E, 0x3C, 0x73, 0x87, 0x8F, 0x1C, 0xE1, 0xC3, 0xC7,
  0x38, 0x70, 0xF1, 0xC6, 0x3C, 0x3C, 0x71, 0x8F, 0x0F, 0x18, 0x63, 0xC3,
  0xC6, 0x1C, 0xF0, 0xF1, 0x87, 0x3C, 0x1C, 0xE1, 0xCF, 0x07, 0x38, 0x73,
  0x81, 0xEE, 0x1C, 0xE0, 0x7B, 0x87, 0x38, 0x1E, 0xE0, 0xCE, 0x07, 0xB0,
  0x37, 0x81, 0xEC, 0x0D, 0xE0, 0x7B, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7,
  0xC0, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xE7,
  0xC0, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xC1, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xDC, 0x00, 0x79, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xF0, 0x0F, 0x07, 0x00,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0xC0, 0x1C,
  0x78, 0x01, 0xE7, 0x80, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xF8, 0x3F, 0x9F, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0x7D, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFD, 0xF8, 0x1D, 0xE7, 0xFF, 0xEF, 0x1F, 0xFE, 0x78, 0x7F,
  0xE3, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFE,
  0x0F, 0xBF, 0xF8, 0xFB, 0xFF, 0xCF, 0x79, 0xFE, 0xF6, 0x03, 0xEF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFF, 0x8F, 0xEF, 0xFF, 0xFC, 0xFB, 0xFF,
  0x8F, 0x9F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFD,
  0xFE, 0x7C, 0x03, 0xE7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x3F, 0x8F,
  0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x07, 0xF0, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF7,
  0xF9, 0xEF, 0x7C, 0x02, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x7F,
  0x0E, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0xFF, 0x8F, 0x03, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7C, 0x03, 0xE7, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x78,
  0x01, 0xF7, 0xC0, 0x1F, 0x3F, 0x07, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF8, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF3, 0xF9, 0xEF, 0x7C, 0x03,
  0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7,
  0xC0, 0x3F, 0x3F, 0x9E, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7F, 0x8F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFE, 0x0F,
  0xBF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF8, 0xFE, 0xFC, 0x03, 0xEF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x01,
  0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x01,
  0xF0, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF0, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0xF3, 0xE3, 0xF3, 0xDF, 0xDF, 0xEF, 0xFF,
  0x7F, 0xBE, 0x3F, 0x1F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83,
  0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F,
  0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0xF0,
  0x78, 0x3F, 0xC1, 0xE0, 0xF0, 0xF8, 0xFE, 0x0F, 0xBF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xF9, 0xFE, 0xFE, 0x03, 0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x03, 0xE7, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x3F, 0x9F, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0xF8, 0xFF, 0x0F, 0xBF, 0xF8, 0xFB, 0xFF, 0xCF, 0xF9,
  0xFE, 0xFE, 0x03, 0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x40, 0x3E, 0xF7, 0x8F,
  0xEF, 0x7F, 0xFC, 0xFB, 0xFF, 0x8F, 0x8F, 0xF0, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0xF1, 0xFF, 0xCF, 0x3F, 0xFE, 0xF3,
  0xF9, 0xEF, 0x7C, 0x02, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x7F,
  0x0E, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0xFF, 0x8F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF,
  0xCF, 0x78, 0xFE, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7C, 0x01, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0xF7, 0xC0, 0x1F, 0x7F, 0x0F, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0,
  0x3E, 0x3F, 0x8F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0x80,
  0x07, 0x8F, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x78, 0x3E, 0x00,
  0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x3E,
  0x01, 0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0xE0, 0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xBC, 0x0F, 0x01, 0xDE,
  0x07, 0xC1, 0xEF, 0x07, 0xE0, 0xF7, 0x83, 0xF0, 0x79, 0xC1, 0xD8, 0x3C,
  0xE0, 0xCC, 0x1C, 0x78, 0x66, 0x0E, 0x3C, 0x33, 0x87, 0x1E, 0x39, 0xC7,
  0x8F, 0x1C, 0xE3, 0xC3, 0x8E, 0x71, 0xE1, 0xC6, 0x18, 0xE0, 0xE3, 0x0C,
  0x70, 0x79, 0x87, 0x38, 0x3C, 0xC3, 0x9C, 0x1E, 0xE1, 0xDE, 0x07, 0x70,
  0xEF, 0x03, 0xB8, 0x37, 0x01, 0xD8, 0x1B, 0x80, 0xEC, 0x0D, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xC0,
  0x01, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xC3, 0xE0, 0x07, 0xC1, 0xE0,
  0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x79,
  0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F,
  0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x3C,
  0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xF1,
  0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3C, 0xFF, 0x80, 0xF7, 0xFF, 0x03, 0xFE,
  0x3E, 0x0F, 0xF0, 0x7C, 0x3F, 0xC0, 0xF9, 0xFF, 0x03, 0xFF, 0xBC, 0x07,
  0xFE, 0xF0, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 34, 28, 11, -34 },
  { 31, 14, 14, 28, 7, -34 },
  { 56, 25, 34, 28, 2, -34 },
  { 163, 22, 48, 28, 3, -41 },
  { 295, 27, 35, 28, 1, -35 },
  { 414, 24, 35, 28, 3, -35 },
  { 519, 4, 14, 28, 12, -34 },
  { 526, 14, 45, 28, 9, -39 },
  { 605, 15, 45, 28, 5, -39 },
  { 690, 25, 25, 28, 2, -29 },
  { 769, 22, 23, 28, 3, -27 },
  { 833, 10, 15, 28, 8, -7 },
  { 852, 15, 3, 28, 7, -17 },
  { 858, 8, 7, 28, 10, -7 },
  { 865, 21, 44, 28, 4, -39 },
  { 981, 20, 35, 28, 4, -35 },
  { 1069, 21, 34, 28, 4, -34 },
  { 1159, 22, 35, 28, 3, -35 },
  { 1256, 21, 34, 28, 3, -34 },
  { 1346, 20, 34, 28, 4, -34 },
  { 1431, 20, 34, 28, 4, -34 },
  { 1516, 22, 34, 28, 3, -34 },
  { 1610, 21, 34, 28, 4, -34 },
  { 1700, 20, 35, 28, 4, -35 },
  { 1788, 22, 35, 28, 3, -35 },
  { 1885, 8, 26, 28, 10, -26 },
  { 1911, 10, 34, 28, 8, -26 },
  { 1954, 20, 25, 28, 4, -28 },
  { 2017, 20, 15, 28, 4, -23 },
  { 2055, 20, 25, 28, 4, -28 },
  { 2118, 17, 34, 28, 6, -34 },
  { 2191, 24, 43, 28, 2, -35 },
  { 2320, 24, 34, 28, 2, -34 },
  { 2422, 21, 34, 28, 4, -34 },
  { 2512, 20, 35, 28, 4, -35 },
  { 2600, 20, 34, 28, 4, -34 },
  { 2685, 19, 34, 28, 5, -34 },
  { 2766, 21, 34, 28, 4, -34 },
  { 2856, 20, 35, 28, 4, -35 },
  { 2944, 20, 34, 28, 4, -34 },
  { 3029, 18, 34, 28, 5, -34 },
  { 3106, 21, 34, 28, 2, -34 },
  { 3196, 22, 34, 28, 4, -34 },
  { 3290, 20, 34, 28, 5, -34 },
  { 3375, 21, 34, 28, 4, -34 },
  { 3465, 20, 34, 28, 4, -34 },
  { 3550, 20, 35, 28, 4, -35 },
  { 3638, 22, 34, 28, 4, -34 },
  { 3732, 21, 43, 28, 4, -35 },
  { 3845, 22, 34, 28, 4, -34 },
  { 3939, 22, 35, 28, 3, -35 },
  { 4036, 23, 34, 28, 3, -34 },
  { 4134, 20, 34, 28, 4, -34 },
  { 4219, 24, 34, 28, 2, -34 },
  { 4321, 26, 34, 28, 1, -34 },
  { 4432, 24, 34, 28, 2, -34 },
  { 4534, 25, 34, 28, 2, -34 },
  { 4641, 20, 34, 28, 4, -34 },
  { 4726, 11, 44, 28, 10, -39 },
  { 4787, 21, 44, 28, 4, -39 },
  { 4903, 12, 44, 28, 7, -39 },
  { 4969, 20, 18, 28, 4, -34 },
  { 5014, 22, 4, 28, 3, 1 },
  { 5025, 9, 7, 28, 9, -37 },
  { 5033, 21, 26, 28, 3, -26 },
  { 5102, 20, 34, 28, 4, -34 },
  { 5187, 20, 26, 28, 4, -26 },
  { 5252, 20, 34, 28, 4, -34 },
  { 5337, 20, 26, 28, 4, -26 },
  { 5402, 22, 34, 28, 3, -34 },
  { 5496, 20, 34, 28, 4, -26 },
  { 5581, 20, 34, 28, 4, -34 },
  { 5666, 22, 37, 28, 4, -37 },
  { 5768, 17, 45, 28, 4, -37 },
  { 5864, 22, 34, 28, 4, -34 },
  { 5958, 25, 34, 28, 1, -34 },
  { 6065, 22, 26, 28, 3, -26 },
  { 6137, 20, 26, 28, 4, -26 },
  { 6202, 20, 26, 28, 4, -26 },
  { 6267, 20, 34, 28, 4, -26 },
  { 6352, 20, 34, 28, 4, -26 },
  { 6437, 20, 26, 28, 5, -26 },
  { 6502, 20, 26, 28, 4, -26 },
  { 6567, 21, 33, 28, 3, -33 },
  { 6654, 20, 26, 28, 4, -26 },
  { 6719, 23, 26, 28, 3, -26 },
  { 6794, 25, 26, 28, 2, -26 },
  { 6876, 24, 26, 28, 2, -26 },
  { 6954, 23, 34, 28, 3, -26 },
  { 7052, 20, 26, 28, 4, -26 },
  { 7117, 20, 44, 28, 4, -39 },
  { 7227, 4, 44, 28, 12, -39 },
  { 7249, 20, 44, 28, 4, -39 },
  { 7359, 22, 9, 28, 3, -21 },
};

const GFXfont JetBrainsMono_Regular47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_REGULAR47PT7B_H_
