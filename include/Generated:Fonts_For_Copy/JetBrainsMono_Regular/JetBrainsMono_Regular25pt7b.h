#ifndef _JETBRAINSMONO_REGULAR25PT7B_H_
#define _JETBRAINSMONO_REGULAR25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE9, 0x24, 0x07, 0xFC, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x0C, 0x30, 0x61, 0x83, 0x08, 0x10, 0xC0, 0x86, 0x3F,
  0xFC, 0x61, 0x83, 0x0C, 0x18, 0x40, 0x86, 0x0C, 0x31, 0xFF, 0xEF, 0xFF,
  0x18, 0x40, 0x86, 0x04, 0x30, 0x61, 0x83, 0x0C, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x03, 0xF8, 0xFF, 0x99, 0x3F, 0x23, 0xE4, 0x1C, 0x81, 0xD0,
  0x3E, 0x03, 0xF0, 0x1F, 0x81, 0x78, 0x27, 0x04, 0x78, 0x8F, 0x11, 0xF2,
  0x77, 0xFC, 0x7F, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x7C, 0x0E, 0xDC,
  0x13, 0x18, 0x66, 0x31, 0x8C, 0x62, 0x18, 0xCC, 0x1F, 0xB0, 0x1E, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x19, 0xE0, 0x37, 0xE0, 0xCC, 0x63, 0x18, 0xC6,
  0x31, 0x98, 0x63, 0x60, 0xFD, 0xC0, 0xF0, 0x04, 0x00, 0xFC, 0x0F, 0xF0,
  0xE1, 0x87, 0x0E, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x03, 0xE0, 0x1B,
  0x8F, 0xCE, 0x6E, 0x37, 0x70, 0xF3, 0x87, 0x9C, 0x1C, 0x61, 0xE3, 0xF9,
  0x8F, 0x8E, 0xFF, 0xFF, 0xB0, 0x02, 0x1C, 0x71, 0x86, 0x1C, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x83, 0x87,
  0x83, 0x83, 0x81, 0xC1, 0xC0, 0xC1, 0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0xE3, 0x8F, 0x38, 0x40, 0x07,
  0x00, 0x38, 0x01, 0xC1, 0x04, 0x1F, 0x27, 0xFD, 0x7C, 0x3F, 0x00, 0xE0,
  0x0D, 0x80, 0xEE, 0x0E, 0x38, 0x60, 0xC1, 0x04, 0x00, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x39, 0xCC, 0xE7, 0x33, 0x98, 0xFF, 0xFF, 0xC0, 0x73, 0xBE,
  0xE0, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0x04, 0x07,
  0xF1, 0xEF, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC4, 0x79, 0xCF,
  0x39, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x60, 0xCF, 0xF8, 0xFE,
  0x00, 0x1E, 0x03, 0xE0, 0x76, 0x0E, 0x60, 0x86, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x04, 0x07, 0xF1, 0xFF, 0x70, 0x6C, 0x0F, 0x80,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x00, 0xFC, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x0F, 0x81, 0xF0, 0x3F, 0x0E, 0x7F, 0xC7, 0xE0, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC7, 0x70, 0xEC, 0x1F, 0x83, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x7F, 0xCF, 0xF9,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1B, 0xE3, 0xFE, 0xF1, 0xDC, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xF0, 0x3B, 0x06, 0x7F, 0xC7, 0xF0, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0xFC, 0xFF, 0xDC, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0x7F, 0xC7, 0xF0, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x7C, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x04, 0x07, 0xF1, 0xEF, 0x30, 0x6E, 0x0F, 0xC1, 0xD8, 0x33, 0x8E, 0x3B,
  0x81, 0xC0, 0xEE, 0x38, 0xEE, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xEF,
  0xF8, 0xFE, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x70, 0x7C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x1D, 0xFF, 0x1F, 0xE0, 0x18, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x00, 0x77, 0xDC, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0xEF, 0xB8, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xCE,
  0x39, 0xC7, 0x18, 0x63, 0x00, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x30, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x06, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x18, 0x07, 0x03, 0xC1, 0xE0,
  0xF0, 0x78, 0x0C, 0x00, 0xFE, 0x7F, 0x80, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x3F, 0x1F, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x78, 0x1C,
  0x00, 0x02, 0x00, 0xFF, 0x0E, 0x3C, 0xE0, 0x66, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x7B, 0xC7, 0xFE, 0x30, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE3, 0x0F,
  0x18, 0x78, 0xE7, 0xC3, 0xFE, 0x04, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x0E, 0xE0, 0x63, 0x03, 0x18, 0x18, 0xC1, 0xC7, 0x0C, 0x18, 0x7F, 0xC3,
  0xFE, 0x38, 0x39, 0x80, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xC0, 0xFF, 0x9F,
  0xFB, 0x83, 0x70, 0x7E, 0x07, 0xC1, 0xF8, 0x37, 0x1E, 0xFF, 0x1C, 0x7B,
  0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xFF, 0xDF, 0xE0, 0x04,
  0x07, 0xF1, 0xFF, 0x30, 0x7E, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x1F, 0x07, 0x60, 0xCF, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x37, 0x0E,
  0xFF, 0x9F, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xFE, 0xFF, 0xDC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x30, 0x7E, 0x07,
  0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x1F, 0xE3, 0xFC, 0x07, 0x80,
  0xF0, 0x1F, 0x07, 0x60, 0xCF, 0xF8, 0xFE, 0x00, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0xFF, 0xFF, 0xC7,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x80, 0xF8, 0x1B, 0x07, 0x7F, 0xC3, 0xF0, 0xE0, 0x7E, 0x0E, 0xE0, 0xCE,
  0x1C, 0xE1, 0x8E, 0x38, 0xE3, 0x0E, 0x70, 0xFE, 0x0F, 0xF0, 0xE3, 0x0E,
  0x38, 0xE1, 0x8E, 0x1C, 0xE0, 0xCE, 0x0E, 0xE0, 0x6E, 0x07, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0xF4, 0x17,
  0xC7, 0xF8, 0xFD, 0x1F, 0xB6, 0xF6, 0xDE, 0x5B, 0xCE, 0x79, 0xCF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0xF0, 0x7E,
  0x0F, 0xC1, 0xEC, 0x3D, 0x87, 0xB0, 0xF3, 0x1E, 0x63, 0xCC, 0x78, 0xCF,
  0x19, 0xE3, 0x3C, 0x37, 0x86, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1C, 0x04,
  0x07, 0xF1, 0xFF, 0x30, 0x6E, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0x60, 0xCF, 0xF8,
  0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xFF, 0xEF, 0xFC, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x04, 0x07, 0xF1, 0xFF, 0x70, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0x07, 0x60, 0xCF, 0xF8, 0xFE, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE, 0x06, 0xE0, 0x6E, 0x06, 0xE0,
  0x6E, 0x0E, 0xFF, 0xCF, 0xF8, 0xE3, 0x0E, 0x38, 0xE3, 0x8E, 0x18, 0xE1,
  0xCE, 0x0C, 0xE0, 0xEE, 0x07, 0x04, 0x07, 0xF1, 0xFF, 0x30, 0x7E, 0x07,
  0xC0, 0x38, 0x03, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x0E, 0x00,
  0xF0, 0x1E, 0x03, 0xE0, 0xEF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC1,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x06,
  0x7F, 0xC7, 0xF0, 0xE0, 0x3B, 0x01, 0x98, 0x0C, 0xE0, 0x67, 0x07, 0x18,
  0x30, 0xC1, 0x87, 0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x30, 0x39, 0x80, 0xD8,
  0x06, 0xC0, 0x36, 0x01, 0xB0, 0x07, 0x00, 0x38, 0x00, 0xC7, 0x1E, 0x38,
  0xF1, 0x47, 0x8A, 0x3C, 0x51, 0xE2, 0x8F, 0x16, 0x6D, 0xB6, 0x6D, 0xB3,
  0x6D, 0x9A, 0x2C, 0xD1, 0x66, 0x8B, 0x34, 0x59, 0xA2, 0xCF, 0x1E, 0x38,
  0xE1, 0xC7, 0x00, 0xE0, 0x3B, 0x83, 0x8C, 0x18, 0x71, 0xC1, 0x8C, 0x0E,
  0xE0, 0x36, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1B, 0x01, 0x9C,
  0x0C, 0x60, 0xC1, 0x8E, 0x0E, 0x60, 0x37, 0x01, 0xC0, 0xE0, 0x3B, 0x01,
  0x9C, 0x1C, 0x60, 0xC3, 0x06, 0x0C, 0x60, 0x63, 0x01, 0xB0, 0x0D, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0xFF, 0x0E, 0x01, 0xC0, 0x6C, 0x0D, 0x83, 0x18, 0x63, 0x18, 0x33, 0x06,
  0xC0, 0x78, 0x0C, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0x1C, 0x60, 0x1F, 0x0F,
  0xF9, 0xC7, 0x70, 0x70, 0x0E, 0x01, 0xCF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7F, 0xF6, 0xFC, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0xF1, 0xFF, 0xBC, 0x77, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x3F, 0x06, 0xFF, 0xDD, 0xF0, 0x1F, 0x0F, 0xF9, 0xC7, 0x70,
  0x7C, 0x07, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x0F, 0x83, 0xB0, 0x77,
  0xFC, 0x7F, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x71, 0xEE, 0xFF, 0xDC,
  0x7F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3B,
  0x07, 0x7F, 0xE7, 0xDC, 0x1F, 0x07, 0xF1, 0x83, 0x70, 0x7C, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x03, 0x81, 0xB0, 0x77, 0xFC, 0x7F, 0x00,
  0x03, 0xF0, 0x7F, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0xEF, 0xFD, 0xC7, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x1D, 0x87, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38,
  0x07, 0x3F, 0xC7, 0xF0, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0xF1, 0xFF, 0xBC, 0x77, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1C, 0x0F, 0x00, 0xF0, 0x06, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0x81, 0xC0, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x37,
  0xFB, 0xF9, 0xE0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7E, 0x0E,
  0xE0, 0xCE, 0x1C, 0xE3, 0x8E, 0x30, 0xFE, 0x0F, 0xF0, 0xE3, 0x0E, 0x38,
  0xE1, 0xCE, 0x0C, 0xE0, 0xEE, 0x07, 0xFE, 0x07, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0xD9, 0xDF, 0xFF, 0x39, 0xE2, 0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xC4,
  0x78, 0x8F, 0x11, 0xE2, 0x3C, 0x47, 0x88, 0xC0, 0xEF, 0x1F, 0xFB, 0xC7,
  0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xC0, 0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x7E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xB0, 0x67, 0xFC, 0x7F, 0x00,
  0xEF, 0x9F, 0xFB, 0xC7, 0x70, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x6F, 0xFD, 0xDF, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x1E, 0xEF, 0xFD, 0xC7, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xB0, 0x77, 0xFE, 0x7D, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xCF, 0x3F, 0xEE, 0x1F, 0x03, 0xC0,
  0xF0, 0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00,
  0x1F, 0x8F, 0xF9, 0xC3, 0xB0, 0x06, 0x00, 0xE0, 0x1F, 0xC0, 0xFE, 0x00,
  0xE0, 0x0C, 0x01, 0xF0, 0x77, 0xFC, 0x7F, 0x00, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xB0, 0x67, 0xFC, 0x7E, 0x00, 0xE0, 0x3B, 0x01, 0x98, 0x0C,
  0xE0, 0xE3, 0x06, 0x18, 0x30, 0xE3, 0x83, 0x18, 0x18, 0xC0, 0xEE, 0x03,
  0x60, 0x1B, 0x00, 0xF8, 0x03, 0x80, 0xC7, 0x1E, 0x38, 0xF1, 0x47, 0x8A,
  0x34, 0x51, 0x32, 0x99, 0xB6, 0xCD, 0xB6, 0x69, 0xB3, 0x45, 0x8A, 0x28,
  0x51, 0x43, 0x8E, 0x1C, 0x70, 0x60, 0x33, 0x83, 0x8E, 0x38, 0x31, 0x81,
  0xDC, 0x06, 0xC0, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0xEE, 0x06, 0x30, 0x71,
  0xC7, 0x07, 0x70, 0x1C, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0x60, 0xC3, 0x06,
  0x1C, 0x70, 0x63, 0x03, 0x98, 0x0D, 0xC0, 0x6C, 0x03, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xFF,
  0xDF, 0xF8, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x7C, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x7E, 0x0F,
  0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x30, 0x03, 0xF0, 0x7E, 0x18, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x3E, 0x07, 0x00, 0x78, 0x7F,
  0x8F, 0x39, 0xE3, 0xFC, 0x1C,
};

const GFXglyph JetBrainsMono_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 18, 15, 6, -18 },
  { 8, 7, 7, 15, 4, -18 },
  { 15, 13, 18, 15, 1, -18 },
  { 45, 11, 26, 15, 2, -22 },
  { 81, 15, 18, 15, 0, -18 },
  { 115, 13, 19, 15, 1, -19 },
  { 146, 3, 7, 15, 6, -18 },
  { 149, 7, 24, 15, 5, -21 },
  { 170, 7, 24, 15, 3, -21 },
  { 191, 13, 13, 15, 1, -15 },
  { 213, 11, 12, 15, 2, -14 },
  { 230, 5, 8, 15, 4, -4 },
  { 235, 9, 2, 15, 3, -9 },
  { 238, 5, 4, 15, 5, -4 },
  { 241, 11, 24, 15, 2, -21 },
  { 274, 11, 19, 15, 2, -19 },
  { 301, 12, 18, 15, 2, -18 },
  { 328, 11, 19, 15, 2, -19 },
  { 355, 11, 18, 15, 2, -18 },
  { 380, 11, 18, 15, 2, -18 },
  { 405, 11, 18, 15, 2, -18 },
  { 430, 11, 18, 15, 2, -18 },
  { 455, 11, 18, 15, 2, -18 },
  { 480, 11, 19, 15, 2, -19 },
  { 507, 11, 19, 15, 2, -19 },
  { 534, 5, 14, 15, 5, -14 },
  { 543, 6, 18, 15, 4, -14 },
  { 557, 11, 13, 15, 2, -15 },
  { 575, 11, 8, 15, 2, -12 },
  { 586, 11, 13, 15, 2, -15 },
  { 604, 9, 18, 15, 3, -18 },
  { 625, 13, 24, 15, 1, -19 },
  { 664, 13, 18, 15, 1, -18 },
  { 694, 11, 18, 15, 2, -18 },
  { 719, 11, 19, 15, 2, -19 },
  { 746, 11, 18, 15, 2, -18 },
  { 771, 11, 18, 15, 2, -18 },
  { 796, 11, 18, 15, 2, -18 },
  { 821, 11, 19, 15, 2, -19 },
  { 848, 11, 18, 15, 2, -18 },
  { 873, 9, 18, 15, 3, -18 },
  { 894, 11, 18, 15, 1, -18 },
  { 919, 12, 18, 15, 2, -18 },
  { 946, 10, 18, 15, 3, -18 },
  { 969, 11, 18, 15, 2, -18 },
  { 994, 11, 18, 15, 2, -18 },
  { 1019, 11, 19, 15, 2, -19 },
  { 1046, 12, 18, 15, 2, -18 },
  { 1073, 11, 24, 15, 2, -19 },
  { 1106, 12, 18, 15, 2, -18 },
  { 1133, 11, 19, 15, 2, -19 },
  { 1160, 13, 18, 15, 1, -18 },
  { 1190, 11, 18, 15, 2, -18 },
  { 1215, 13, 18, 15, 1, -18 },
  { 1245, 13, 18, 15, 1, -18 },
  { 1275, 13, 18, 15, 1, -18 },
  { 1305, 13, 18, 15, 1, -18 },
  { 1335, 11, 18, 15, 2, -18 },
  { 1360, 6, 24, 15, 5, -21 },
  { 1378, 11, 24, 15, 2, -21 },
  { 1411, 6, 24, 15, 4, -21 },
  { 1429, 11, 10, 15, 2, -18 },
  { 1443, 13, 2, 15, 1, 1 },
  { 1447, 5, 4, 15, 5, -20 },
  { 1450, 11, 14, 15, 2, -14 },
  { 1470, 11, 18, 15, 2, -18 },
  { 1495, 11, 14, 15, 2, -14 },
  { 1515, 11, 18, 15, 2, -18 },
  { 1540, 11, 14, 15, 2, -14 },
  { 1560, 12, 18, 15, 1, -18 },
  { 1587, 11, 19, 15, 2, -14 },
  { 1614, 11, 18, 15, 2, -18 },
  { 1639, 12, 19, 15, 2, -19 },
  { 1668, 9, 24, 15, 2, -19 },
  { 1695, 12, 18, 15, 2, -18 },
  { 1722, 13, 18, 15, 1, -18 },
  { 1752, 11, 14, 15, 2, -14 },
  { 1772, 11, 14, 15, 2, -14 },
  { 1792, 11, 14, 15, 2, -14 },
  { 1812, 11, 19, 15, 2, -14 },
  { 1839, 11, 19, 15, 2, -14 },
  { 1866, 10, 14, 15, 3, -14 },
  { 1884, 11, 14, 15, 2, -14 },
  { 1904, 12, 18, 15, 1, -18 },
  { 1931, 11, 14, 15, 2, -14 },
  { 1951, 13, 14, 15, 1, -14 },
  { 1974, 13, 14, 15, 1, -14 },
  { 1997, 13, 14, 15, 1, -14 },
  { 2020, 13, 19, 15, 1, -14 },
  { 2051, 11, 14, 15, 2, -14 },
  { 2071, 11, 24, 15, 2, -21 },
  { 2104, 3, 24, 15, 6, -21 },
  { 2113, 11, 24, 15, 2, -21 },
  { 2146, 11, 5, 15, 2, -11 },
};

const GFXfont JetBrainsMono_Regular25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_REGULAR25PT7B_H_
