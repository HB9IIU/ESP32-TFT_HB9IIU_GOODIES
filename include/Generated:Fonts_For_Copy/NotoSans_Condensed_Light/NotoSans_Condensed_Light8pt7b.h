#ifndef _NOTOSANS_CONDENSED_LIGHT8PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light8pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0xC0, 0x56, 0xF6, 0xFA, 0x7B, 0x17, 0xC0, 0x55, 0xAA, 0xF3,
  0xAC, 0x6A, 0x4B, 0xBF, 0xC0, 0x5A, 0xA4, 0x95, 0x58, 0xCD, 0x80, 0x4B,
  0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x76, 0xDA, 0xC0, 0xFC, 0xE4,
  0x95, 0xC0, 0xE4, 0xB3, 0xC0, 0x22, 0x6A, 0xF2, 0x73, 0x13, 0xC0, 0x73,
  0x5A, 0xC0, 0xE4, 0x94, 0x80, 0x75, 0xBB, 0xC0, 0x76, 0xB2, 0xC0, 0x90,
  0x98, 0x2B, 0x10, 0xFC, 0x8C, 0xE0, 0xD5, 0x50, 0x32, 0x6F, 0xBB, 0xC1,
  0xC0, 0x46, 0x6E, 0x99, 0xD6, 0xFB, 0x80, 0x78, 0x88, 0x87, 0xD6, 0xDB,
  0x80, 0xEB, 0xB0, 0xEB, 0xA0, 0x78, 0x89, 0x97, 0xB6, 0xFB, 0x40, 0xD5,
  0x70, 0xFE, 0xBA, 0x4D, 0x40, 0xAA, 0xB0, 0x99, 0x9B, 0xFD, 0xB6, 0xFB,
  0x40, 0x69, 0x99, 0x97, 0xFF, 0xA0, 0x69, 0x99, 0x97, 0x10, 0xD6, 0xED,
  0x40, 0x73, 0x13, 0xC0, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0xC0, 0x99, 0xA6,
  0x44, 0xA6, 0x9B, 0x56, 0x49, 0x20, 0xB5, 0x2B, 0x40, 0xB5, 0x24, 0x80,
  0xE5, 0x29, 0xC0, 0xFE, 0x91, 0x24, 0x40, 0xD5, 0x5C, 0x46, 0xB0, 0xE0,
  0xC0, 0x6E, 0xF0, 0x9A, 0xDB, 0x80, 0xF2, 0x30, 0x2E, 0xDB, 0xC0, 0xFE,
  0x30, 0x7A, 0xA0, 0xF6, 0xF3, 0xC0, 0xAF, 0xF0, 0xBC, 0xBF, 0xAE, 0xB0,
  0xFC, 0xFD, 0xDD, 0xFF, 0xF6, 0xB0, 0xF6, 0xE9, 0x00, 0xF6, 0xB2, 0x40,
  0xF0, 0xF8, 0xF0, 0xEA, 0xC0, 0xFF, 0xB5, 0x20, 0xAF, 0x74, 0xA0, 0xA9,
  0x50, 0xB5, 0x25, 0x00, 0xD7, 0x29, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0,
  0xE0,
};

const GFXglyph NotoSans_Condensed_Light8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 6, 4, 0, -6 },
  { 9, 5, 6, 5, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 2, 0, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 3, 3, 3, 0, -6 },
  { 23, 3, 4, 4, 0, -5 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 3, 6, 4, 0, -6 },
  { 34, 1, 6, 4, 1, -6 },
  { 35, 3, 6, 4, 0, -6 },
  { 38, 3, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 3, 6, 4, 0, -6 },
  { 47, 3, 6, 4, 0, -6 },
  { 50, 3, 6, 4, 0, -6 },
  { 53, 3, 6, 4, 0, -6 },
  { 56, 3, 6, 4, 0, -6 },
  { 59, 1, 4, 2, 0, -4 },
  { 60, 1, 5, 2, 0, -4 },
  { 61, 3, 4, 4, 0, -5 },
  { 63, 3, 2, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -5 },
  { 66, 2, 6, 3, 0, -6 },
  { 68, 5, 7, 6, 0, -6 },
  { 73, 4, 6, 4, 0, -6 },
  { 76, 3, 6, 4, 1, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 3, 6, 4, 1, -6 },
  { 85, 2, 6, 4, 1, -6 },
  { 87, 2, 6, 3, 1, -6 },
  { 89, 4, 6, 5, 0, -6 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 2, 6, 2, 0, -6 },
  { 97, 1, 7, 2, 0, -6 },
  { 98, 3, 6, 4, 1, -6 },
  { 101, 2, 6, 3, 1, -6 },
  { 103, 4, 6, 6, 1, -6 },
  { 106, 3, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 0, -6 },
  { 112, 2, 6, 4, 1, -6 },
  { 114, 4, 7, 5, 0, -6 },
  { 118, 3, 6, 4, 1, -6 },
  { 121, 3, 6, 4, 0, -6 },
  { 124, 3, 6, 3, 0, -6 },
  { 127, 3, 6, 5, 1, -6 },
  { 130, 4, 6, 4, 0, -6 },
  { 133, 6, 6, 6, 0, -6 },
  { 138, 3, 6, 3, 0, -6 },
  { 141, 3, 6, 3, 0, -6 },
  { 144, 3, 6, 3, 0, -6 },
  { 147, 1, 7, 3, 1, -6 },
  { 148, 3, 6, 3, 0, -6 },
  { 151, 2, 7, 3, 0, -6 },
  { 153, 4, 3, 4, 0, -6 },
  { 155, 3, 1, 3, 0, 0 },
  { 156, 2, 1, 2, 0, -6 },
  { 157, 3, 4, 3, 0, -4 },
  { 159, 3, 6, 4, 1, -6 },
  { 162, 3, 4, 3, 0, -4 },
  { 164, 3, 6, 4, 0, -6 },
  { 167, 3, 4, 4, 0, -4 },
  { 169, 2, 6, 2, 0, -6 },
  { 171, 3, 6, 4, 0, -4 },
  { 174, 2, 6, 4, 1, -6 },
  { 176, 1, 6, 2, 0, -6 },
  { 177, 1, 8, 2, 0, -6 },
  { 178, 2, 6, 3, 1, -6 },
  { 180, 1, 6, 2, 0, -6 },
  { 181, 4, 4, 6, 1, -4 },
  { 183, 2, 4, 4, 1, -4 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 3, 6, 4, 1, -4 },
  { 189, 3, 6, 4, 0, -4 },
  { 192, 1, 4, 3, 1, -4 },
  { 193, 3, 4, 3, 0, -4 },
  { 195, 2, 5, 2, 0, -5 },
  { 197, 2, 4, 4, 1, -4 },
  { 198, 3, 4, 3, 0, -4 },
  { 200, 5, 4, 5, 0, -4 },
  { 203, 3, 4, 3, 0, -4 },
  { 205, 3, 6, 3, 0, -4 },
  { 208, 2, 4, 3, 0, -4 },
  { 209, 3, 7, 3, 0, -6 },
  { 212, 1, 8, 4, 1, -6 },
  { 213, 3, 7, 3, 0, -6 },
  { 216, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_Light8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_LIGHT8PT7B_H_
