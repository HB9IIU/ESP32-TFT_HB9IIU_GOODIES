#ifndef _NOTOSANS_CONDENSED_LIGHT17PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x8B, 0x99, 0x99, 0x12, 0x12, 0x12, 0x7F, 0x24, 0x24,
  0x24, 0xFF, 0x24, 0x24, 0x24, 0x48, 0x21, 0xEA, 0x68, 0xA2, 0x86, 0x0E,
  0x24, 0x92, 0x7E, 0x20, 0x80, 0xE3, 0x24, 0x89, 0x22, 0x50, 0x95, 0x26,
  0xAE, 0xA4, 0x29, 0x12, 0x44, 0x92, 0x24, 0x8E, 0x70, 0x48, 0x48, 0x48,
  0x50, 0x20, 0x52, 0x92, 0x8A, 0x84, 0x8E, 0x7B, 0xF0, 0x29, 0x49, 0x24,
  0x92, 0x44, 0x88, 0x89, 0x22, 0x49, 0x24, 0xA5, 0x20, 0x21, 0x3E, 0x45,
  0x64, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0xEA, 0xE0, 0xB0, 0x0C, 0x20,
  0x84, 0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x7A, 0x28, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x14, 0x9E, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0xF8, 0x20,
  0x41, 0x08, 0x21, 0x04, 0x21, 0x08, 0x3F, 0xF8, 0x20, 0x41, 0x09, 0xC0,
  0x81, 0x04, 0x10, 0xFE, 0x04, 0x0C, 0x14, 0x14, 0x24, 0x24, 0x44, 0x44,
  0xFF, 0x04, 0x04, 0x04, 0xFA, 0x08, 0x20, 0x83, 0xE0, 0x41, 0x04, 0x10,
  0xBE, 0x39, 0x08, 0x20, 0xB3, 0x28, 0x61, 0x86, 0x14, 0x5E, 0xFC, 0x10,
  0x82, 0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x7A, 0x18, 0x61, 0x48, 0xC4,
  0xA1, 0x86, 0x18, 0x5E, 0x7A, 0x28, 0x61, 0x86, 0x15, 0xC9, 0x04, 0x20,
  0xBC, 0xE0, 0x02, 0xC0, 0xE0, 0x03, 0xA8, 0x04, 0x23, 0x30, 0xC0, 0xC0,
  0xC1, 0xFC, 0x00, 0x3F, 0x83, 0x03, 0x03, 0x0C, 0xCC, 0x20, 0xF8, 0x42,
  0x10, 0x88, 0x84, 0x20, 0x08, 0x40, 0x1F, 0x08, 0x24, 0x0A, 0x39, 0x92,
  0x64, 0x99, 0x26, 0x49, 0x92, 0x67, 0x68, 0x01, 0x00, 0x22, 0x07, 0x00,
  0x18, 0x18, 0x18, 0x24, 0x24, 0x24, 0x24, 0x7E, 0x42, 0x42, 0x81, 0x81,
  0xFD, 0x0A, 0x0C, 0x18, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x17, 0xC0, 0x3E,
  0x81, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x01, 0xF0, 0xF8, 0x86,
  0x82, 0x82, 0x82, 0x81, 0x81, 0x82, 0x82, 0x82, 0x84, 0xF8, 0xFE, 0x08,
  0x20, 0x83, 0xE8, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x0F,
  0xA0, 0x82, 0x08, 0x20, 0x3F, 0x40, 0x40, 0x80, 0x80, 0x80, 0x87, 0x81,
  0x81, 0x41, 0x41, 0x3F, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0xE9, 0x24, 0x92, 0x49, 0x70, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x78, 0x87, 0x0A, 0x24, 0x89, 0x14, 0x34, 0x48, 0x89, 0x1A, 0x14,
  0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xC0, 0x70,
  0x3A, 0x0E, 0x83, 0xA1, 0x64, 0x59, 0x16, 0x49, 0x8A, 0x62, 0x98, 0xC6,
  0x11, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83,
  0x83, 0x3E, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42,
  0x3C, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x08, 0x20, 0x3E, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x04, 0x06,
  0x02, 0xF9, 0x0A, 0x14, 0x28, 0x51, 0xBC, 0x44, 0x89, 0x0A, 0x14, 0x10,
  0x7E, 0x08, 0x20, 0xC1, 0x81, 0x83, 0x04, 0x10, 0xBE, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x81, 0x82, 0x42, 0x42, 0x44,
  0x24, 0x24, 0x24, 0x28, 0x18, 0x18, 0x18, 0x82, 0x1A, 0x10, 0x91, 0x84,
  0x8A, 0x24, 0x51, 0x22, 0x90, 0xA4, 0x85, 0x14, 0x28, 0xA1, 0x46, 0x04,
  0x30, 0x20, 0x80, 0xC2, 0x88, 0x91, 0x41, 0x82, 0x06, 0x14, 0x28, 0x89,
  0x14, 0x10, 0x82, 0x89, 0x12, 0x42, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x80, 0xF8, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08, 0x3F, 0xF8, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x10, 0x20, 0x81, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x78, 0x18, 0x18, 0x24,
  0x24, 0x42, 0xC3, 0xFE, 0x88, 0x80, 0xF8, 0x42, 0x17, 0xC6, 0x31, 0xF8,
  0x81, 0x02, 0x04, 0x0B, 0x98, 0xA1, 0x41, 0x83, 0x0A, 0x16, 0x2B, 0x80,
  0x7E, 0x21, 0x08, 0x42, 0x10, 0x78, 0x04, 0x10, 0x41, 0x7E, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x7C, 0x7A, 0x28, 0x61, 0xFE, 0x08, 0x20, 0x78, 0x39,
  0x10, 0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x7C, 0x10, 0x41, 0xF8, 0x82, 0x08, 0x20, 0xBB, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x84, 0x9F, 0xF0, 0x41, 0x55, 0x55, 0x57, 0x82, 0x08,
  0x21, 0x8A, 0x49, 0x28, 0xE2, 0x49, 0x22, 0x8C, 0xFF, 0xF8, 0xBB, 0xB3,
  0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x40, 0xBB, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x78,
  0xB9, 0x8A, 0x14, 0x18, 0x30, 0xA1, 0x62, 0xB9, 0x02, 0x04, 0x08, 0x00,
  0x7E, 0x18, 0x61, 0x86, 0x18, 0x63, 0x74, 0x10, 0x41, 0x04, 0xBC, 0x88,
  0x88, 0x88, 0x80, 0xFC, 0x21, 0x86, 0x08, 0x21, 0xF0, 0x44, 0xF4, 0x44,
  0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x74, 0x86, 0x14,
  0x52, 0x48, 0xA3, 0x0C, 0x30, 0x84, 0x53, 0x14, 0xC5, 0x2A, 0x4A, 0x94,
  0xA3, 0x28, 0xC4, 0x21, 0x00, 0xC5, 0x22, 0x8C, 0x10, 0xA2, 0x91, 0xC4,
  0x85, 0x14, 0x52, 0x48, 0xA2, 0x8C, 0x10, 0x42, 0x08, 0xC0, 0xF1, 0x22,
  0x44, 0x88, 0xF0, 0x32, 0x44, 0x44, 0x4C, 0x44, 0x44, 0x42, 0x10, 0xFF,
  0xFF, 0x80, 0xC4, 0x22, 0x22, 0x23, 0x22, 0x22, 0x24, 0x80, 0xE6, 0x70,
};

const GFXglyph NotoSans_Condensed_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 6, 1, -12 },
  { 6, 8, 12, 9, 0, -12 },
  { 18, 6, 14, 8, 1, -13 },
  { 29, 10, 12, 11, 1, -12 },
  { 44, 8, 12, 9, 1, -12 },
  { 56, 1, 4, 3, 1, -12 },
  { 57, 3, 15, 5, 1, -12 },
  { 63, 3, 15, 5, 1, -12 },
  { 69, 5, 6, 7, 1, -13 },
  { 73, 6, 8, 8, 1, -10 },
  { 79, 2, 4, 4, 1, -2 },
  { 80, 3, 1, 5, 1, -5 },
  { 81, 2, 2, 4, 1, -2 },
  { 82, 6, 12, 6, 0, -12 },
  { 91, 6, 12, 8, 1, -12 },
  { 100, 4, 12, 8, 1, -12 },
  { 106, 6, 12, 8, 1, -12 },
  { 115, 6, 12, 8, 1, -12 },
  { 124, 8, 12, 8, 0, -12 },
  { 136, 6, 12, 8, 1, -12 },
  { 145, 6, 12, 8, 1, -12 },
  { 154, 6, 12, 8, 1, -12 },
  { 163, 6, 12, 8, 1, -12 },
  { 172, 6, 12, 8, 1, -12 },
  { 181, 2, 9, 4, 1, -9 },
  { 184, 2, 11, 4, 1, -9 },
  { 187, 6, 8, 8, 1, -10 },
  { 193, 6, 4, 8, 1, -8 },
  { 196, 6, 8, 8, 1, -10 },
  { 202, 5, 12, 6, 0, -12 },
  { 210, 10, 14, 12, 1, -12 },
  { 228, 8, 12, 8, 0, -12 },
  { 240, 7, 12, 9, 1, -12 },
  { 251, 7, 12, 8, 1, -12 },
  { 262, 8, 12, 10, 1, -12 },
  { 274, 6, 12, 7, 1, -12 },
  { 283, 6, 12, 7, 1, -12 },
  { 292, 8, 12, 10, 1, -12 },
  { 304, 7, 12, 10, 1, -12 },
  { 315, 3, 12, 5, 1, -12 },
  { 320, 3, 15, 4, -1, -12 },
  { 326, 7, 12, 8, 1, -12 },
  { 337, 6, 12, 7, 1, -12 },
  { 346, 10, 12, 13, 1, -12 },
  { 361, 8, 12, 10, 1, -12 },
  { 373, 8, 12, 10, 1, -12 },
  { 385, 6, 12, 8, 1, -12 },
  { 394, 8, 15, 10, 1, -12 },
  { 409, 7, 12, 8, 1, -12 },
  { 420, 6, 12, 8, 1, -12 },
  { 429, 7, 12, 7, 0, -12 },
  { 440, 7, 12, 10, 1, -12 },
  { 451, 8, 12, 8, 0, -12 },
  { 463, 13, 12, 13, 0, -12 },
  { 483, 7, 12, 7, 0, -12 },
  { 494, 7, 12, 7, 0, -12 },
  { 505, 6, 12, 7, 1, -12 },
  { 514, 4, 15, 5, 1, -12 },
  { 522, 6, 12, 6, 0, -12 },
  { 531, 3, 15, 5, 1, -12 },
  { 537, 8, 6, 8, 0, -12 },
  { 543, 7, 1, 7, 0, 1 },
  { 544, 3, 3, 4, 1, -13 },
  { 546, 5, 9, 7, 1, -9 },
  { 552, 7, 13, 8, 1, -13 },
  { 564, 5, 9, 6, 1, -9 },
  { 570, 6, 13, 8, 1, -13 },
  { 580, 6, 9, 8, 1, -9 },
  { 587, 5, 13, 4, 0, -13 },
  { 596, 6, 13, 8, 1, -9 },
  { 606, 6, 13, 8, 1, -13 },
  { 616, 1, 12, 4, 1, -12 },
  { 618, 2, 16, 4, 0, -12 },
  { 622, 6, 13, 7, 1, -13 },
  { 632, 1, 13, 3, 1, -13 },
  { 634, 10, 9, 12, 1, -9 },
  { 646, 6, 9, 8, 1, -9 },
  { 653, 6, 9, 8, 1, -9 },
  { 660, 7, 13, 8, 1, -9 },
  { 672, 6, 13, 8, 1, -9 },
  { 682, 4, 9, 5, 1, -9 },
  { 687, 5, 9, 6, 1, -9 },
  { 693, 4, 11, 5, 0, -11 },
  { 699, 6, 9, 8, 1, -9 },
  { 706, 6, 9, 6, 0, -9 },
  { 713, 10, 9, 10, 0, -9 },
  { 725, 6, 9, 7, 0, -9 },
  { 732, 6, 13, 6, 0, -9 },
  { 742, 4, 9, 6, 1, -9 },
  { 747, 4, 15, 6, 1, -12 },
  { 755, 1, 17, 7, 3, -13 },
  { 758, 4, 15, 6, 1, -12 },
  { 766, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Light17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_LIGHT17PT7B_H_
