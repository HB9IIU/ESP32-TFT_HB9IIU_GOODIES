#ifndef _NOTOSANS_CONDENSED_LIGHT66PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x00,
  0x00, 0x00, 0x03, 0xBF, 0xFF, 0xFF, 0xEC, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0,
  0x77, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0,
  0x18, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3E, 0x38, 0x3C, 0x7C, 0x38, 0x04,
  0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x3F, 0x38, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x38, 0xF8,
  0x00, 0x38, 0x7C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0x38, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E,
  0x80, 0x38, 0x3C, 0xF0, 0x38, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x38, 0x00, 0x7F, 0xE0,
  0x00, 0x70, 0x01, 0xE1, 0xC0, 0x01, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x80,
  0x0E, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x03, 0xC0, 0xE0,
  0x00, 0x70, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x0F, 0x07, 0x00, 0x01, 0xC0,
  0x1C, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x38, 0x00, 0x07, 0x00, 0x70, 0x70,
  0x7C, 0x0E, 0x00, 0xE1, 0xC1, 0xFE, 0x0E, 0x01, 0xC3, 0x87, 0xFE, 0x1C,
  0x03, 0x8F, 0x1E, 0x1C, 0x38, 0x0F, 0x1C, 0x38, 0x1C, 0x78, 0x1C, 0x38,
  0xF0, 0x38, 0x70, 0x78, 0xE1, 0xC0, 0x38, 0xF1, 0xE1, 0xC3, 0x80, 0x70,
  0xFF, 0xC7, 0x87, 0x00, 0xE0, 0xFE, 0x0E, 0x1E, 0x01, 0xC0, 0x78, 0x1C,
  0x38, 0x03, 0x80, 0x00, 0x70, 0x70, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x3C, 0x00, 0x0E,
  0x07, 0x00, 0x78, 0x00, 0x38, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x1C, 0x01,
  0xE0, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x07, 0x00, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xC0,
  0x38, 0x00, 0xF0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x80, 0x07, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x1C, 0x00, 0x0F,
  0xFC, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xE0, 0x0F,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xF0, 0x78, 0x03, 0xC3,
  0xC0, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x0F, 0x1C, 0x00, 0xF0, 0x1C, 0x78,
  0x00, 0xF0, 0x38, 0xF0, 0x01, 0xF0, 0xF1, 0xC0, 0x01, 0xE1, 0xE3, 0x80,
  0x01, 0xE7, 0x87, 0x00, 0x01, 0xEF, 0x0E, 0x00, 0x03, 0xFC, 0x1C, 0x00,
  0x03, 0xF8, 0x38, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0xF7, 0x83, 0xE0, 0x03,
  0xCF, 0x83, 0xE0, 0x1F, 0x0F, 0x03, 0xFF, 0xFC, 0x0F, 0x03, 0xFF, 0xF0,
  0x1F, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x0C, 0x06, 0xFC, 0x30,
  0xFF, 0xFE, 0xDF, 0xF3, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x00, 0x1C,
  0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xC0, 0x10, 0x02,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8E,
  0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xFF, 0xFF, 0x7D, 0xE1, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C,
  0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x7F,
  0x03, 0xFC, 0x3E, 0xF1, 0xF3, 0xCF, 0x8F, 0x7C, 0x3F, 0xE0, 0xF7, 0x03,
  0xC8, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0xFC, 0x01, 0xF0, 0x70, 0x00, 0xF8, 0x20, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0xFC, 0x01, 0xF8, 0xF0, 0x00, 0x78, 0x40, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0xF8, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x3C, 0x01, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x80, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0C, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF2, 0x00, 0x07, 0xC7, 0x00, 0x3F, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x7F, 0xC0, 0x70, 0xFF,
  0xE0, 0x73, 0xFF, 0xF8, 0x73, 0xC0, 0xF8, 0xF7, 0x00, 0x3C, 0xFE, 0x00,
  0x3E, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x80,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFC, 0xFF, 0x01, 0xF0,
  0x0F, 0x81, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xC7,
  0x80, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3E,
  0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xF3, 0xF0, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1D,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07,
  0x87, 0x80, 0x07, 0xC3, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3E,
  0x00, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0x3C, 0x00, 0x7F, 0x3E,
  0x00, 0xEF, 0x1F, 0x03, 0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x0E, 0x01,
  0xFE, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x79,
  0xFF, 0xFF, 0x7D, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xFF, 0xFD,
  0xF7, 0x8C, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0x00, 0x7C, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x3F, 0xE0, 0x0E, 0x3C,
  0x00, 0xFF, 0xF0, 0x0E, 0x38, 0x01, 0xFF, 0xF0, 0x0E, 0x38, 0x03, 0xE0,
  0x70, 0x0F, 0x38, 0x03, 0x80, 0x70, 0x07, 0x78, 0x07, 0x80, 0x70, 0x07,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x70, 0x0F, 0x00, 0x70, 0x07, 0x70, 0x0E,
  0x00, 0x70, 0x07, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x70, 0x0E, 0x00, 0x70,
  0x07, 0x70, 0x1E, 0x00, 0x70, 0x07, 0xF0, 0x1E, 0x00, 0x70, 0x07, 0xF0,
  0x1E, 0x00, 0x70, 0x07, 0xF0, 0x1C, 0x00, 0x70, 0x07, 0xF0, 0x1C, 0x00,
  0xF0, 0x07, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0xF0, 0x07,
  0x70, 0x1E, 0x00, 0xF0, 0x0E, 0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x70, 0x0E,
  0x01, 0xB0, 0x0E, 0x70, 0x0F, 0x01, 0xB0, 0x1C, 0x70, 0x07, 0x03, 0xB8,
  0x3C, 0x70, 0x07, 0xC7, 0x1C, 0x78, 0x78, 0x03, 0xFF, 0x1F, 0xF8, 0x38,
  0x01, 0xFC, 0x0F, 0xE0, 0x38, 0x00, 0x70, 0x01, 0x80, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x83, 0xC0, 0x07, 0xF0, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x3C,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x03,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0xF0,
  0x00, 0xFC, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xE3, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xC1, 0xF8, 0x00, 0x20, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0x03, 0xF8, 0x01, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x7F, 0xC0, 0xF0, 0x00, 0x7E, 0x0F,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x07, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0xFC,
  0x0F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x3F, 0x00,
  0x00, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF, 0xF0, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x03, 0xD8, 0x7E, 0xFF, 0xE7, 0xFE, 0x1F, 0xC0, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0x7F,
  0x00, 0x03, 0xDD, 0xE0, 0x00, 0xFF, 0x78, 0x00, 0x3F, 0x8F, 0x00, 0x0F,
  0xC3, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x77, 0xFB, 0x80, 0x00, 0x00, 0xEF, 0xF7, 0x80, 0x00,
  0x03, 0xDF, 0xEF, 0x00, 0x00, 0x07, 0x3F, 0xCE, 0x00, 0x00, 0x0E, 0x7F,
  0x9E, 0x00, 0x00, 0x3C, 0xFF, 0x3C, 0x00, 0x00, 0x71, 0xFE, 0x38, 0x00,
  0x00, 0xE3, 0xFC, 0x78, 0x00, 0x03, 0xC7, 0xF8, 0xF0, 0x00, 0x07, 0x0F,
  0xF0, 0xE0, 0x00, 0x0E, 0x1F, 0xE1, 0xE0, 0x00, 0x3C, 0x3F, 0xC3, 0xC0,
  0x00, 0x70, 0x7F, 0x83, 0x80, 0x00, 0xE0, 0xFF, 0x07, 0x80, 0x03, 0xC1,
  0xFE, 0x0F, 0x00, 0x07, 0x03, 0xFC, 0x0E, 0x00, 0x0E, 0x07, 0xF8, 0x1E,
  0x00, 0x3C, 0x0F, 0xF0, 0x3C, 0x00, 0x70, 0x1F, 0xE0, 0x38, 0x00, 0xE0,
  0x3F, 0xC0, 0x70, 0x03, 0xC0, 0x7F, 0x80, 0xF0, 0x07, 0x00, 0xFF, 0x00,
  0xE0, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3C, 0x03, 0xFC, 0x03, 0xC0, 0x78,
  0x07, 0xF8, 0x03, 0x80, 0xE0, 0x0F, 0xF0, 0x07, 0x03, 0xC0, 0x1F, 0xE0,
  0x0F, 0x07, 0x80, 0x3F, 0xC0, 0x0E, 0x0E, 0x00, 0x7F, 0x80, 0x1C, 0x3C,
  0x00, 0xFF, 0x00, 0x3C, 0x78, 0x01, 0xFE, 0x00, 0x38, 0xE0, 0x03, 0xFC,
  0x00, 0x73, 0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xEE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0xF0, 0x00,
  0x0F, 0xF7, 0x80, 0x00, 0x7F, 0x9E, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x1F,
  0xE3, 0xC0, 0x00, 0xFF, 0x1E, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x3F, 0xC3,
  0xC0, 0x01, 0xFE, 0x0F, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x7F, 0x81, 0xE0,
  0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xE0, 0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x07,
  0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x3C, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0,
  0x07, 0x80, 0x7F, 0x80, 0x1E, 0x03, 0xFC, 0x00, 0xF0, 0x1F, 0xE0, 0x03,
  0xC0, 0xFF, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x78, 0x3F, 0xC0, 0x03, 0xC1,
  0xFE, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x78, 0x7F, 0x80, 0x01, 0xE3, 0xFC,
  0x00, 0x0F, 0x1F, 0xE0, 0x00, 0x3C, 0xFF, 0x00, 0x01, 0xE7, 0xF8, 0x00,
  0x07, 0xBF, 0xC0, 0x00, 0x3D, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0x80, 0x7F, 0x8F, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0x78, 0x01, 0xF8,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x7C, 0x3C,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xC0, 0x3F, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xF8, 0x03, 0xC7, 0xC0, 0x00, 0x9F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF4, 0x00, 0x07, 0xCF, 0x00, 0x3F, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x78, 0x38, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x1C,
  0x78, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x38,
  0x38, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x38,
  0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x1C, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x70,
  0x1C, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0xF0,
  0x0E, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xE0,
  0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xE0,
  0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x80, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x01, 0xE3, 0xC0,
  0x07, 0x87, 0x00, 0x01, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80,
  0x03, 0x8F, 0x00, 0x00, 0xE3, 0x80, 0x03, 0x8F, 0x00, 0x00, 0xF3, 0x80,
  0x03, 0xCE, 0x00, 0x00, 0xF7, 0x80, 0x01, 0xDE, 0x00, 0x00, 0xF7, 0x80,
  0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0x80, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0E,
  0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x0F, 0xC1, 0xC0,
  0x1F, 0x08, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xFC, 0x1E, 0x7E, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x37,
  0x78, 0x07, 0x39, 0xF8, 0xF9, 0xCF, 0xFF, 0x8E, 0x1F, 0xF0, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0xFF, 0xF0, 0xE7, 0x00, 0xF8, 0xEE,
  0x00, 0x7C, 0xEC, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x3C, 0xEC, 0x00, 0x3C, 0xEE, 0x00, 0x78, 0xE7, 0x00, 0xF8, 0xE7,
  0xFF, 0xF0, 0xE3, 0xFF, 0xE0, 0xE0, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xBE, 0x0F, 0x80, 0x21,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x30, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1E, 0x03, 0xFF, 0x0F, 0x07, 0xFF,
  0xC7, 0x87, 0xFB, 0xF3, 0xC3, 0xE0, 0x3D, 0xE3, 0xC0, 0x06, 0xF3, 0xE0,
  0x03, 0xF9, 0xE0, 0x00, 0xFC, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00,
  0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xE7, 0x80,
  0x03, 0xF3, 0xC0, 0x03, 0xF8, 0xF0, 0x01, 0xBC, 0x7C, 0x03, 0xDE, 0x1F,
  0xFF, 0xCF, 0x07, 0xFF, 0xC7, 0x80, 0xFF, 0x81, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x3F, 0x80,
  0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x02, 0x0F, 0x80, 0x1C, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x80, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x87, 0x07, 0xFF,
  0xC7, 0x0F, 0xF7, 0xE7, 0x1F, 0x80, 0xF7, 0x1E, 0x00, 0x37, 0x3E, 0x00,
  0x1F, 0x3C, 0x00, 0x1F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00,
  0x3F, 0x1E, 0x00, 0x77, 0x1F, 0x00, 0xE7, 0x0F, 0xFF, 0xE7, 0x07, 0xFF,
  0xC7, 0x01, 0xFF, 0x07, 0x00, 0x7C, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x20, 0x00,
  0x3C, 0x38, 0x00, 0x7C, 0x3F, 0x87, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xE0, 0x38, 0x3F, 0xF0,
  0xE3, 0xFF, 0xE3, 0x9F, 0xFF, 0xCE, 0x70, 0x0F, 0xBB, 0x80, 0x1E, 0xEC,
  0x00, 0x7B, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x7B, 0xFF,
  0xF7, 0x98, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x9F, 0x3F, 0xCF, 0xE3, 0xE0,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x1E, 0xE0, 0x01, 0xE7, 0x00, 0x1E, 0x38,
  0x00, 0xF1, 0xC0, 0x0F, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x83, 0x80, 0x78,
  0x1C, 0x07, 0x80, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x38, 0x3C, 0x01, 0xC3,
  0xC0, 0x0E, 0x1E, 0x00, 0x71, 0xF0, 0x03, 0x9F, 0x80, 0x1C, 0xFE, 0x00,
  0xEE, 0xF0, 0x07, 0xE3, 0xC0, 0x3F, 0x1E, 0x01, 0xF0, 0x78, 0x0F, 0x03,
  0xC0, 0x70, 0x0F, 0x03, 0x80, 0x78, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x00,
  0xF3, 0x80, 0x07, 0x9C, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0x87, 0xFE, 0x03, 0xFF, 0x0E, 0x3F,
  0xFC, 0x1F, 0xFE, 0x39, 0xFB, 0xF8, 0xF9, 0xFC, 0xEE, 0x01, 0xE7, 0x00,
  0xF3, 0xB0, 0x07, 0xD8, 0x01, 0xEF, 0xC0, 0x0F, 0xE0, 0x07, 0xBE, 0x00,
  0x3F, 0x00, 0x0E, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0x80, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x3F,
  0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x78,
  0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xF8,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3E, 0x03, 0x83, 0xFF, 0x0E, 0x3F, 0xFE,
  0x39, 0xF9, 0xFC, 0xE7, 0x00, 0xFB, 0xB8, 0x01, 0xEE, 0xC0, 0x07, 0xBE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x0F,
  0x80, 0x7C, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0xE0, 0xFF, 0xC0, 0xE1, 0xFF, 0xE0,
  0xE3, 0xF7, 0xF0, 0xE7, 0x00, 0xF8, 0xEE, 0x00, 0x7C, 0xEC, 0x00, 0x3C,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xEC, 0x00, 0x3C,
  0xEE, 0x00, 0x78, 0xE7, 0x00, 0xF8, 0xE3, 0xFF, 0xF0, 0xE1, 0xFF, 0xE0,
  0xF0, 0xFF, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x87, 0x07, 0xFF, 0xC7,
  0x0F, 0xF7, 0xE7, 0x0F, 0x80, 0xF7, 0x1E, 0x00, 0x37, 0x3E, 0x00, 0x3F,
  0x3C, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x3F,
  0x1E, 0x00, 0x77, 0x1F, 0x80, 0xE7, 0x0F, 0xFF, 0xE7, 0x07, 0xFF, 0xC7,
  0x01, 0xFF, 0x07, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x3D, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x78,
  0x1D, 0xC0, 0x3B, 0x80, 0x76, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xC7, 0xE7, 0x80, 0x0D, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF4, 0x00, 0x1E, 0xE0, 0x07, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xF8,
  0x01, 0x80, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0x77, 0x80, 0x1D, 0xDF, 0x00, 0xE7, 0x3F, 0xFF, 0x1C, 0x7F, 0xF8, 0x70,
  0xFF, 0xC1, 0xC0, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x38, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x01,
  0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3B,
  0xC0, 0x01, 0xF0, 0x00, 0xF3, 0x80, 0x03, 0xE0, 0x01, 0xE7, 0x00, 0x0F,
  0xC0, 0x03, 0xCF, 0x00, 0x1D, 0xC0, 0x07, 0x1E, 0x00, 0x3B, 0x80, 0x0E,
  0x1C, 0x00, 0x77, 0x00, 0x3C, 0x38, 0x01, 0xCE, 0x00, 0x78, 0x78, 0x03,
  0x9E, 0x00, 0xE0, 0xF0, 0x07, 0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x38, 0x07,
  0x81, 0xC0, 0x3C, 0x70, 0x0F, 0x03, 0xC0, 0x70, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0xE0, 0x38, 0x0F, 0x01, 0xC1, 0xC0, 0x70, 0x0E, 0x07, 0x83, 0x81,
  0xE0, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x07, 0x07, 0x00, 0x78,
  0x38, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x3C,
  0x78, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x71, 0xC0, 0x03,
  0x9E, 0x00, 0xE3, 0x80, 0x07, 0x38, 0x01, 0xCF, 0x00, 0x0E, 0x70, 0x03,
  0xDC, 0x00, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x07, 0x70, 0x00,
  0x3F, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x00, 0x01,
  0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1C,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1E,
  0x00, 0x70, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x81, 0xC0, 0x07,
  0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x01,
  0xC7, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x8F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x47, 0xFC, 0x00, 0x17,
  0xFF, 0xC0, 0x0F, 0xF1, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xC8, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 48, 15, 5, -47 },
  { 31, 15, 17, 23, 4, -47 },
  { 63, 31, 47, 33, 1, -47 },
  { 246, 24, 54, 30, 3, -50 },
  { 408, 39, 49, 45, 3, -48 },
  { 647, 31, 49, 34, 3, -48 },
  { 837, 4, 17, 12, 4, -47 },
  { 846, 13, 57, 18, 3, -47 },
  { 939, 13, 57, 18, 2, -47 },
  { 1032, 22, 22, 28, 3, -50 },
  { 1093, 26, 31, 30, 2, -39 },
  { 1194, 7, 16, 14, 3, -7 },
  { 1208, 15, 4, 19, 2, -20 },
  { 1216, 6, 7, 14, 4, -6 },
  { 1222, 21, 47, 23, 1, -47 },
  { 1346, 24, 49, 30, 3, -48 },
  { 1493, 14, 47, 30, 5, -47 },
  { 1576, 24, 48, 30, 3, -48 },
  { 1720, 24, 49, 30, 3, -48 },
  { 1867, 28, 47, 30, 1, -47 },
  { 2032, 23, 48, 30, 4, -47 },
  { 2170, 24, 49, 30, 3, -48 },
  { 2317, 24, 47, 30, 3, -47 },
  { 2458, 25, 49, 30, 3, -48 },
  { 2612, 24, 49, 30, 3, -48 },
  { 2759, 6, 36, 14, 4, -35 },
  { 2786, 8, 44, 14, 2, -35 },
  { 2830, 26, 29, 30, 2, -38 },
  { 2925, 26, 17, 30, 2, -32 },
  { 2981, 26, 29, 30, 2, -38 },
  { 3076, 19, 49, 22, 1, -48 },
  { 3193, 40, 53, 47, 3, -47 },
  { 3458, 31, 47, 31, 0, -47 },
  { 3641, 26, 47, 33, 5, -47 },
  { 3794, 26, 49, 32, 4, -48 },
  { 3954, 28, 47, 37, 5, -47 },
  { 4119, 21, 47, 29, 5, -47 },
  { 4243, 21, 47, 27, 5, -47 },
  { 4367, 31, 49, 39, 4, -48 },
  { 4557, 27, 47, 38, 5, -47 },
  { 4716, 12, 47, 18, 3, -47 },
  { 4787, 13, 59, 14, -4, -47 },
  { 4883, 26, 47, 31, 5, -47 },
  { 5036, 20, 47, 27, 5, -47 },
  { 5154, 39, 47, 49, 5, -47 },
  { 5384, 29, 47, 39, 5, -47 },
  { 5555, 32, 49, 40, 4, -48 },
  { 5751, 23, 47, 31, 5, -47 },
  { 5887, 32, 59, 40, 4, -48 },
  { 6123, 26, 47, 32, 5, -47 },
  { 6276, 23, 49, 29, 3, -48 },
  { 6417, 25, 47, 27, 1, -47 },
  { 6564, 28, 48, 38, 5, -47 },
  { 6732, 30, 47, 30, 0, -47 },
  { 6909, 48, 47, 49, 1, -47 },
  { 7191, 27, 47, 28, 0, -47 },
  { 7350, 27, 47, 27, 0, -47 },
  { 7509, 23, 47, 27, 2, -47 },
  { 7645, 14, 58, 21, 5, -47 },
  { 7747, 21, 47, 23, 1, -47 },
  { 7871, 13, 58, 21, 2, -47 },
  { 7966, 27, 25, 31, 2, -47 },
  { 8051, 28, 3, 27, 0, 6 },
  { 8062, 11, 10, 17, 3, -50 },
  { 8076, 21, 37, 29, 3, -36 },
  { 8174, 24, 51, 32, 5, -50 },
  { 8327, 20, 37, 25, 3, -36 },
  { 8420, 25, 51, 32, 3, -50 },
  { 8580, 23, 37, 29, 3, -36 },
  { 8687, 18, 50, 17, 1, -50 },
  { 8800, 24, 52, 32, 3, -36 },
  { 8956, 22, 50, 32, 5, -50 },
  { 9094, 5, 48, 14, 4, -48 },
  { 9124, 10, 64, 14, -1, -48 },
  { 9204, 21, 50, 26, 5, -50 },
  { 9336, 4, 50, 13, 5, -50 },
  { 9361, 38, 36, 48, 5, -36 },
  { 9532, 22, 36, 32, 5, -36 },
  { 9631, 25, 37, 31, 3, -36 },
  { 9747, 24, 52, 32, 5, -36 },
  { 9903, 24, 52, 32, 3, -36 },
  { 10059, 15, 36, 21, 5, -36 },
  { 10127, 19, 37, 24, 3, -36 },
  { 10215, 15, 44, 18, 1, -43 },
  { 10298, 22, 36, 32, 5, -35 },
  { 10397, 24, 35, 25, 0, -35 },
  { 10502, 39, 35, 40, 1, -35 },
  { 10673, 24, 35, 26, 1, -35 },
  { 10778, 24, 51, 25, 1, -35 },
  { 10931, 18, 35, 22, 2, -35 },
  { 11010, 18, 58, 23, 3, -47 },
  { 11141, 3, 66, 29, 13, -50 },
  { 11166, 18, 58, 23, 3, -47 },
  { 11297, 26, 7, 30, 2, -27 },
};

const GFXfont NotoSans_Condensed_Light66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_LIGHT66PT7B_H_
