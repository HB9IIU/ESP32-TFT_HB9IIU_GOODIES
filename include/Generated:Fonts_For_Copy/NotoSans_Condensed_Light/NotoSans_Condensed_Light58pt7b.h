#ifndef _NOTOSANS_CONDENSED_LIGHT58PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x7F, 0xFF, 0x71, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0,
  0x30, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03,
  0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x0C, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xC0, 0x38, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x38, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03, 0x80,
  0x01, 0x80, 0x60, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xC0, 0x38, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x18, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0x8C, 0x3C, 0x78, 0x60, 0x27, 0x83, 0x00,
  0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81,
  0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x83, 0x00, 0x1E, 0x18, 0x00,
  0x78, 0xC0, 0x03, 0xF6, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0x7E, 0x00, 0x18, 0xF8, 0x00, 0xC1, 0xE0,
  0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0x80, 0xE0, 0x0C, 0x07, 0x00, 0x60,
  0x38, 0x03, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0xE0, 0x06, 0x0F, 0x40,
  0x30, 0xF3, 0xC1, 0x8F, 0x9F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x03, 0xDE,
  0x00, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x80, 0x18,
  0x0C, 0x00, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x1C, 0x00,
  0xE0, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x03, 0x80, 0x0C, 0x03, 0x80, 0xC0,
  0x03, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x38, 0x1C, 0x00, 0x30, 0x0E, 0x0E,
  0x00, 0x0C, 0x03, 0x83, 0x80, 0x03, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x38,
  0x70, 0x00, 0x38, 0x0E, 0x1C, 0x3F, 0x0E, 0x03, 0x8E, 0x1F, 0xE3, 0x80,
  0xE3, 0x8E, 0x3C, 0x60, 0x30, 0xC7, 0x07, 0x1C, 0x1C, 0x71, 0xC0, 0xE7,
  0x07, 0x1C, 0x60, 0x38, 0xFF, 0x8E, 0x38, 0x0E, 0x1F, 0xC3, 0x8E, 0x03,
  0x83, 0xE0, 0xC3, 0x80, 0x60, 0x00, 0x70, 0xE0, 0x18, 0x00, 0x1C, 0x38,
  0x07, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x70, 0x01, 0xC0,
  0xE0, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x00, 0x18, 0x0E, 0x01, 0x80, 0x0E,
  0x03, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x0E, 0x00,
  0x70, 0x06, 0x03, 0x80, 0x18, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x80, 0x0E, 0x3C, 0x01, 0xC0, 0x01, 0xFE, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x01, 0xE1, 0xC0, 0x1C, 0x3C, 0x1E, 0x01, 0xC3, 0x80, 0xF0, 0x1C,
  0x78, 0x07, 0x03, 0xC7, 0x00, 0x38, 0x38, 0x70, 0x03, 0xC3, 0x8F, 0x00,
  0x1E, 0x38, 0xE0, 0x00, 0xE7, 0x0E, 0x00, 0x0F, 0x70, 0xE0, 0x00, 0x7E,
  0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x7F, 0x07, 0x80, 0x0F, 0x70, 0x3C, 0x01, 0xE7, 0x81, 0xF9, 0xFC,
  0x3C, 0x0F, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x30, 0x37, 0xC6, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x80, 0x0E,
  0x70, 0x03, 0xC7, 0x00, 0x70, 0x70, 0x1C, 0x0F, 0x07, 0x80, 0xE0, 0x60,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x38, 0x71, 0xE3,
  0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x8E, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF7, 0xFF, 0xFF, 0x10, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3E,
  0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x8F, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x9E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x78, 0x0E, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x0F, 0x70, 0xFB, 0x8F, 0x1C, 0xF0, 0xFF, 0x0F, 0x70, 0x79, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F,
  0x81, 0xF0, 0x38, 0x01, 0xE0, 0x80, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF1, 0xF8, 0x07, 0xC7, 0x00, 0x1E,
  0x10, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x40, 0x00, 0x7B, 0x80, 0x0F, 0x9F, 0xC1, 0xF8, 0xFF, 0xFF, 0x81, 0xFF,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x77, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x60, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC8, 0x00, 0x3E, 0x60, 0x03, 0xE3, 0xF0, 0xFE, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xC0, 0x40, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x78, 0x07, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xCE, 0x0F, 0x8E,
  0xE0, 0x1E, 0x7C, 0x00, 0x7B, 0xE0, 0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x03,
  0xDC, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x70, 0x78,
  0x07, 0x81, 0xF0, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xC0, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07,
  0x8E, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0xF0, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x80,
  0x38, 0x0F, 0x01, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7C, 0xF8, 0x03, 0xC0, 0xF8, 0x1E,
  0x01, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x38, 0xF0,
  0x01, 0xE3, 0xE0, 0x0F, 0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x07, 0xC1, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x1E,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x1F, 0x38,
  0x00, 0x7C, 0xF0, 0x03, 0xE1, 0xE0, 0x3B, 0x87, 0xF7, 0xEE, 0x0F, 0xFF,
  0x38, 0x0F, 0xF0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x06, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x77, 0xBF, 0xFF, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xC0, 0x1C,
  0x7C, 0xF9, 0xF3, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x70, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF,
  0x0E, 0x07, 0xC4, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x0F, 0xE0, 0x1C, 0x70,
  0x07, 0xFF, 0x03, 0x9C, 0x01, 0xF3, 0xE0, 0x73, 0x80, 0x78, 0x1C, 0x06,
  0x70, 0x1E, 0x03, 0x80, 0xEE, 0x03, 0x80, 0x70, 0x1D, 0x80, 0x60, 0x0C,
  0x03, 0xF0, 0x1C, 0x01, 0x80, 0x7E, 0x03, 0x80, 0x70, 0x0F, 0xC0, 0x70,
  0x0E, 0x01, 0xF8, 0x0E, 0x01, 0xC0, 0x3F, 0x01, 0x80, 0x38, 0x07, 0xE0,
  0x30, 0x07, 0x00, 0xFC, 0x06, 0x00, 0xE0, 0x1F, 0x80, 0xC0, 0x1C, 0x03,
  0xF0, 0x18, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x70, 0x0D, 0xC0, 0x70, 0x1E,
  0x03, 0xB8, 0x0E, 0x03, 0xC0, 0x77, 0x00, 0xE0, 0xEC, 0x1C, 0x70, 0x1E,
  0x39, 0xC7, 0x8E, 0x01, 0xFE, 0x3F, 0xE1, 0xC0, 0x1F, 0x83, 0xF8, 0x38,
  0x00, 0x40, 0x08, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0E, 0x03, 0xFE, 0x38, 0x00, 0xF8, 0xE0, 0x00,
  0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x1F,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC3, 0x80, 0x0F, 0x8E,
  0x00, 0x0F, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8,
  0x00, 0x1E, 0xE0, 0x00, 0xF3, 0x80, 0x0F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x03, 0xF0, 0x1E, 0x07, 0xC0, 0x02, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x02, 0x01, 0xFC, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0xFF, 0xC0, 0xE0, 0x03,
  0xE0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xB8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x3E,
  0x03, 0xE0, 0x00, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x1F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC7, 0xFF, 0xFF, 0xE0,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0xCF, 0xDF, 0xF3, 0xFC, 0x18, 0x00,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x78, 0xE0,
  0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xC0, 0xE0, 0x0E,
  0x03, 0x80, 0x78, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x78, 0x03,
  0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE3, 0xC0, 0x03, 0x8E,
  0x00, 0x0E, 0x7C, 0x00, 0x3B, 0xF0, 0x00, 0xEF, 0xE0, 0x03, 0xF3, 0x80,
  0x0F, 0x8F, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x0E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0x3C, 0x0E, 0x00,
  0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xB8, 0x00,
  0x00, 0xEF, 0xDC, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x3B, 0xF3, 0x80,
  0x00, 0x39, 0xF9, 0xC0, 0x00, 0x1C, 0xFC, 0xE0, 0x00, 0x0E, 0x7E, 0x38,
  0x00, 0x0E, 0x3F, 0x1C, 0x00, 0x07, 0x1F, 0x8E, 0x00, 0x03, 0x8F, 0xC3,
  0x80, 0x03, 0x87, 0xE1, 0xC0, 0x01, 0xC3, 0xF0, 0xE0, 0x00, 0xE1, 0xF8,
  0x38, 0x00, 0xE0, 0xFC, 0x1C, 0x00, 0x70, 0x7E, 0x0E, 0x00, 0x38, 0x3F,
  0x03, 0x80, 0x38, 0x1F, 0x81, 0xC0, 0x1C, 0x0F, 0xC0, 0xE0, 0x0E, 0x07,
  0xE0, 0x38, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0x80,
  0xFC, 0x07, 0x83, 0x80, 0x7E, 0x01, 0xC1, 0xC0, 0x3F, 0x00, 0xE0, 0xE0,
  0x1F, 0x80, 0x78, 0xE0, 0x0F, 0xC0, 0x1C, 0x70, 0x07, 0xE0, 0x0E, 0x38,
  0x03, 0xF0, 0x07, 0xB8, 0x01, 0xF8, 0x01, 0xDC, 0x00, 0xFC, 0x00, 0xEE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xB8, 0x00, 0x0F, 0xDE, 0x00, 0x07,
  0xE7, 0x00, 0x03, 0xF3, 0xC0, 0x01, 0xF8, 0xE0, 0x00, 0xFC, 0x78, 0x00,
  0x7E, 0x1C, 0x00, 0x3F, 0x0F, 0x00, 0x1F, 0x83, 0x80, 0x0F, 0xC1, 0xE0,
  0x07, 0xE0, 0x70, 0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x0E, 0x00, 0xFC, 0x07,
  0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0x80, 0x38, 0x0F, 0xC0,
  0x1E, 0x07, 0xE0, 0x07, 0x03, 0xF0, 0x03, 0xC1, 0xF8, 0x00, 0xE0, 0xFC,
  0x00, 0x78, 0x7E, 0x00, 0x1C, 0x3F, 0x00, 0x0F, 0x1F, 0x80, 0x03, 0x8F,
  0xC0, 0x01, 0xE7, 0xE0, 0x00, 0x73, 0xF0, 0x00, 0x3D, 0xF8, 0x00, 0x0E,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x78,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38,
  0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xE1, 0xFF, 0x8E, 0x00, 0x7C, 0xE0, 0x03, 0xEE, 0x00, 0x1E, 0xE0,
  0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x0F,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1,
  0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38, 0x01, 0xF0, 0xE0,
  0x03, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x8E, 0x00, 0x3C, 0x38, 0x03, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x78, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0xF3, 0xF0, 0x1E, 0x3C, 0x00, 0x27, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0xC0, 0x07, 0xCF, 0xF7, 0xF8, 0xFF, 0xFF, 0x07,
  0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0xF8,
  0x03, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x3C, 0x03, 0x80, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x38,
  0x07, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xE0,
  0x00, 0x3B, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x70, 0x00, 0x3E, 0x00, 0x07,
  0x9C, 0x00, 0x0D, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x71, 0xE0,
  0x01, 0xDC, 0x00, 0x1C, 0x38, 0x00, 0x77, 0x00, 0x0F, 0x0E, 0x00, 0x1D,
  0xC0, 0x03, 0xC3, 0x80, 0x07, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0x8E, 0x00,
  0x38, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x81,
  0xC0, 0x0E, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x70, 0x1E, 0x01,
  0xC1, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x0C,
  0x03, 0xC0, 0x38, 0x07, 0x03, 0x80, 0xE0, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x0E, 0x07, 0x80, 0x1C,
  0x0E, 0x01, 0xC1, 0xC0, 0x07, 0x87, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xC0,
  0x1C, 0x1C, 0x00, 0x38, 0x70, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x00, 0xF3, 0x80, 0x0E, 0x38, 0x00,
  0x1C, 0xE0, 0x03, 0x9E, 0x00, 0x07, 0x38, 0x00, 0xE7, 0x80, 0x01, 0xCE,
  0x00, 0x1D, 0xC0, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x01,
  0xDC, 0x00, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x0E, 0x00,
  0x38, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC1, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xE3,
  0xC0, 0x00, 0xE3, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x77, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC1,
  0xC0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3,
  0x80, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xF0, 0x7E,
  0x7E, 0x0C, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x87, 0x1E, 0x00, 0xE7, 0x80,
  0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0xBC, 0x03,
  0x73, 0xC1, 0xEE, 0x3F, 0xF8, 0xC3, 0xFC, 0x18, 0x1E, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x83, 0xFC,
  0x0E, 0x3F, 0xF8, 0x39, 0xFB, 0xF0, 0xEE, 0x01, 0xE3, 0xB0, 0x03, 0xCF,
  0x80, 0x07, 0x3E, 0x00, 0x1C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00,
  0x0E, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xCF, 0x80, 0x0F, 0x3B, 0x00, 0x3C,
  0xEE, 0x01, 0xE3, 0x9E, 0x1F, 0x0E, 0x3F, 0xF8, 0x38, 0x7F, 0xC0, 0x00,
  0x10, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFB, 0xE3, 0xE0, 0x13, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x11, 0xFC, 0x78, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x81, 0xFE, 0x1C, 0x3F,
  0xF8, 0xE3, 0xFB, 0xE7, 0x1E, 0x03, 0xB9, 0xE0, 0x0F, 0xDE, 0x00, 0x3E,
  0xF0, 0x00, 0xF7, 0x00, 0x07, 0xB8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8,
  0x00, 0x3D, 0xE0, 0x03, 0xE7, 0x00, 0x1F, 0x3C, 0x01, 0xB8, 0xF8, 0x39,
  0xC3, 0xFF, 0xC6, 0x0F, 0xF8, 0x30, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x3C, 0x3C, 0x01, 0xC3, 0x80, 0x1E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x06, 0x0F, 0x83, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x07, 0xEE, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xFC, 0x38,
  0x7F, 0xF9, 0xC7, 0xF7, 0xCE, 0x3C, 0x07, 0x73, 0xC0, 0x0F, 0xBC, 0x00,
  0x7D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x0F,
  0x70, 0x00, 0x7B, 0xC0, 0x07, 0xCE, 0x00, 0x3E, 0x78, 0x03, 0x71, 0xF0,
  0x73, 0x87, 0xFF, 0x1C, 0x1F, 0xF0, 0xE0, 0x08, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x40, 0x01, 0xE3, 0xC0, 0x3E, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xF0, 0xE3, 0xFF, 0x8E, 0x7D, 0xFC,
  0xEE, 0x03, 0xEE, 0xC0, 0x1E, 0xF8, 0x00, 0xEF, 0x80, 0x0E, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0x60, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF7, 0xF3, 0xF9, 0xF0, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x07, 0xB8, 0x00, 0xE7, 0x00, 0x3C,
  0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81,
  0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x03,
  0x9F, 0x00, 0x73, 0xF0, 0x0E, 0xEE, 0x01, 0xF9, 0xE0, 0x3E, 0x1C, 0x07,
  0x83, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x83, 0x80, 0x70, 0x70, 0x0F, 0x0E,
  0x00, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x3C, 0xE0, 0x03, 0x9C,
  0x00, 0x7B, 0x80, 0x07, 0x70, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE1, 0xFE, 0x03, 0xFC, 0x38, 0xFF, 0xC1, 0xFF, 0x8E, 0x79, 0xF8, 0xF3,
  0xF3, 0xB8, 0x1E, 0x70, 0x3E, 0xEC, 0x03, 0xF8, 0x07, 0xBE, 0x00, 0x7C,
  0x00, 0xEF, 0x80, 0x1F, 0x00, 0x3B, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x80,
  0x07, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE,
  0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x03,
  0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x80,
  0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x00,
  0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0xE0,
  0x01, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x3C,
  0xE0, 0xFF, 0x0E, 0x3F, 0xF8, 0xE7, 0xCF, 0xCE, 0xE0, 0x3E, 0xEC, 0x01,
  0xEF, 0x80, 0x0E, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xF8, 0xFC, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0xC7, 0x80,
  0x07, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1E,
  0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0xC0, 0x0E, 0x07, 0x80, 0x78, 0x0F,
  0x87, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0xE0, 0xFF,
  0x03, 0x8F, 0xFE, 0x0E, 0x7C, 0xFC, 0x39, 0x80, 0x78, 0xEC, 0x00, 0xF3,
  0xE0, 0x01, 0xCF, 0x80, 0x07, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00,
  0x03, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0x73, 0xE0, 0x03, 0xCE, 0xC0, 0x0E,
  0x3B, 0x80, 0x78, 0xE7, 0x87, 0xC3, 0x8F, 0xFE, 0x0E, 0x1F, 0xF0, 0x38,
  0x04, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x38, 0x7F, 0xF1, 0xC7, 0xF7, 0xCE, 0x3C, 0x07,
  0x73, 0xC0, 0x1F, 0x9C, 0x00, 0x7D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0xC0, 0x07, 0xCE, 0x00,
  0x7E, 0x78, 0x07, 0x71, 0xF0, 0xF3, 0x87, 0xFF, 0x1C, 0x1F, 0xF0, 0xE0,
  0x08, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0xE1, 0xFF, 0x8F, 0xEE, 0x7F, 0xB9, 0xC0, 0xEE, 0x03, 0xB0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFF,
  0xCF, 0xC7, 0xCF, 0x00, 0x27, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xEF, 0x83, 0xF7, 0xFF, 0xF0,
  0xFF, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1F, 0x10, 0x7F, 0x81, 0xFC, 0x01, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xF7, 0x00,
  0x1F, 0x78, 0x03, 0x77, 0x80, 0x77, 0x3E, 0x1E, 0x71, 0xFF, 0xC7, 0x0F,
  0xF8, 0x70, 0x08, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0xE7, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x3C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00,
  0x1E, 0x00, 0x3B, 0xC0, 0x0F, 0x80, 0x0E, 0x70, 0x03, 0xF0, 0x03, 0x9C,
  0x00, 0xFC, 0x01, 0xE7, 0x00, 0x37, 0x00, 0x71, 0xE0, 0x1C, 0xC0, 0x1C,
  0x38, 0x07, 0x38, 0x07, 0x0E, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0x63, 0x80,
  0xE0, 0xE0, 0x38, 0xE0, 0x38, 0x1C, 0x0E, 0x1C, 0x0E, 0x07, 0x03, 0x87,
  0x03, 0x81, 0xC0, 0xE1, 0xC1, 0xC0, 0x70, 0x70, 0x70, 0x70, 0x0E, 0x1C,
  0x0E, 0x1C, 0x03, 0x87, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0xE1, 0xC0, 0x38,
  0xE0, 0x38, 0xE0, 0x0F, 0x38, 0x07, 0x38, 0x01, 0xCE, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x73, 0x80, 0x1C, 0xC0, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0x70,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x78, 0x03,
  0xC1, 0xC0, 0x1C, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x77, 0x00, 0x07, 0x3C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x80,
  0x1C, 0x1C, 0x01, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x1E, 0x0F, 0x00,
  0x70, 0x70, 0x03, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x7B, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xBC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x0F, 0x38, 0x00, 0x71, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1,
  0xC0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x7F,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xC0,
  0x05, 0xFF, 0xE0, 0x1F, 0x87, 0xF0, 0xFC, 0x03, 0xFF, 0xD0, 0x01, 0xFF,
  0x00, 0x00, 0x20, 0x00,
};

const GFXglyph NotoSans_Condensed_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 42, 13, 4, -41 },
  { 28, 12, 15, 20, 4, -41 },
  { 51, 27, 41, 29, 1, -41 },
  { 190, 21, 47, 27, 3, -44 },
  { 314, 34, 43, 39, 3, -42 },
  { 497, 28, 43, 30, 2, -42 },
  { 648, 3, 15, 11, 4, -41 },
  { 654, 11, 51, 16, 3, -42 },
  { 725, 11, 51, 16, 2, -42 },
  { 796, 19, 19, 25, 3, -44 },
  { 842, 23, 27, 27, 2, -34 },
  { 920, 7, 14, 12, 2, -6 },
  { 933, 13, 3, 17, 2, -17 },
  { 938, 5, 6, 12, 4, -5 },
  { 942, 18, 41, 20, 1, -41 },
  { 1035, 21, 43, 27, 3, -42 },
  { 1148, 13, 41, 27, 4, -41 },
  { 1215, 22, 42, 27, 2, -42 },
  { 1331, 21, 43, 27, 2, -42 },
  { 1444, 25, 42, 27, 1, -42 },
  { 1576, 21, 42, 27, 3, -41 },
  { 1687, 21, 43, 27, 3, -42 },
  { 1800, 22, 41, 27, 2, -41 },
  { 1913, 22, 43, 27, 2, -42 },
  { 2032, 22, 43, 27, 2, -42 },
  { 2151, 5, 31, 13, 4, -31 },
  { 2171, 7, 39, 12, 2, -31 },
  { 2206, 23, 25, 27, 2, -33 },
  { 2278, 23, 15, 27, 2, -28 },
  { 2322, 23, 25, 27, 2, -33 },
  { 2394, 17, 43, 19, 1, -42 },
  { 2486, 35, 47, 41, 3, -42 },
  { 2692, 27, 41, 27, 0, -41 },
  { 2831, 22, 41, 29, 5, -41 },
  { 2944, 24, 43, 28, 3, -42 },
  { 3073, 24, 41, 32, 5, -41 },
  { 3196, 18, 41, 26, 5, -41 },
  { 3289, 18, 41, 24, 5, -41 },
  { 3382, 28, 43, 34, 3, -42 },
  { 3533, 23, 41, 33, 5, -41 },
  { 3651, 11, 41, 16, 2, -41 },
  { 3708, 11, 52, 13, -3, -41 },
  { 3780, 22, 41, 27, 5, -41 },
  { 3893, 17, 41, 23, 5, -41 },
  { 3981, 33, 41, 43, 5, -41 },
  { 4151, 25, 41, 34, 5, -41 },
  { 4280, 29, 43, 35, 3, -42 },
  { 4436, 20, 41, 27, 5, -41 },
  { 4539, 29, 52, 35, 3, -42 },
  { 4728, 22, 41, 28, 5, -41 },
  { 4841, 20, 43, 26, 3, -42 },
  { 4949, 23, 41, 24, 0, -41 },
  { 5067, 25, 42, 33, 4, -41 },
  { 5199, 27, 41, 27, 0, -41 },
  { 5338, 42, 41, 43, 1, -41 },
  { 5554, 24, 41, 24, 0, -41 },
  { 5677, 24, 41, 24, 0, -41 },
  { 5800, 20, 41, 24, 2, -41 },
  { 5903, 11, 51, 18, 5, -42 },
  { 5974, 18, 41, 20, 1, -41 },
  { 6067, 12, 51, 18, 2, -42 },
  { 6144, 25, 22, 27, 1, -41 },
  { 6213, 24, 3, 24, 0, 5 },
  { 6222, 10, 9, 15, 2, -44 },
  { 6234, 19, 32, 25, 2, -31 },
  { 6310, 22, 45, 28, 4, -44 },
  { 6434, 17, 32, 22, 3, -31 },
  { 6502, 21, 45, 28, 3, -44 },
  { 6621, 20, 32, 26, 3, -31 },
  { 6701, 16, 44, 15, 1, -44 },
  { 6789, 21, 45, 28, 3, -31 },
  { 6908, 20, 44, 28, 4, -44 },
  { 7018, 4, 42, 12, 4, -42 },
  { 7039, 9, 56, 12, -1, -42 },
  { 7102, 19, 44, 23, 4, -44 },
  { 7207, 3, 44, 12, 4, -44 },
  { 7224, 34, 31, 42, 4, -31 },
  { 7356, 20, 31, 28, 4, -31 },
  { 7434, 22, 32, 27, 3, -31 },
  { 7522, 22, 45, 28, 4, -31 },
  { 7646, 21, 45, 28, 3, -31 },
  { 7765, 14, 31, 18, 4, -31 },
  { 7820, 17, 32, 21, 2, -31 },
  { 7888, 13, 39, 15, 1, -38 },
  { 7952, 20, 32, 28, 4, -31 },
  { 8032, 21, 31, 22, 0, -31 },
  { 8114, 34, 31, 36, 1, -31 },
  { 8246, 21, 31, 23, 1, -31 },
  { 8328, 21, 45, 22, 1, -31 },
  { 8447, 16, 31, 19, 2, -31 },
  { 8509, 16, 50, 21, 2, -41 },
  { 8609, 3, 58, 25, 11, -44 },
  { 8631, 16, 50, 21, 2, -41 },
  { 8731, 23, 7, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Light58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_LIGHT58PT7B_H_
