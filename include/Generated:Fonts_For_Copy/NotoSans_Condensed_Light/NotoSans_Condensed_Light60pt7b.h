#ifndef _NOTOSANS_CONDENSED_LIGHT60PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xDE, 0x40, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xB8, 0x0D, 0xC0,
  0x6E, 0x03, 0x70, 0x1B, 0x80, 0xDC, 0x06, 0x00, 0x38, 0x07, 0x00, 0x03,
  0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x60, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0E, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00,
  0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3C, 0x70, 0x71, 0xE1, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x03, 0x81, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x70, 0x00,
  0xFD, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1C, 0xF8, 0x00, 0x70, 0xF0, 0x01, 0xC1,
  0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0x70,
  0x07, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x07, 0xB0, 0x1C, 0x3C, 0xF8, 0x73, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x03, 0xFC, 0x00,
  0x1C, 0x00, 0xE3, 0xC0, 0x03, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x70, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x70, 0x38, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x0E, 0x01, 0xC1,
  0xC0, 0x01, 0xC0, 0x38, 0x38, 0x00, 0x38, 0x07, 0x07, 0x00, 0x07, 0x00,
  0xE1, 0xC0, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0x1C, 0x03, 0x8E, 0x0F, 0xC3,
  0x80, 0x61, 0xC3, 0xFC, 0x70, 0x1C, 0x38, 0xE3, 0xC6, 0x03, 0x8E, 0x38,
  0x38, 0xE0, 0x71, 0xC7, 0x03, 0x9C, 0x1C, 0x70, 0xC0, 0x71, 0xC7, 0x8E,
  0x38, 0x0E, 0x1F, 0xE1, 0xC7, 0x00, 0xC1, 0xF8, 0x70, 0xE0, 0x1C, 0x00,
  0x0E, 0x1C, 0x03, 0x80, 0x03, 0x83, 0x80, 0x70, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x38, 0x00, 0x70, 0x38,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x70,
  0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x60, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0xE0, 0x06, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0x01, 0xC7, 0x80, 0x1C, 0x00, 0x1F, 0xE0, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x1C, 0x1E, 0x0E, 0x00,
  0xE1, 0xE0, 0x78, 0x07, 0x1E, 0x01, 0xE0, 0x78, 0xF0, 0x07, 0x03, 0x87,
  0x00, 0x3C, 0x1C, 0x38, 0x00, 0xF0, 0xE3, 0xC0, 0x03, 0xCF, 0x1E, 0x00,
  0x0E, 0x70, 0xF0, 0x00, 0x7F, 0x87, 0x80, 0x01, 0xF8, 0x3C, 0x00, 0x07,
  0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x3F, 0xC0,
  0xF0, 0x03, 0xCE, 0x07, 0xC0, 0x3E, 0x78, 0x1F, 0xDF, 0xC1, 0xE0, 0x7F,
  0xFC, 0x07, 0x81, 0xFF, 0x80, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0F,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0E,
  0x06, 0x0E, 0xFC, 0x67, 0xEF, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3B, 0x80, 0x07, 0x9C, 0x00, 0x71, 0xE0, 0x0E, 0x0E,
  0x01, 0xE0, 0x70, 0x3C, 0x07, 0x81, 0x80, 0x30, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF7, 0xFF, 0xFF, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xC0, 0xF0, 0x1E, 0x01,
  0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71,
  0xC0, 0x01, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0xC0,
  0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3F, 0x0F, 0xF1, 0xF7, 0x3E, 0x77, 0x87,
  0xF0, 0x7E, 0x07, 0x40, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE1, 0xF0, 0x0F, 0x86, 0x00, 0x1E, 0x10, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0x00, 0x7C, 0x70, 0x00, 0xF0,
  0x80, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE8, 0x00, 0x0F, 0xB8, 0x00, 0x7C,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x03,
  0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xCF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x38, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC8, 0x00, 0x1E, 0x38, 0x01, 0xF0, 0xFE, 0x7F, 0x83,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x18, 0x03, 0xC7, 0xFE, 0x0E, 0x3F, 0xFC,
  0x39, 0xF1, 0xF8, 0xEE, 0x01, 0xF3, 0xB0, 0x03, 0xCF, 0x80, 0x07, 0xBE,
  0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0F,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9E, 0x00, 0x0E, 0x38,
  0x00, 0x78, 0xF0, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0xC7,
  0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xBF, 0x80, 0xF8, 0x07, 0x81, 0xE0, 0x07, 0x87, 0x80,
  0x07, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x07,
  0x07, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x87, 0x80,
  0x0F, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFB, 0xF0, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0xF0,
  0x00, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xDC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x7B, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x1E,
  0x0F, 0x00, 0x7C, 0x1F, 0xC3, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C,
  0x07, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0xDE, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0xBC, 0x00,
  0x7C, 0xF0, 0x06, 0xE7, 0xC0, 0xF7, 0x1F, 0xFF, 0x38, 0x7F, 0xE1, 0xC0,
  0x7C, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x38, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x77,
  0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xEE, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xFE, 0x3F,
  0xFF, 0x8C, 0x03, 0xE4, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x7F, 0x00, 0xE3, 0x80, 0x1F, 0xFC, 0x0E, 0x38, 0x07, 0xEF, 0xC0,
  0x77, 0x00, 0x70, 0x1C, 0x07, 0x70, 0x0E, 0x01, 0x80, 0x77, 0x01, 0xE0,
  0x18, 0x07, 0x70, 0x1C, 0x03, 0x80, 0x76, 0x01, 0xC0, 0x38, 0x07, 0xE0,
  0x38, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x38, 0x03, 0x80,
  0x7E, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x38, 0x03, 0x80, 0x7E, 0x03, 0x80,
  0x38, 0x07, 0xE0, 0x38, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x38, 0x07, 0xE0,
  0x38, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x78, 0x06, 0xE0, 0x3C, 0x07, 0x80,
  0xEE, 0x01, 0xC0, 0x78, 0x0E, 0x70, 0x1E, 0x0C, 0xC1, 0xC7, 0x00, 0xF3,
  0xCF, 0x7C, 0x70, 0x0F, 0xF8, 0x7F, 0x87, 0x00, 0x3F, 0x07, 0xF0, 0x38,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x40, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x1E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00, 0x3F, 0x8E,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0xE0, 0x00,
  0x71, 0xC0, 0x01, 0xE3, 0x80, 0x0F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x38, 0x00, 0xFC, 0x70, 0x00, 0x7C, 0xE0, 0x00, 0x79,
  0xC0, 0x00, 0x7B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00,
  0x0F, 0x38, 0x00, 0x3E, 0x70, 0x01, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x7E, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x06, 0x01, 0xFF, 0x7F,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1C, 0x01, 0xFC, 0x0E, 0x00,
  0x1F, 0x07, 0x00, 0x07, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x9C,
  0x00, 0x07, 0x8E, 0x00, 0x07, 0xC7, 0x00, 0x07, 0xC3, 0x80, 0x07, 0xC1,
  0xC0, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x02, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01,
  0xE0, 0x7E, 0x00, 0x0F, 0x01, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x83, 0xEF, 0xFC, 0xFF, 0x87, 0xE0, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B,
  0x80, 0x01, 0xE7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x38, 0x1E,
  0x00, 0x70, 0x78, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x8F, 0x00,
  0x07, 0x3E, 0x00, 0x0E, 0x7E, 0x00, 0x1D, 0xFC, 0x00, 0x3F, 0x3C, 0x00,
  0x7E, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xF0, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x70,
  0x03, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x78, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFB, 0x80, 0x00, 0x03, 0xFF, 0x70, 0x00, 0x00, 0xEF, 0xEF, 0x00,
  0x00, 0x1D, 0xFC, 0xE0, 0x00, 0x03, 0xBF, 0x9C, 0x00, 0x00, 0xE7, 0xF3,
  0xC0, 0x00, 0x1C, 0xFE, 0x38, 0x00, 0x03, 0x9F, 0xC7, 0x00, 0x00, 0xE3,
  0xF8, 0xF0, 0x00, 0x1C, 0x7F, 0x0E, 0x00, 0x03, 0x8F, 0xE1, 0xC0, 0x00,
  0xE1, 0xFC, 0x38, 0x00, 0x1C, 0x3F, 0x83, 0x80, 0x03, 0x87, 0xF0, 0x70,
  0x00, 0xE0, 0xFE, 0x0E, 0x00, 0x1C, 0x1F, 0xC0, 0xE0, 0x03, 0x83, 0xF8,
  0x1C, 0x00, 0xE0, 0x7F, 0x03, 0x80, 0x1C, 0x0F, 0xE0, 0x38, 0x03, 0x81,
  0xFC, 0x07, 0x00, 0xE0, 0x3F, 0x80, 0xE0, 0x1C, 0x07, 0xF0, 0x1E, 0x03,
  0x80, 0xFE, 0x01, 0xC0, 0xE0, 0x1F, 0xC0, 0x38, 0x1C, 0x03, 0xF8, 0x07,
  0x83, 0x80, 0x7F, 0x00, 0x70, 0xF0, 0x0F, 0xE0, 0x0E, 0x1C, 0x01, 0xFC,
  0x01, 0xE3, 0x80, 0x3F, 0x80, 0x1C, 0xF0, 0x07, 0xF0, 0x03, 0x9C, 0x00,
  0xFE, 0x00, 0x7B, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00,
  0x3C, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFE, 0xE0, 0x00, 0x3F, 0xBC, 0x00, 0x0F, 0xE7, 0x00,
  0x03, 0xF9, 0xE0, 0x00, 0xFE, 0x38, 0x00, 0x3F, 0x8F, 0x00, 0x0F, 0xE1,
  0xC0, 0x03, 0xF8, 0x78, 0x00, 0xFE, 0x0E, 0x00, 0x3F, 0x83, 0xC0, 0x0F,
  0xE0, 0x70, 0x03, 0xF8, 0x1E, 0x00, 0xFE, 0x03, 0x80, 0x3F, 0x80, 0xF0,
  0x0F, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x00, 0xE0, 0x3F, 0x80,
  0x3C, 0x0F, 0xE0, 0x07, 0x03, 0xF8, 0x01, 0xE0, 0xFE, 0x00, 0x38, 0x3F,
  0x80, 0x0F, 0x0F, 0xE0, 0x01, 0xC3, 0xF8, 0x00, 0x78, 0xFE, 0x00, 0x0E,
  0x3F, 0x80, 0x03, 0xC7, 0xE0, 0x00, 0x71, 0xF8, 0x00, 0x1E, 0x7E, 0x00,
  0x03, 0x9F, 0x80, 0x00, 0xF7, 0xE0, 0x00, 0x1D, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x3C,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xC0, 0x3F, 0x8E,
  0x00, 0x3E, 0x70, 0x00, 0xF3, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x03, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x07,
  0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0xFE,
  0x0E, 0x00, 0x3E, 0x1C, 0x00, 0x3E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xCE,
  0x00, 0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0,
  0x00, 0x71, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0E, 0x00,
  0x7C, 0x1C, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xE0, 0x3C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xF0,
  0x1C, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0xC1,
  0xC0, 0x07, 0x83, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1C,
  0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x7B, 0x80, 0x00, 0x78, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7C, 0x00, 0xE3, 0xC0, 0x01, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x7A, 0x00, 0x07, 0x9C,
  0x00, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0x7C, 0x00, 0xF8, 0x1F, 0xF7, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0F, 0x00,
  0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x01,
  0xC0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x70, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xDC, 0x00,
  0x1E, 0x78, 0x00, 0x3B, 0x80, 0x03, 0x87, 0x00, 0x07, 0x70, 0x00, 0x70,
  0xE0, 0x01, 0xCE, 0x00, 0x1E, 0x1E, 0x00, 0x39, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x70, 0x01, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0xE0,
  0x0F, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x83, 0x80, 0x38,
  0x07, 0x00, 0xE0, 0x70, 0x0F, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x1E,
  0x03, 0x80, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x38, 0x1E,
  0x03, 0x80, 0xE0, 0x07, 0x83, 0x80, 0x70, 0x3C, 0x00, 0xF0, 0x70, 0x07,
  0x07, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x1C, 0x1C,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x00,
  0xF1, 0xC0, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x1C, 0xF0, 0x00, 0x39, 0xC0, 0x03, 0x9E, 0x00, 0x07, 0xB8, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x01, 0xD8, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0xC0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0x78, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x07,
  0x01, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x0E, 0x01,
  0xC0, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC1,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x00, 0xE7,
  0x80, 0x00, 0xF7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x07, 0x00,
  0x03, 0x87, 0x80, 0x01, 0xE3, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0xFC,
  0x0C, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xF8, 0x07, 0x3E,
  0x00, 0x73, 0xC0, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xF7, 0x00, 0x1F,
  0x78, 0x03, 0x77, 0x80, 0x77, 0x3E, 0x0E, 0x71, 0xFF, 0xC7, 0x0F, 0xF8,
  0x70, 0x08, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x3C, 0x3F, 0xE0, 0x79, 0xFF,
  0xE0, 0xF7, 0xEF, 0xE1, 0xEE, 0x03, 0xE3, 0xF8, 0x03, 0xC7, 0xE0, 0x03,
  0xCF, 0x80, 0x03, 0x9F, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x0E,
  0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x00,
  0x01, 0xDE, 0x00, 0x07, 0xBE, 0x00, 0x0E, 0x7C, 0x00, 0x1C, 0xFC, 0x00,
  0x79, 0xF8, 0x01, 0xE3, 0x98, 0x07, 0xC7, 0x3E, 0x3F, 0x0E, 0x3F, 0xFC,
  0x1C, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xE0,
  0x7F, 0xFC, 0x3F, 0xDE, 0x1F, 0x00, 0x87, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x10, 0xFE, 0x7C, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x80, 0x70, 0x3F, 0xE1, 0xC1, 0xFF, 0xC7, 0x0F, 0xCF, 0x9C, 0x78,
  0x07, 0x73, 0xC0, 0x0D, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xC0, 0x00,
  0xF7, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE,
  0x00, 0x1F, 0x38, 0x00, 0x7C, 0xF0, 0x03, 0x71, 0xE0, 0x1D, 0xC7, 0xE1,
  0xE7, 0x0F, 0xFF, 0x1C, 0x0F, 0xF8, 0x70, 0x06, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1F, 0x1F, 0x81, 0xE0, 0x3C, 0x1E,
  0x00, 0xF0, 0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x01, 0x0F, 0x80, 0x18, 0x3F, 0x07, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xC1,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0xF8, 0x70, 0x7F, 0xF1, 0xC3, 0xFB, 0xE7, 0x1E,
  0x01, 0xDC, 0xF0, 0x03, 0x73, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7,
  0x80, 0x07, 0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xDC, 0x78, 0x07, 0x71, 0xF8,
  0x79, 0xC3, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x01, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE4, 0x00, 0x0F, 0x1C, 0x00,
  0x78, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x0C, 0x03, 0xC3,
  0xFC, 0x1E, 0x7F, 0xF8, 0xF7, 0xEF, 0xE7, 0xB8, 0x0F, 0x3F, 0x80, 0x3D,
  0xF8, 0x01, 0xEF, 0x80, 0x07, 0x7C, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0x7F,
  0xFF, 0xF2, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3D, 0xFE,
  0xFE, 0x7E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78,
  0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xC0, 0x0F, 0x3C,
  0x00, 0xF7, 0xE0, 0x0F, 0x7E, 0x00, 0xFE, 0xF0, 0x0F, 0xC7, 0x00, 0xF8,
  0x78, 0x0F, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x1E, 0x0F,
  0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x8F, 0x00, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00,
  0x30, 0x1C, 0x3F, 0xC0, 0x3F, 0xC3, 0x8F, 0xFE, 0x1F, 0xFC, 0x73, 0xE7,
  0xC7, 0xCF, 0xCE, 0xE0, 0x3C, 0xE0, 0x7D, 0xD8, 0x03, 0xB8, 0x07, 0xBE,
  0x00, 0x7E, 0x00, 0x77, 0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x70,
  0x00, 0x7F, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x3F, 0x80, 0x07, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0xFE,
  0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x03, 0xF8, 0x00, 0x70, 0x00,
  0x7F, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x38,
  0x00, 0x3F, 0x80, 0x07, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0xFE, 0x00,
  0x1C, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x7F,
  0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x38, 0x00,
  0x3F, 0x80, 0x07, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x08,
  0x07, 0x07, 0xFC, 0x38, 0xFF, 0xF1, 0xCF, 0x8F, 0xCE, 0x70, 0x1E, 0x76,
  0x00, 0x7B, 0xB0, 0x03, 0xDF, 0x00, 0x0E, 0xF8, 0x00, 0x77, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7E, 0x7F,
  0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0x71, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x0F,
  0x03, 0xC0, 0x3E, 0x03, 0xF1, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x08, 0x01, 0xC1, 0xFF, 0x03, 0x87, 0xFF, 0x07,
  0x1F, 0x3F, 0x0E, 0x70, 0x1F, 0x1D, 0xC0, 0x1E, 0x3B, 0x00, 0x1E, 0x7C,
  0x00, 0x1C, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0E,
  0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x73, 0xE0, 0x00, 0xE7, 0xE0, 0x03, 0xCF,
  0xE0, 0x0F, 0x1E, 0xE0, 0x3E, 0x3D, 0xF1, 0xF8, 0x79, 0xFF, 0xE0, 0xF0,
  0xFF, 0x81, 0xE0, 0x30, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8,
  0x70, 0x7F, 0xF1, 0xC3, 0xF3, 0xE7, 0x1E, 0x01, 0xDC, 0xF0, 0x03, 0x73,
  0x80, 0x07, 0xDE, 0x00, 0x1F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F,
  0x3C, 0x00, 0xDC, 0x78, 0x07, 0x71, 0xF8, 0xF9, 0xC3, 0xFF, 0xC7, 0x03,
  0xFE, 0x1C, 0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xC0,
  0xEE, 0x03, 0xB0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0xFC, 0x7E, 0x7C, 0x01,
  0x9E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xB8, 0x01, 0xEF, 0xC7, 0xF3, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x8C, 0x1F,
  0xF0, 0x3F, 0xC0, 0x18, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x01, 0xF7,
  0x80, 0x1F, 0x3C, 0x07, 0x33, 0xF3, 0xF3, 0x1F, 0xFE, 0x30, 0xFF, 0x83,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE,
  0x00, 0x0E, 0x78, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0F, 0x00,
  0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x80, 0x38,
  0x0E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x70, 0x07,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0x00,
  0xE7, 0x00, 0x1B, 0x00, 0x1C, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x00, 0xEE,
  0x00, 0xF3, 0xC0, 0x1D, 0xC0, 0x1C, 0x38, 0x03, 0xB8, 0x03, 0x87, 0x00,
  0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x1E, 0x1E, 0x03, 0x8E, 0x03, 0x81,
  0xC0, 0x71, 0xC0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81,
  0xC0, 0xF0, 0x70, 0x70, 0x70, 0x0E, 0x0E, 0x0E, 0x0E, 0x01, 0xC3, 0x81,
  0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x8E, 0x00, 0xF1,
  0xC0, 0x71, 0xC0, 0x0E, 0x70, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x1C, 0xE0, 0x07, 0xB8, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x77,
  0x00, 0x0F, 0xC0, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x7B, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x78,
  0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x70,
  0x07, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xF3, 0xC0, 0x03, 0x9C, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xBC, 0x00, 0x3C, 0xE0, 0x01, 0xC7,
  0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xF0, 0x0F, 0x03, 0x80, 0xF0, 0x0E, 0x07,
  0x00, 0x78, 0x78, 0x01, 0xC3, 0x80, 0x0F, 0x3C, 0x00, 0x39, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0x9C,
  0x00, 0x1E, 0x70, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0x81, 0xC0, 0x1E, 0x07, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0F,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x8F,
  0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1F,
  0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0x7F, 0xF0, 0x03, 0xFF, 0xFE,
  0x0F, 0xE0, 0x3F, 0xFE, 0x80, 0x0F, 0xFC, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 44, 13, 4, -43 },
  { 29, 13, 16, 21, 4, -43 },
  { 55, 28, 43, 30, 1, -43 },
  { 206, 22, 49, 28, 3, -46 },
  { 341, 35, 44, 41, 3, -43 },
  { 534, 29, 44, 31, 2, -43 },
  { 694, 4, 16, 11, 4, -43 },
  { 702, 12, 52, 17, 3, -43 },
  { 780, 12, 52, 17, 2, -43 },
  { 858, 20, 20, 25, 3, -46 },
  { 908, 23, 28, 28, 2, -35 },
  { 989, 7, 15, 12, 2, -7 },
  { 1003, 13, 3, 17, 2, -18 },
  { 1008, 5, 6, 13, 4, -5 },
  { 1012, 19, 43, 21, 1, -43 },
  { 1115, 22, 44, 28, 3, -43 },
  { 1236, 12, 43, 28, 5, -43 },
  { 1301, 21, 43, 28, 3, -43 },
  { 1414, 22, 44, 28, 2, -43 },
  { 1535, 26, 43, 28, 1, -43 },
  { 1675, 22, 44, 28, 3, -43 },
  { 1796, 22, 44, 28, 3, -43 },
  { 1917, 22, 43, 28, 3, -43 },
  { 2036, 23, 44, 28, 2, -43 },
  { 2163, 21, 44, 28, 3, -43 },
  { 2279, 5, 32, 13, 4, -32 },
  { 2299, 7, 40, 13, 2, -32 },
  { 2334, 23, 27, 28, 2, -35 },
  { 2412, 23, 16, 28, 2, -29 },
  { 2458, 24, 27, 28, 2, -35 },
  { 2539, 17, 44, 20, 1, -43 },
  { 2633, 36, 48, 42, 3, -43 },
  { 2849, 28, 43, 28, 0, -43 },
  { 3000, 23, 43, 30, 5, -43 },
  { 3124, 25, 44, 29, 3, -43 },
  { 3262, 25, 43, 34, 5, -43 },
  { 3397, 18, 43, 26, 5, -43 },
  { 3494, 18, 43, 24, 5, -43 },
  { 3591, 29, 44, 35, 3, -43 },
  { 3751, 24, 43, 34, 5, -43 },
  { 3880, 12, 43, 16, 2, -43 },
  { 3945, 12, 54, 13, -4, -43 },
  { 4026, 23, 43, 28, 5, -43 },
  { 4150, 18, 43, 24, 5, -43 },
  { 4247, 35, 43, 44, 5, -43 },
  { 4436, 26, 43, 36, 5, -43 },
  { 4576, 30, 44, 36, 3, -43 },
  { 4741, 21, 43, 28, 5, -43 },
  { 4854, 30, 53, 36, 3, -43 },
  { 5053, 23, 43, 29, 5, -43 },
  { 5177, 21, 44, 27, 3, -43 },
  { 5293, 24, 43, 25, 0, -43 },
  { 5422, 25, 44, 34, 5, -43 },
  { 5560, 27, 43, 27, 0, -43 },
  { 5706, 43, 43, 45, 1, -43 },
  { 5938, 25, 43, 25, 0, -43 },
  { 6073, 24, 43, 24, 0, -43 },
  { 6202, 21, 43, 25, 2, -43 },
  { 6315, 12, 53, 19, 5, -43 },
  { 6395, 19, 43, 21, 1, -43 },
  { 6498, 12, 53, 19, 2, -43 },
  { 6578, 25, 23, 28, 1, -43 },
  { 6650, 25, 3, 25, 0, 5 },
  { 6660, 11, 10, 15, 2, -46 },
  { 6674, 20, 34, 26, 2, -33 },
  { 6759, 23, 47, 29, 4, -46 },
  { 6895, 18, 34, 22, 3, -33 },
  { 6972, 22, 47, 29, 3, -46 },
  { 7102, 21, 34, 27, 3, -33 },
  { 7192, 16, 46, 15, 1, -46 },
  { 7284, 22, 47, 29, 3, -33 },
  { 7414, 21, 46, 29, 4, -46 },
  { 7535, 4, 44, 12, 4, -44 },
  { 7557, 9, 58, 12, -1, -44 },
  { 7623, 20, 46, 24, 4, -46 },
  { 7738, 4, 46, 12, 4, -46 },
  { 7761, 35, 33, 43, 4, -33 },
  { 7906, 21, 33, 29, 4, -33 },
  { 7993, 23, 34, 28, 3, -33 },
  { 8091, 23, 47, 29, 4, -33 },
  { 8227, 22, 47, 29, 3, -33 },
  { 8357, 14, 32, 19, 4, -32 },
  { 8413, 18, 34, 22, 2, -33 },
  { 8490, 14, 40, 16, 1, -39 },
  { 8560, 20, 33, 29, 4, -32 },
  { 8643, 22, 32, 22, 0, -32 },
  { 8731, 35, 32, 37, 1, -32 },
  { 8871, 21, 32, 24, 1, -32 },
  { 8955, 22, 46, 23, 1, -32 },
  { 9082, 16, 32, 20, 2, -32 },
  { 9146, 17, 53, 21, 2, -43 },
  { 9259, 3, 60, 26, 12, -46 },
  { 9282, 16, 53, 21, 3, -43 },
  { 9388, 24, 6, 28, 2, -24 },
};

const GFXfont NotoSans_Condensed_Light60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_LIGHT60PT7B_H_
