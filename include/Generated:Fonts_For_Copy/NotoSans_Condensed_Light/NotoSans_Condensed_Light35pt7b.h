#ifndef _NOTOSANS_CONDENSED_LIGHT35PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light35pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x1F, 0x60, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x43, 0x42, 0x02, 0x08, 0x06, 0x08,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x04, 0x18, 0x04, 0x10, 0x7F, 0xFF,
  0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30,
  0x08, 0x20, 0x18, 0x20, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x10, 0x60, 0x10, 0x40, 0x10, 0x40, 0x30, 0x40, 0x30, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x01, 0xFC, 0x7F, 0xFE, 0x62, 0xC6, 0x08, 0x60, 0x86, 0x08,
  0x60, 0xC6, 0x0C, 0x60, 0x76, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x06, 0xE0,
  0x63, 0x06, 0x30, 0x61, 0x06, 0x10, 0x63, 0x06, 0x3C, 0x6E, 0xFF, 0xC1,
  0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7C, 0x03, 0x06, 0x60, 0x60, 0xC6,
  0x06, 0x0C, 0x20, 0x40, 0x83, 0x0C, 0x08, 0x30, 0x80, 0x83, 0x18, 0x08,
  0x31, 0x80, 0x83, 0x10, 0x08, 0x33, 0x00, 0x83, 0x23, 0xCC, 0x26, 0x66,
  0xC6, 0x64, 0x26, 0x64, 0xC3, 0x7C, 0xCC, 0x30, 0x08, 0xC3, 0x01, 0x8C,
  0x30, 0x18, 0xC3, 0x01, 0x0C, 0x30, 0x30, 0xC3, 0x02, 0x0C, 0x30, 0x60,
  0xC3, 0x06, 0x04, 0x20, 0x40, 0x66, 0x0C, 0x03, 0xC0, 0x0F, 0xC0, 0x0E,
  0x60, 0x06, 0x18, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0x41, 0x80,
  0x30, 0xC0, 0x18, 0xC0, 0x06, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xF0,
  0x01, 0xDC, 0x00, 0xC6, 0x0C, 0xC1, 0x86, 0x60, 0x62, 0x60, 0x33, 0x30,
  0x0D, 0x98, 0x03, 0x86, 0x01, 0xC3, 0x00, 0xE1, 0xC0, 0xD8, 0x7B, 0xC6,
  0x1F, 0xC3, 0x80, 0xFF, 0xF5, 0x40, 0x0E, 0x10, 0x61, 0x83, 0x0C, 0x18,
  0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x81, 0x80, 0xC0, 0xC0,
  0xC1, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0x61, 0x83, 0x0C,
  0x30, 0x00, 0x0C, 0x00, 0x80, 0x10, 0x02, 0x08, 0x47, 0xFF, 0xC7, 0xC0,
  0x70, 0x1B, 0x06, 0x31, 0xC6, 0x10, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x33, 0x37, 0x66, 0x64, 0xC0, 0xFF, 0x7F, 0x80, 0x00, 0x60, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x70,
  0xE6, 0x06, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x60, 0x66, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x06, 0x1C,
  0x7B, 0xBE, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1F, 0xC3, 0xEF, 0x18,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC7, 0xCF, 0x18, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x38, 0x3F, 0x01, 0xFC, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x1E, 0x01, 0xDF, 0x3C, 0x7F, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x6C, 0x00, 0x98, 0x03, 0x30, 0x04, 0x60, 0x18,
  0xC0, 0x61, 0x80, 0xC3, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0xC0, 0x61, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x8F, 0xFC, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x06, 0x80, 0xEF, 0x3C, 0x7F, 0x80, 0x07, 0xE1, 0xF6, 0x38, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x30, 0xDF, 0xCF,
  0x8E, 0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x60, 0x36, 0x03, 0x70, 0x63, 0x9E, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0x0F, 0xC0, 0xF3, 0xC3, 0x03, 0x18, 0x06, 0x60, 0x19, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x30, 0x30, 0x61, 0xC0, 0xCC, 0x01, 0xE0, 0x0F,
  0xC0, 0x73, 0x83, 0x07, 0x18, 0x0E, 0x60, 0x19, 0x80, 0x6C, 0x00, 0xF0,
  0x03, 0x60, 0x19, 0x80, 0x67, 0x03, 0x8F, 0x3C, 0x1F, 0xE0, 0x0F, 0xC1,
  0xEF, 0x0C, 0x1C, 0xC0, 0x66, 0x03, 0x30, 0x0D, 0x80, 0x78, 0x03, 0x40,
  0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x77, 0x03, 0x9C, 0x6C, 0x7F, 0x60, 0x43,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x04,
  0x78, 0x3F, 0x00, 0x7F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x7D, 0x80, 0x37,
  0x72, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x66, 0x66, 0x4C, 0x00,
  0x0C, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x7E, 0x3D, 0xE8,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xE0, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x3E, 0x78, 0x03, 0x80,
  0x60, 0x30, 0x01, 0x83, 0x80, 0x06, 0x18, 0x00, 0x19, 0x80, 0x00, 0xCC,
  0x0F, 0xC2, 0x41, 0xCE, 0x1E, 0x0C, 0x30, 0xF0, 0xC1, 0x87, 0x86, 0x0C,
  0x3C, 0x20, 0x61, 0xE1, 0x02, 0x0F, 0x08, 0x10, 0x78, 0x40, 0x83, 0xC2,
  0x0C, 0x1E, 0x18, 0x60, 0xB0, 0xC3, 0x8D, 0x83, 0xE6, 0xCC, 0x0F, 0x3C,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x08, 0x03, 0xE7, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x68, 0x00, 0x36, 0x00, 0x13, 0x00, 0x19, 0x80, 0x0C, 0x60,
  0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x86,
  0x00, 0xC6, 0x00, 0x63, 0x00, 0x39, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x80, 0xFF, 0x87, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x36, 0x01, 0xB0, 0x39, 0xFF, 0x8F, 0xFC, 0x60, 0x3B,
  0x00, 0xD8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x01, 0xDF, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0x3E, 0xF1, 0xC0, 0x4E,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xEF,
  0x07, 0xF8, 0xFF, 0x01, 0xFF, 0xC3, 0x03, 0xC6, 0x01, 0xCC, 0x01, 0x98,
  0x03, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x3C, 0x7F, 0xE0, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x7F, 0xEF, 0xFD, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0F, 0xFD, 0xFF, 0xB0, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x03,
  0xFE, 0x0F, 0xDF, 0x1C, 0x01, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0x60,
  0x01, 0x60, 0x01, 0x30, 0x01, 0x38, 0x01, 0x1C, 0x01, 0x0F, 0xDF, 0x03,
  0xFE, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xFE, 0x70, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0xFE, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xD3, 0xBE, 0x00, 0xC0,
  0x3E, 0x01, 0xB0, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0xC3, 0x0E, 0x18, 0x60,
  0xC6, 0x06, 0x60, 0x33, 0x01, 0xB8, 0x0F, 0xC0, 0x73, 0x03, 0x1C, 0x18,
  0x60, 0xC3, 0x86, 0x0C, 0x30, 0x31, 0x81, 0x8C, 0x06, 0x60, 0x33, 0x00,
  0xD8, 0x07, 0xC0, 0x18, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFD, 0x80, 0x1B, 0xD8, 0x01, 0xBD, 0x80, 0x1B, 0xC8, 0x03, 0x3C, 0xC0,
  0x33, 0xCC, 0x03, 0x3C, 0x40, 0x63, 0xC6, 0x06, 0x3C, 0x60, 0x63, 0xC2,
  0x0C, 0x3C, 0x30, 0xC3, 0xC3, 0x0C, 0x3C, 0x11, 0x83, 0xC1, 0x98, 0x3C,
  0x19, 0x83, 0xC0, 0x90, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0xC0, 0x60, 0x30, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x7B, 0x00, 0xF6, 0x01, 0xE6, 0x03, 0xCC, 0x07, 0x8C, 0x0F, 0x18, 0x1E,
  0x18, 0x3C, 0x30, 0x78, 0x30, 0xF0, 0x61, 0xE0, 0x63, 0xC0, 0xC7, 0x80,
  0xCF, 0x01, 0x9E, 0x01, 0xBC, 0x03, 0x78, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0E, 0x07, 0xF0, 0x0F, 0xBE, 0x0E, 0x03, 0x86, 0x00, 0xC7, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x31, 0x80,
  0x30, 0x60, 0x38, 0x3E, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xFC, 0xC0,
  0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x06, 0xC1, 0xEF, 0xF8, 0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0xBE, 0x0E, 0x03, 0x86, 0x00, 0xC7, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xD8, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x31, 0x80, 0x30, 0x60, 0x38, 0x3E,
  0xF8, 0x07, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0xFF, 0x07, 0xFE, 0x30, 0x39, 0x80, 0xEC, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x19, 0x81, 0xCF,
  0xFC, 0x7F, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x0E, 0x30, 0x31, 0x81,
  0xCC, 0x06, 0x60, 0x3B, 0x00, 0xD8, 0x07, 0xC0, 0x18, 0x1F, 0xE7, 0xFF,
  0x60, 0x2C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x80, 0xEF, 0xFC, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x67, 0x03, 0x8F,
  0xBC, 0x1F, 0xE0, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x04,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xD8, 0x03, 0x00, 0x76,
  0x00, 0xE0, 0x19, 0x80, 0x78, 0x06, 0x60, 0x1E, 0x01, 0x8C, 0x07, 0x80,
  0x63, 0x01, 0x20, 0x30, 0xC0, 0xCC, 0x0C, 0x30, 0x33, 0x03, 0x04, 0x0C,
  0xC0, 0xC1, 0x83, 0x10, 0x60, 0x60, 0x86, 0x18, 0x18, 0x61, 0x86, 0x06,
  0x18, 0x61, 0x80, 0xC6, 0x18, 0x60, 0x31, 0x02, 0x30, 0x0C, 0xC0, 0xCC,
  0x03, 0x30, 0x33, 0x00, 0x4C, 0x0C, 0xC0, 0x1B, 0x01, 0x60, 0x06, 0x80,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x00, 0x60, 0x0C, 0xC0, 0x73, 0x01, 0x86, 0x06, 0x18, 0x30,
  0x60, 0xC0, 0xC6, 0x03, 0x18, 0x06, 0xC0, 0x1B, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0x60, 0x31, 0x81, 0x83,
  0x06, 0x0C, 0x30, 0x30, 0xC0, 0x66, 0x01, 0x98, 0x03, 0xE0, 0x0C, 0xC0,
  0x0D, 0x80, 0x36, 0x01, 0x98, 0x06, 0x30, 0x30, 0xC0, 0xC1, 0x83, 0x06,
  0x18, 0x18, 0x60, 0x31, 0x00, 0xCC, 0x01, 0xB0, 0x07, 0x80, 0x1E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0x80, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x60, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x78,
  0x01, 0xB0, 0x0C, 0xC0, 0x31, 0x81, 0x86, 0x06, 0x0C, 0x30, 0x30, 0xC0,
  0x46, 0x01, 0x98, 0x02, 0xC0, 0x0F, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE1, 0x83, 0x06, 0x0C, 0x10, 0x0F, 0x83, 0xFC, 0x20, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x07, 0xF1, 0xFF, 0x30, 0x36, 0x03, 0x60,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x60, 0xF7, 0x1B, 0x3F, 0x30, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x8F,
  0x84, 0xFE, 0x2C, 0x39, 0x40, 0xCC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06,
  0x80, 0x14, 0x00, 0xE0, 0x05, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x0E, 0xA0, 0x65, 0xCE, 0x27, 0xE0, 0x0F, 0xC7, 0xF3, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x70, 0x0F, 0x31, 0xFC, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0F, 0x19, 0xFC, 0xDC, 0x16,
  0xC0, 0xFE, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xEC, 0x07, 0x60, 0x59, 0xCE,
  0xC7, 0xE6, 0x0F, 0x03, 0xFC, 0x70, 0xE6, 0x06, 0xC0, 0x2C, 0x03, 0xC0,
  0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x13, 0x8E, 0x1F, 0xE0, 0x03, 0x83, 0xF0, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x3F, 0x3F, 0xC1, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x0F, 0x19, 0xFC, 0xDC, 0x16, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xEC, 0x07, 0x60, 0x59, 0xCE, 0xC7, 0xE6,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x80, 0x73, 0x8F, 0x1F,
  0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x8F, 0x93, 0xFA, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x5F, 0xA0, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6C, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x86, 0x9B, 0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0xD0, 0x1A, 0x06, 0x41, 0x88, 0x61, 0x0C, 0x23, 0x04,
  0xC0, 0x9C, 0x17, 0x83, 0xB8, 0x63, 0x08, 0x31, 0x06, 0x20, 0x64, 0x0C,
  0x80, 0xD0, 0x1A, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x8F, 0x07, 0x89, 0xF8, 0xFC, 0xA0, 0xD0, 0x6E, 0x0F, 0x06, 0xC0, 0x60,
  0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06,
  0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80,
  0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x38, 0x06, 0x03, 0x80, 0x60, 0x30,
  0x8F, 0x93, 0xFA, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x0F, 0x81, 0xFE, 0x1C, 0x18, 0xC0, 0x6C, 0x03, 0x60,
  0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xCC, 0x06, 0x60, 0x61, 0xCF, 0x07, 0xF0, 0x8F, 0x84,
  0xFE, 0x2C, 0x39, 0x40, 0xCC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x16, 0x00, 0xF0, 0x05, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xDC, 0x0E,
  0xA0, 0x65, 0xCE, 0x33, 0xE1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x0F, 0x19, 0xFC, 0xDC, 0x16, 0xC0,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0x60, 0x59, 0xCE, 0xC7,
  0xE6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x8F, 0x9F, 0xB0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x87, 0xF9,
  0x81, 0x30, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x80, 0xDE, 0x79, 0xFE, 0x00,
  0x30, 0x30, 0x30, 0x30, 0x7F, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x39, 0x1F, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x36, 0x07, 0x60,
  0x53, 0x99, 0x3F, 0x10, 0xC0, 0x1E, 0x00, 0xD8, 0x0C, 0xC0, 0x66, 0x03,
  0x10, 0x10, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC6, 0x06, 0x30, 0x31, 0x80,
  0x88, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x05, 0x00, 0x38, 0x01, 0xC0, 0xC0,
  0x30, 0x1B, 0x03, 0x80, 0xD8, 0x1C, 0x06, 0xC0, 0xF0, 0x66, 0x05, 0x83,
  0x18, 0x6C, 0x18, 0xC3, 0x20, 0xC6, 0x19, 0x84, 0x30, 0x8C, 0x60, 0x8C,
  0x63, 0x06, 0x61, 0x18, 0x33, 0x0C, 0x81, 0x98, 0x6C, 0x0C, 0x83, 0x60,
  0x3C, 0x1B, 0x01, 0xE0, 0x50, 0x0F, 0x03, 0x80, 0x70, 0x1C, 0x01, 0x80,
  0xE0, 0xC0, 0x3E, 0x06, 0x60, 0x63, 0x0C, 0x30, 0xC1, 0x98, 0x19, 0x80,
  0xF0, 0x0F, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x19, 0x81, 0x98, 0x30, 0xC7,
  0x0C, 0x60, 0x6C, 0x06, 0xC0, 0x30, 0xC0, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x62, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x30,
  0x11, 0x80, 0xCC, 0x06, 0xC0, 0x16, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x04, 0xC0,
  0x3E, 0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x3F,
  0xFF, 0xFC, 0x01, 0xC1, 0xF0, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x0F, 0x83, 0xC0, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x07, 0x00, 0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x3E, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x3C, 0x07, 0x07, 0x01,
  0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x3E, 0x0C, 0x00, 0x7E, 0x07, 0xBE, 0x38, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_Light35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 25, 8, 2, -25 },
  { 11, 8, 9, 12, 2, -25 },
  { 20, 16, 25, 18, 1, -25 },
  { 70, 12, 29, 16, 2, -27 },
  { 114, 20, 25, 24, 2, -25 },
  { 177, 17, 25, 18, 1, -25 },
  { 231, 2, 9, 7, 2, -25 },
  { 234, 7, 31, 10, 2, -25 },
  { 262, 7, 31, 10, 1, -25 },
  { 290, 11, 12, 15, 2, -27 },
  { 307, 14, 17, 16, 1, -21 },
  { 337, 4, 9, 7, 1, -4 },
  { 342, 8, 1, 10, 1, -10 },
  { 343, 3, 3, 8, 2, -3 },
  { 345, 11, 25, 12, 1, -25 },
  { 380, 12, 25, 16, 2, -25 },
  { 418, 7, 25, 16, 3, -25 },
  { 440, 13, 25, 16, 1, -25 },
  { 481, 13, 25, 16, 1, -25 },
  { 522, 15, 25, 16, 1, -25 },
  { 569, 12, 25, 16, 2, -25 },
  { 607, 12, 25, 16, 2, -25 },
  { 645, 13, 25, 16, 1, -25 },
  { 686, 14, 25, 16, 1, -25 },
  { 730, 13, 25, 16, 1, -25 },
  { 771, 3, 19, 8, 2, -19 },
  { 779, 4, 24, 8, 1, -19 },
  { 791, 14, 15, 16, 1, -20 },
  { 818, 14, 9, 16, 1, -17 },
  { 834, 14, 15, 16, 1, -20 },
  { 861, 10, 25, 12, 1, -25 },
  { 893, 21, 28, 25, 2, -25 },
  { 967, 17, 25, 17, 0, -25 },
  { 1021, 13, 25, 18, 3, -25 },
  { 1062, 14, 25, 17, 2, -25 },
  { 1106, 15, 25, 20, 3, -25 },
  { 1153, 11, 25, 15, 3, -25 },
  { 1188, 11, 25, 14, 3, -25 },
  { 1223, 16, 25, 21, 2, -25 },
  { 1273, 14, 25, 20, 3, -25 },
  { 1317, 7, 25, 9, 1, -25 },
  { 1339, 7, 31, 8, -2, -25 },
  { 1367, 13, 25, 16, 3, -25 },
  { 1408, 10, 25, 14, 3, -25 },
  { 1440, 20, 25, 26, 3, -25 },
  { 1503, 15, 25, 21, 3, -25 },
  { 1550, 17, 25, 21, 2, -25 },
  { 1604, 12, 25, 16, 3, -25 },
  { 1642, 17, 31, 21, 2, -25 },
  { 1708, 13, 25, 17, 3, -25 },
  { 1749, 12, 25, 16, 2, -25 },
  { 1787, 14, 25, 14, 0, -25 },
  { 1831, 14, 25, 20, 3, -25 },
  { 1875, 16, 25, 16, 0, -25 },
  { 1925, 26, 25, 26, 0, -25 },
  { 2007, 14, 25, 15, 0, -25 },
  { 2051, 14, 25, 14, 0, -25 },
  { 2095, 13, 25, 14, 1, -25 },
  { 2136, 7, 31, 11, 3, -25 },
  { 2164, 11, 25, 12, 1, -25 },
  { 2199, 7, 31, 11, 1, -25 },
  { 2227, 14, 14, 16, 1, -25 },
  { 2252, 15, 2, 15, 0, 3 },
  { 2256, 6, 6, 9, 1, -27 },
  { 2261, 12, 19, 15, 1, -19 },
  { 2290, 13, 27, 17, 3, -27 },
  { 2334, 10, 19, 13, 2, -19 },
  { 2358, 13, 27, 17, 2, -27 },
  { 2402, 12, 19, 16, 2, -19 },
  { 2431, 10, 27, 9, 0, -27 },
  { 2465, 13, 27, 17, 2, -19 },
  { 2509, 11, 27, 17, 3, -27 },
  { 2547, 3, 26, 7, 2, -26 },
  { 2557, 6, 34, 7, -1, -26 },
  { 2583, 11, 27, 14, 3, -27 },
  { 2621, 2, 27, 7, 3, -27 },
  { 2628, 20, 19, 25, 3, -19 },
  { 2676, 11, 19, 17, 3, -19 },
  { 2703, 13, 19, 17, 2, -19 },
  { 2734, 13, 27, 17, 3, -19 },
  { 2778, 13, 27, 17, 2, -19 },
  { 2822, 8, 19, 11, 3, -19 },
  { 2841, 11, 19, 13, 1, -19 },
  { 2868, 8, 23, 9, 1, -23 },
  { 2891, 12, 19, 17, 2, -19 },
  { 2920, 13, 19, 13, 0, -19 },
  { 2951, 21, 19, 21, 0, -19 },
  { 3001, 12, 19, 14, 1, -19 },
  { 3030, 13, 27, 13, 0, -19 },
  { 3074, 10, 19, 12, 1, -19 },
  { 3098, 10, 31, 12, 1, -25 },
  { 3137, 2, 35, 15, 7, -27 },
  { 3146, 10, 31, 12, 1, -25 },
  { 3185, 14, 3, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Light35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_LIGHT35PT7B_H_
