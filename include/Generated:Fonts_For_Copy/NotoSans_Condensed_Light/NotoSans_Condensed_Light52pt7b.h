#ifndef _NOTOSANS_CONDENSED_LIGHT52PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x00, 0x00, 0x6F, 0xFF, 0xF0, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x60, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60,
  0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x01, 0xC0,
  0x60, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80, 0x06, 0x03,
  0x80, 0x06, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1,
  0xE3, 0x0E, 0x78, 0x60, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x70, 0x30, 0x0E,
  0x06, 0x01, 0xC0, 0xC0, 0x38, 0x18, 0x03, 0x83, 0x00, 0x70, 0x60, 0x07,
  0x0C, 0x00, 0xF9, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0x7C, 0x00, 0x63, 0xC0, 0x0C, 0x38, 0x01, 0x83, 0x80,
  0x30, 0x70, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x07, 0x00,
  0x60, 0xE0, 0x0C, 0x3B, 0x01, 0x8F, 0x7F, 0x3F, 0xCF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x06, 0x00, 0xFF, 0x80,
  0x1C, 0x01, 0xC7, 0x00, 0x30, 0x07, 0x07, 0x00, 0xE0, 0x0E, 0x0E, 0x01,
  0x80, 0x18, 0x0C, 0x03, 0x00, 0x30, 0x18, 0x0E, 0x00, 0x60, 0x30, 0x18,
  0x01, 0xC0, 0x70, 0x70, 0x03, 0x80, 0xE0, 0xC0, 0x07, 0x01, 0xC1, 0x80,
  0x0E, 0x03, 0x87, 0x00, 0x1C, 0x07, 0x0C, 0x00, 0x38, 0x0E, 0x38, 0x00,
  0x30, 0x18, 0x60, 0xE0, 0x60, 0x31, 0xC7, 0xF0, 0xC0, 0x63, 0x9E, 0xF1,
  0xC1, 0xC6, 0x38, 0x63, 0x83, 0x9C, 0x60, 0xE3, 0x8E, 0x31, 0xC0, 0xC7,
  0xF8, 0xE3, 0x01, 0x87, 0xF1, 0xC6, 0x03, 0x83, 0x03, 0x0C, 0x07, 0x00,
  0x0E, 0x18, 0x0E, 0x00, 0x18, 0x30, 0x1C, 0x00, 0x70, 0x60, 0x38, 0x00,
  0xE0, 0xC0, 0x70, 0x01, 0x81, 0x80, 0xE0, 0x07, 0x03, 0x01, 0xC0, 0x0C,
  0x06, 0x03, 0x80, 0x38, 0x0C, 0x06, 0x00, 0x70, 0x1C, 0x0C, 0x00, 0xC0,
  0x38, 0x18, 0x03, 0x80, 0x30, 0x70, 0x06, 0x00, 0x71, 0xC0, 0x1C, 0x00,
  0x7F, 0x80, 0x38, 0x00, 0x7E, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE7, 0x00, 0x01,
  0xE3, 0xC0, 0x70, 0xE0, 0xE0, 0x38, 0xE0, 0x38, 0x1C, 0x70, 0x0E, 0x0E,
  0x70, 0x07, 0x86, 0x38, 0x01, 0xC7, 0x1C, 0x00, 0x73, 0x8E, 0x00, 0x3F,
  0x87, 0x00, 0x0F, 0xC3, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x70, 0x01,
  0xF8, 0x38, 0x00, 0xFC, 0x1E, 0x01, 0xE7, 0x07, 0xC3, 0xE3, 0xC1, 0xFF,
  0xE0, 0xF0, 0x7F, 0xC0, 0x3C, 0x02, 0x00, 0x00, 0xFE, 0xEE, 0x66, 0x66,
  0x66, 0x66, 0x60, 0x01, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1E, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x06, 0x0C, 0x1B, 0xF3, 0x3E, 0xFF, 0xFF, 0xC1, 0xFE,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x30, 0x01, 0x8E, 0x00, 0xE1, 0xC0,
  0x70, 0x38, 0x1C, 0x0E, 0x02, 0x01, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x3C, 0xF3,
  0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x86, 0x38, 0xC0, 0xFF, 0xFF, 0xFC, 0x33,
  0xFE, 0xF7, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x07, 0x87, 0x81, 0xE0, 0x78, 0x38, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC3,
  0x80, 0x70, 0x78, 0x1E, 0x07, 0xCF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xF1, 0xEE, 0x79, 0xDE, 0x3F, 0x87, 0x40,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x3E, 0x07,
  0x87, 0x00, 0x78, 0x40, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x7C, 0x07, 0x86, 0x00, 0x38, 0x80, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7A, 0x00, 0x1E, 0x78, 0x0F, 0x8F,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00,
  0x01, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x71, 0x80, 0x01, 0xC6, 0x00, 0x0E,
  0x18, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x38, 0x18,
  0x00, 0xC0, 0x60, 0x07, 0x01, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0x60, 0x1C, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x00, 0x18, 0x1C, 0x00,
  0x60, 0x60, 0x01, 0x83, 0x80, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1C, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0xA0, 0x03, 0xCF, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xC0,
  0x40, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x0F, 0xC0, 0xE7, 0xFE, 0x1D, 0xF7, 0xE3, 0xF0, 0x1E,
  0x6C, 0x01, 0xCF, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1D,
  0xC0, 0x03, 0x98, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x70,
  0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xE0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x70, 0x00, 0xC7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x38, 0x01,
  0xC3, 0x80, 0x3C, 0x1C, 0x03, 0x80, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x3F,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0x1E, 0x01, 0xE0, 0xF8, 0x3C,
  0x03, 0x83, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x1E, 0x38, 0x03, 0xC3, 0xE0, 0x78, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x70, 0x07, 0x1C, 0x00, 0x73, 0x80,
  0x0E, 0x70, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00,
  0x3D, 0xC0, 0x07, 0x9C, 0x01, 0xF3, 0xC0, 0x6E, 0x3F, 0xFD, 0xC3, 0xFF,
  0x38, 0x1F, 0x87, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x10, 0x3E, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x01, 0x80, 0x00, 0x73, 0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xDE, 0xE0, 0x38, 0xF3, 0xCF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xCF, 0x38, 0xE3, 0x8E, 0x71, 0xC7, 0x18, 0xE3, 0x8C, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0xE7, 0x83,
  0xE4, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C,
  0x18, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x38, 0xC0, 0x0F, 0xC0, 0x73,
  0x80, 0x7F, 0xE0, 0x67, 0x01, 0xE1, 0xC0, 0xCC, 0x07, 0x03, 0x81, 0xF8,
  0x0E, 0x07, 0x03, 0xF0, 0x38, 0x0E, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0x80,
  0xC0, 0x38, 0x0F, 0x03, 0x80, 0x70, 0x1E, 0x07, 0x00, 0xC0, 0x3C, 0x0E,
  0x01, 0x80, 0x78, 0x1C, 0x03, 0x01, 0xF0, 0x38, 0x06, 0x03, 0xE0, 0x70,
  0x1C, 0x07, 0xC0, 0xE0, 0x38, 0x0F, 0x80, 0xC0, 0x70, 0x1B, 0x01, 0x80,
  0xB0, 0x77, 0x03, 0x83, 0x60, 0xEE, 0x03, 0x8E, 0xE3, 0x9C, 0x07, 0xF8,
  0xFE, 0x18, 0x07, 0xE0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x30, 0xE0, 0x00, 0x38,
  0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x9C, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x78, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xE0, 0x7F, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x78,
  0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x0E, 0x00, 0x7C, 0xE0, 0x01,
  0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xFE, 0x0F, 0xC0, 0xE0, 0xF8, 0x01, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x02, 0x0F, 0xC0, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x38, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0E, 0x0F, 0xF8, 0x38, 0x01, 0xF0, 0xE0,
  0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE, 0x00,
  0x0F, 0x38, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x3E, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xE0, 0x1F, 0x07, 0x80,
  0x02, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0x70, 0x00, 0x03, 0x70, 0x00,
  0x03, 0x78, 0x00, 0x03, 0x38, 0x00, 0x03, 0x3C, 0x00, 0x03, 0x1E, 0x00,
  0x03, 0x0F, 0x00, 0x03, 0x0F, 0x80, 0x03, 0x03, 0xF0, 0x1F, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3E, 0x1E, 0xFF, 0x3F, 0x83, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8E,
  0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0,
  0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0xF8, 0x00, 0xEF, 0xC0, 0x0F, 0xDE,
  0x00, 0xF8, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xEF, 0xB0, 0x00, 0x03, 0xBE, 0xE0, 0x00, 0x0F,
  0xFB, 0x80, 0x00, 0x37, 0xE6, 0x00, 0x01, 0xDF, 0x9C, 0x00, 0x07, 0x7E,
  0x70, 0x00, 0x19, 0xF8, 0xC0, 0x00, 0xE7, 0xE3, 0x80, 0x03, 0x9F, 0x8E,
  0x00, 0x0C, 0x7E, 0x38, 0x00, 0x71, 0xF8, 0x70, 0x01, 0xC7, 0xE1, 0xC0,
  0x06, 0x1F, 0x87, 0x00, 0x38, 0x7E, 0x0E, 0x00, 0xE1, 0xF8, 0x38, 0x03,
  0x07, 0xE0, 0xE0, 0x1C, 0x1F, 0x81, 0xC0, 0x70, 0x7E, 0x07, 0x01, 0x81,
  0xF8, 0x1C, 0x0E, 0x07, 0xE0, 0x38, 0x38, 0x1F, 0x80, 0xE0, 0xC0, 0x7E,
  0x03, 0x87, 0x01, 0xF8, 0x07, 0x1C, 0x07, 0xE0, 0x1C, 0x60, 0x1F, 0x80,
  0x73, 0x80, 0x7E, 0x00, 0xCE, 0x01, 0xF8, 0x03, 0xB0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x1C, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFB, 0x80,
  0x03, 0xF7, 0x80, 0x07, 0xE7, 0x00, 0x0F, 0xCF, 0x00, 0x1F, 0x8E, 0x00,
  0x3F, 0x1E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x3C, 0x01, 0xF8, 0x38, 0x03,
  0xF0, 0x78, 0x07, 0xE0, 0x70, 0x0F, 0xC0, 0xF0, 0x1F, 0x80, 0xE0, 0x3F,
  0x01, 0xE0, 0x7E, 0x01, 0xC0, 0xFC, 0x03, 0xC1, 0xF8, 0x03, 0x83, 0xF0,
  0x07, 0x87, 0xE0, 0x07, 0x0F, 0xC0, 0x0F, 0x1F, 0x80, 0x0E, 0x3F, 0x00,
  0x1E, 0x7E, 0x00, 0x1C, 0xFC, 0x00, 0x3D, 0xF8, 0x00, 0x3B, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0xF0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0F,
  0x00, 0x0E, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0E, 0x1F,
  0xF3, 0x80, 0x3E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x01,
  0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x1E, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x3F, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0x00, 0xF8, 0xE0, 0x03, 0x8E, 0x00, 0x3C,
  0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x38, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x0E,
  0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x0F, 0x81, 0xE3, 0xC0, 0x04, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x7B, 0x00, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x1E, 0x78, 0x00, 0x70,
  0xF0, 0x03, 0xC1, 0xF0, 0x3E, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x83, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x77,
  0x00, 0x0F, 0x80, 0x07, 0x38, 0x00, 0x6C, 0x00, 0x39, 0xC0, 0x07, 0x60,
  0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0xE1, 0xC0,
  0x0C, 0xE0, 0x07, 0x0E, 0x00, 0x63, 0x00, 0x38, 0x70, 0x07, 0x18, 0x01,
  0xC3, 0x80, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x70, 0x0C,
  0x38, 0x07, 0x03, 0x80, 0xE0, 0xC0, 0x38, 0x1C, 0x07, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x38, 0x1C, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x1C, 0x0C, 0x06,
  0x07, 0x00, 0xE0, 0xE0, 0x30, 0x38, 0x07, 0x07, 0x01, 0xC3, 0x80, 0x1C,
  0x38, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x70, 0xE0, 0x07, 0x1C, 0x01, 0x87,
  0x00, 0x38, 0xE0, 0x0E, 0x38, 0x00, 0xC7, 0x00, 0x73, 0x80, 0x07, 0x30,
  0x03, 0x9C, 0x00, 0x39, 0x80, 0x0C, 0xE0, 0x01, 0xDC, 0x00, 0x67, 0x00,
  0x0E, 0xE0, 0x03, 0xB0, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x38,
  0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0,
  0x00, 0x71, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x0E,
  0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0,
  0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38,
  0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFE, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xEC, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0x60, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x18,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xC0, 0x70, 0x1C, 0x07, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xCF, 0x82, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x1F, 0xF8, 0x7F, 0xFC, 0x7C, 0x0E,
  0x78, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x70, 0x0F, 0xBC, 0x0C, 0xCF,
  0xFC, 0x63, 0xFC, 0x30, 0x30, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x1F,
  0x81, 0xCF, 0xFC, 0x3B, 0xE7, 0xC7, 0xE0, 0x3C, 0xF8, 0x03, 0x9E, 0x00,
  0x3B, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x7C, 0x01, 0xCD, 0x80, 0x79, 0x9C, 0x1E,
  0x31, 0xFF, 0x86, 0x1F, 0xE0, 0x00, 0x60, 0x00, 0x03, 0xFC, 0x1F, 0xFC,
  0x7E, 0x79, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x0C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x03, 0xF8, 0x70,
  0x7F, 0xC7, 0x0F, 0x9E, 0x71, 0xE0, 0x37, 0x3C, 0x01, 0xF3, 0x80, 0x1F,
  0x38, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0x38, 0x00, 0xF3, 0x80, 0x1F, 0x1C, 0x03, 0x71,
  0xE0, 0x77, 0x0F, 0xFE, 0x70, 0x7F, 0x87, 0x00, 0x40, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xE3, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x1C, 0x00, 0xE6,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x87, 0x80, 0xE0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x3F, 0xE3, 0xFF, 0x8F, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x03, 0xF8, 0x70, 0x7F, 0xE7, 0x0F, 0x9F, 0x71, 0xE0, 0x37,
  0x3C, 0x01, 0xF3, 0x80, 0x1F, 0x38, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x38, 0x00, 0xF3,
  0x80, 0x1F, 0x1C, 0x03, 0x71, 0xF0, 0x77, 0x0F, 0xFE, 0x70, 0x7F, 0x87,
  0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x20, 0x03, 0xC3, 0x80,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x1F,
  0x87, 0x3F, 0xF3, 0xBE, 0xFD, 0xF8, 0x0E, 0xF8, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x77, 0xF7,
  0x20, 0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x07, 0x07, 0x0F, 0x07, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0xFE, 0xFC, 0x20, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x77,
  0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x38, 0x38, 0x3C,
  0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0xEF,
  0x80, 0x77, 0xC0, 0x3E, 0x70, 0x1F, 0x38, 0x0F, 0x0E, 0x07, 0x07, 0x03,
  0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x07, 0x1C, 0x03,
  0x8E, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF0, 0x0F, 0xC3, 0x1F, 0xF0, 0xFF, 0x8C, 0xF3, 0xE7, 0x9F, 0x36,
  0x03, 0xB8, 0x1E, 0xD8, 0x0F, 0xC0, 0x3B, 0xC0, 0x1E, 0x00, 0xEE, 0x00,
  0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C,
  0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00,
  0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07,
  0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8,
  0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E, 0x00,
  0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C,
  0x00, 0x7E, 0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xC1, 0xF8, 0x63,
  0xFF, 0x33, 0xCF, 0xDB, 0x80, 0xED, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x30, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0x8F, 0x81, 0xE0, 0x3C, 0x3C, 0x01, 0xC3, 0x80, 0x0E,
  0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x67, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x1C, 0x03, 0xC0,
  0xF0, 0x78, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xC1, 0xF8,
  0x18, 0xFF, 0xC3, 0x3C, 0x7C, 0x66, 0x03, 0xCD, 0x80, 0x39, 0xE0, 0x03,
  0xBC, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1D,
  0xE0, 0x03, 0xBC, 0x00, 0x77, 0xC0, 0x1C, 0xF8, 0x07, 0x9D, 0xC1, 0xE3,
  0x9F, 0xF8, 0x71, 0xFE, 0x0E, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x70,
  0x7F, 0xE7, 0x0F, 0x9E, 0x71, 0xE0, 0x37, 0x3C, 0x01, 0xF3, 0x80, 0x1F,
  0x38, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00,
  0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0x38, 0x01, 0xF3, 0x80, 0x1F, 0x1C, 0x03, 0x71,
  0xF0, 0xE7, 0x0F, 0xFE, 0x70, 0x7F, 0x87, 0x00, 0x40, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC1, 0xFC, 0x7F, 0xCF, 0xFC, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xF8, 0x3F, 0xFC, 0xF8,
  0xF3, 0x80, 0x2E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x1F, 0xE0, 0x7B, 0xFF, 0xE3, 0xFF, 0x80,
  0x20, 0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xE1, 0x0F, 0xF0, 0x7F, 0x00, 0x80, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0B, 0x70, 0x0D,
  0xBC, 0x1C, 0xCF, 0xFC, 0x63, 0xFC, 0x30, 0x10, 0x00, 0xE0, 0x00, 0xFC,
  0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x07,
  0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x39, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x1E, 0x00, 0x7E,
  0x00, 0x78, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x60, 0x0F, 0xC0, 0x39, 0xC0,
  0x3F, 0x00, 0xE7, 0x00, 0xCC, 0x03, 0x9C, 0x03, 0x30, 0x0E, 0x30, 0x1C,
  0xE0, 0x30, 0xE0, 0x73, 0x81, 0xC3, 0x81, 0xCE, 0x07, 0x0E, 0x06, 0x18,
  0x1C, 0x38, 0x38, 0x70, 0x60, 0x70, 0xE1, 0xC3, 0x81, 0xC3, 0x87, 0x0E,
  0x07, 0x0C, 0x0C, 0x38, 0x1C, 0x30, 0x38, 0xC0, 0x31, 0xC0, 0xE3, 0x00,
  0xE7, 0x03, 0x9C, 0x03, 0x98, 0x06, 0x70, 0x0E, 0x60, 0x19, 0x80, 0x1B,
  0x80, 0x76, 0x00, 0x6E, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0xC0, 0xF0, 0x01, 0xDC, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x1C, 0x07,
  0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00,
  0x3B, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x70, 0x0E, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0xF0, 0xE0, 0x1C, 0x38, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x1F, 0x80, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0x80, 0x18,
  0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x07,
  0x00, 0xE0, 0x70, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x30,
  0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x03, 0xF0, 0x0F, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x3F, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x00,
  0x17, 0xFE, 0x01, 0xF3, 0xF8, 0x7C, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 37, 12, 4, -37 },
  { 20, 12, 13, 18, 3, -37 },
  { 40, 24, 37, 26, 1, -37 },
  { 151, 19, 43, 24, 2, -40 },
  { 254, 31, 38, 35, 2, -38 },
  { 402, 25, 39, 27, 2, -38 },
  { 524, 4, 13, 10, 3, -37 },
  { 531, 11, 45, 14, 2, -37 },
  { 593, 10, 45, 14, 2, -37 },
  { 650, 18, 18, 22, 2, -40 },
  { 691, 20, 25, 24, 2, -31 },
  { 754, 6, 13, 11, 2, -6 },
  { 764, 11, 2, 15, 2, -15 },
  { 767, 5, 5, 11, 3, -5 },
  { 771, 16, 37, 18, 1, -37 },
  { 845, 19, 38, 24, 2, -38 },
  { 936, 11, 37, 24, 4, -37 },
  { 987, 19, 38, 24, 2, -38 },
  { 1078, 19, 39, 24, 2, -38 },
  { 1171, 22, 37, 24, 1, -37 },
  { 1273, 18, 38, 24, 3, -37 },
  { 1359, 19, 39, 24, 3, -38 },
  { 1452, 19, 37, 24, 2, -37 },
  { 1540, 20, 39, 24, 2, -38 },
  { 1638, 19, 39, 24, 2, -38 },
  { 1731, 5, 28, 11, 3, -28 },
  { 1749, 6, 35, 11, 2, -28 },
  { 1776, 20, 23, 24, 2, -30 },
  { 1834, 20, 13, 24, 2, -25 },
  { 1867, 20, 23, 24, 2, -30 },
  { 1925, 15, 38, 17, 1, -38 },
  { 1997, 31, 42, 37, 3, -37 },
  { 2160, 25, 37, 25, 0, -37 },
  { 2276, 20, 37, 26, 4, -37 },
  { 2369, 21, 39, 25, 3, -38 },
  { 2472, 22, 37, 29, 4, -37 },
  { 2574, 16, 37, 23, 4, -37 },
  { 2648, 16, 37, 21, 4, -37 },
  { 2722, 24, 39, 31, 3, -38 },
  { 2839, 22, 37, 30, 4, -37 },
  { 2941, 10, 37, 14, 2, -37 },
  { 2988, 10, 47, 11, -3, -37 },
  { 3047, 20, 37, 24, 4, -37 },
  { 3140, 16, 37, 21, 4, -37 },
  { 3214, 30, 37, 39, 4, -37 },
  { 3353, 23, 37, 31, 4, -37 },
  { 3460, 25, 39, 31, 3, -38 },
  { 3582, 18, 37, 24, 4, -37 },
  { 3666, 25, 47, 31, 3, -38 },
  { 3813, 20, 37, 25, 4, -37 },
  { 3906, 19, 39, 23, 2, -38 },
  { 3999, 21, 37, 21, 0, -37 },
  { 4097, 22, 38, 30, 4, -37 },
  { 4202, 24, 37, 24, 0, -37 },
  { 4313, 37, 37, 39, 1, -37 },
  { 4485, 22, 37, 22, 0, -37 },
  { 4587, 21, 37, 21, 0, -37 },
  { 4685, 18, 37, 21, 2, -37 },
  { 4769, 11, 45, 16, 4, -37 },
  { 4831, 16, 37, 18, 1, -37 },
  { 4905, 10, 45, 16, 2, -37 },
  { 4962, 22, 20, 24, 1, -37 },
  { 5017, 22, 2, 22, 0, 5 },
  { 5023, 9, 8, 13, 2, -40 },
  { 5032, 17, 29, 23, 2, -28 },
  { 5094, 19, 41, 25, 4, -40 },
  { 5192, 15, 29, 19, 3, -28 },
  { 5247, 20, 41, 25, 2, -40 },
  { 5350, 18, 29, 23, 3, -28 },
  { 5416, 14, 40, 13, 1, -40 },
  { 5486, 20, 41, 25, 2, -28 },
  { 5589, 17, 40, 25, 4, -40 },
  { 5674, 4, 38, 11, 3, -38 },
  { 5693, 8, 51, 11, -1, -38 },
  { 5744, 17, 40, 21, 4, -40 },
  { 5829, 3, 40, 11, 4, -40 },
  { 5844, 30, 28, 37, 4, -28 },
  { 5949, 17, 28, 25, 4, -28 },
  { 6009, 20, 29, 25, 2, -28 },
  { 6082, 19, 40, 25, 4, -28 },
  { 6177, 20, 40, 25, 2, -28 },
  { 6277, 12, 28, 16, 4, -28 },
  { 6319, 15, 29, 19, 2, -28 },
  { 6374, 12, 35, 14, 1, -34 },
  { 6427, 17, 29, 25, 4, -28 },
  { 6489, 19, 28, 19, 0, -28 },
  { 6556, 30, 28, 32, 1, -28 },
  { 6661, 18, 28, 20, 1, -28 },
  { 6724, 20, 41, 20, 0, -28 },
  { 6827, 14, 28, 17, 2, -28 },
  { 6876, 14, 45, 18, 2, -37 },
  { 6955, 3, 53, 23, 10, -40 },
  { 6975, 14, 45, 18, 2, -37 },
  { 7054, 20, 5, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Light52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_LIGHT52PT7B_H_
