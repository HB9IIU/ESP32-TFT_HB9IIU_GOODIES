#ifndef _NOTOSANS_CONDENSED_LIGHT37PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x06, 0xF8, 0xE3,
  0xE3, 0xE3, 0x43, 0x43, 0x43, 0x43, 0x43, 0x43, 0x03, 0x0C, 0x01, 0x06,
  0x00, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x40, 0x18, 0x20, 0xFF,
  0xFF, 0x7F, 0xFF, 0x82, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x00,
  0x60, 0x80, 0x30, 0xC0, 0x18, 0x60, 0xFF, 0xFF, 0x7F, 0xFF, 0x86, 0x0C,
  0x03, 0x04, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x10,
  0x60, 0x18, 0x30, 0x00, 0x02, 0x00, 0x10, 0x01, 0x80, 0x7F, 0xE7, 0x27,
  0x71, 0x03, 0x08, 0x18, 0x40, 0xC2, 0x06, 0x10, 0x30, 0x81, 0xC4, 0x07,
  0x20, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x02, 0xF0, 0x11, 0x80, 0x86, 0x04,
  0x30, 0x21, 0x81, 0x0C, 0x08, 0x60, 0x46, 0xE2, 0xF7, 0xFE, 0x03, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x83, 0xF0, 0x08, 0x19, 0x80,
  0xC1, 0x86, 0x06, 0x0C, 0x30, 0x60, 0x61, 0x83, 0x02, 0x04, 0x10, 0x10,
  0x21, 0x80, 0x81, 0x0C, 0x04, 0x08, 0xC0, 0x20, 0x46, 0x01, 0x86, 0x23,
  0xCC, 0x33, 0x37, 0x61, 0x9B, 0x0D, 0x99, 0x98, 0x6F, 0xCC, 0xC3, 0x18,
  0x46, 0x18, 0x06, 0x20, 0x40, 0x31, 0x02, 0x03, 0x08, 0x10, 0x18, 0x40,
  0x80, 0x82, 0x0C, 0x0C, 0x18, 0x60, 0x40, 0xC3, 0x06, 0x06, 0x18, 0x30,
  0x19, 0x83, 0x00, 0x78, 0x03, 0x80, 0x03, 0xF8, 0x01, 0xC6, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x60,
  0x07, 0x18, 0x00, 0xCC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0x98, 0x00, 0xC7, 0x06, 0x70, 0xC1, 0x98, 0x18, 0x66, 0x07, 0x33, 0x80,
  0xCC, 0xC0, 0x1E, 0x38, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x78, 0x70, 0x3B,
  0x0F, 0xFC, 0xE1, 0xFC, 0x1C, 0xFF, 0xB4, 0x92, 0x40, 0x0E, 0x18, 0x61,
  0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xE0, 0xC1, 0x81, 0x83, 0x03,
  0x03, 0xE0, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xE6, 0x7F, 0xFF, 0x0F, 0x00, 0xF0, 0x1B, 0x01, 0x98,
  0x30, 0xC6, 0x0C, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0xC0, 0xFF, 0xFF, 0x6F, 0x60, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x07,
  0x00, 0xFE, 0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x30, 0x1B, 0x80, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xB0, 0x19, 0x80,
  0xCC, 0x06, 0x30, 0x61, 0xFF, 0x03, 0xE0, 0x07, 0x0F, 0x1B, 0x73, 0xE3,
  0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x03, 0xFE,
  0x3C, 0x38, 0x80, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0x03, 0xFE, 0x38, 0x39, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0xC1, 0xF8, 0x0F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x80, 0x77, 0xDF, 0x3F,
  0xE0, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xB0, 0x01,
  0xB0, 0x01, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x18, 0x30, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x30, 0xC0,
  0x30, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x7F, 0xF3, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x37,
  0xE1, 0xFF, 0xC4, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xD0, 0x0C, 0xFF, 0xE3,
  0xFC, 0x00, 0x01, 0xE0, 0x3F, 0x87, 0x84, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x9F, 0x8D, 0xDF, 0x78,
  0x1B, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x0D, 0x80, 0x6C, 0x06, 0x30, 0x31, 0xEF, 0x03, 0xF0, 0xFF, 0xF8,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6E,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x60, 0x33, 0x01, 0x8C, 0x18, 0x3B,
  0x80, 0xF8, 0x07, 0xC0, 0x67, 0x0E, 0x0C, 0x60, 0x36, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x60, 0x33, 0xEF, 0x87,
  0xF0, 0x0F, 0x01, 0xFE, 0x1C, 0x38, 0xC0, 0xCC, 0x03, 0x60, 0x1B, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xF0, 0x1D,
  0xC1, 0x67, 0xFB, 0x1F, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x1C, 0x01, 0xC3, 0x7C, 0x1F, 0xC0, 0x6F, 0x66, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xF6, 0x31, 0xCE, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0x8C, 0x66, 0x31, 0x88, 0xC0, 0x00,
  0x06, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x00, 0x40, 0x00, 0x1C, 0x3F, 0xCC, 0x38, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x78, 0x3C,
  0x03, 0x80, 0x38, 0x1C, 0x00, 0x70, 0x60, 0x00, 0xC3, 0x00, 0x01, 0x8C,
  0x00, 0x06, 0x60, 0x7F, 0x0D, 0x83, 0x9C, 0x34, 0x18, 0x30, 0xF0, 0x60,
  0xC3, 0xC3, 0x02, 0x0F, 0x0C, 0x08, 0x3C, 0x30, 0x20, 0xF0, 0xC1, 0x83,
  0xC3, 0x06, 0x0F, 0x0C, 0x18, 0x3C, 0x30, 0x60, 0xF0, 0xC1, 0x82, 0xC1,
  0x8F, 0x1B, 0x07, 0xE7, 0xC6, 0x07, 0x0E, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x20, 0x07, 0x8F, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x38, 0x03, 0x0C,
  0x03, 0x06, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x3F,
  0xF8, 0x1F, 0xFE, 0x1C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xE3, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x0C, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0xFF,
  0xE3, 0x07, 0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x7C, 0x01, 0xF0,
  0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x07, 0x3F, 0xF8, 0xFF, 0xE3, 0x01, 0xCC,
  0x01, 0xB0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xB0, 0x0E, 0xFF, 0xF3, 0xFF, 0x00, 0x00, 0xF8, 0x0F,
  0xFC, 0x3C, 0x18, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x02, 0x1F, 0xFC, 0x0F, 0xF0,
  0xFF, 0xC0, 0xC3, 0xF0, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x70,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0xF0, 0x38, 0x70,
  0x02, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1D, 0x80,
  0x07, 0x60, 0x01, 0xDC, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x07, 0x1E, 0x01,
  0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x3D, 0xFC, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0x7E, 0xF0, 0xC0, 0x1F,
  0x00, 0xEC, 0x03, 0x30, 0x18, 0xC0, 0xE3, 0x07, 0x0C, 0x18, 0x30, 0xC0,
  0xC7, 0x03, 0x18, 0x0C, 0xC0, 0x37, 0x00, 0xDE, 0x03, 0xD8, 0x0E, 0x30,
  0x30, 0xC0, 0xC1, 0x83, 0x07, 0x0C, 0x0C, 0x30, 0x38, 0xC0, 0x63, 0x01,
  0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x30, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFD, 0x80, 0x07, 0xEC, 0x00, 0x6F,
  0x60, 0x03, 0x79, 0x80, 0x1B, 0xCC, 0x01, 0x9E, 0x60, 0x0C, 0xF1, 0x80,
  0x67, 0x8C, 0x06, 0x3C, 0x60, 0x31, 0xE1, 0x81, 0x8F, 0x0C, 0x18, 0x78,
  0x60, 0xC3, 0xC1, 0x86, 0x1E, 0x0C, 0x20, 0xF0, 0x63, 0x07, 0x81, 0x98,
  0x3C, 0x0C, 0x81, 0xE0, 0x6C, 0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x1E, 0x03, 0x80, 0xC0, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xD8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xC6, 0x03, 0xC6,
  0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0xC3, 0xC0,
  0xC3, 0xC0, 0x63, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x3B, 0xC0, 0x1B, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x01, 0xF0, 0x01,
  0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x0D, 0x80, 0x07, 0x60, 0x01, 0x98, 0x00, 0x63, 0x00,
  0x38, 0xE0, 0x0C, 0x1C, 0x06, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xC6,
  0x3F, 0x30, 0x1D, 0x80, 0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x07, 0x7F, 0xF3, 0xFE, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0x01, 0xE1, 0xE0,
  0xE0, 0x1C, 0x30, 0x03, 0x1C, 0x00, 0x66, 0x00, 0x19, 0x80, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0D,
  0x80, 0x07, 0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x0C, 0x1C,
  0x06, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0xFF, 0xC3, 0x1F, 0x8C,
  0x07, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B,
  0x00, 0xEC, 0x03, 0x30, 0x1C, 0xC1, 0xE3, 0xFE, 0x0F, 0xF0, 0x30, 0x60,
  0xC1, 0x83, 0x03, 0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xCC, 0x03,
  0x30, 0x06, 0xC0, 0x1B, 0x00, 0x30, 0x07, 0x81, 0xFF, 0x9E, 0x1C, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x80, 0x77, 0xFF,
  0x3F, 0xE0, 0xFF, 0xFE, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xD8, 0x03, 0x38, 0x0E,
  0x3F, 0xF8, 0x1F, 0xE0, 0xC0, 0x01, 0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00,
  0x66, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x38, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60,
  0x18, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x36,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x06, 0x00, 0x6C, 0x01, 0xC0, 0x0D, 0x80, 0x38, 0x01, 0xB0, 0x07,
  0x80, 0x67, 0x00, 0xF0, 0x0C, 0x60, 0x36, 0x01, 0x8C, 0x06, 0xC0, 0x31,
  0x80, 0xCC, 0x0E, 0x30, 0x19, 0x81, 0x83, 0x02, 0x30, 0x30, 0x60, 0xC6,
  0x06, 0x0C, 0x18, 0x41, 0xC1, 0x83, 0x0C, 0x30, 0x18, 0x61, 0x86, 0x03,
  0x18, 0x30, 0xC0, 0x63, 0x02, 0x18, 0x0C, 0x60, 0x66, 0x01, 0xCC, 0x0C,
  0xC0, 0x19, 0x01, 0x98, 0x03, 0x60, 0x33, 0x00, 0x6C, 0x02, 0xE0, 0x0D,
  0x80, 0x78, 0x00, 0xB0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x00, 0x70, 0x0E, 0x60, 0x18, 0xE0, 0x30, 0xC0, 0xC1,
  0x81, 0x81, 0x86, 0x03, 0x0C, 0x03, 0x30, 0x06, 0x60, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x18, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x30, 0x06, 0x60,
  0x18, 0xE0, 0x30, 0xC0, 0xC1, 0x81, 0x81, 0x87, 0x03, 0x0C, 0x03, 0x38,
  0x06, 0x60, 0x0F, 0xC0, 0x0C, 0xE0, 0x06, 0xC0, 0x19, 0x80, 0x31, 0x80,
  0xE3, 0x01, 0x87, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x0C, 0x70, 0x18, 0xC0,
  0x31, 0x80, 0x36, 0x00, 0x6C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x7F, 0xF8, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF,
  0xFF, 0x03, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x36, 0x00, 0x46, 0x01, 0x8C,
  0x02, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x60, 0x30, 0xC0, 0x33, 0x00, 0x66,
  0x00, 0x78, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x60, 0xE0, 0xC0,
  0xC0, 0xC0, 0x0F, 0xC3, 0xFE, 0x30, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0xFF, 0x3C, 0x37, 0x03, 0x60, 0x36, 0x03, 0xE0,
  0x3E, 0x03, 0x60, 0x36, 0x05, 0x79, 0xD3, 0xF1, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xCF, 0xC6, 0xFF,
  0x3C, 0x1D, 0xC0, 0x6E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x37, 0x83, 0xB7, 0x79, 0x1F, 0x80, 0x0F, 0xC3, 0xFC, 0xE0, 0xB8, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xFB, 0x8F, 0xF0, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0F,
  0x99, 0xFE, 0xCC, 0x1E, 0xC0, 0x76, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0x60, 0x3B, 0x81, 0x4F, 0x72, 0x3F, 0x10, 0x0F, 0x80, 0xFE, 0x0C,
  0x18, 0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x8F, 0x3C, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x30, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x3F, 0x9F, 0xF0, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x89, 0xFE, 0x4C,
  0x1A, 0xC0, 0x76, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0x60, 0x3B,
  0x83, 0xCF, 0x76, 0x3F, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x90, 0x1C, 0xFF, 0xC1, 0xF8, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x8D, 0xFE, 0xF0,
  0x6E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x7D, 0x80, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0x80, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x6F, 0xBC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC1, 0xCC, 0x18, 0xC3, 0x0C,
  0x60, 0xC6, 0x0C, 0xC0, 0xDC, 0x0D, 0xC0, 0xF6, 0x0E, 0x60, 0xC3, 0x0C,
  0x30, 0xC1, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x83, 0xC4, 0xFE, 0x7F, 0xBC, 0x3A,
  0x0D, 0xC0, 0xE0, 0x7C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0x80, 0x78,
  0x0C, 0x03, 0xC0, 0x60, 0x1E, 0x03, 0x00, 0xF0, 0x18, 0x07, 0x80, 0xC0,
  0x3C, 0x06, 0x01, 0xE0, 0x30, 0x0F, 0x01, 0x80, 0x78, 0x0C, 0x03, 0xC0,
  0x60, 0x1E, 0x03, 0x00, 0xF0, 0x18, 0x07, 0x80, 0xC0, 0x30, 0x8F, 0xC9,
  0xFE, 0xB0, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x0F, 0xC0, 0xFF, 0x83, 0x07, 0x18, 0x0C, 0x60,
  0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xB8, 0x06, 0x60, 0x39, 0xC0, 0xC3,
  0xDE, 0x07, 0xF0, 0x8F, 0xC4, 0xFF, 0x3C, 0x1D, 0xC0, 0x6E, 0x03, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x37, 0x83, 0xB7, 0x79, 0x9F, 0x8C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x0F, 0x89, 0xFE, 0x4C, 0x1A, 0xC0, 0x76, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0x60, 0x3B, 0x83, 0xCF, 0x76, 0x3F, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x8F, 0x9F, 0xB8, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F,
  0xC7, 0xFD, 0xC0, 0xB0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x1F,
  0xEF, 0x3F, 0xC0, 0x30, 0x30, 0x30, 0x30, 0x7F, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x3D, 0x1F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7E, 0x0F, 0x7B, 0xB3, 0xF3, 0xC0, 0x0F, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x60, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30,
  0x60, 0x61, 0x81, 0x86, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03,
  0x60, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00, 0xC0, 0xC0, 0x38, 0x0D, 0x80,
  0xE0, 0x36, 0x03, 0x80, 0xD8, 0x0A, 0x02, 0x60, 0x6C, 0x18, 0xC1, 0xB0,
  0x63, 0x06, 0xC1, 0x8C, 0x13, 0x06, 0x30, 0xC4, 0x30, 0x63, 0x18, 0xC1,
  0x8C, 0x63, 0x06, 0x21, 0x8C, 0x19, 0x82, 0x60, 0x26, 0x0D, 0x80, 0xD8,
  0x36, 0x03, 0x40, 0xD8, 0x0F, 0x01, 0x40, 0x3C, 0x07, 0x00, 0x70, 0x1C,
  0x01, 0x80, 0x70, 0xC0, 0x3B, 0x01, 0x98, 0x18, 0x60, 0xC3, 0x0C, 0x0C,
  0x60, 0x66, 0x01, 0xB0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xD8,
  0x0C, 0xC0, 0x63, 0x06, 0x18, 0x70, 0x63, 0x03, 0xB8, 0x0D, 0x80, 0x70,
  0xC0, 0x0D, 0x80, 0x76, 0x01, 0x98, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03,
  0x0C, 0x0C, 0x18, 0x30, 0x61, 0x81, 0x86, 0x03, 0x18, 0x0C, 0xC0, 0x33,
  0x00, 0x4C, 0x01, 0xA0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x3E,
  0x00, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0F, 0xFF, 0xFF, 0x07, 0xC3, 0xC0, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x03, 0x80,
  0xF0, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x0F, 0x07, 0xC3, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0E, 0x0F, 0x03, 0x00, 0x3E, 0x02,
  0xFF, 0x0F, 0x07, 0xF4, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 26, 8, 3, -26 },
  { 11, 8, 9, 13, 2, -26 },
  { 20, 17, 26, 19, 1, -26 },
  { 76, 13, 30, 17, 2, -28 },
  { 125, 21, 27, 25, 2, -27 },
  { 196, 18, 27, 19, 1, -27 },
  { 257, 3, 9, 7, 2, -26 },
  { 261, 7, 32, 10, 2, -26 },
  { 289, 8, 32, 10, 1, -26 },
  { 321, 12, 12, 16, 2, -28 },
  { 339, 15, 18, 17, 1, -22 },
  { 373, 5, 9, 8, 1, -4 },
  { 379, 8, 2, 11, 1, -11 },
  { 381, 4, 3, 8, 2, -3 },
  { 383, 11, 26, 13, 1, -26 },
  { 419, 13, 27, 17, 2, -27 },
  { 463, 8, 26, 17, 3, -26 },
  { 489, 13, 27, 17, 2, -27 },
  { 533, 13, 27, 17, 2, -27 },
  { 577, 16, 27, 17, 1, -27 },
  { 631, 13, 26, 17, 2, -26 },
  { 674, 13, 27, 17, 2, -27 },
  { 718, 13, 26, 17, 2, -26 },
  { 761, 13, 27, 17, 2, -27 },
  { 805, 13, 27, 17, 2, -27 },
  { 849, 4, 20, 8, 2, -20 },
  { 859, 5, 25, 8, 1, -20 },
  { 875, 15, 16, 17, 1, -21 },
  { 905, 15, 10, 17, 1, -18 },
  { 924, 15, 16, 17, 1, -21 },
  { 954, 10, 27, 12, 1, -27 },
  { 988, 22, 30, 26, 2, -27 },
  { 1071, 17, 26, 17, 0, -26 },
  { 1127, 14, 26, 19, 3, -26 },
  { 1173, 15, 27, 18, 2, -27 },
  { 1224, 16, 26, 21, 3, -26 },
  { 1276, 11, 26, 16, 3, -26 },
  { 1312, 11, 26, 15, 3, -26 },
  { 1348, 18, 27, 22, 2, -27 },
  { 1409, 15, 26, 21, 3, -26 },
  { 1458, 7, 26, 10, 1, -26 },
  { 1481, 7, 33, 8, -2, -26 },
  { 1510, 14, 26, 17, 3, -26 },
  { 1556, 11, 26, 15, 3, -26 },
  { 1592, 21, 26, 27, 3, -26 },
  { 1661, 16, 26, 22, 3, -26 },
  { 1713, 18, 27, 22, 2, -27 },
  { 1774, 13, 26, 17, 3, -26 },
  { 1817, 18, 33, 22, 2, -27 },
  { 1892, 14, 26, 18, 3, -26 },
  { 1938, 13, 27, 16, 2, -27 },
  { 1982, 15, 26, 15, 0, -26 },
  { 2031, 15, 26, 21, 3, -26 },
  { 2080, 17, 26, 17, 0, -26 },
  { 2136, 27, 26, 28, 0, -26 },
  { 2224, 15, 26, 16, 0, -26 },
  { 2273, 15, 26, 15, 0, -26 },
  { 2322, 13, 26, 15, 1, -26 },
  { 2365, 7, 32, 12, 3, -26 },
  { 2393, 11, 26, 13, 1, -26 },
  { 2429, 8, 32, 12, 1, -26 },
  { 2461, 15, 14, 17, 1, -26 },
  { 2488, 15, 2, 15, 0, 3 },
  { 2492, 7, 6, 9, 1, -28 },
  { 2498, 12, 20, 16, 1, -20 },
  { 2528, 13, 28, 18, 3, -28 },
  { 2574, 11, 20, 14, 2, -20 },
  { 2602, 13, 28, 18, 2, -28 },
  { 2648, 13, 20, 16, 2, -20 },
  { 2681, 11, 28, 9, 0, -28 },
  { 2720, 13, 29, 18, 2, -20 },
  { 2768, 12, 28, 18, 3, -28 },
  { 2810, 3, 27, 8, 2, -27 },
  { 2821, 6, 36, 8, -1, -27 },
  { 2848, 12, 28, 15, 3, -28 },
  { 2890, 2, 28, 7, 3, -28 },
  { 2897, 21, 20, 27, 3, -20 },
  { 2950, 12, 20, 18, 3, -20 },
  { 2980, 14, 20, 18, 2, -20 },
  { 3015, 13, 29, 18, 3, -20 },
  { 3063, 13, 29, 18, 2, -20 },
  { 3111, 8, 20, 12, 3, -20 },
  { 3131, 11, 20, 14, 1, -20 },
  { 3159, 8, 24, 10, 1, -24 },
  { 3183, 12, 20, 18, 3, -20 },
  { 3213, 14, 20, 14, 0, -20 },
  { 3248, 22, 20, 23, 0, -20 },
  { 3303, 13, 20, 15, 1, -20 },
  { 3336, 14, 29, 14, 0, -20 },
  { 3387, 10, 20, 12, 1, -20 },
  { 3412, 10, 32, 13, 2, -26 },
  { 3452, 2, 37, 16, 7, -28 },
  { 3462, 10, 32, 13, 2, -26 },
  { 3502, 15, 4, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Light37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_LIGHT37PT7B_H_
