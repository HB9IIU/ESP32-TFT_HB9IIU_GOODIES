#ifndef _NOTOSANS_CONDENSED_LIGHT49PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0x00, 0x0E, 0xFF, 0x9C, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0x60, 0xCC,
  0x19, 0x83, 0x30, 0x66, 0x0C, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x70,
  0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x81, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x60, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70,
  0x30, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE3,
  0x8C, 0x11, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x83,
  0x00, 0xE0, 0xC0, 0x38, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x00, 0x3C, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x37, 0xC0,
  0x0C, 0x78, 0x03, 0x0E, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x1A, 0x03, 0x0E, 0xF8, 0xCF,
  0x3F, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x1F, 0x80, 0x0E, 0x01, 0xFE, 0x00, 0x60, 0x0C,
  0x30, 0x07, 0x00, 0xE1, 0xC0, 0x30, 0x06, 0x06, 0x01, 0x80, 0x30, 0x30,
  0x1C, 0x03, 0x81, 0xC0, 0xC0, 0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x60,
  0x07, 0x03, 0x83, 0x00, 0x38, 0x1C, 0x38, 0x01, 0xC0, 0xE1, 0x80, 0x0E,
  0x07, 0x1C, 0x00, 0x70, 0x38, 0xC0, 0x83, 0x81, 0x86, 0x3F, 0x0C, 0x0C,
  0x73, 0xFC, 0x60, 0x63, 0x18, 0x73, 0x87, 0x39, 0xC1, 0x8C, 0x31, 0x8C,
  0x0C, 0x7F, 0x8C, 0x60, 0x61, 0xF8, 0xE3, 0x03, 0x80, 0x06, 0x38, 0x1C,
  0x00, 0x71, 0xC0, 0xE0, 0x03, 0x0E, 0x03, 0x00, 0x18, 0x70, 0x18, 0x01,
  0xC3, 0x80, 0xC0, 0x0C, 0x1C, 0x0E, 0x00, 0xE0, 0x60, 0x70, 0x06, 0x03,
  0x03, 0x80, 0x30, 0x18, 0x18, 0x03, 0x80, 0xC0, 0xC0, 0x18, 0x07, 0x06,
  0x01, 0xC0, 0x18, 0x70, 0x0C, 0x00, 0xFF, 0x00, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x03, 0x01, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7B, 0x80, 0x01, 0xC3, 0x80, 0xE7, 0x03, 0x81, 0xCE,
  0x07, 0x03, 0x38, 0x07, 0x06, 0x70, 0x07, 0x1C, 0xE0, 0x0E, 0x39, 0xC0,
  0x0E, 0xE3, 0x80, 0x0F, 0xC7, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0xFC, 0x38, 0x03, 0xBC, 0x3C, 0x1E, 0x38, 0x3F, 0xF8,
  0x38, 0x3F, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0x01, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70,
  0x70, 0x30, 0x30, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x03, 0x0C, 0x1B, 0xF6, 0x7C, 0xFF, 0xFF, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xD8, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xE0, 0x70,
  0x30, 0x10, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x39, 0xCE, 0x77,
  0x39, 0xCC, 0x67, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xF7, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0x70,
  0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01,
  0x9C, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x70, 0x70, 0x1C, 0x1E, 0x1E, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x01,
  0xC0, 0xF0, 0x7C, 0x3F, 0x1D, 0xDE, 0x7F, 0x1F, 0x87, 0x41, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0xF8, 0x0F, 0xFF, 0x07,
  0x81, 0xE1, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0x81, 0xE1, 0x80, 0x1C, 0x40,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x03, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3A,
  0x00, 0x1C, 0xE0, 0x1E, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D,
  0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x0C,
  0x00, 0xC0, 0x60, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30,
  0x06, 0x03, 0x80, 0x30, 0x38, 0x01, 0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x60,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x70, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3D, 0x00,
  0x3C, 0xE0, 0x3C, 0x7F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x7C, 0x08, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x3C, 0x06, 0x3F, 0xE1, 0x9F, 0xFC, 0x6E, 0x07, 0x1E, 0x00,
  0xEF, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D,
  0x80, 0x03, 0x60, 0x00, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70,
  0x01, 0xCE, 0x00, 0x63, 0x80, 0x38, 0x70, 0x1E, 0x1E, 0x0F, 0x03, 0xFF,
  0x80, 0x3F, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x07, 0xFC, 0x07, 0xFF, 0x81, 0xC0, 0xF0, 0xE0, 0x1E, 0x70, 0x03, 0x9C,
  0x00, 0x67, 0x00, 0x19, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x67, 0x00,
  0x38, 0xE0, 0x0E, 0x3C, 0x07, 0x07, 0x83, 0x80, 0xF1, 0xC0, 0x1F, 0xE0,
  0x01, 0xE0, 0x01, 0xFE, 0x00, 0xF3, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x1C,
  0x00, 0xE7, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x1D, 0xE0, 0x0E,
  0x3C, 0x0F, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x03,
  0xC1, 0xE0, 0xE0, 0x3C, 0x70, 0x07, 0x1C, 0x00, 0xE6, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x0F, 0x70, 0x03, 0xDC, 0x01, 0xF3,
  0x80, 0xDC, 0x7F, 0xF7, 0x0F, 0xF9, 0xC0, 0xF0, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x40, 0x78, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xF7, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF7, 0x3B, 0xDE, 0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xE7, 0x3B, 0x9C, 0xE6, 0x33, 0x98, 0x00,
  0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xE3,
  0xFF, 0xCE, 0x07, 0xA0, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03,
  0x9C, 0x03, 0xFC, 0x0C, 0xC0, 0x3F, 0xE0, 0x66, 0x03, 0x83, 0x03, 0xF0,
  0x38, 0x18, 0x1F, 0x81, 0x80, 0xC0, 0x78, 0x1C, 0x06, 0x03, 0xC0, 0xC0,
  0x30, 0x1E, 0x06, 0x01, 0x80, 0xF0, 0x30, 0x0C, 0x07, 0x81, 0x80, 0x60,
  0x3C, 0x0C, 0x07, 0x01, 0xE0, 0x60, 0x38, 0x0F, 0x03, 0x01, 0xC0, 0xF8,
  0x18, 0x0E, 0x07, 0xC0, 0xC0, 0x70, 0x36, 0x07, 0x07, 0x83, 0xB0, 0x18,
  0x36, 0x19, 0xC0, 0xFF, 0x3F, 0xCE, 0x03, 0xF0, 0xFC, 0x30, 0x02, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x01, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x60, 0x01, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x18, 0x03, 0x00, 0x70, 0x07, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0x60, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x86, 0x00, 0x03,
  0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0D, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x38, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0x81, 0xFC, 0x70, 0x03,
  0xCE, 0x00, 0x39, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x03, 0xC7, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0x80, 0x3C,
  0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x7F, 0x1F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xC0, 0xE0, 0xF0,
  0x02, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x38, 0x7F, 0xC1, 0xC0, 0x1F, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x03, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70,
  0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x01, 0xE0, 0xE1, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xFB, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF, 0xFB, 0xFF, 0xF7, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0x80, 0xF0,
  0x78, 0x00, 0x61, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x03, 0x87, 0x80, 0x07, 0x07,
  0xC0, 0x3E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x7F, 0xFF, 0xE0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0xBF, 0xCF, 0xF3, 0xF0, 0xE0,
  0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83,
  0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xEF, 0x80, 0x1F, 0xF0, 0x03, 0xE7, 0x00, 0x78, 0xE0, 0x0F, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x03,
  0x83, 0x80, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x3B, 0x80, 0x03, 0x80, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xBF, 0xC0,
  0x00, 0x3B, 0xEC, 0x00, 0x03, 0xBE, 0xC0, 0x00, 0x33, 0xEE, 0x00, 0x07,
  0x3E, 0x60, 0x00, 0x73, 0xE6, 0x00, 0x06, 0x3E, 0x70, 0x00, 0x63, 0xE7,
  0x00, 0x0E, 0x3E, 0x30, 0x00, 0xC3, 0xE3, 0x80, 0x0C, 0x3E, 0x38, 0x01,
  0xC3, 0xE1, 0x80, 0x18, 0x3E, 0x1C, 0x01, 0x83, 0xE1, 0xC0, 0x38, 0x3E,
  0x0C, 0x03, 0x03, 0xE0, 0xE0, 0x30, 0x3E, 0x0E, 0x07, 0x03, 0xE0, 0x60,
  0x60, 0x3E, 0x07, 0x06, 0x03, 0xE0, 0x70, 0xE0, 0x3E, 0x03, 0x0E, 0x03,
  0xE0, 0x38, 0xC0, 0x3E, 0x03, 0x9C, 0x03, 0xE0, 0x19, 0xC0, 0x3E, 0x01,
  0xD8, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x00, 0x30, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7D, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xB8, 0x00, 0xFD, 0xC0, 0x07, 0xE7, 0x00, 0x3F, 0x38, 0x01, 0xF8, 0xE0,
  0x0F, 0xC7, 0x00, 0x7E, 0x1C, 0x03, 0xF0, 0xE0, 0x1F, 0x83, 0x80, 0xFC,
  0x1C, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x0E, 0x0F, 0xC0, 0x70,
  0x7E, 0x01, 0xC3, 0xF0, 0x0E, 0x1F, 0x80, 0x38, 0xFC, 0x01, 0xC7, 0xE0,
  0x07, 0x3F, 0x00, 0x39, 0xF8, 0x00, 0xEF, 0xC0, 0x07, 0x3E, 0x00, 0x1D,
  0xF0, 0x00, 0xEF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0E, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0x81,
  0xE0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x38, 0x7F, 0x9C, 0x03, 0xCE, 0x00, 0x77,
  0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0E, 0xE0,
  0x0F, 0x70, 0x0F, 0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0x81,
  0xE0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x70, 0x0F, 0x8E, 0x00,
  0x71, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x01,
  0xC7, 0x00, 0x78, 0xE0, 0x1E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x1C,
  0x1C, 0x03, 0x83, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xF1, 0xC0, 0x0E,
  0x38, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xE0, 0x78, 0xE0, 0x02, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7A, 0x00,
  0x3C, 0xF0, 0x1E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x77, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x3E, 0x07, 0xC1, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00, 0x01,
  0xDC, 0x00, 0x06, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x8E,
  0x00, 0x0C, 0x38, 0x00, 0x70, 0x60, 0x01, 0xC1, 0xC0, 0x06, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xE0, 0x0C, 0x03, 0x80, 0x70,
  0x06, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x03,
  0x03, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0x87,
  0x00, 0x07, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00,
  0x03, 0xB0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x77, 0x00, 0x07,
  0x00, 0x07, 0x70, 0x00, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x00, 0x06, 0x70,
  0x00, 0xF8, 0x00, 0xE3, 0x80, 0x0F, 0x80, 0x0E, 0x38, 0x01, 0xD8, 0x00,
  0xE3, 0x80, 0x1D, 0x80, 0x0E, 0x38, 0x01, 0xDC, 0x01, 0xC1, 0x80, 0x19,
  0xC0, 0x1C, 0x1C, 0x01, 0x9C, 0x01, 0xC1, 0xC0, 0x38, 0xC0, 0x1C, 0x1C,
  0x03, 0x8C, 0x01, 0x80, 0xC0, 0x30, 0xE0, 0x38, 0x0E, 0x03, 0x0E, 0x03,
  0x80, 0xE0, 0x70, 0x60, 0x38, 0x0E, 0x07, 0x06, 0x03, 0x00, 0xE0, 0x70,
  0x70, 0x70, 0x06, 0x06, 0x07, 0x07, 0x00, 0x70, 0x60, 0x70, 0x70, 0x07,
  0x0E, 0x03, 0x06, 0x00, 0x70, 0xE0, 0x30, 0xE0, 0x03, 0x0C, 0x03, 0x8E,
  0x00, 0x38, 0xC0, 0x38, 0xE0, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0x39, 0xC0,
  0x18, 0xC0, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0x19, 0x80, 0x1D, 0xC0, 0x01,
  0xD8, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x0D, 0x80, 0x01, 0xF8, 0x00, 0xD8,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x73, 0x80, 0x0E,
  0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x18, 0x0E, 0x03,
  0x80, 0x70, 0x30, 0x07, 0x07, 0x00, 0x30, 0x70, 0x03, 0x8E, 0x00, 0x18,
  0xE0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0D, 0x80, 0x01, 0xDC, 0x00,
  0x19, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x0E, 0x03, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70,
  0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x9C,
  0x00, 0x39, 0xC0, 0x01, 0x98, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0xFF, 0xFF,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x1D, 0xC0,
  0x00, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x30,
  0x38, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x18, 0x0C, 0x00, 0xE0,
  0xE0, 0x03, 0x07, 0x00, 0x1C, 0x70, 0x00, 0x63, 0x80, 0x03, 0xB8, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x70, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x00, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x38, 0x1E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x03, 0xFF, 0x0F, 0xFF, 0x3E, 0x07, 0x78, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0x70, 0x33, 0x3F, 0xF3, 0x1F, 0xC3, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x04, 0x03, 0x1F,
  0xE0, 0xCF, 0xFC, 0x37, 0x07, 0x8D, 0x80, 0x73, 0xC0, 0x1C, 0xE0, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xF0, 0x07,
  0x36, 0x03, 0xCD, 0xC1, 0xE3, 0x3F, 0xF0, 0xC7, 0xF8, 0x00, 0x00, 0x30,
  0x07, 0xFC, 0x3F, 0xF8, 0xF0, 0x11, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x02, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x0C, 0x0C, 0x1F, 0xE3, 0x0F, 0xFC, 0xC7, 0x83, 0xB3, 0xC0, 0x6C, 0xE0,
  0x0F, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x07, 0x38, 0x03, 0xCE, 0x01, 0xB1, 0xE0, 0xEC, 0x3F, 0xF3, 0x07, 0xF8,
  0xC0, 0x00, 0x40, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38, 0x07,
  0x0E, 0x00, 0xC3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01, 0x98, 0x00, 0x66,
  0x00, 0x1B, 0x80, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x02, 0x1E, 0x03, 0x83, 0xFF, 0xE0,
  0x3F, 0xE0, 0x03, 0xF8, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xFF, 0xCF, 0xFE, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x30, 0xFF, 0xCC, 0x78, 0x3B,
  0x3C, 0x02, 0xCE, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xD8,
  0x00, 0x36, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x1B, 0x1E, 0x0E, 0xC3,
  0xFF, 0x30, 0x7F, 0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0xC0, 0x1C,
  0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0xC0, 0xC7, 0xF8, 0xCF, 0xFC, 0xDC, 0x1E, 0xD8,
  0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x6F, 0xFF, 0x20,
  0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x06, 0x0F, 0x0F, 0x0F, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E,
  0xFC, 0xFC, 0xF0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0xFC, 0x01, 0xD8, 0x07, 0x30, 0x1C, 0x60, 0x38, 0xC0, 0xE1, 0x83,
  0x83, 0x06, 0x06, 0x1C, 0x0C, 0x70, 0x19, 0xE0, 0x33, 0xC0, 0x6D, 0xC0,
  0xFB, 0x81, 0xE3, 0x83, 0x87, 0x06, 0x07, 0x0C, 0x0E, 0x18, 0x0E, 0x30,
  0x1C, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x3B, 0x00, 0x76, 0x00, 0x7C, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xC0, 0x0C, 0x0C, 0x7F, 0x07, 0xF8, 0xCF, 0xF8, 0xFF, 0xCD, 0x83, 0xCC,
  0x1E, 0xD0, 0x1D, 0x80, 0xEF, 0x00, 0xF0, 0x06, 0xE0, 0x0F, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x0E,
  0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07,
  0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00,
  0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00,
  0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0,
  0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x40,
  0xC7, 0xF8, 0xCF, 0xFC, 0xDC, 0x1E, 0xD8, 0x0E, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F,
  0x07, 0x83, 0xC0, 0x38, 0x70, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x00, 0xCC, 0x00, 0x1D, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80,
  0x03, 0xB8, 0x00, 0x67, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0xE1, 0xE0,
  0x1C, 0x1E, 0x0F, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x31,
  0xFE, 0x0C, 0xFF, 0xC3, 0x70, 0x38, 0xD8, 0x07, 0x3C, 0x01, 0xCE, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x6E, 0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEF, 0x00,
  0x73, 0x60, 0x3C, 0xDC, 0x1E, 0x33, 0xFF, 0x0C, 0x7F, 0x83, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x40, 0x01, 0xFE, 0x30, 0xFF, 0xCC, 0x78, 0x3B, 0x3C, 0x06,
  0xCE, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x73, 0x80, 0x3C, 0xE0, 0x1B, 0x1E, 0x0E, 0xC3, 0xFF, 0x30,
  0x7F, 0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x98, 0xFF, 0x3F, 0xEF, 0x1D, 0x81,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x01, 0x00, 0x7F, 0xE3, 0xFF,
  0xDE, 0x06, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0xE0, 0x7B, 0xFF, 0xC7, 0xFE, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x3F, 0xFF, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0xF8, 0x3F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x7B,
  0x80, 0x2D, 0xC0, 0x36, 0x78, 0x33, 0x3F, 0xF1, 0x87, 0xF0, 0xC0, 0xE0,
  0x01, 0xD8, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x70, 0x03, 0x8C, 0x00,
  0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x18, 0x07, 0x07, 0x01, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0C, 0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x18, 0x70, 0x06,
  0x18, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xC0, 0x07,
  0x00, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07,
  0x60, 0x0F, 0x80, 0x67, 0x01, 0xD8, 0x06, 0x70, 0x19, 0x80, 0xE7, 0x01,
  0x98, 0x0E, 0x30, 0x19, 0xC0, 0xC3, 0x03, 0x9C, 0x0C, 0x38, 0x30, 0xC1,
  0xC3, 0x83, 0x0C, 0x1C, 0x18, 0x30, 0xE1, 0x81, 0x87, 0x0E, 0x18, 0x1C,
  0x70, 0x63, 0x81, 0xC6, 0x06, 0x38, 0x1C, 0x60, 0x73, 0x80, 0xCE, 0x07,
  0x30, 0x0E, 0xE0, 0x33, 0x00, 0xEC, 0x03, 0x70, 0x0E, 0xC0, 0x37, 0x00,
  0x6C, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0xB8, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x07, 0x30,
  0x03, 0xB8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0E, 0xE0, 0x07, 0x30, 0x07, 0x1C, 0x03, 0x86, 0x03, 0x83, 0x81,
  0xC0, 0xC1, 0xC0, 0x70, 0xE0, 0x18, 0xE0, 0x0E, 0x70, 0x03, 0xF0, 0x01,
  0xC0, 0xE0, 0x00, 0xDC, 0x00, 0x77, 0x00, 0x1C, 0xC0, 0x06, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x38, 0x60, 0x0C, 0x1C, 0x07, 0x07, 0x01, 0xC0,
  0xC0, 0x60, 0x38, 0x38, 0x0E, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x1C,
  0x70, 0x07, 0x1C, 0x00, 0xC6, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38,
  0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x0F, 0xC0, 0x78, 0x01, 0xF0, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xF8, 0x07, 0xC0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x80, 0x1C, 0x07, 0xE0, 0x78, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0xFE, 0x07, 0xE0, 0x38,
  0x00, 0x1E, 0x00, 0x2F, 0xF8, 0x07, 0xDF, 0xC3, 0xE0, 0x7F, 0xE8, 0x01,
  0xF8,
};

const GFXglyph NotoSans_Condensed_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 35, 11, 3, -35 },
  { 23, 11, 13, 17, 3, -35 },
  { 41, 23, 35, 25, 1, -35 },
  { 142, 18, 40, 22, 2, -37 },
  { 232, 29, 35, 33, 2, -35 },
  { 359, 23, 35, 25, 2, -35 },
  { 460, 3, 13, 9, 3, -35 },
  { 465, 10, 43, 14, 2, -35 },
  { 519, 9, 43, 14, 2, -35 },
  { 568, 17, 16, 21, 2, -37 },
  { 602, 19, 23, 23, 2, -29 },
  { 657, 5, 11, 10, 2, -5 },
  { 664, 10, 3, 14, 2, -15 },
  { 668, 4, 4, 11, 3, -4 },
  { 670, 15, 35, 17, 1, -35 },
  { 736, 18, 35, 22, 2, -35 },
  { 815, 10, 35, 22, 4, -35 },
  { 859, 18, 35, 22, 2, -35 },
  { 938, 18, 35, 22, 2, -35 },
  { 1017, 21, 35, 22, 1, -35 },
  { 1109, 17, 35, 22, 3, -35 },
  { 1184, 18, 36, 22, 2, -35 },
  { 1265, 18, 35, 22, 2, -35 },
  { 1344, 18, 35, 22, 2, -35 },
  { 1423, 18, 35, 22, 2, -35 },
  { 1502, 4, 26, 11, 3, -26 },
  { 1515, 5, 32, 11, 2, -26 },
  { 1535, 19, 21, 23, 2, -28 },
  { 1585, 19, 13, 23, 2, -24 },
  { 1616, 19, 21, 23, 2, -28 },
  { 1666, 14, 35, 16, 1, -35 },
  { 1728, 29, 39, 35, 3, -35 },
  { 1870, 23, 35, 23, 0, -35 },
  { 1971, 19, 35, 25, 4, -35 },
  { 2055, 20, 35, 24, 3, -35 },
  { 2143, 21, 35, 27, 4, -35 },
  { 2235, 15, 35, 22, 4, -35 },
  { 2301, 15, 35, 20, 4, -35 },
  { 2367, 23, 35, 29, 3, -35 },
  { 2468, 20, 35, 28, 4, -35 },
  { 2556, 9, 35, 13, 2, -35 },
  { 2596, 10, 44, 11, -3, -35 },
  { 2651, 19, 35, 23, 4, -35 },
  { 2735, 15, 35, 20, 4, -35 },
  { 2801, 28, 35, 36, 4, -35 },
  { 2924, 21, 35, 29, 4, -35 },
  { 3016, 24, 35, 30, 3, -35 },
  { 3121, 17, 35, 23, 4, -35 },
  { 3196, 24, 43, 30, 3, -35 },
  { 3325, 19, 35, 24, 4, -35 },
  { 3409, 18, 35, 22, 2, -35 },
  { 3488, 20, 35, 20, 0, -35 },
  { 3576, 20, 35, 28, 4, -35 },
  { 3664, 22, 35, 22, 0, -35 },
  { 3761, 36, 35, 37, 0, -35 },
  { 3919, 20, 35, 21, 0, -35 },
  { 4007, 20, 35, 20, 0, -35 },
  { 4095, 18, 35, 20, 1, -35 },
  { 4174, 10, 43, 15, 4, -35 },
  { 4228, 15, 35, 17, 1, -35 },
  { 4294, 9, 43, 15, 2, -35 },
  { 4343, 21, 19, 23, 1, -35 },
  { 4393, 20, 3, 20, 0, 4 },
  { 4401, 8, 7, 12, 2, -37 },
  { 4408, 16, 27, 21, 2, -27 },
  { 4462, 18, 37, 24, 4, -37 },
  { 4546, 15, 27, 18, 2, -27 },
  { 4597, 18, 37, 24, 2, -37 },
  { 4681, 18, 27, 22, 2, -27 },
  { 4742, 13, 37, 13, 1, -37 },
  { 4803, 18, 39, 24, 2, -27 },
  { 4891, 16, 37, 24, 4, -37 },
  { 4965, 4, 36, 10, 3, -36 },
  { 4983, 8, 48, 10, -1, -36 },
  { 5031, 15, 37, 20, 4, -37 },
  { 5101, 2, 37, 10, 4, -37 },
  { 5111, 28, 27, 35, 4, -27 },
  { 5206, 16, 27, 24, 4, -27 },
  { 5260, 19, 27, 23, 2, -27 },
  { 5325, 18, 39, 24, 4, -27 },
  { 5413, 18, 39, 24, 2, -27 },
  { 5501, 11, 27, 15, 4, -27 },
  { 5539, 14, 27, 18, 2, -27 },
  { 5587, 11, 32, 13, 1, -32 },
  { 5631, 17, 26, 24, 3, -26 },
  { 5687, 18, 26, 18, 0, -26 },
  { 5746, 28, 26, 30, 1, -26 },
  { 5837, 17, 26, 19, 1, -26 },
  { 5893, 18, 38, 19, 0, -26 },
  { 5979, 13, 26, 16, 2, -26 },
  { 6022, 13, 43, 17, 2, -35 },
  { 6092, 3, 49, 21, 9, -37 },
  { 6111, 13, 43, 17, 2, -35 },
  { 6181, 19, 5, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Light49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_LIGHT49PT7B_H_
