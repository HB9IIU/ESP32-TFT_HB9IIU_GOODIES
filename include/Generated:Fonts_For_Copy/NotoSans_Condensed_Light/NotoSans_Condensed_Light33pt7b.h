#ifndef _NOTOSANS_CONDENSED_LIGHT33PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD2, 0x48, 0x00, 0xFF, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC2, 0x06, 0x18, 0x0C, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x86, 0x03, 0x0C, 0x3F, 0xFF, 0x7F, 0xFE, 0x10,
  0x40, 0x20, 0x80, 0x41, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x7F, 0xFE,
  0xFF, 0xFC, 0x20, 0x80, 0x41, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x20, 0x18, 0x40, 0x02, 0x00, 0x10, 0x03, 0xE0, 0x7F, 0xE7, 0x22, 0x31,
  0x01, 0x08, 0x18, 0x40, 0xC2, 0x03, 0x10, 0x18, 0x80, 0x74, 0x01, 0xE0,
  0x03, 0xC0, 0x0B, 0x80, 0x4E, 0x02, 0x30, 0x10, 0xC0, 0x86, 0x04, 0x20,
  0x23, 0x61, 0x3B, 0xFF, 0x83, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x38,
  0x06, 0x0F, 0x80, 0x83, 0x18, 0x30, 0x43, 0x04, 0x08, 0x61, 0x81, 0x04,
  0x30, 0x20, 0x84, 0x04, 0x11, 0x80, 0x82, 0x20, 0x10, 0x4C, 0x02, 0x19,
  0x9E, 0x43, 0x26, 0x6C, 0x4C, 0x84, 0xF9, 0x30, 0xCE, 0x66, 0x18, 0x0C,
  0xC3, 0x01, 0x18, 0x60, 0x63, 0x0C, 0x08, 0x61, 0x83, 0x0C, 0x30, 0x61,
  0x84, 0x08, 0x10, 0x83, 0x03, 0x30, 0x40, 0x3C, 0x07, 0x00, 0x1F, 0x80,
  0x18, 0xC0, 0x30, 0x40, 0x30, 0x40, 0x30, 0x40, 0x30, 0x40, 0x10, 0xC0,
  0x18, 0xC0, 0x09, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1B, 0x00, 0x33, 0x06,
  0x61, 0x86, 0x60, 0xC6, 0xC0, 0xC4, 0xC0, 0x6C, 0xC0, 0x3C, 0xC0, 0x18,
  0x60, 0x38, 0x60, 0x6C, 0x39, 0xC6, 0x1F, 0x87, 0xFF, 0xFF, 0xC0, 0x0C,
  0x61, 0x8C, 0x31, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xC2, 0x08, 0x20, 0x83,
  0x0C, 0x30, 0xC3, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x0C, 0xC0, 0xC1, 0x81,
  0x81, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x40, 0xC1, 0x83, 0x06,
  0x08, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC3, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x23, 0x1F, 0x6E, 0x3F, 0x01, 0x80, 0x58, 0x19, 0x86,
  0x18, 0x42, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x33, 0x36, 0x66, 0x4C, 0xFF, 0xFC, 0xFF, 0x80,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x0F, 0x03, 0xF8, 0x70, 0xC6, 0x0C,
  0x40, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x2C, 0x02, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06,
  0x60, 0x46, 0x0C, 0x3B, 0x81, 0xF0, 0x06, 0x1C, 0x7B, 0xBE, 0x78, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x0F, 0x03, 0xFC, 0x60, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xFC, 0xE0, 0x64, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x01, 0xC1, 0xF0, 0x1F, 0xC0, 0x0E,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x06,
  0xF1, 0xE7, 0xF8, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x60,
  0x0D, 0x80, 0x66, 0x01, 0x18, 0x0C, 0x60, 0x21, 0x81, 0x86, 0x04, 0x18,
  0x30, 0x61, 0x81, 0x86, 0x06, 0x30, 0x18, 0xC0, 0x63, 0xFF, 0xF0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x7F, 0xC7, 0xFC,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0x8E, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x68, 0x0C, 0xE3, 0x8F, 0xF0, 0x07, 0xC1, 0xFC,
  0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x60,
  0xDF, 0x8F, 0x0C, 0xE0, 0x6C, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x06, 0x60, 0x66, 0x06, 0x31, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x0F, 0x80, 0xFF, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80, 0xCC,
  0x06, 0x30, 0x61, 0xC7, 0x07, 0x70, 0x0E, 0x01, 0xF8, 0x1C, 0x71, 0xC1,
  0xCC, 0x06, 0x40, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x36, 0x03, 0x30, 0x18,
  0xE3, 0x83, 0xF8, 0x0F, 0x01, 0xFC, 0x30, 0xE6, 0x06, 0x60, 0x34, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x36, 0x03, 0x70, 0x53, 0xFF,
  0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C,
  0x43, 0x83, 0xF0, 0x5F, 0xA0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x27, 0x72,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x36, 0x66, 0x4C, 0x00, 0x08, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x7C, 0x7F, 0xA0, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0x40, 0x20, 0x10, 0x08, 0x00, 0x00,
  0x00, 0x01, 0x80, 0xE0, 0x70, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x0E, 0x07,
  0x01, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x60, 0x00, 0x66, 0x0F,
  0xC6, 0x41, 0x8C, 0x2C, 0x30, 0xC2, 0xC2, 0x0C, 0x38, 0x60, 0xC3, 0x86,
  0x0C, 0x38, 0x60, 0xC3, 0x86, 0x08, 0x38, 0x60, 0x82, 0x86, 0x18, 0x2C,
  0x21, 0xC6, 0xC3, 0x34, 0xCC, 0x1E, 0x7C, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x02, 0x00, 0xFB, 0xC0, 0x03, 0xF8,
  0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0xC0, 0x02, 0xC0, 0x06,
  0x40, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x60, 0x0C, 0x20, 0x0C, 0x30, 0x08,
  0x30, 0x18, 0x30, 0x18, 0x18, 0x1F, 0xF8, 0x3F, 0xF8, 0x30, 0x08, 0x30,
  0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0,
  0x07, 0xFC, 0x0F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x6C, 0x06, 0xC1, 0xCF, 0xF0, 0xC3, 0xCC, 0x06, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xFF, 0xCF,
  0xF8, 0x03, 0xE0, 0x7F, 0xC7, 0x02, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x7C, 0xE0, 0xFF, 0xF8, 0x03, 0xFE, 0x0C, 0x1E, 0x30, 0x1C, 0xC0,
  0x33, 0x00, 0xEC, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0x6C,
  0x01, 0xB0, 0x0C, 0xC0, 0x73, 0x03, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x01, 0xF8,
  0x1F, 0xFC, 0x70, 0x19, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x05, 0x80, 0x0B, 0x00, 0x13,
  0x00, 0x23, 0x00, 0x43, 0xC7, 0x83, 0xFE, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFC,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x6F, 0xDE, 0x00, 0xC0, 0x3C,
  0x06, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x38, 0xC3, 0x0C, 0x60, 0xCE, 0x0C,
  0xC0, 0xD8, 0x0F, 0x80, 0xFC, 0x0E, 0xE0, 0xC6, 0x0C, 0x30, 0xC3, 0x0C,
  0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x7C, 0x03, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xD0,
  0x00, 0xFB, 0x00, 0x17, 0x60, 0x06, 0xE4, 0x00, 0xDC, 0xC0, 0x13, 0x98,
  0x06, 0x71, 0x00, 0xCE, 0x30, 0x11, 0xC6, 0x06, 0x38, 0x40, 0xC7, 0x0C,
  0x18, 0xE1, 0x86, 0x1C, 0x10, 0xC3, 0x83, 0x18, 0x70, 0x66, 0x0E, 0x04,
  0xC1, 0xC0, 0xD8, 0x38, 0x1A, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x06,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xB0, 0x0E, 0xC0, 0x39,
  0x80, 0xE6, 0x03, 0x8C, 0x0E, 0x30, 0x38, 0x60, 0xE1, 0x83, 0x83, 0x0E,
  0x0C, 0x38, 0x18, 0xE0, 0x63, 0x80, 0xCE, 0x03, 0x38, 0x06, 0xE0, 0x1B,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x07, 0xE0, 0x1F, 0xF0, 0x38,
  0x18, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x38, 0x1C, 0x1E, 0x78, 0x0F, 0xE0, 0xF8, 0x1F, 0xF3, 0x07, 0x60,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x6C,
  0x3D, 0xFE, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0x38, 0x18, 0x30, 0x0C,
  0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x38, 0x1C,
  0x1E, 0x78, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0xF8, 0x0F, 0xF8, 0xC3, 0xCC, 0x0E, 0xC0, 0x6C,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x1C, 0xFF, 0x8F,
  0xE0, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C,
  0x06, 0xC0, 0x3C, 0x03, 0x0F, 0xC1, 0xFF, 0x30, 0x26, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x06, 0xF9, 0xE7, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xB0, 0x19, 0xF3, 0x83, 0xF8, 0xC0, 0x07,
  0x80, 0x0D, 0x00, 0x1B, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x8C, 0x02, 0x18,
  0x0C, 0x30, 0x18, 0x60, 0x30, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x01, 0x04,
  0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x08, 0x80, 0x1B, 0x00, 0x36, 0x00,
  0x2C, 0x00, 0x50, 0x00, 0xE0, 0x01, 0xC0, 0xC0, 0x18, 0x03, 0x40, 0x18,
  0x03, 0x60, 0x1C, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x3C, 0x02, 0x60, 0x34,
  0x06, 0x30, 0x36, 0x06, 0x30, 0x26, 0x06, 0x30, 0x26, 0x06, 0x30, 0x62,
  0x0C, 0x10, 0x62, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0x43, 0x0C, 0x18, 0xC3,
  0x18, 0x08, 0xC1, 0x18, 0x0C, 0xC1, 0x98, 0x0C, 0xC1, 0x98, 0x0C, 0x81,
  0x90, 0x0D, 0x80, 0xB0, 0x05, 0x80, 0xB0, 0x07, 0x80, 0xF0, 0x07, 0x00,
  0xF0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x60, 0x19, 0x80, 0x63, 0x01,
  0x0C, 0x0C, 0x18, 0x30, 0x61, 0x80, 0xC6, 0x03, 0x30, 0x04, 0xC0, 0x1E,
  0x00, 0x78, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x68, 0x03, 0x30, 0x0C,
  0xC0, 0x61, 0x81, 0x86, 0x0C, 0x0C, 0x30, 0x31, 0x80, 0x66, 0x01, 0xB0,
  0x07, 0xC0, 0x1E, 0x00, 0xD8, 0x06, 0xC0, 0x63, 0x03, 0x18, 0x10, 0xC1,
  0x83, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x20, 0x1B, 0x00, 0x78, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0xFF, 0xEF, 0xFE, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xFC, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x08, 0x03, 0xFF, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x02, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x60, 0x0C, 0x80, 0x23, 0x01, 0x84, 0x04, 0x18,
  0x30, 0x20, 0x80, 0xC6, 0x03, 0x10, 0x06, 0xC0, 0x1C, 0xFF, 0xFC, 0xE1,
  0xC3, 0x06, 0x0C, 0x0F, 0x07, 0xF8, 0x83, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x0F, 0xE7, 0x0D, 0x81, 0xB0, 0x3C, 0x07, 0x80, 0xF0, 0x1B,
  0x07, 0x71, 0xE7, 0xE4, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0xF0, 0xDF, 0xC6, 0x83, 0x38, 0x0D, 0xC0, 0x6E,
  0x03, 0x60, 0x0B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x6E, 0x03, 0x70, 0x1B, 0xC1, 0x9B, 0x3C, 0xCF, 0xC0, 0x0F, 0xCF, 0xE7,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x80, 0x38, 0x87, 0xE0, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x31, 0xE3, 0x3F, 0xB6, 0x0F, 0x60,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x60, 0x77, 0x9B, 0x3F, 0x30, 0x0F, 0x07,
  0xF1, 0x83, 0x30, 0x2C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xFF, 0xF0, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x38, 0xE3, 0xF8, 0x0F,
  0xC3, 0x21, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xFC, 0xFF, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x1E, 0x33, 0xFB, 0x60, 0xF6,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x76, 0x0F, 0x79, 0xB3, 0xF3, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x68, 0x0E, 0xFF, 0xC3, 0xF0, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x78, 0xDF, 0xCD,
  0x06, 0xE0, 0x6E, 0x02, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30,
  0xDD, 0x00, 0x12, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x18, 0x70, 0x80,
  0x00, 0x01, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x6F, 0xBC, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0xC0, 0xD8, 0x33, 0x0C,
  0x61, 0x8C, 0x61, 0x98, 0x33, 0x06, 0xE0, 0xF6, 0x1C, 0xC3, 0x0C, 0x61,
  0x8C, 0x19, 0x83, 0x30, 0x36, 0x06, 0xC0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC7, 0x07, 0x9B, 0xF9, 0xFB, 0x43, 0x41, 0xF0, 0x38,
  0x3E, 0x06, 0x07, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x04, 0xC7, 0x8D,
  0xFC, 0xD0, 0x6E, 0x06, 0xE0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x0F, 0x03, 0xFC, 0x60, 0xC6, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x66,
  0x06, 0x31, 0xC1, 0xF8, 0xC7, 0x86, 0x7E, 0x34, 0x19, 0xC0, 0x6E, 0x03,
  0x70, 0x1B, 0x00, 0x58, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x2C,
  0x03, 0x70, 0x1B, 0x80, 0xDE, 0x0C, 0xD8, 0xE6, 0x7E, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x1E,
  0x33, 0xFB, 0x60, 0xF6, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x76, 0x0F, 0x79,
  0xB3, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0xC7, 0xCF, 0xD8, 0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x0F, 0xF6, 0x0B,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x30, 0x0E, 0x03, 0xE3, 0x9F, 0xC0, 0x20, 0x40, 0x81, 0x07, 0xFF,
  0xC8, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x83, 0x23, 0xC0, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xD0, 0x1B,
  0x05, 0x71, 0xA7, 0xE4, 0xC0, 0x3C, 0x03, 0x60, 0x36, 0x06, 0x60, 0x62,
  0x06, 0x30, 0x43, 0x0C, 0x30, 0xC1, 0x0C, 0x18, 0x81, 0x98, 0x09, 0x80,
  0xD0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0xC0, 0x60, 0x34, 0x06, 0x03,
  0x60, 0x70, 0x26, 0x0F, 0x06, 0x60, 0xD0, 0x62, 0x0D, 0x06, 0x30, 0x98,
  0x43, 0x19, 0x8C, 0x31, 0x98, 0xC3, 0x18, 0x8C, 0x19, 0x0C, 0x81, 0xB0,
  0xC8, 0x1B, 0x0D, 0x81, 0xB0, 0x58, 0x0A, 0x05, 0x80, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x30, 0xC0, 0x78, 0x0D, 0x83, 0x10, 0x63, 0x18, 0x22,
  0x06, 0xC0, 0x50, 0x0E, 0x01, 0xC0, 0x38, 0x0D, 0x83, 0x10, 0x63, 0x18,
  0x23, 0x06, 0xC0, 0x78, 0x0C, 0xC0, 0x14, 0x03, 0x60, 0x36, 0x03, 0x20,
  0x63, 0x06, 0x30, 0x63, 0x04, 0x10, 0xC1, 0x8C, 0x18, 0x80, 0x98, 0x0D,
  0x80, 0xD8, 0x0D, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0x7F, 0xBF, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x01,
  0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x83, 0xC3, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC3, 0xC1, 0xE0, 0x18,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x78, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x0E, 0x0F, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x07, 0x0F, 0x00, 0x7E, 0x0E, 0x3F, 0xE0,
  0x7C,
};

const GFXglyph NotoSans_Condensed_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 24, 7, 2, -24 },
  { 10, 7, 9, 11, 2, -24 },
  { 18, 15, 24, 17, 1, -24 },
  { 63, 13, 27, 15, 1, -25 },
  { 107, 19, 24, 22, 2, -24 },
  { 164, 16, 24, 17, 1, -24 },
  { 212, 2, 9, 6, 2, -24 },
  { 215, 6, 29, 9, 2, -24 },
  { 237, 7, 29, 9, 1, -24 },
  { 263, 11, 11, 14, 1, -25 },
  { 279, 13, 15, 15, 1, -19 },
  { 304, 4, 8, 7, 1, -4 },
  { 308, 7, 2, 9, 1, -10 },
  { 310, 3, 3, 7, 2, -3 },
  { 312, 10, 24, 12, 1, -24 },
  { 342, 12, 24, 15, 2, -24 },
  { 378, 7, 24, 15, 3, -24 },
  { 399, 12, 24, 15, 1, -24 },
  { 435, 12, 24, 15, 1, -24 },
  { 471, 14, 24, 15, 1, -24 },
  { 513, 12, 24, 15, 2, -24 },
  { 549, 12, 24, 15, 2, -24 },
  { 585, 13, 24, 15, 1, -24 },
  { 624, 13, 24, 15, 1, -24 },
  { 663, 12, 24, 15, 1, -24 },
  { 699, 3, 18, 7, 2, -18 },
  { 706, 4, 22, 7, 1, -18 },
  { 717, 13, 15, 15, 1, -19 },
  { 742, 13, 9, 15, 1, -16 },
  { 757, 13, 15, 15, 1, -19 },
  { 782, 9, 24, 11, 1, -24 },
  { 809, 20, 27, 23, 2, -24 },
  { 877, 16, 24, 16, 0, -24 },
  { 925, 12, 24, 17, 3, -24 },
  { 961, 13, 24, 16, 2, -24 },
  { 1000, 14, 24, 18, 3, -24 },
  { 1042, 10, 24, 15, 3, -24 },
  { 1072, 10, 24, 13, 3, -24 },
  { 1102, 15, 24, 19, 2, -24 },
  { 1147, 13, 24, 19, 3, -24 },
  { 1186, 7, 24, 9, 1, -24 },
  { 1207, 7, 30, 7, -2, -24 },
  { 1234, 12, 24, 15, 3, -24 },
  { 1270, 10, 24, 13, 3, -24 },
  { 1300, 19, 24, 24, 3, -24 },
  { 1357, 14, 24, 20, 3, -24 },
  { 1399, 16, 24, 20, 2, -24 },
  { 1447, 11, 24, 16, 3, -24 },
  { 1480, 16, 30, 20, 2, -24 },
  { 1540, 12, 24, 16, 3, -24 },
  { 1576, 12, 24, 15, 1, -24 },
  { 1612, 13, 24, 14, 0, -24 },
  { 1651, 13, 24, 19, 3, -24 },
  { 1690, 15, 24, 15, 0, -24 },
  { 1735, 24, 24, 25, 0, -24 },
  { 1807, 14, 24, 14, 0, -24 },
  { 1849, 13, 24, 13, 0, -24 },
  { 1888, 12, 24, 14, 1, -24 },
  { 1924, 6, 29, 10, 3, -24 },
  { 1946, 10, 24, 11, 1, -24 },
  { 1976, 7, 29, 10, 1, -24 },
  { 2002, 14, 13, 15, 1, -24 },
  { 2025, 14, 1, 14, 0, 3 },
  { 2027, 6, 5, 8, 1, -25 },
  { 2031, 11, 18, 14, 1, -18 },
  { 2056, 13, 25, 16, 2, -25 },
  { 2097, 10, 18, 12, 2, -18 },
  { 2120, 12, 25, 16, 2, -25 },
  { 2158, 11, 18, 15, 2, -18 },
  { 2183, 10, 25, 8, 0, -25 },
  { 2215, 12, 26, 16, 2, -18 },
  { 2254, 12, 25, 16, 2, -25 },
  { 2292, 3, 24, 7, 2, -24 },
  { 2301, 6, 32, 7, -1, -24 },
  { 2325, 11, 25, 13, 2, -25 },
  { 2360, 2, 25, 7, 2, -25 },
  { 2367, 19, 18, 24, 2, -18 },
  { 2410, 12, 18, 16, 2, -18 },
  { 2437, 12, 18, 16, 2, -18 },
  { 2464, 13, 26, 16, 2, -18 },
  { 2507, 12, 26, 16, 2, -18 },
  { 2546, 8, 18, 10, 2, -18 },
  { 2564, 10, 18, 12, 1, -18 },
  { 2587, 7, 22, 9, 1, -22 },
  { 2607, 11, 18, 16, 2, -18 },
  { 2632, 12, 18, 12, 0, -18 },
  { 2659, 20, 18, 20, 0, -18 },
  { 2704, 11, 18, 13, 1, -18 },
  { 2729, 12, 26, 13, 0, -18 },
  { 2768, 9, 18, 11, 1, -18 },
  { 2789, 9, 29, 12, 1, -24 },
  { 2822, 2, 33, 14, 6, -25 },
  { 2831, 9, 29, 12, 1, -24 },
  { 2864, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Light33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_LIGHT33PT7B_H_
