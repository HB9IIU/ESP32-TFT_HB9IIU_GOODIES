#ifndef _NOTOSANS_CONDENSED_LIGHT13PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x2B, 0xF4, 0x94, 0x50,
  0x4F, 0xCC, 0xC2, 0x55, 0xD6, 0x40, 0xED, 0x52, 0xA5, 0xAB, 0xAD, 0x4A,
  0x95, 0x4E, 0x70, 0x91, 0x21, 0x86, 0x0A, 0xA3, 0x46, 0x76, 0xE0, 0x6A,
  0xAA, 0xA4, 0xC8, 0x92, 0x49, 0x2B, 0x00, 0x4D, 0x6A, 0x20, 0x82, 0x3F,
  0x20, 0x80, 0x58, 0xE0, 0x80, 0x11, 0x22, 0x24, 0x44, 0x80, 0xF9, 0x99,
  0x99, 0x99, 0x60, 0x74, 0x92, 0x49, 0x20, 0xF1, 0x11, 0x22, 0x48, 0xF0,
  0xF1, 0x11, 0x61, 0x11, 0xE0, 0x18, 0x62, 0x8A, 0x4A, 0x2F, 0xC2, 0x08,
  0xF8, 0x8E, 0x11, 0x11, 0xE0, 0x78, 0x8E, 0x99, 0x99, 0x70, 0xF1, 0x12,
  0x22, 0x44, 0x40, 0xF9, 0x96, 0x69, 0x99, 0xF0, 0xF9, 0x99, 0x97, 0x11,
  0xE0, 0x82, 0x40, 0x05, 0x80, 0x04, 0x62, 0x30, 0x30, 0x30, 0xFC, 0x0F,
  0xC0, 0x81, 0x81, 0x03, 0x33, 0x00, 0xF1, 0x11, 0x24, 0x40, 0x40, 0x7C,
  0x82, 0x9A, 0xA9, 0xA9, 0xA9, 0xAA, 0x94, 0x80, 0x78, 0x30, 0xC3, 0x12,
  0x49, 0xE4, 0x61, 0x84, 0xF4, 0x63, 0x2F, 0x46, 0x31, 0xF0, 0x7C, 0x21,
  0x08, 0x42, 0x10, 0x78, 0xF2, 0x28, 0xA1, 0x86, 0x18, 0xA2, 0xF0, 0xF8,
  0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0x80, 0x7E, 0x08, 0x20,
  0x9E, 0x18, 0x61, 0x7C, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xEA, 0xAA,
  0xC0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x9C, 0xA9, 0x8E, 0x52, 0x52, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xF0, 0x83, 0xC3, 0xC5, 0xA5, 0xA5, 0xA9, 0xA9,
  0x99, 0x91, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x84, 0x7A, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x80, 0x7A, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x78, 0x40, 0x80, 0xF4, 0x63, 0x2F, 0x52, 0x52,
  0x88, 0xF8, 0x88, 0x61, 0x11, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x86, 0x14, 0x92, 0x49, 0x43, 0x0C,
  0x20, 0x88, 0x63, 0x24, 0xC9, 0x52, 0x54, 0x94, 0xC3, 0x30, 0x8C, 0x21,
  0x00, 0xCA, 0x54, 0x62, 0x19, 0x49, 0x88, 0x8A, 0x54, 0xA2, 0x10, 0x84,
  0x20, 0x78, 0x84, 0x22, 0x11, 0x08, 0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80,
  0x84, 0x44, 0x22, 0x11, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x30, 0xC4,
  0x92, 0x84, 0xF8, 0xB0, 0x70, 0x42, 0xF8, 0xC5, 0xE0, 0x84, 0x21, 0xE8,
  0xC6, 0x31, 0x8F, 0x80, 0x78, 0x88, 0x88, 0x70, 0x11, 0x17, 0x99, 0x99,
  0x9F, 0x69, 0x9F, 0x88, 0x70, 0x34, 0x4E, 0x44, 0x44, 0x44, 0x79, 0x99,
  0x99, 0xF1, 0x1F, 0x88, 0x8F, 0x99, 0x99, 0x99, 0xDF, 0xC0, 0x51, 0x55,
  0x55, 0x80, 0x88, 0x89, 0xAC, 0xCA, 0xA9, 0xFF, 0xC0, 0xFF, 0x26, 0x4C,
  0x99, 0x32, 0x64, 0x80, 0xF9, 0x99, 0x99, 0x90, 0x74, 0xA3, 0x18, 0xC9,
  0xC0, 0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x00, 0x79, 0x99, 0x99, 0xF1,
  0x11, 0xF2, 0x49, 0x20, 0x78, 0x42, 0x11, 0xF0, 0x4B, 0xA4, 0x92, 0x60,
  0x99, 0x99, 0x99, 0xF0, 0x8C, 0x54, 0xA5, 0x30, 0x80, 0x91, 0x99, 0x5A,
  0x5A, 0x66, 0x66, 0x24, 0x8A, 0x94, 0x45, 0x2A, 0x20, 0x8C, 0x54, 0xA5,
  0x10, 0x84, 0x26, 0x00, 0x71, 0x22, 0x44, 0xF0, 0x69, 0x25, 0x12, 0x49,
  0x80, 0xFF, 0xF8, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_Light13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 4, 1, -9 },
  { 5, 6, 9, 7, 0, -9 },
  { 12, 4, 11, 6, 1, -10 },
  { 18, 7, 9, 9, 1, -9 },
  { 26, 7, 9, 7, 0, -9 },
  { 34, 1, 3, 2, 1, -9 },
  { 35, 2, 11, 4, 1, -9 },
  { 38, 3, 11, 4, 0, -9 },
  { 43, 4, 4, 6, 1, -10 },
  { 45, 6, 6, 6, 0, -8 },
  { 50, 2, 3, 3, 0, -1 },
  { 51, 3, 1, 4, 0, -4 },
  { 52, 1, 1, 3, 1, -1 },
  { 53, 4, 9, 5, 0, -9 },
  { 58, 4, 9, 6, 1, -9 },
  { 63, 3, 9, 6, 1, -9 },
  { 67, 4, 9, 6, 1, -9 },
  { 72, 4, 9, 6, 1, -9 },
  { 77, 6, 9, 6, 0, -9 },
  { 84, 4, 9, 6, 1, -9 },
  { 89, 4, 9, 6, 1, -9 },
  { 94, 4, 9, 6, 1, -9 },
  { 99, 4, 9, 6, 1, -9 },
  { 104, 4, 9, 6, 1, -9 },
  { 109, 1, 7, 3, 1, -7 },
  { 110, 2, 9, 3, 0, -7 },
  { 113, 6, 6, 6, 0, -8 },
  { 118, 6, 3, 6, 0, -6 },
  { 121, 6, 6, 6, 0, -8 },
  { 126, 4, 9, 4, 0, -9 },
  { 131, 8, 10, 9, 1, -9 },
  { 141, 6, 9, 6, 0, -9 },
  { 148, 5, 9, 7, 1, -9 },
  { 154, 5, 9, 6, 1, -9 },
  { 160, 6, 9, 7, 1, -9 },
  { 167, 4, 9, 6, 1, -9 },
  { 172, 4, 9, 5, 1, -9 },
  { 177, 6, 9, 8, 1, -9 },
  { 184, 5, 9, 7, 1, -9 },
  { 190, 2, 9, 4, 1, -9 },
  { 193, 3, 11, 3, -1, -9 },
  { 198, 5, 9, 6, 1, -9 },
  { 204, 4, 9, 5, 1, -9 },
  { 209, 8, 9, 10, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 5, 9, 6, 1, -9 },
  { 238, 6, 11, 8, 1, -9 },
  { 247, 5, 9, 6, 1, -9 },
  { 253, 4, 9, 6, 1, -9 },
  { 258, 5, 9, 5, 0, -9 },
  { 264, 5, 9, 7, 1, -9 },
  { 270, 6, 9, 6, 0, -9 },
  { 277, 10, 9, 10, 0, -9 },
  { 289, 5, 9, 5, 0, -9 },
  { 295, 5, 9, 5, 0, -9 },
  { 301, 5, 9, 5, 0, -9 },
  { 307, 3, 11, 4, 1, -9 },
  { 312, 4, 9, 5, 0, -9 },
  { 317, 3, 11, 4, 0, -9 },
  { 322, 6, 5, 6, 0, -9 },
  { 326, 5, 1, 5, 0, 1 },
  { 327, 2, 2, 3, 1, -10 },
  { 328, 5, 7, 6, 0, -7 },
  { 333, 5, 10, 6, 1, -10 },
  { 340, 4, 7, 5, 1, -7 },
  { 344, 4, 10, 6, 1, -10 },
  { 349, 4, 7, 6, 1, -7 },
  { 353, 4, 10, 3, 0, -10 },
  { 358, 4, 10, 6, 1, -7 },
  { 363, 4, 10, 6, 1, -10 },
  { 368, 1, 10, 3, 1, -10 },
  { 370, 2, 13, 3, 0, -10 },
  { 374, 4, 10, 5, 1, -10 },
  { 379, 1, 10, 3, 1, -10 },
  { 381, 7, 7, 9, 1, -7 },
  { 388, 4, 7, 6, 1, -7 },
  { 392, 5, 7, 6, 1, -7 },
  { 397, 5, 10, 6, 1, -7 },
  { 404, 4, 10, 6, 1, -7 },
  { 409, 3, 7, 4, 1, -7 },
  { 412, 4, 7, 5, 0, -7 },
  { 416, 3, 9, 3, 0, -9 },
  { 420, 4, 7, 6, 1, -7 },
  { 424, 5, 7, 5, 0, -7 },
  { 429, 8, 7, 8, 0, -7 },
  { 436, 5, 7, 5, 0, -7 },
  { 441, 5, 10, 5, 0, -7 },
  { 448, 4, 7, 4, 0, -7 },
  { 452, 3, 11, 5, 1, -9 },
  { 457, 1, 13, 6, 2, -10 },
  { 459, 3, 11, 5, 1, -9 },
  { 464, 6, 1, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Light13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_LIGHT13PT7B_H_
