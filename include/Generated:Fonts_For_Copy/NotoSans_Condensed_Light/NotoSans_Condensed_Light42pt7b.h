#ifndef _NOTOSANS_CONDENSED_LIGHT42PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x01, 0xFF,
  0xC0, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0x60,
  0xB0, 0x40, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x04, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x0F,
  0xFF, 0xFD, 0xFF, 0xFF, 0x83, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x00, 0x81, 0x80, 0x30, 0x30, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x08,
  0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0x83, 0xFF, 0xCF,
  0x23, 0x98, 0x40, 0x70, 0x80, 0xC1, 0x01, 0x82, 0x03, 0x04, 0x06, 0x08,
  0x0E, 0x10, 0x0C, 0x20, 0x1E, 0x40, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x05, 0xE0, 0x08, 0xE0, 0x10, 0xE0, 0x20, 0xC0, 0x41, 0x80, 0x83, 0x01,
  0x06, 0x02, 0x0C, 0x04, 0x3C, 0x08, 0xEF, 0xDF, 0x8F, 0xFE, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x3E, 0x00, 0x60, 0x3B, 0x80, 0x30,
  0x18, 0x60, 0x30, 0x0C, 0x30, 0x18, 0x0C, 0x18, 0x18, 0x06, 0x06, 0x0C,
  0x03, 0x03, 0x06, 0x01, 0x81, 0x86, 0x00, 0xC0, 0xC3, 0x00, 0x60, 0x63,
  0x00, 0x30, 0x31, 0x80, 0x18, 0x18, 0xC0, 0x0C, 0x0C, 0xC7, 0xC6, 0x0C,
  0x67, 0x71, 0x86, 0x63, 0x18, 0xC3, 0x33, 0x06, 0x7F, 0x19, 0x83, 0x1F,
  0x18, 0xC1, 0x80, 0x0C, 0x60, 0xC0, 0x0C, 0x30, 0x60, 0x06, 0x18, 0x38,
  0x03, 0x0C, 0x18, 0x03, 0x06, 0x0C, 0x01, 0x83, 0x06, 0x01, 0x81, 0x83,
  0x00, 0xC0, 0xC1, 0x80, 0x60, 0x60, 0xC0, 0x60, 0x18, 0xC0, 0x30, 0x0E,
  0xE0, 0x30, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x18, 0x30, 0x03,
  0x83, 0x00, 0x30, 0x38, 0x03, 0x03, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00,
  0x38, 0x30, 0x01, 0x83, 0x00, 0x1C, 0x60, 0x00, 0xCE, 0x00, 0x0F, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0xC7, 0x0C,
  0x0C, 0xE0, 0x60, 0xCC, 0x07, 0x0C, 0xC0, 0x39, 0xCC, 0x01, 0x98, 0xC0,
  0x1F, 0x8C, 0x00, 0xF0, 0xC0, 0x07, 0x0C, 0x00, 0xF0, 0xE0, 0x1F, 0x87,
  0x03, 0x9C, 0x3F, 0xF0, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x0E, 0x0E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x83, 0x07, 0xCC, 0xFF, 0xFF, 0xC3, 0xE0, 0x07, 0x80, 0x36, 0x01, 0xCC,
  0x06, 0x18, 0x38, 0x70, 0x40, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x37, 0x77,
  0x66, 0x6E, 0xCC, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x3F,
  0xE0, 0xE0, 0xE1, 0x80, 0xC7, 0x01, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xD8, 0x03, 0xB0, 0x06, 0x70, 0x0C, 0xE0, 0x38, 0xE0, 0x61,
  0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0x83, 0xC3, 0xE3, 0xB3, 0x9B,
  0x8F, 0x86, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x1F, 0xE0, 0xFF, 0xE3, 0x80, 0xE2, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0xFF, 0xE3, 0x80, 0xE2, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x76, 0x01, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18,
  0x30, 0x0E, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x0C,
  0x0C, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x0C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x08, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x76, 0x03, 0xCF, 0xFF,
  0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x0E, 0x0E, 0x7F, 0x19, 0xCF, 0x36, 0x07, 0x78, 0x06, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xD8, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xE0, 0x1C, 0xC0, 0x31, 0xC0, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x3F,
  0xF8, 0x38, 0x1C, 0x70, 0x0C, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0E, 0x60,
  0x0E, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x38, 0x1E, 0x70, 0x07,
  0xE0, 0x07, 0xC0, 0x0E, 0xF0, 0x38, 0x78, 0x70, 0x1C, 0x60, 0x0C, 0xE0,
  0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xE0,
  0x06, 0x60, 0x0E, 0x70, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F,
  0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xD8,
  0x07, 0xB8, 0x1B, 0x3C, 0xF6, 0x3F, 0xCC, 0x1E, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x5F, 0xF4, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x27, 0x77, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x37, 0x77, 0x66, 0x6C, 0xCC, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x7F, 0x8F, 0xFC, 0xC0, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x30, 0xC0,
  0x00, 0x0C, 0x30, 0x0F, 0x03, 0x9C, 0x0F, 0xF0, 0x66, 0x07, 0x0C, 0x19,
  0x83, 0x83, 0x06, 0x60, 0xC0, 0xC1, 0xB8, 0x30, 0x30, 0x6C, 0x18, 0x0C,
  0x0F, 0x06, 0x03, 0x03, 0xC1, 0x80, 0xC1, 0xF0, 0x60, 0x30, 0x6C, 0x18,
  0x1C, 0x1B, 0x06, 0x07, 0x06, 0xC1, 0x81, 0xC1, 0xB0, 0x30, 0x70, 0x66,
  0x0C, 0x34, 0x31, 0x83, 0xF9, 0xFC, 0x60, 0x7C, 0x3E, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x02, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xB8, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x39, 0x80, 0x03,
  0x1C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x0E, 0x06, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x18, 0x01, 0x83, 0x80, 0x18, 0x38, 0x01,
  0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x3C,
  0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x1C, 0xFF, 0xF8, 0xFF, 0xF0,
  0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xC0,
  0x63, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x10, 0x7F, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0,
  0x3F, 0xFE, 0x0E, 0x07, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xCE,
  0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E,
  0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x81,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x07, 0x80, 0x60, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x37, 0x00, 0x03, 0x70, 0x00, 0x33, 0x00, 0x03, 0x38, 0x00, 0x31, 0xC0,
  0x03, 0x1E, 0x00, 0x30, 0xF0, 0x07, 0x03, 0xFF, 0xF0, 0x1F, 0xFC, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xFE,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06,
  0xFE, 0xFC, 0x70, 0xE0, 0x07, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x03, 0x8E,
  0x03, 0x87, 0x01, 0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0,
  0x38, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xBC, 0x01, 0xF7,
  0x00, 0xF3, 0x80, 0x78, 0xE0, 0x38, 0x30, 0x1C, 0x1C, 0x0E, 0x06, 0x07,
  0x03, 0x83, 0x80, 0xC1, 0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x03,
  0x9C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xB0, 0x00, 0x6F, 0xD8, 0x00, 0x37, 0xEE, 0x00, 0x3B,
  0xF3, 0x00, 0x19, 0xF9, 0x80, 0x0C, 0xFC, 0xE0, 0x0E, 0x7E, 0x30, 0x06,
  0x3F, 0x18, 0x03, 0x1F, 0x8E, 0x01, 0x8F, 0xC3, 0x01, 0x87, 0xE1, 0x80,
  0xC3, 0xF0, 0xE0, 0x61, 0xF8, 0x30, 0x60, 0xFC, 0x18, 0x30, 0x7E, 0x0E,
  0x18, 0x3F, 0x03, 0x18, 0x1F, 0x81, 0x8C, 0x0F, 0xC0, 0xE6, 0x07, 0xE0,
  0x36, 0x03, 0xF0, 0x1B, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x03, 0x80, 0x7E,
  0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1C, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xD8, 0x01, 0xFB, 0x00, 0x3F, 0x30,
  0x07, 0xE6, 0x00, 0xFC, 0x60, 0x1F, 0x8E, 0x03, 0xF0, 0xC0, 0x7E, 0x1C,
  0x0F, 0xC1, 0x81, 0xF8, 0x38, 0x3F, 0x03, 0x07, 0xE0, 0x70, 0xFC, 0x06,
  0x1F, 0x80, 0xE3, 0xF0, 0x0C, 0x7E, 0x01, 0xCF, 0xC0, 0x19, 0xF8, 0x03,
  0xBF, 0x00, 0x37, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03,
  0x80, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x31, 0xC0, 0x01,
  0xCE, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00,
  0x03, 0xB0, 0x00, 0x19, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x38, 0x00, 0x61,
  0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0x81, 0xE7, 0x00, 0xEE, 0x00, 0xDC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xB8, 0x0F, 0x70, 0xFC, 0xFF, 0xE1, 0xFE, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0x80, 0xF0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x1C,
  0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01,
  0xD8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x19, 0xC0, 0x00, 0xC6, 0x00,
  0x0E, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x38, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x38, 0x01, 0x9C,
  0x01, 0xCE, 0x00, 0xC7, 0x00, 0xE3, 0x81, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x70, 0x60, 0x38, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x07, 0x01, 0x83, 0x80,
  0xE1, 0xC0, 0x30, 0xE0, 0x1C, 0x70, 0x06, 0x38, 0x03, 0x9C, 0x00, 0xCE,
  0x00, 0x77, 0x00, 0x1C, 0x0F, 0xF8, 0x7F, 0xF8, 0xE0, 0x33, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x76, 0x01, 0xCF, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0x60,
  0x01, 0x9C, 0x00, 0xE7, 0x00, 0x30, 0xF0, 0x3C, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x67, 0x00,
  0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x03, 0x83, 0x00,
  0x70, 0x60, 0x0C, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x70, 0x30, 0x06, 0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x8E,
  0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x1D, 0xC0, 0x01, 0xB0,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0xC0, 0x07, 0x00, 0x1D, 0x80, 0x0E, 0x00,
  0x33, 0x80, 0x1E, 0x00, 0x67, 0x00, 0x3C, 0x00, 0xC6, 0x00, 0xD8, 0x03,
  0x8C, 0x01, 0xB0, 0x07, 0x1C, 0x03, 0x60, 0x0C, 0x38, 0x06, 0x60, 0x18,
  0x30, 0x1C, 0xC0, 0x70, 0x60, 0x31, 0x80, 0xE0, 0xC0, 0x63, 0x01, 0x81,
  0xC0, 0xC7, 0x03, 0x03, 0x83, 0x86, 0x06, 0x03, 0x06, 0x0C, 0x1C, 0x06,
  0x0C, 0x18, 0x30, 0x0E, 0x18, 0x38, 0x60, 0x1C, 0x30, 0x30, 0xC0, 0x18,
  0xE0, 0x63, 0x80, 0x31, 0x80, 0xC7, 0x00, 0x63, 0x01, 0x8C, 0x00, 0xE6,
  0x01, 0x98, 0x00, 0xDC, 0x03, 0x70, 0x01, 0xB0, 0x06, 0xE0, 0x03, 0x60,
  0x0D, 0x80, 0x06, 0xC0, 0x1B, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x98, 0x01, 0x8E, 0x01, 0xC3, 0x00, 0xE1, 0xC0, 0x60, 0x60, 0x70, 0x38,
  0x30, 0x0C, 0x38, 0x06, 0x18, 0x03, 0x9C, 0x00, 0xCC, 0x00, 0x7E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0xCC, 0x00, 0xE7, 0x00, 0x61, 0x80, 0x70, 0xE0, 0x30, 0x30, 0x38,
  0x18, 0x18, 0x0E, 0x1C, 0x03, 0x0C, 0x01, 0xCE, 0x00, 0x66, 0x00, 0x3F,
  0x00, 0x0C, 0xE0, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xCE, 0x00, 0xE3, 0x00,
  0x61, 0xC0, 0x30, 0x60, 0x38, 0x30, 0x18, 0x1C, 0x1C, 0x06, 0x0C, 0x03,
  0x86, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x3B, 0x80, 0x0D, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xF8, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0xFF, 0xFF,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x7F, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0D,
  0x80, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x0C,
  0x07, 0x03, 0x01, 0x80, 0xE0, 0xE0, 0x18, 0x30, 0x07, 0x1C, 0x00, 0xC6,
  0x00, 0x3B, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xC1, 0xC1,
  0xC1, 0xC1, 0x81, 0x80, 0x07, 0x83, 0xFF, 0x0E, 0x1C, 0x40, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC1, 0xFE, 0x3F, 0xF7,
  0x81, 0xB0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7E, 0x07, 0xBF, 0xEC, 0xFE, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC1, 0xC0, 0xCF, 0xF0, 0xCE, 0x78, 0xD8, 0x1C, 0xF0, 0x0C, 0xE0, 0x0E,
  0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E,
  0xE0, 0x0E, 0xF0, 0x0C, 0xD8, 0x1C, 0xCF, 0xF8, 0xC7, 0xF0, 0x01, 0xE0,
  0x7F, 0xC7, 0x8C, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x8F, 0xFC, 0x3F, 0xC0,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0x87, 0x0F, 0xE7, 0x3C, 0x77,
  0x38, 0x1F, 0x70, 0x0F, 0x60, 0x0F, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x0F, 0x70, 0x0F, 0x38, 0x1F,
  0x1F, 0xF3, 0x0F, 0xE3, 0x03, 0x80, 0x1F, 0xE0, 0x71, 0xE1, 0xC0, 0xC7,
  0x01, 0xCC, 0x01, 0x98, 0x03, 0x70, 0x06, 0xE0, 0x0F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x43, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0xFF, 0xCF, 0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x03, 0x80, 0x3F, 0xCC, 0xF9, 0xD9, 0xC0, 0xF7, 0x00, 0xEC, 0x01, 0xD8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x3B,
  0x80, 0x73, 0x81, 0xE3, 0xFE, 0xC3, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x98, 0x0F, 0x3F, 0xFC,
  0x1F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0F, 0x0C, 0xFF, 0x37, 0x1E, 0xD8,
  0x1B, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x5F, 0xF0,
  0x00, 0x1B, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x04, 0x1C,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x7C, 0xF0, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x03, 0xB0, 0x1C, 0xC0, 0x63, 0x03, 0x0C, 0x1C,
  0x30, 0xE0, 0xC3, 0x03, 0x18, 0x0C, 0xE0, 0x33, 0x80, 0xDF, 0x03, 0xCC,
  0x0E, 0x38, 0x38, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x0E, 0x30, 0x18, 0xC0,
  0x73, 0x00, 0xCC, 0x03, 0xB0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x78, 0xCF, 0xE1, 0xFC, 0xDC, 0x73, 0x9E, 0xD0,
  0x3E, 0x07, 0xF0, 0x3C, 0x07, 0xE0, 0x1C, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0x03,
  0xC3, 0x3F, 0xCD, 0xC7, 0xB6, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xC0, 0x03, 0xC0, 0x0F, 0xF0, 0x1C, 0x78, 0x38, 0x1C,
  0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x1F, 0xF8,
  0x0F, 0xF0, 0x03, 0xC0, 0xC7, 0xF0, 0xCC, 0x78, 0xD8, 0x1C, 0xF0, 0x0C,
  0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x0E, 0xE0, 0x0E, 0xD0, 0x0C, 0xD8, 0x1C, 0xCF, 0xF8, 0xC7, 0xF0,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xCC,
  0x71, 0xD9, 0xC0, 0xF7, 0x00, 0xEC, 0x01, 0xD8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x80, 0x73, 0x81, 0x63,
  0xFE, 0xC3, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x03, 0xB1,
  0xFC, 0xFF, 0x60, 0xD0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x00, 0x07, 0x03, 0xFF, 0x70, 0xEE, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x80, 0xEF, 0xFC,
  0xFF, 0x80, 0x10, 0x08, 0x04, 0x06, 0x03, 0x01, 0x83, 0xFF, 0xFF, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0xE1, 0xF0, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xDC, 0x1B, 0x7F, 0xCC, 0x7E,
  0x30, 0xE0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x1C, 0x38, 0x18, 0x18, 0x18, 0x18, 0x38, 0x18, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x1C, 0x01,
  0xB0, 0x0F, 0x00, 0xD8, 0x07, 0x80, 0xEE, 0x03, 0xC0, 0x63, 0x01, 0xE0,
  0x31, 0x81, 0x98, 0x18, 0xC0, 0xCC, 0x1C, 0x70, 0x66, 0x0C, 0x18, 0x33,
  0x06, 0x0C, 0x31, 0xC3, 0x06, 0x18, 0x61, 0x83, 0x8C, 0x31, 0x81, 0xC6,
  0x18, 0xC0, 0x66, 0x0E, 0x60, 0x33, 0x03, 0x30, 0x19, 0x81, 0xB8, 0x0E,
  0xC0, 0xD8, 0x03, 0xC0, 0x6C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x00, 0x18, 0x03, 0x80, 0xE0, 0x1C, 0xE0, 0x30, 0xC0, 0xE1,
  0xC1, 0x81, 0x87, 0x03, 0x8C, 0x03, 0x38, 0x07, 0x60, 0x07, 0xC0, 0x0F,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xD8, 0x03, 0x38, 0x0E, 0x30,
  0x18, 0x70, 0x70, 0x60, 0xC0, 0xE3, 0x80, 0xC6, 0x01, 0xDC, 0x01, 0xC0,
  0xE0, 0x07, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C,
  0x38, 0x0C, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x30,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x7C, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x1F, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1F, 0x01, 0xF0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x1F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x7C, 0x03, 0x81, 0xE0, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x81, 0xF0, 0x7C, 0x0C, 0x00, 0x7E, 0x01, 0xFF, 0x83, 0xC3, 0xFF,
  0x80, 0xFE,
};

const GFXglyph NotoSans_Condensed_Light42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 30, 9, 3, -30 },
  { 13, 9, 11, 14, 3, -30 },
  { 26, 19, 30, 21, 1, -30 },
  { 98, 15, 34, 19, 2, -32 },
  { 162, 25, 30, 28, 2, -30 },
  { 256, 20, 30, 22, 2, -30 },
  { 331, 2, 11, 8, 3, -30 },
  { 334, 8, 37, 12, 2, -30 },
  { 371, 9, 37, 12, 1, -30 },
  { 413, 14, 14, 18, 2, -32 },
  { 438, 16, 20, 19, 2, -25 },
  { 478, 4, 10, 9, 2, -5 },
  { 483, 10, 2, 12, 1, -12 },
  { 486, 3, 4, 9, 3, -4 },
  { 488, 13, 30, 15, 1, -30 },
  { 537, 15, 30, 19, 2, -30 },
  { 594, 9, 30, 19, 3, -30 },
  { 628, 15, 30, 19, 2, -30 },
  { 685, 15, 30, 19, 2, -30 },
  { 742, 18, 30, 19, 1, -30 },
  { 810, 15, 30, 19, 2, -30 },
  { 867, 15, 30, 19, 2, -30 },
  { 924, 15, 30, 19, 2, -30 },
  { 981, 16, 30, 19, 2, -30 },
  { 1041, 15, 30, 19, 2, -30 },
  { 1098, 3, 23, 9, 3, -23 },
  { 1107, 4, 28, 9, 2, -23 },
  { 1121, 16, 18, 19, 2, -24 },
  { 1157, 16, 11, 19, 2, -20 },
  { 1179, 16, 18, 19, 2, -24 },
  { 1215, 12, 30, 14, 1, -30 },
  { 1260, 26, 34, 30, 2, -30 },
  { 1371, 20, 30, 20, 0, -30 },
  { 1446, 16, 30, 21, 3, -30 },
  { 1506, 17, 30, 21, 2, -30 },
  { 1570, 18, 30, 23, 3, -30 },
  { 1638, 13, 30, 18, 3, -30 },
  { 1687, 13, 30, 17, 3, -30 },
  { 1736, 20, 30, 25, 2, -30 },
  { 1811, 18, 30, 24, 3, -30 },
  { 1879, 8, 30, 11, 2, -30 },
  { 1909, 8, 38, 9, -2, -30 },
  { 1947, 17, 30, 20, 3, -30 },
  { 2011, 13, 30, 17, 3, -30 },
  { 2060, 25, 30, 31, 3, -30 },
  { 2154, 19, 30, 25, 3, -30 },
  { 2226, 21, 30, 25, 2, -30 },
  { 2305, 15, 30, 20, 3, -30 },
  { 2362, 21, 37, 25, 2, -30 },
  { 2460, 17, 30, 20, 3, -30 },
  { 2524, 15, 30, 19, 2, -30 },
  { 2581, 17, 30, 17, 0, -30 },
  { 2645, 18, 30, 24, 3, -30 },
  { 2713, 19, 30, 19, 0, -30 },
  { 2785, 31, 30, 31, 0, -30 },
  { 2902, 17, 30, 18, 0, -30 },
  { 2966, 17, 30, 17, 0, -30 },
  { 3030, 15, 30, 17, 1, -30 },
  { 3087, 9, 37, 13, 3, -30 },
  { 3129, 13, 30, 15, 1, -30 },
  { 3178, 9, 37, 13, 1, -30 },
  { 3220, 18, 16, 19, 1, -30 },
  { 3256, 18, 2, 17, 0, 4 },
  { 3261, 7, 7, 11, 2, -32 },
  { 3268, 13, 23, 18, 2, -23 },
  { 3306, 16, 32, 21, 3, -32 },
  { 3370, 13, 23, 16, 2, -23 },
  { 3408, 16, 32, 21, 2, -32 },
  { 3472, 15, 23, 19, 2, -23 },
  { 3516, 12, 32, 11, 0, -32 },
  { 3564, 15, 33, 21, 2, -23 },
  { 3626, 14, 32, 20, 3, -32 },
  { 3682, 3, 31, 9, 3, -31 },
  { 3694, 7, 41, 9, -1, -31 },
  { 3730, 14, 32, 17, 3, -32 },
  { 3786, 2, 32, 8, 3, -32 },
  { 3794, 24, 23, 30, 3, -23 },
  { 3863, 14, 23, 20, 3, -23 },
  { 3904, 16, 23, 20, 2, -23 },
  { 3950, 16, 33, 21, 3, -23 },
  { 4016, 15, 33, 21, 2, -23 },
  { 4078, 10, 23, 13, 3, -23 },
  { 4107, 12, 23, 15, 2, -23 },
  { 4142, 9, 28, 11, 1, -28 },
  { 4174, 14, 22, 20, 3, -22 },
  { 4213, 16, 22, 16, 0, -22 },
  { 4257, 25, 22, 26, 0, -22 },
  { 4326, 15, 22, 16, 1, -22 },
  { 4368, 16, 32, 16, 0, -22 },
  { 4432, 12, 22, 14, 1, -22 },
  { 4465, 11, 37, 15, 2, -30 },
  { 4516, 2, 42, 18, 8, -32 },
  { 4527, 11, 37, 15, 2, -30 },
  { 4578, 16, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_Light42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_LIGHT42PT7B_H_
