#ifndef _NOTOSANS_CONDENSED_LIGHT27PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x8E, 0x38, 0xA2, 0x8A, 0x28, 0x80,
  0x08, 0x40, 0x84, 0x08, 0xC0, 0x8C, 0x18, 0x8F, 0xFF, 0xFF, 0xF1, 0x08,
  0x10, 0x81, 0x08, 0x11, 0x83, 0x10, 0xFF, 0xE2, 0x10, 0x21, 0x02, 0x10,
  0x21, 0x02, 0x30, 0x62, 0x00, 0x04, 0x01, 0x00, 0xE0, 0xFE, 0x64, 0xB1,
  0x0C, 0x43, 0x10, 0xC4, 0x19, 0x03, 0xC0, 0x38, 0x07, 0x81, 0x30, 0x44,
  0x11, 0x04, 0x41, 0x3E, 0x79, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x78, 0x10, 0x44, 0x10, 0xC4, 0x30, 0xC4, 0x20, 0xC6, 0x60, 0xC6, 0x40,
  0xC6, 0x40, 0xC4, 0xCC, 0x44, 0x96, 0x45, 0xA3, 0x79, 0x21, 0x11, 0x21,
  0x03, 0x21, 0x02, 0x21, 0x06, 0x21, 0x04, 0x21, 0x04, 0x23, 0x0C, 0x32,
  0x08, 0x1E, 0x0C, 0x00, 0xF8, 0x0C, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x06, 0x60, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xCC, 0x24, 0x23, 0x61,
  0x9B, 0x06, 0x98, 0x1C, 0xC0, 0x46, 0x07, 0x18, 0xEC, 0x7C, 0x30, 0xFE,
  0x0C, 0x43, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x10,
  0x41, 0x86, 0x08, 0x30, 0x40, 0xC0, 0xC3, 0x08, 0x63, 0x08, 0x63, 0x18,
  0x42, 0x10, 0x84, 0x63, 0x18, 0x8C, 0x62, 0x33, 0x00, 0x08, 0x04, 0x02,
  0x11, 0x1F, 0xF8, 0x60, 0x50, 0x64, 0x63, 0x11, 0x00, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x00, 0x6D, 0xA5, 0xA0, 0xFC, 0xF0, 0x03, 0x02, 0x02, 0x06, 0x04,
  0x0C, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0xC0,
  0xC0, 0x80, 0x04, 0x07, 0xC3, 0x19, 0x82, 0x40, 0x90, 0x3C, 0x0F, 0x03,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x34, 0x0D, 0x03, 0x60, 0x98,
  0x63, 0x30, 0x7C, 0x0C, 0xF6, 0xF3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x0C, 0x1F, 0xCC, 0x18, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x03, 0xFF, 0x0C, 0x1F, 0xCC, 0x18, 0x02,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x0F, 0x83, 0xF0, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x2C, 0x3B, 0xFC, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x2C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0x8C, 0x10, 0xC3, 0x0C, 0x20,
  0xC6, 0x0C, 0x40, 0xCF, 0xFF, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x7F, 0x98, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x70, 0x7F,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x01, 0xB0, 0xE7,
  0xE0, 0x01, 0x03, 0xE1, 0x80, 0xC0, 0x60, 0x18, 0x04, 0x01, 0x00, 0x4F,
  0x34, 0xEE, 0x0F, 0x03, 0xC0, 0x70, 0x14, 0x05, 0x01, 0x40, 0xD8, 0x33,
  0x18, 0x7C, 0xFF, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04,
  0x03, 0x00, 0x04, 0x0F, 0xC6, 0x19, 0x03, 0x40, 0xD0, 0x34, 0x0D, 0x86,
  0x33, 0x07, 0x81, 0xE0, 0xC6, 0x60, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x50,
  0x36, 0x18, 0xFC, 0x08, 0x0F, 0xC6, 0x19, 0x02, 0xC0, 0xB0, 0x3C, 0x0F,
  0x03, 0xC0, 0xD0, 0x36, 0x1C, 0xFF, 0x1C, 0xC0, 0x30, 0x08, 0x02, 0x01,
  0x80, 0xC0, 0x71, 0xF0, 0xBC, 0x00, 0x00, 0x3C, 0x4D, 0x80, 0x00, 0x00,
  0x06, 0xDA, 0xDA, 0x00, 0x00, 0x40, 0x30, 0x38, 0x38, 0x18, 0x18, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x03, 0x00, 0x18, 0xFE, 0x43, 0x01, 0x01,
  0x01, 0x01, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00,
  0x00, 0x38, 0x18, 0x07, 0xF0, 0x06, 0x06, 0x06, 0x01, 0x86, 0x00, 0x42,
  0x00, 0x33, 0x0F, 0x89, 0x0C, 0x44, 0x8C, 0x63, 0x46, 0x31, 0xE2, 0x18,
  0xF1, 0x0C, 0x78, 0x86, 0x3C, 0x43, 0x12, 0x21, 0x89, 0x09, 0x4C, 0x87,
  0x1C, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x01, 0x00, 0xFF, 0x00,
  0x07, 0x00, 0x38, 0x01, 0x40, 0x1A, 0x00, 0xD8, 0x04, 0xC0, 0x22, 0x03,
  0x10, 0x10, 0xC0, 0x82, 0x0C, 0x10, 0x7F, 0xC2, 0x06, 0x10, 0x11, 0x80,
  0x8C, 0x06, 0x40, 0x36, 0x00, 0xB0, 0x06, 0xFF, 0x18, 0x33, 0x03, 0x60,
  0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xFF, 0x1F, 0xF3, 0x03, 0x60, 0x2C,
  0x05, 0x80, 0xF0, 0x16, 0x02, 0xC0, 0xD8, 0x73, 0xFC, 0x00, 0x01, 0x81,
  0xFC, 0x60, 0x98, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x70,
  0x87, 0xF0, 0xFF, 0x0C, 0x18, 0xC0, 0xCC, 0x06, 0xC0, 0x6C, 0x02, 0xC0,
  0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0,
  0x6C, 0x04, 0xC0, 0xCC, 0x38, 0xFE, 0x00, 0xFF, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xFF, 0x7F, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x3F, 0xE0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x7F, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x00, 0x00, 0x80, 0x7F, 0xC7, 0x02, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x3E, 0x81, 0xF4, 0x00,
  0xA0, 0x05, 0x80, 0x2C, 0x01, 0x30, 0x09, 0x80, 0x47, 0x06, 0x0F, 0xF0,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x80, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x3E, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x2B, 0xBC, 0xC0, 0xD8, 0x33,
  0x04, 0x61, 0x8C, 0x61, 0x88, 0x33, 0x06, 0xC0, 0xD8, 0x1D, 0x03, 0xB0,
  0x62, 0x0C, 0x61, 0x86, 0x30, 0xC6, 0x0C, 0xC0, 0x98, 0x1B, 0x01, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xD0, 0x0B, 0xD0, 0x0B, 0xD8, 0x1B, 0xC8, 0x13, 0xC8,
  0x13, 0xCC, 0x33, 0xCC, 0x23, 0xC4, 0x23, 0xC6, 0x63, 0xC6, 0x43, 0xC2,
  0x43, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x3E, 0x03,
  0xE0, 0x3F, 0x03, 0xD0, 0x3D, 0x83, 0xC8, 0x3C, 0xC3, 0xC4, 0x3C, 0x63,
  0xC2, 0x3C, 0x33, 0xC1, 0x3C, 0x1B, 0xC0, 0xBC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x30, 0x01, 0x00, 0x3F, 0x81, 0x83, 0x0C, 0x04, 0x60, 0x19, 0x80,
  0x24, 0x00, 0x90, 0x03, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40,
  0x0D, 0x00, 0x34, 0x00, 0x98, 0x06, 0x20, 0x18, 0xC0, 0xC1, 0x86, 0x03,
  0xF0, 0xFE, 0x30, 0xEC, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x02, 0xC1,
  0xB1, 0xCF, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x01, 0x00, 0x3F, 0x81, 0x83, 0x0C, 0x04, 0x60, 0x19, 0x80, 0x24,
  0x00, 0x90, 0x03, 0x40, 0x0F, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x40, 0x0D,
  0x00, 0x34, 0x00, 0x98, 0x06, 0x20, 0x18, 0xC0, 0xC1, 0x86, 0x03, 0xF0,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0xFF, 0x18, 0x73,
  0x06, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x04, 0xC1, 0x9F, 0xE3, 0xF0,
  0x63, 0x0C, 0x21, 0x86, 0x30, 0x46, 0x0C, 0xC0, 0x98, 0x1B, 0x01, 0x80,
  0x04, 0x0F, 0xF6, 0x09, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x2C, 0x3B,
  0xF8, 0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0x60, 0x6E, 0x18, 0xFE, 0x00, 0xC0, 0x1C, 0x03, 0x40, 0x36,
  0x02, 0x60, 0x62, 0x06, 0x20, 0x43, 0x04, 0x30, 0xC1, 0x0C, 0x10, 0x81,
  0x88, 0x09, 0x80, 0x98, 0x0D, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x60, 0x34, 0x06, 0x03, 0x40, 0x60, 0x26, 0x0F, 0x02, 0x60, 0xF0,
  0x62, 0x09, 0x06, 0x20, 0x90, 0x43, 0x09, 0x84, 0x31, 0x98, 0xC3, 0x18,
  0x8C, 0x11, 0x08, 0x81, 0x10, 0x88, 0x1B, 0x0D, 0x81, 0xB0, 0x58, 0x0A,
  0x05, 0x80, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xE0, 0x70, 0x06, 0x03, 0x00,
  0x60, 0x64, 0x08, 0xC3, 0x18, 0x41, 0x18, 0x32, 0x02, 0xC0, 0x70, 0x06,
  0x00, 0xC0, 0x38, 0x05, 0x81, 0x90, 0x23, 0x0C, 0x21, 0x06, 0x60, 0xC8,
  0x0F, 0x01, 0x80, 0xC0, 0x68, 0x09, 0x83, 0x10, 0x62, 0x08, 0x63, 0x04,
  0x40, 0xD8, 0x0A, 0x01, 0x40, 0x38, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0xFF, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x30, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x3F, 0xE0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0x80, 0xC0,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x04,
  0x04, 0x06, 0x02, 0x02, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x0C, 0x01, 0xC0, 0x68,
  0x09, 0x83, 0x10, 0x43, 0x18, 0x22, 0x06, 0xC0, 0x50, 0x0C, 0xFF, 0xFF,
  0xFC, 0xC3, 0x08, 0x20, 0x80, 0x0C, 0x3F, 0x90, 0x40, 0x30, 0x18, 0x0C,
  0x06, 0x7F, 0x61, 0xE0, 0xF0, 0x78, 0x3C, 0x1A, 0x15, 0xF2, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0xC2, 0xFC, 0xA1, 0xB0, 0x2C, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x1A, 0x86, 0x9F,
  0x00, 0x0E, 0x3F, 0x30, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40,
  0x40, 0x60, 0x31, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0xC4, 0xFD, 0x61, 0xD8, 0x34, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x50, 0x36, 0x0C, 0xC5, 0x3E, 0x40, 0x0C, 0x0F, 0xC2, 0x19, 0x82,
  0x40, 0xF0, 0x3C, 0x0F, 0xFF, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x0C,
  0x21, 0xF8, 0x06, 0x1F, 0x10, 0x30, 0x30, 0x30, 0x30, 0xFC, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x0C,
  0x0F, 0xD6, 0x1D, 0x83, 0x40, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x05, 0x03, 0x60, 0xCC, 0x53, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x0D, 0x06,
  0x7F, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x11, 0x7E,
  0xA1, 0xE0, 0xF0, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x08, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0x10, 0xC4, 0x00, 0x00,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x17,
  0x90, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x06, 0x86, 0x42,
  0x23, 0x13, 0x09, 0x05, 0xC3, 0x21, 0x98, 0x84, 0x43, 0x20, 0x90, 0x68,
  0x18, 0xFF, 0xFF, 0xF8, 0x0C, 0x18, 0xBE, 0x7E, 0xA3, 0xC6, 0xC1, 0x82,
  0xC1, 0x82, 0xC1, 0x83, 0x81, 0x83, 0x81, 0x83, 0x81, 0x83, 0x81, 0x83,
  0x81, 0x83, 0x81, 0x83, 0x81, 0x83, 0x81, 0x83, 0x81, 0x83, 0x04, 0x5F,
  0xA8, 0x78, 0x3C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x0C, 0x07, 0xF1, 0x82, 0x30, 0x64, 0x05, 0x80, 0xB0,
  0x16, 0x03, 0xC0, 0x58, 0x09, 0x01, 0x20, 0x66, 0x0C, 0x63, 0x07, 0xC0,
  0x04, 0x27, 0xCA, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xF0,
  0x3C, 0x0F, 0x02, 0xC1, 0xA8, 0x69, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x00, 0x0C, 0x0F, 0xD6, 0x1D, 0x83, 0x40, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x05, 0x03, 0x60, 0xCC, 0x53, 0xE4, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0E, 0x7A, 0x30, 0xC3, 0x0C, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x18, 0x7F, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x03, 0x03, 0x03, 0x86, 0xFC, 0x30, 0x60, 0xC1,
  0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x3C, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x78, 0x36, 0x2B, 0xE4, 0xC0, 0xD0, 0x24, 0x09, 0x86, 0x61, 0x88,
  0x42, 0x10, 0xCC, 0x12, 0x04, 0x81, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0xC1,
  0x81, 0x41, 0xC3, 0x41, 0x43, 0x61, 0x42, 0x63, 0x42, 0x22, 0x66, 0x22,
  0x66, 0x32, 0x24, 0x36, 0x24, 0x14, 0x34, 0x14, 0x3C, 0x14, 0x18, 0x1C,
  0x18, 0x08, 0x18, 0x60, 0xC8, 0x63, 0x10, 0x4C, 0x1A, 0x03, 0x80, 0xC0,
  0x38, 0x1A, 0x04, 0xC3, 0x10, 0x86, 0x60, 0xB0, 0x30, 0xC0, 0xD0, 0x36,
  0x09, 0x82, 0x21, 0x88, 0x43, 0x10, 0x4C, 0x13, 0x06, 0x81, 0xA0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x03, 0xC0, 0x40, 0x00,
  0xFE, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x1F,
  0xC0, 0x0E, 0x30, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC6, 0x03,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x30, 0x30, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86,
  0x38, 0x00, 0x78, 0x73, 0xB8, 0x38,
};

const GFXglyph NotoSans_Condensed_Light27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 6, 7, 9, 2, -19 },
  { 12, 12, 19, 14, 1, -19 },
  { 41, 10, 23, 12, 1, -21 },
  { 70, 16, 20, 18, 1, -20 },
  { 110, 13, 20, 14, 1, -20 },
  { 143, 1, 7, 5, 2, -19 },
  { 144, 6, 23, 7, 1, -19 },
  { 162, 5, 23, 7, 1, -19 },
  { 177, 9, 10, 11, 1, -21 },
  { 189, 10, 13, 12, 1, -16 },
  { 206, 3, 7, 6, 1, -3 },
  { 209, 6, 1, 8, 1, -8 },
  { 210, 2, 2, 6, 2, -2 },
  { 211, 8, 19, 9, 1, -19 },
  { 230, 10, 20, 12, 1, -20 },
  { 255, 6, 19, 12, 2, -19 },
  { 270, 10, 20, 12, 1, -20 },
  { 295, 10, 20, 12, 1, -20 },
  { 320, 12, 19, 12, 0, -19 },
  { 349, 10, 19, 12, 1, -19 },
  { 373, 10, 20, 12, 1, -20 },
  { 398, 10, 19, 12, 1, -19 },
  { 422, 10, 20, 12, 1, -20 },
  { 447, 10, 20, 12, 1, -20 },
  { 472, 2, 15, 6, 2, -15 },
  { 476, 3, 19, 6, 1, -15 },
  { 484, 10, 12, 12, 1, -16 },
  { 499, 10, 7, 12, 1, -13 },
  { 508, 10, 12, 12, 1, -16 },
  { 523, 8, 20, 9, 0, -20 },
  { 543, 17, 21, 19, 1, -19 },
  { 588, 13, 19, 13, 0, -19 },
  { 619, 11, 19, 14, 2, -19 },
  { 646, 11, 20, 13, 1, -20 },
  { 674, 12, 19, 15, 2, -19 },
  { 703, 9, 19, 12, 2, -19 },
  { 725, 9, 19, 11, 2, -19 },
  { 747, 13, 20, 16, 1, -20 },
  { 780, 11, 19, 16, 2, -19 },
  { 807, 5, 19, 7, 1, -19 },
  { 819, 6, 24, 6, -2, -19 },
  { 837, 11, 19, 13, 2, -19 },
  { 864, 8, 19, 11, 2, -19 },
  { 883, 16, 19, 20, 2, -19 },
  { 921, 12, 19, 16, 2, -19 },
  { 950, 14, 20, 16, 1, -20 },
  { 985, 10, 19, 13, 2, -19 },
  { 1009, 14, 25, 16, 1, -20 },
  { 1053, 11, 19, 13, 2, -19 },
  { 1080, 10, 20, 12, 1, -20 },
  { 1105, 11, 19, 11, 0, -19 },
  { 1132, 11, 19, 15, 2, -19 },
  { 1159, 12, 19, 12, 0, -19 },
  { 1188, 20, 19, 20, 0, -19 },
  { 1236, 11, 19, 11, 0, -19 },
  { 1263, 11, 19, 11, 0, -19 },
  { 1290, 9, 19, 11, 1, -19 },
  { 1312, 6, 23, 8, 2, -19 },
  { 1330, 8, 19, 9, 1, -19 },
  { 1349, 5, 23, 8, 1, -19 },
  { 1364, 11, 10, 13, 1, -19 },
  { 1378, 11, 2, 11, 0, 2 },
  { 1381, 5, 5, 7, 1, -21 },
  { 1385, 9, 15, 12, 1, -15 },
  { 1402, 10, 21, 13, 2, -21 },
  { 1429, 8, 15, 10, 1, -15 },
  { 1444, 10, 21, 13, 1, -21 },
  { 1471, 10, 15, 12, 1, -15 },
  { 1490, 8, 21, 7, 0, -21 },
  { 1511, 10, 22, 13, 1, -15 },
  { 1539, 9, 21, 13, 2, -21 },
  { 1563, 2, 20, 6, 2, -20 },
  { 1568, 5, 27, 6, -1, -20 },
  { 1585, 9, 21, 11, 2, -21 },
  { 1609, 1, 21, 5, 2, -21 },
  { 1612, 16, 15, 19, 2, -15 },
  { 1642, 9, 15, 13, 2, -15 },
  { 1659, 11, 15, 13, 1, -15 },
  { 1680, 10, 21, 13, 2, -15 },
  { 1707, 10, 21, 13, 1, -15 },
  { 1734, 6, 15, 9, 2, -15 },
  { 1746, 8, 15, 10, 1, -15 },
  { 1761, 7, 18, 7, 0, -18 },
  { 1777, 9, 14, 13, 2, -14 },
  { 1793, 10, 14, 10, 0, -14 },
  { 1811, 16, 14, 17, 0, -14 },
  { 1839, 10, 14, 11, 0, -14 },
  { 1857, 10, 21, 10, 0, -14 },
  { 1884, 7, 14, 9, 1, -14 },
  { 1897, 7, 23, 10, 1, -19 },
  { 1918, 2, 28, 12, 5, -21 },
  { 1925, 7, 23, 10, 1, -19 },
  { 1946, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Light27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_LIGHT27PT7B_H_
