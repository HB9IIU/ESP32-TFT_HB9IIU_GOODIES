#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x1E, 0x00, 0x20, 0x00, 0x3E, 0x3F, 0x3E, 0x3F, 0x7E, 0x3E,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C,
  0xF8, 0x78, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x07,
  0x87, 0x80, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xB1, 0xC0,
  0x7C, 0xC2, 0x01, 0xF3, 0x00, 0x0F, 0x8C, 0x00, 0x3E, 0x30, 0x00, 0xFD,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x67, 0xC0, 0x01, 0x9F, 0x00, 0x06, 0x7C, 0x00, 0x19,
  0xF0, 0x40, 0xC7, 0xC1, 0x83, 0x3F, 0x07, 0x8D, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0x7F, 0x80, 0x7C,
  0x03, 0xFF, 0x01, 0xE0, 0x1E, 0x3C, 0x0F, 0x80, 0x78, 0xF0, 0x3C, 0x03,
  0xC3, 0xC1, 0xE0, 0x0F, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x3C, 0x01, 0xE0,
  0xF0, 0xF0, 0x07, 0x83, 0xC7, 0x80, 0x1E, 0x1E, 0x1E, 0x00, 0x78, 0x78,
  0xF0, 0x01, 0xE1, 0xE3, 0xC0, 0x07, 0x87, 0x9E, 0x1E, 0x3E, 0x3C, 0xF8,
  0xFE, 0x78, 0xF3, 0xC7, 0xF9, 0xE7, 0x9F, 0x3F, 0xF7, 0xFE, 0x79, 0xE3,
  0xDF, 0xF3, 0xE7, 0x8F, 0x3F, 0x8F, 0x3C, 0x3C, 0x7C, 0x78, 0xF0, 0xF0,
  0x01, 0xE3, 0xC3, 0xC0, 0x0F, 0x1E, 0x0F, 0x00, 0x3C, 0x78, 0x7C, 0x01,
  0xE1, 0xE1, 0xE0, 0x07, 0x87, 0x87, 0x80, 0x3C, 0x3E, 0x1E, 0x00, 0xF0,
  0xF0, 0xF8, 0x07, 0x83, 0xC3, 0xC0, 0x3E, 0x0F, 0x0F, 0x00, 0xF0, 0x3C,
  0x78, 0x07, 0xC0, 0x7B, 0xE0, 0x1E, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xF8,
  0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE3,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0x0F, 0xFE, 0x3E, 0x1F, 0xFE, 0x3E, 0x3F, 0x3E, 0x7E, 0x3E, 0x3F,
  0x7C, 0x7C, 0x3F, 0xFC, 0x7C, 0x1F, 0xF8, 0xFC, 0x1F, 0xF8, 0xF8, 0x1F,
  0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0xFC, 0x1F,
  0xE0, 0xFE, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF3,
  0xF8, 0x1F, 0xE1, 0xF8, 0x02, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0x07,
  0xC0, 0x31, 0xF0, 0x1F, 0x7C, 0x27, 0xFE, 0x79, 0xFF, 0xFE, 0xFF, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xDE, 0x07,
  0xE7, 0xC0, 0xF8, 0xF8, 0x1C, 0x3E, 0x02, 0x0E, 0x00, 0x01, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0x08, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x7C, 0x07,
  0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0,
  0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8,
  0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x7E, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x1F,
  0xFC, 0x7E, 0xF9, 0xFB, 0xF1, 0xE7, 0xE1, 0x8F, 0x82, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x1F, 0xC0,
  0x38, 0x1F, 0x80, 0x40, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xFF, 0xFC, 0x07, 0x03, 0xF0, 0x08, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x0C, 0x01, 0xFC, 0x3E, 0x3F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x77, 0xC0,
  0x03, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0x7B, 0xF0, 0x03, 0xCF, 0x80, 0x1E,
  0x3E, 0x00, 0x78, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x1F, 0x80, 0x78, 0x7C,
  0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0xFC, 0x0F,
  0x03, 0xE0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xDF,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x40, 0x0F, 0xC3, 0x01, 0xFC, 0x1F, 0x7F, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x8F, 0x00, 0xFD, 0xFE, 0x07, 0xDF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xE3, 0xF0, 0xFE, 0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x03, 0xE3, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x9F, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xC0, 0x1F, 0xDF, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0,
  0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF8,
  0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80,
  0xFC, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xF0, 0xFC, 0x3F, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xBE, 0x07, 0xFB, 0xF0, 0x1F, 0x9F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x1C, 0x7F, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE, 0x0F, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x60, 0xFC, 0x20, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x01, 0x00, 0xF0, 0xF0, 0x3F,
  0xE3, 0xC3, 0xC1, 0xFF, 0x8F, 0x1E, 0x0F, 0xFE, 0x3C, 0x78, 0x78, 0x70,
  0xF1, 0xC1, 0xE3, 0xC3, 0xCF, 0x0F, 0x0F, 0x0F, 0x3C, 0x38, 0x3C, 0x3C,
  0xE1, 0xE0, 0xE0, 0xE7, 0x87, 0x87, 0x87, 0x9E, 0x1C, 0x1E, 0x1E, 0x78,
  0xF0, 0x78, 0x79, 0xC3, 0xC3, 0xE1, 0xC7, 0x0F, 0x0F, 0x0F, 0x3C, 0x3C,
  0x3C, 0x38, 0xF0, 0xF1, 0xF0, 0xE3, 0xC3, 0xC7, 0xC7, 0x0F, 0x0F, 0x3F,
  0x3C, 0x3C, 0x3F, 0xDF, 0xE0, 0xF0, 0x7E, 0x7F, 0x03, 0xC1, 0xF0, 0xF8,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x08, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7C, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0,
  0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xE0, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x20, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF3,
  0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x7E, 0x1F, 0x00, 0xFE, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F,
  0xE0, 0x7E, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x70, 0x1F, 0xC0, 0x08, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xFC, 0x3F, 0x07, 0xFE, 0x3F, 0x03, 0xFF,
  0x1F, 0x81, 0xFF, 0x8F, 0xC0, 0xFF, 0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0xC0,
  0x01, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xF7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF0,
  0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xF7, 0xC0, 0x7D, 0xE0, 0x3F, 0xF8, 0x0F, 0xBC, 0x07, 0xBF,
  0x03, 0xF7, 0x81, 0xF7, 0xC0, 0x7C, 0xF0, 0x3E, 0xF8, 0x0F, 0x9E, 0x0F,
  0x9F, 0x01, 0xF3, 0xC1, 0xF7, 0xE0, 0x3E, 0x78, 0x7C, 0xF8, 0x0F, 0xCF,
  0x0F, 0x9F, 0x01, 0xF1, 0xE1, 0xE3, 0xE0, 0x3E, 0x3C, 0x7C, 0xFC, 0x07,
  0xC7, 0xCF, 0x1F, 0x80, 0xF8, 0xFB, 0xE3, 0xE0, 0x3E, 0x1F, 0x78, 0x7C,
  0x07, 0xC3, 0xFF, 0x0F, 0x80, 0xF8, 0x7F, 0xE3, 0xF0, 0x1F, 0x0F, 0xF8,
  0x7E, 0x03, 0xE1, 0xFF, 0x0F, 0x80, 0xF8, 0x3F, 0xC1, 0xF0, 0x1F, 0x07,
  0xF8, 0x3E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0x7C, 0x1F, 0xC1, 0xF0, 0x1F,
  0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8,
  0x00, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x7C,
  0x03, 0xF8, 0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x01, 0xFF, 0x01, 0xF0, 0x0F,
  0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x7C, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0xF0,
  0x3F, 0x01, 0xF7, 0x81, 0xF0, 0x0F, 0xBE, 0x0F, 0x80, 0x7D, 0xF0, 0x7C,
  0x03, 0xEF, 0x83, 0xE0, 0x3F, 0x7C, 0x3F, 0x01, 0xF3, 0xE1, 0xF0, 0x0F,
  0x8F, 0x0F, 0x80, 0x7C, 0x7C, 0x7C, 0x03, 0xE3, 0xE3, 0xE0, 0x3F, 0x1F,
  0x3F, 0x01, 0xF0, 0xF9, 0xF0, 0x0F, 0x87, 0xCF, 0x80, 0x7C, 0x1E, 0x7C,
  0x03, 0xE0, 0xFB, 0xE0, 0x3E, 0x07, 0xFE, 0x01, 0xF0, 0x3F, 0xF0, 0x0F,
  0x81, 0xFF, 0x80, 0x7C, 0x0F, 0xFC, 0x03, 0xE0, 0x3F, 0xE0, 0x3E, 0x01,
  0xFE, 0x01, 0xF0, 0x0F, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC,
  0x07, 0xE0, 0x1F, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0,
  0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F,
  0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xFC, 0x1F, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x3F, 0x81, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0x83, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x87, 0x00, 0xFC, 0x02, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x08, 0x03, 0xF8,
  0x1C, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF0, 0x0F,
  0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01,
  0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xE1,
  0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07,
  0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xBE,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x00, 0xFD, 0xF8,
  0x07, 0xE0, 0x1F, 0x3F, 0x00, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x80, 0xFC,
  0xFC, 0x07, 0xF0, 0x1F, 0x1F, 0x80, 0xFE, 0x07, 0xE3, 0xE0, 0x3F, 0x80,
  0xF8, 0x7C, 0x07, 0xF0, 0x1F, 0x0F, 0x81, 0xFE, 0x07, 0xE1, 0xF0, 0x3F,
  0xC0, 0xF8, 0x3E, 0x07, 0xF8, 0x3F, 0x07, 0xC1, 0xFF, 0x07, 0xE0, 0xF8,
  0x3D, 0xE0, 0xF8, 0x1F, 0x0F, 0xBC, 0x3F, 0x03, 0xE1, 0xF7, 0x87, 0xC0,
  0x7C, 0x3C, 0xF0, 0xF8, 0x0F, 0x8F, 0x9E, 0x3F, 0x01, 0xF1, 0xE3, 0xC7,
  0xC0, 0x3E, 0x7C, 0x79, 0xF8, 0x07, 0xCF, 0x8F, 0x3E, 0x00, 0xF9, 0xE1,
  0xE7, 0xC0, 0x1F, 0x7C, 0x7D, 0xF8, 0x03, 0xEF, 0x8F, 0xBE, 0x00, 0x7D,
  0xE1, 0xF7, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01,
  0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x03,
  0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7C,
  0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C, 0x1F, 0x87,
  0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0,
  0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xF0, 0x3E, 0x07,
  0x83, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x3C, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFE, 0x3F, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3C, 0x0F, 0x00, 0x20, 0x00,
  0x07, 0xF1, 0xF0, 0x3F, 0xEF, 0x81, 0xFF, 0xBE, 0x0F, 0xFF, 0xF8, 0x3F,
  0x9F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x87,
  0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8,
  0x3F, 0x9F, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFD, 0xF0, 0x0F,
  0xE7, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x60, 0x0F, 0xDF,
  0xC0, 0x7D, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x3F, 0x0F,
  0xE1, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF9, 0xF8,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0xFF,
  0xE1, 0xF7, 0xFE, 0x0F, 0xBF, 0xE0, 0x78, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0xF8, 0xC1, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x83, 0xFC, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x20, 0xFC, 0x01, 0xFC, 0xF8, 0x03, 0xFE, 0xF8, 0x07, 0xFE, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0,
  0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xC0,
  0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFE, 0x7F, 0x80,
  0x7F, 0xFF, 0x00, 0x7F, 0xEF, 0x00, 0x3F, 0xCF, 0x00, 0x3F, 0x8F, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0x87, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F, 0x03,
  0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3F, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x83, 0xF0, 0x30,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0x60, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0x1F, 0x00, 0xFF, 0xBE, 0x01, 0xFF,
  0xBE, 0x03, 0xFF, 0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x01,
  0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x9F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF7, 0xC0, 0x0F, 0xEF,
  0xC0, 0x01, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x80, 0x3F, 0x00, 0xC0, 0x7F, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x60, 0x0F, 0xDF, 0xC0, 0x7D, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x0F, 0xC0, 0x00, 0x60, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x3F, 0x01,
  0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xEF,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xCF, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x03, 0x00, 0x60, 0x0F, 0x9F, 0xC3,
  0xF8, 0x1F, 0x7F, 0xCF, 0xF8, 0x3D, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFE, 0x7F, 0xCF, 0xC3, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0xFC, 0x1F,
  0x0F, 0xC1, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x7E, 0x07, 0xC1, 0xF8,
  0xFC, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x1F, 0x1F, 0x83, 0xF0, 0x7E, 0x3E, 0x07, 0xE0, 0xF8, 0x7C,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xC7, 0xE0,
  0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x07,
  0xC0, 0xF8, 0xFC, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0x80, 0x3E, 0x7F, 0x01,
  0xE7, 0xFC, 0x0F, 0x7F, 0xE0, 0x7B, 0xFF, 0x83, 0xF9, 0xFC, 0x3F, 0x87,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x3F,
  0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x7C,
  0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x87, 0xE0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87,
  0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F, 0xC7, 0xE0,
  0xF8, 0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x3F,
  0x3F, 0x0F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x30, 0x00, 0xF9, 0xFC, 0x00,
  0xFB, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF7, 0xFF, 0x00, 0xFE, 0x3F, 0x01,
  0xFC, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0xE1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0x7F, 0xC0, 0x1F, 0x3F, 0x80, 0x1F, 0x04, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x30, 0x04, 0x03, 0xF1, 0xE0, 0x3F,
  0xEF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x1F, 0xE1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F,
  0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x01,
  0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x9F, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFD, 0xF0, 0x0F, 0xE7, 0xC0, 0x04, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC1, 0xF3, 0xE0,
  0x7D, 0xF8, 0x1F, 0xFE, 0x07, 0xBF, 0x81, 0xFF, 0xC0, 0xFF, 0x90, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xE0, 0xC1,
  0xF8, 0x10, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x08,
  0x0F, 0xC3, 0xCF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE0, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x41, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0xC0, 0x30, 0x00, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C,
  0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFE, 0xF8,
  0x0F, 0xE7, 0x80, 0x08, 0x00, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8,
  0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x81, 0xFF, 0xC0,
  0xFC, 0x0F, 0xBE, 0x0F, 0xE0, 0x7D, 0xF0, 0x7F, 0x07, 0xCF, 0x83, 0xF8,
  0x3E, 0x7C, 0x3F, 0xC1, 0xF3, 0xE1, 0xFE, 0x1F, 0x1F, 0x0F, 0xF0, 0xF8,
  0xF8, 0xF7, 0x8F, 0x87, 0xC7, 0xBC, 0x7C, 0x3E, 0x7D, 0xE3, 0xE1, 0xF3,
  0xCF, 0x3E, 0x0F, 0x9E, 0x79, 0xF0, 0x7D, 0xF3, 0xDF, 0x03, 0xEF, 0x1E,
  0xF8, 0x1F, 0x79, 0xF7, 0xC0, 0xFF, 0x8F, 0xFC, 0x07, 0xBC, 0x7F, 0xE0,
  0x3D, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F,
  0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E,
  0x07, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE3, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0xFC,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x3D,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x40, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80,
  0x17, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x07,
  0xFE, 0x80, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 37, 12, 0, -36 },
  { 66, 16, 13, 19, 5, -36 },
  { 92, 24, 36, 23, 0, -36 },
  { 200, 22, 41, 21, 0, -38 },
  { 313, 30, 36, 33, 2, -36 },
  { 448, 24, 37, 24, 0, -36 },
  { 559, 8, 13, 11, 5, -36 },
  { 572, 16, 44, 13, 1, -36 },
  { 660, 16, 44, 13, -4, -36 },
  { 748, 18, 19, 20, 4, -38 },
  { 791, 20, 24, 23, 2, -30 },
  { 851, 11, 13, 11, -3, -6 },
  { 869, 12, 5, 14, 1, -16 },
  { 877, 7, 8, 11, 0, -7 },
  { 884, 25, 36, 18, -3, -36 },
  { 997, 20, 37, 21, 1, -36 },
  { 1090, 15, 36, 21, 5, -36 },
  { 1158, 23, 36, 21, -2, -36 },
  { 1262, 22, 37, 21, -1, -36 },
  { 1364, 22, 36, 21, -1, -36 },
  { 1463, 21, 37, 21, 0, -36 },
  { 1561, 21, 37, 21, 1, -36 },
  { 1659, 22, 36, 21, 1, -36 },
  { 1758, 22, 37, 21, 0, -36 },
  { 1860, 21, 37, 21, 0, -36 },
  { 1958, 11, 28, 11, 0, -27 },
  { 1997, 14, 34, 11, -3, -27 },
  { 2057, 20, 23, 23, 2, -29 },
  { 2115, 20, 15, 23, 2, -25 },
  { 2153, 20, 23, 23, 2, -29 },
  { 2211, 17, 36, 16, 1, -36 },
  { 2288, 30, 40, 31, 1, -36 },
  { 2438, 22, 36, 22, -3, -36 },
  { 2537, 23, 36, 23, 0, -36 },
  { 2641, 22, 37, 21, 2, -36 },
  { 2743, 24, 36, 25, 0, -36 },
  { 2851, 22, 36, 19, 0, -36 },
  { 2950, 22, 36, 18, 0, -36 },
  { 3049, 25, 37, 26, 2, -36 },
  { 3165, 27, 36, 26, 0, -36 },
  { 3287, 20, 36, 15, -2, -36 },
  { 3377, 21, 46, 12, -8, -36 },
  { 3498, 26, 36, 22, 0, -36 },
  { 3615, 15, 36, 18, 0, -36 },
  { 3683, 35, 36, 34, 0, -36 },
  { 3841, 29, 36, 27, 0, -36 },
  { 3972, 24, 37, 26, 2, -36 },
  { 4083, 23, 36, 22, 0, -36 },
  { 4187, 24, 45, 26, 2, -36 },
  { 4322, 23, 36, 22, 0, -36 },
  { 4426, 23, 37, 20, -1, -36 },
  { 4533, 20, 36, 19, 3, -36 },
  { 4623, 25, 37, 25, 2, -36 },
  { 4739, 22, 36, 22, 4, -36 },
  { 4838, 35, 36, 34, 3, -36 },
  { 4996, 27, 36, 21, -3, -36 },
  { 5118, 20, 36, 20, 4, -36 },
  { 5208, 24, 36, 18, -2, -36 },
  { 5316, 20, 44, 14, -2, -36 },
  { 5426, 9, 36, 18, 5, -36 },
  { 5467, 20, 44, 14, -4, -36 },
  { 5577, 21, 21, 21, 0, -36 },
  { 5633, 17, 3, 16, -5, 4 },
  { 5640, 9, 8, 14, 7, -38 },
  { 5649, 22, 29, 22, 1, -28 },
  { 5729, 21, 39, 22, 0, -38 },
  { 5832, 18, 29, 17, 1, -28 },
  { 5898, 24, 39, 22, 1, -38 },
  { 6015, 19, 29, 20, 1, -28 },
  { 6084, 25, 50, 13, -6, -38 },
  { 6241, 24, 40, 22, -1, -28 },
  { 6361, 21, 38, 22, 0, -38 },
  { 6461, 13, 38, 11, 0, -38 },
  { 6523, 19, 50, 11, -6, -38 },
  { 6642, 22, 38, 20, 0, -38 },
  { 6747, 13, 38, 11, 0, -38 },
  { 6809, 31, 28, 32, 0, -28 },
  { 6918, 21, 28, 22, 0, -28 },
  { 6992, 19, 29, 22, 1, -28 },
  { 7061, 24, 40, 22, -3, -28 },
  { 7181, 22, 40, 22, 1, -28 },
  { 7291, 18, 28, 15, 0, -28 },
  { 7354, 18, 29, 17, 0, -28 },
  { 7420, 14, 34, 14, 1, -33 },
  { 7480, 21, 28, 22, 1, -27 },
  { 7554, 18, 27, 19, 3, -27 },
  { 7615, 29, 27, 29, 3, -27 },
  { 7713, 23, 27, 19, -2, -27 },
  { 7791, 26, 39, 19, -4, -27 },
  { 7918, 19, 27, 16, -2, -27 },
  { 7983, 19, 44, 17, 1, -36 },
  { 8088, 4, 50, 19, 7, -38 },
  { 8113, 19, 44, 17, -3, -36 },
  { 8218, 20, 7, 23, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC50PT7B_H_
