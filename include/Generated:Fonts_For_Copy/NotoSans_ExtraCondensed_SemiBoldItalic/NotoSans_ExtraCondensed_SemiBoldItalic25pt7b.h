#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC1, 0x87,
  0x00, 0x00, 0x78, 0xE1, 0xC0, 0x73, 0xBB, 0x9D, 0xCC, 0xE6, 0x63, 0x33,
  0x98, 0x03, 0x30, 0x66, 0x06, 0x60, 0x66, 0x0C, 0xC3, 0xFF, 0x3F, 0xF0,
  0xC8, 0x19, 0x81, 0x98, 0x19, 0x8F, 0xFC, 0xFF, 0xC3, 0x30, 0x66, 0x06,
  0x60, 0x66, 0x0C, 0xC0, 0x01, 0x00, 0x20, 0x1F, 0x0F, 0xF1, 0xEC, 0x74,
  0x0E, 0x81, 0xD0, 0x1C, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x13, 0x22,
  0xE7, 0xFC, 0xFF, 0x0F, 0x80, 0x40, 0x08, 0x00, 0x1C, 0x18, 0x7C, 0x31,
  0xD8, 0xC3, 0x33, 0x86, 0x66, 0x1C, 0xDC, 0x33, 0xB0, 0x66, 0xCE, 0xCD,
  0xBF, 0xF6, 0xED, 0xCD, 0x98, 0x33, 0x30, 0x6C, 0x61, 0x99, 0xC3, 0x33,
  0x0C, 0x66, 0x18, 0xF8, 0x60, 0xE0, 0x07, 0x80, 0xFC, 0x0C, 0xC1, 0xCC,
  0x1D, 0xC1, 0xD8, 0x1F, 0x80, 0xF0, 0x1E, 0x03, 0xE7, 0x77, 0x66, 0x7E,
  0xE7, 0xCE, 0x3C, 0xE3, 0x8E, 0x7C, 0xFF, 0xC7, 0xDE, 0x77, 0x76, 0x66,
  0xE0, 0x03, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x06,
  0x07, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x07, 0x06,
  0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0, 0x0C, 0x06, 0x13,
  0x1F, 0xF7, 0xF9, 0xE1, 0xF8, 0xCC, 0x27, 0x00, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x39,
  0x9C, 0xCE, 0x60, 0x7E, 0xFB, 0xF0, 0x7E, 0xE0, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07,
  0x83, 0xF1, 0xFC, 0x73, 0x38, 0xCE, 0x33, 0x0D, 0xC7, 0x71, 0xDC, 0x76,
  0x1D, 0x86, 0x63, 0xB8, 0xE6, 0x71, 0xDC, 0x7E, 0x0F, 0x00, 0x07, 0x0F,
  0x1E, 0x3E, 0xFE, 0x6E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x70, 0x07, 0xC0, 0xFE, 0x1E, 0xE0, 0x87, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0x83, 0xF8, 0x77, 0x88,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x1E, 0x03, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE4, 0x78, 0xFE, 0x1F, 0x80, 0x00, 0xE0, 0x38, 0x0F,
  0x01, 0xE0, 0x7C, 0x1B, 0x83, 0x60, 0xDC, 0x33, 0x86, 0x71, 0x8C, 0x71,
  0x8F, 0xFD, 0xFF, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xF8, 0x3F, 0x84, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE4, 0x78, 0xFE, 0x1F, 0x80, 0x07, 0xC3,
  0xF1, 0xE4, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xBC, 0xFF, 0x3C, 0xEE, 0x3B,
  0x8E, 0xC3, 0x31, 0xCC, 0x73, 0xB8, 0xFE, 0x1F, 0x00, 0x3F, 0xE7, 0xF9,
  0xFF, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x07, 0x83,
  0xF8, 0x77, 0x9C, 0x73, 0x8E, 0x71, 0x86, 0x70, 0xFC, 0x0F, 0x07, 0xE1,
  0xEE, 0x31, 0xCE, 0x39, 0xC3, 0x38, 0xE7, 0x1C, 0xFF, 0x0F, 0xC0, 0x07,
  0x87, 0xF1, 0xDC, 0xE3, 0x38, 0xCC, 0x37, 0x1D, 0xC7, 0x73, 0xCF, 0xF3,
  0xDC, 0x6E, 0x03, 0x80, 0xC0, 0x72, 0x38, 0xFC, 0x3E, 0x00, 0x08, 0xF3,
  0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3, 0x80, 0x0C, 0x1C, 0x78,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x0E, 0x18, 0x70, 0xC0,
  0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x3E, 0x3E, 0x3E,
  0x0E, 0x02, 0x00, 0x1F, 0x1F, 0xCC, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x1C,
  0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0xE0, 0xF0, 0x30, 0x00,
  0x01, 0xF0, 0x1F, 0xE0, 0xC1, 0xC6, 0x03, 0x30, 0x0C, 0xCF, 0x96, 0x76,
  0x59, 0x9B, 0xCC, 0xCF, 0x33, 0x3C, 0xCC, 0xF6, 0x72, 0xD9, 0x9A, 0x7F,
  0xC8, 0xEE, 0x30, 0x00, 0xC0, 0x03, 0x82, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x66, 0x0E,
  0x60, 0xE6, 0x0C, 0x61, 0xFE, 0x1F, 0xF3, 0x87, 0x38, 0x77, 0x07, 0x70,
  0x7F, 0x07, 0x0F, 0xC1, 0xFE, 0x1D, 0xE1, 0xC7, 0x1C, 0x71, 0x86, 0x38,
  0xE3, 0xBC, 0x3F, 0x83, 0xF8, 0x31, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x61,
  0xCE, 0x78, 0xFF, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x7B, 0x1E, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x98, 0x7F, 0x07, 0xE0, 0x0F, 0x81, 0xFE, 0x1F, 0xF1, 0xC7,
  0x1C, 0x71, 0x87, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x30, 0xE7, 0x0E,
  0x70, 0xE7, 0x1C, 0x73, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0x0F, 0xE3, 0xFC,
  0x7F, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0xF8, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3,
  0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x3F, 0x87, 0xF0,
  0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0xF0, 0xFF, 0x1F, 0x73, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE3,
  0xEE, 0x3E, 0xE3, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x1C, 0x7F,
  0x83, 0xF8, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0xC3, 0x87, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0x06, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x0F, 0xC7,
  0xF0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0xFE, 0x3F, 0x80, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x07, 0xC1, 0xF0, 0x3C, 0x00, 0x0C, 0x38, 0xE3, 0x87, 0x1C, 0x39, 0xC1,
  0xDC, 0x0C, 0xE0, 0xEE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xEE,
  0x07, 0x30, 0x39, 0xC1, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1E, 0x00, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x60, 0xE1, 0xFE, 0xFE, 0x0E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3, 0xF1, 0xB0, 0xFC, 0xFC, 0x3F,
  0x37, 0x0D, 0xCD, 0xC3, 0x77, 0x61, 0xDD, 0x98, 0x77, 0xEE, 0x18, 0xF3,
  0x86, 0x3C, 0xE3, 0x8E, 0x30, 0xE3, 0x8C, 0x38, 0xC7, 0x00, 0x0E, 0x0C,
  0x78, 0x71, 0xE1, 0xC7, 0x87, 0x1F, 0x18, 0x7C, 0x63, 0xB3, 0x8E, 0xCE,
  0x3B, 0x38, 0xCC, 0xC3, 0x3B, 0x1C, 0xFC, 0x71, 0xF1, 0x87, 0x86, 0x1E,
  0x38, 0x78, 0xE1, 0xE3, 0x87, 0x80, 0x07, 0xC0, 0xFE, 0x1E, 0xF3, 0x87,
  0x38, 0x77, 0x07, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x1C, 0xE3, 0xCF, 0x78, 0x7F, 0x03, 0xE0, 0x0F, 0x81, 0xFE,
  0x1F, 0xE1, 0xC7, 0x1C, 0x71, 0x87, 0x38, 0x63, 0x8E, 0x39, 0xE3, 0xFC,
  0x3F, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0xC0, 0xFE, 0x1E, 0xF3, 0x87, 0x38, 0x77, 0x07, 0x70, 0x77, 0x07,
  0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0xCF, 0x78,
  0x7F, 0x03, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0F, 0x83, 0xFC,
  0x77, 0x8E, 0x71, 0xCE, 0x31, 0xCE, 0x39, 0xC7, 0x3B, 0xC7, 0xF0, 0xFC,
  0x3B, 0x87, 0x30, 0xE6, 0x18, 0xE7, 0x1C, 0xE3, 0x9C, 0x70, 0x03, 0xE0,
  0xFF, 0x0F, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x43, 0x87, 0x78, 0x7F, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x18, 0x73,
  0x87, 0x38, 0x73, 0x87, 0x38, 0x63, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE6,
  0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8F, 0x78, 0xFF, 0x07,
  0xE0, 0xE0, 0xFC, 0x1F, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0x38, 0xC7, 0x38,
  0xE7, 0x1D, 0xC3, 0xB8, 0x76, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x00, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x71, 0xDC, 0x78, 0xEE, 0x3C,
  0x67, 0x3E, 0x73, 0x9F, 0x39, 0xCF, 0x98, 0xEF, 0xDC, 0x76, 0xEE, 0x37,
  0x6E, 0x1B, 0x37, 0x0D, 0x9B, 0x07, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xC0,
  0xE1, 0xE0, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x71, 0x83, 0x9C, 0x1D, 0xC0,
  0xEE, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x3F,
  0x01, 0xF8, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0xE1, 0x87, 0x0E, 0x00, 0xE1,
  0xF8, 0x6E, 0x39, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0xF0,
  0xFF, 0x1F, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xFF, 0x8F,
  0xF0, 0x07, 0xC3, 0xF0, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xFC, 0x3E, 0x00, 0xE3, 0x18, 0xC6, 0x39, 0xCE, 0x31, 0x8C,
  0x63, 0x9C, 0xE7, 0x18, 0xC0, 0x07, 0xC1, 0xF0, 0x98, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x7C, 0x3E, 0x00, 0x03, 0x00, 0x60,
  0x1E, 0x07, 0xC0, 0xD8, 0x33, 0x0E, 0x71, 0x8E, 0x70, 0xDC, 0x1C, 0xFF,
  0xFF, 0xEE, 0x63, 0x0C, 0xCF, 0xB3, 0xFD, 0xCF, 0x71, 0xB8, 0xEE, 0x3B,
  0x8E, 0xC3, 0xB1, 0xCC, 0x73, 0xBC, 0xFF, 0x3D, 0xC0, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x33, 0x07, 0xF1, 0xFE, 0x38, 0xE7, 0x1C, 0xC3,
  0xB8, 0x67, 0x1C, 0xE3, 0x9C, 0x73, 0x9C, 0xF3, 0x9F, 0xE3, 0x78, 0x00,
  0x0F, 0x3F, 0x3F, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE4,
  0xFC, 0x7C, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x66, 0x1F,
  0xE1, 0xFE, 0x39, 0xE3, 0x0C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0xE1,
  0x8E, 0x38, 0x77, 0x87, 0xF8, 0x7B, 0x00, 0x0E, 0x0F, 0x8E, 0xEE, 0x76,
  0x3F, 0x3B, 0xFD, 0xF8, 0xC0, 0x60, 0x30, 0x1C, 0x4F, 0xE3, 0xF0, 0x00,
  0xF0, 0x1F, 0x01, 0xD0, 0x38, 0x03, 0x80, 0x3E, 0x0F, 0xC0, 0xFC, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0xB8, 0x0F, 0x00, 0xE0,
  0x00, 0x03, 0x30, 0xFB, 0x0F, 0xF1, 0xCF, 0x18, 0x63, 0x8E, 0x38, 0xE3,
  0x8E, 0x30, 0xE3, 0x1C, 0x71, 0xC3, 0xBC, 0x3F, 0xC3, 0xDC, 0x01, 0x80,
  0x38, 0x03, 0x8C, 0x70, 0xFF, 0x07, 0xC0, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x61, 0xFC, 0xFF, 0x38, 0xCE, 0x33, 0x1D, 0xC7, 0x71, 0xDC,
  0x67, 0x19, 0x8E, 0xE3, 0xB8, 0xEE, 0x30, 0x0C, 0x71, 0xC2, 0x00, 0x61,
  0x8E, 0x38, 0xE3, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x00, 0x01, 0x81,
  0xC0, 0xE0, 0x20, 0x00, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x81, 0xC3, 0xE1,
  0xE0, 0xE0, 0x00, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x31, 0xC6,
  0x31, 0xCE, 0x3B, 0x86, 0xE0, 0xD8, 0x3F, 0x07, 0xE0, 0xEC, 0x19, 0xC3,
  0x38, 0xE7, 0x1C, 0x63, 0x8E, 0x00, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x06,
  0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x80, 0x1B,
  0x8C, 0x1F, 0xDE, 0x3F, 0xFF, 0x39, 0xE7, 0x39, 0xC6, 0x31, 0xC6, 0x71,
  0xCE, 0x71, 0x8E, 0x71, 0x8E, 0x63, 0x8C, 0x63, 0x8C, 0xE3, 0x9C, 0xE3,
  0x1C, 0xE7, 0x1C, 0x19, 0x87, 0xF3, 0xFC, 0xE3, 0x38, 0xCC, 0x77, 0x1D,
  0xC7, 0x71, 0x9C, 0x66, 0x3B, 0x8E, 0xE3, 0xB8, 0xC0, 0x0E, 0x1F, 0x8F,
  0xEE, 0x76, 0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xB1, 0xDD, 0xEF, 0xE3,
  0xE0, 0x0C, 0xC0, 0xFE, 0x1F, 0xE1, 0xC7, 0x1C, 0x71, 0x87, 0x38, 0x63,
  0x8E, 0x38, 0xE3, 0x8E, 0x39, 0xC7, 0x9C, 0x7F, 0x87, 0xF0, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x63, 0xEC, 0x7F, 0x9C,
  0xF3, 0x0C, 0xE3, 0x9C, 0x73, 0x8E, 0x61, 0xCC, 0x33, 0x8E, 0x3B, 0xC7,
  0xF8, 0xF6, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x1B,
  0x8F, 0xCF, 0xC7, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x07, 0x00, 0x0E, 0x1F, 0xCE, 0xCE, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0E, 0x07, 0x03, 0x91, 0xCF, 0xE7, 0xE0, 0x18, 0x30, 0x61, 0xFF, 0xDF,
  0x9C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x78, 0xF0, 0x31, 0xCC,
  0x77, 0x1D, 0xC6, 0x61, 0x98, 0xEE, 0x3B, 0x8C, 0xE3, 0x31, 0xCC, 0x73,
  0x3C, 0xFE, 0x3D, 0x80, 0xE1, 0xD8, 0x66, 0x39, 0x8C, 0x67, 0x19, 0x86,
  0xE1, 0xB8, 0x6C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00, 0x63, 0x8E,
  0xC7, 0x1D, 0x9E, 0x33, 0x3C, 0xEE, 0x79, 0x9D, 0xB7, 0x3B, 0x6E, 0x76,
  0xD8, 0xF9, 0xF1, 0xF3, 0xC3, 0xE7, 0x87, 0x8F, 0x0F, 0x1C, 0x1C, 0x78,
  0x00, 0x1C, 0x71, 0xCE, 0x1C, 0xC1, 0xDC, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x3B, 0x07, 0x30, 0x73, 0x8E, 0x38, 0x0C, 0x38,
  0x61, 0x83, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x70, 0x33, 0x01, 0xB8, 0x0D,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x05, 0xC0, 0x3C, 0x01, 0xC0, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x0E,
  0x07, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC4, 0xFE, 0x3F,
  0x80, 0x01, 0xC0, 0xF0, 0x78, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C,
  0x0F, 0x07, 0x83, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0C, 0x07, 0x07, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C,
  0x0E, 0x07, 0x01, 0xE0, 0xF0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x0E, 0x0F, 0x06, 0x00, 0x30, 0x7F, 0x3F, 0xFE, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 9, 7, 9, 2, -18 },
  { 25, 12, 18, 11, 0, -18 },
  { 52, 11, 20, 10, 0, -19 },
  { 80, 15, 18, 17, 1, -18 },
  { 114, 12, 18, 12, 0, -18 },
  { 141, 4, 7, 6, 2, -18 },
  { 145, 8, 22, 7, 0, -18 },
  { 167, 8, 22, 7, -2, -18 },
  { 189, 9, 9, 10, 2, -19 },
  { 200, 10, 12, 11, 1, -15 },
  { 215, 5, 6, 6, -1, -3 },
  { 219, 7, 3, 7, 0, -8 },
  { 222, 4, 3, 6, 0, -3 },
  { 224, 12, 18, 9, -1, -18 },
  { 251, 10, 18, 10, 0, -18 },
  { 274, 8, 18, 10, 2, -18 },
  { 292, 12, 18, 10, -1, -18 },
  { 319, 11, 18, 10, 0, -18 },
  { 344, 11, 18, 10, 0, -18 },
  { 369, 11, 18, 10, 0, -18 },
  { 394, 10, 18, 10, 1, -18 },
  { 417, 11, 18, 10, 1, -18 },
  { 442, 11, 18, 10, 0, -18 },
  { 467, 10, 18, 10, 0, -18 },
  { 490, 6, 14, 6, 0, -14 },
  { 501, 7, 17, 6, -1, -14 },
  { 516, 10, 12, 11, 1, -15 },
  { 531, 10, 7, 11, 1, -12 },
  { 540, 10, 12, 11, 1, -15 },
  { 555, 9, 18, 8, 0, -18 },
  { 576, 14, 20, 16, 1, -18 },
  { 611, 12, 18, 11, -2, -18 },
  { 638, 12, 18, 11, 0, -18 },
  { 665, 11, 18, 10, 1, -18 },
  { 690, 12, 18, 12, 0, -18 },
  { 717, 11, 18, 10, 0, -18 },
  { 742, 11, 18, 9, 0, -18 },
  { 767, 12, 18, 13, 1, -18 },
  { 794, 14, 18, 13, 0, -18 },
  { 826, 10, 18, 7, -1, -18 },
  { 849, 11, 23, 6, -4, -18 },
  { 881, 13, 18, 11, 0, -18 },
  { 911, 8, 18, 9, 0, -18 },
  { 929, 18, 18, 17, 0, -18 },
  { 970, 14, 18, 14, 0, -18 },
  { 1002, 12, 18, 13, 1, -18 },
  { 1029, 12, 18, 11, 0, -18 },
  { 1056, 12, 22, 13, 1, -18 },
  { 1089, 11, 18, 11, 0, -18 },
  { 1114, 12, 18, 10, -1, -18 },
  { 1141, 9, 18, 9, 2, -18 },
  { 1162, 12, 18, 12, 1, -18 },
  { 1189, 11, 18, 11, 2, -18 },
  { 1214, 17, 18, 17, 2, -18 },
  { 1253, 13, 18, 10, -1, -18 },
  { 1283, 10, 18, 10, 2, -18 },
  { 1306, 12, 18, 9, -1, -18 },
  { 1333, 10, 22, 7, -1, -18 },
  { 1361, 5, 18, 9, 2, -18 },
  { 1373, 10, 22, 7, -2, -18 },
  { 1401, 11, 10, 11, 0, -18 },
  { 1415, 8, 2, 8, -2, 2 },
  { 1417, 4, 4, 7, 4, -19 },
  { 1419, 10, 14, 11, 1, -14 },
  { 1437, 11, 19, 11, 0, -19 },
  { 1464, 8, 14, 9, 1, -14 },
  { 1478, 12, 19, 11, 0, -19 },
  { 1507, 9, 14, 10, 1, -14 },
  { 1523, 12, 25, 7, -3, -19 },
  { 1561, 12, 20, 11, -1, -14 },
  { 1591, 10, 19, 11, 0, -19 },
  { 1615, 6, 19, 5, 0, -19 },
  { 1630, 9, 25, 5, -3, -19 },
  { 1659, 11, 19, 10, 0, -19 },
  { 1686, 7, 19, 5, 0, -19 },
  { 1703, 16, 14, 16, 0, -14 },
  { 1731, 10, 14, 11, 0, -14 },
  { 1749, 9, 14, 11, 1, -14 },
  { 1765, 12, 20, 11, -1, -14 },
  { 1795, 11, 20, 11, 0, -14 },
  { 1823, 9, 14, 8, 0, -14 },
  { 1839, 9, 14, 9, 0, -14 },
  { 1855, 7, 17, 7, 1, -17 },
  { 1870, 10, 14, 11, 1, -14 },
  { 1888, 10, 14, 9, 1, -14 },
  { 1906, 15, 14, 15, 1, -14 },
  { 1933, 12, 14, 10, -1, -14 },
  { 1954, 13, 20, 9, -2, -14 },
  { 1987, 10, 14, 8, -1, -14 },
  { 2005, 10, 22, 8, 0, -18 },
  { 2033, 3, 25, 9, 3, -19 },
  { 2043, 9, 22, 8, -1, -18 },
  { 2068, 10, 4, 11, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC25PT7B_H_
