#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0x24, 0xA6, 0xFA, 0xA0, 0x29, 0x5E, 0xA5, 0x7D, 0x94, 0x13,
  0xD8, 0xC3, 0x1B, 0xC8, 0x40, 0x4A, 0xAD, 0x37, 0xF4, 0xD5, 0x66, 0x33,
  0x9C, 0x46, 0xDE, 0x5F, 0xE8, 0x32, 0x44, 0x48, 0x88, 0x84, 0x21, 0x11,
  0x32, 0x26, 0x48, 0xAF, 0x6A, 0x21, 0x09, 0xF2, 0x10, 0x78, 0xFC, 0xB0,
  0x0C, 0x21, 0x84, 0x20, 0x84, 0x30, 0x33, 0xD6, 0xAD, 0x4A, 0xDC, 0x2E,
  0xB4, 0x96, 0x32, 0xC6, 0x22, 0x23, 0x1E, 0x72, 0xC6, 0xE3, 0x08, 0xDC,
  0x18, 0x8C, 0xA5, 0x78, 0x84, 0x3A, 0x10, 0xE1, 0x08, 0xDC, 0x19, 0x10,
  0xED, 0x4A, 0x4C, 0x78, 0x44, 0x22, 0x11, 0x18, 0x32, 0x56, 0xE7, 0x4A,
  0x5C, 0x32, 0xD6, 0xA7, 0x08, 0x9C, 0x50, 0xB0, 0x32, 0x00, 0x24, 0xC0,
  0x1B, 0x38, 0x30, 0x80, 0xF8, 0x3E, 0xC1, 0x87, 0xC8, 0x00, 0x75, 0x12,
  0x44, 0x0C, 0x1C, 0x45, 0x6B, 0x5A, 0xB5, 0xAE, 0x40, 0x70, 0x18, 0xC6,
  0x52, 0xBD, 0x39, 0x3B, 0x52, 0xE5, 0x2E, 0x5E, 0x39, 0x10, 0x8C, 0x63,
  0x0E, 0x33, 0x52, 0x94, 0xAF, 0x5C, 0x3B, 0x10, 0xE4, 0x23, 0x1C, 0x3B,
  0x10, 0x87, 0x23, 0x10, 0x1C, 0x94, 0x10, 0xDB, 0x2C, 0x9E, 0x25, 0xB4,
  0x9E, 0x49, 0x2D, 0xA4, 0x38, 0x84, 0x42, 0x10, 0x9E, 0x08, 0xC4, 0x21,
  0x08, 0xC4, 0x27, 0x00, 0x2D, 0xA5, 0x1C, 0x61, 0xC9, 0x24, 0x2D, 0x24,
  0xB7, 0x23, 0x66, 0x66, 0x66, 0x6A, 0x6E, 0xB4, 0xB4, 0x25, 0x96, 0x57,
  0x59, 0x69, 0xA6, 0x39, 0xB4, 0xD3, 0xCB, 0x2D, 0x9C, 0x3B, 0x52, 0xB7,
  0x23, 0x10, 0x39, 0xB4, 0xD3, 0xCB, 0x2D, 0x9C, 0x30, 0x40, 0x33, 0x52,
  0xB7, 0x3A, 0x52, 0x3A, 0x50, 0xC3, 0x0A, 0xDC, 0xF4, 0x44, 0x4C, 0x88,
  0x25, 0xB4, 0x92, 0x4B, 0x6D, 0x1C, 0x9C, 0xA5, 0x4A, 0x63, 0x18, 0x93,
  0x26, 0xD5, 0xAD, 0x5B, 0x36, 0x4C, 0x24, 0xF1, 0x84, 0x30, 0xC5, 0xB6,
  0x9B, 0xAE, 0xCC, 0x88, 0x78, 0x8C, 0x46, 0x22, 0x1C, 0x34, 0x44, 0x44,
  0x88, 0x8C, 0xA9, 0x55, 0x38, 0x84, 0x23, 0x10, 0x84, 0x27, 0x00, 0x11,
  0x94, 0xA8, 0x80, 0xF0, 0x80, 0x7A, 0xF5, 0xA9, 0x78, 0x22, 0x1C, 0xB5,
  0xEB, 0x5C, 0x34, 0xCC, 0xC6, 0x08, 0x5E, 0xBD, 0x6A, 0x5E, 0x35, 0xF8,
  0x86, 0x19, 0x8C, 0xC2, 0x11, 0x88, 0x46, 0x20, 0x7A, 0xF5, 0xA9, 0x78,
  0xD4, 0xC0, 0x23, 0x1C, 0xB5, 0x6A, 0x56, 0x61, 0x25, 0xA4, 0x30, 0x22,
  0x26, 0x44, 0x4C, 0x80, 0x22, 0x16, 0xA6, 0x72, 0x96, 0x2D, 0x25, 0xA4,
  0x76, 0xB5, 0x4E, 0xA9, 0x56, 0x80, 0x72, 0xD5, 0xA9, 0x58, 0x32, 0xF5,
  0x29, 0x30, 0x38, 0xB2, 0xDA, 0x69, 0xC4, 0x10, 0xC0, 0x7A, 0xD5, 0x29,
  0x78, 0xC4, 0x20, 0x74, 0x4C, 0x88, 0x74, 0x42, 0x2E, 0x2D, 0x25, 0x30,
  0x4A, 0xD5, 0xA9, 0x78, 0xBA, 0xEC, 0xC8, 0xA6, 0xAE, 0xBA, 0xB2, 0xC0,
  0x2C, 0xA3, 0x0C, 0x73, 0x40, 0x2C, 0xA2, 0x8C, 0x30, 0x82, 0x10, 0x80,
  0x72, 0x64, 0x8E, 0x12, 0x22, 0xC4, 0x44, 0x46, 0xFF, 0xFF, 0xFC, 0x31,
  0x13, 0x13, 0x22, 0x6C, 0x4D, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 4, 1, -8 },
  { 6, 5, 8, 5, 0, -8 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 6, 8, 7, 1, -8 },
  { 23, 5, 8, 5, 0, -8 },
  { 28, 2, 3, 2, 1, -8 },
  { 29, 4, 10, 3, 0, -8 },
  { 34, 4, 10, 3, -1, -8 },
  { 39, 4, 4, 4, 1, -8 },
  { 41, 5, 6, 5, 0, -7 },
  { 45, 3, 2, 2, -1, -1 },
  { 46, 3, 2, 3, 0, -4 },
  { 47, 2, 2, 2, 0, -2 },
  { 48, 6, 8, 4, -1, -8 },
  { 54, 5, 8, 5, 0, -8 },
  { 59, 3, 8, 5, 1, -8 },
  { 62, 5, 8, 5, 0, -8 },
  { 67, 5, 8, 5, 0, -8 },
  { 72, 5, 8, 5, 0, -8 },
  { 77, 5, 8, 5, 0, -8 },
  { 82, 5, 8, 5, 0, -8 },
  { 87, 5, 8, 5, 0, -8 },
  { 92, 5, 8, 5, 0, -8 },
  { 97, 5, 8, 5, 0, -8 },
  { 102, 2, 6, 3, 0, -6 },
  { 104, 4, 7, 3, -1, -6 },
  { 108, 5, 5, 5, 0, -6 },
  { 112, 5, 3, 5, 0, -5 },
  { 114, 5, 5, 5, 0, -6 },
  { 118, 4, 8, 3, 0, -8 },
  { 122, 7, 9, 7, 0, -8 },
  { 130, 5, 8, 5, -1, -8 },
  { 135, 5, 8, 5, 0, -8 },
  { 140, 5, 8, 5, 0, -8 },
  { 145, 5, 8, 5, 0, -8 },
  { 150, 5, 8, 4, 0, -8 },
  { 155, 5, 8, 4, 0, -8 },
  { 160, 6, 8, 6, 0, -8 },
  { 166, 6, 8, 6, 0, -8 },
  { 172, 5, 8, 3, -1, -8 },
  { 177, 5, 10, 3, -2, -8 },
  { 184, 6, 8, 5, 0, -8 },
  { 190, 3, 8, 4, 0, -8 },
  { 193, 8, 8, 7, 0, -8 },
  { 201, 6, 8, 6, 0, -8 },
  { 207, 6, 8, 6, 0, -8 },
  { 213, 5, 8, 5, 0, -8 },
  { 218, 6, 10, 6, 0, -8 },
  { 226, 5, 8, 5, 0, -8 },
  { 231, 5, 8, 4, 0, -8 },
  { 236, 4, 8, 4, 1, -8 },
  { 240, 6, 8, 5, 0, -8 },
  { 246, 5, 8, 5, 1, -8 },
  { 251, 7, 8, 8, 1, -8 },
  { 258, 6, 8, 5, -1, -8 },
  { 264, 4, 8, 4, 1, -8 },
  { 268, 5, 8, 4, 0, -8 },
  { 273, 4, 10, 3, 0, -8 },
  { 278, 2, 8, 4, 1, -8 },
  { 280, 5, 10, 3, -1, -8 },
  { 287, 5, 5, 5, 0, -8 },
  { 291, 4, 1, 3, -1, 1 },
  { 292, 1, 1, 3, 2, -8 },
  { 293, 5, 6, 5, 0, -6 },
  { 297, 5, 8, 5, 0, -8 },
  { 302, 4, 6, 4, 0, -6 },
  { 305, 5, 8, 5, 0, -8 },
  { 310, 4, 6, 4, 0, -6 },
  { 313, 5, 11, 3, -1, -8 },
  { 320, 5, 9, 5, 0, -6 },
  { 326, 5, 8, 5, 0, -8 },
  { 331, 3, 8, 2, 0, -8 },
  { 334, 4, 11, 2, -1, -8 },
  { 340, 5, 8, 4, 0, -8 },
  { 345, 3, 8, 2, 0, -8 },
  { 348, 7, 6, 7, 0, -6 },
  { 354, 5, 6, 5, 0, -6 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 6, 9, 5, -1, -6 },
  { 369, 5, 9, 5, 0, -6 },
  { 375, 4, 6, 3, 0, -6 },
  { 378, 4, 6, 4, 0, -6 },
  { 381, 3, 7, 3, 0, -7 },
  { 384, 5, 6, 5, 0, -6 },
  { 388, 4, 6, 4, 1, -6 },
  { 391, 6, 6, 6, 1, -6 },
  { 396, 6, 6, 4, -1, -6 },
  { 401, 6, 9, 4, -1, -6 },
  { 408, 4, 6, 4, 0, -6 },
  { 411, 4, 10, 4, 0, -8 },
  { 416, 2, 11, 4, 1, -8 },
  { 419, 4, 10, 4, -1, -8 },
  { 424, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC11PT7B_H_
