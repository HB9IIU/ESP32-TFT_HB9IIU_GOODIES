#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0x80, 0x00, 0x1F,
  0xC3, 0xF8, 0xFE, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF8,
  0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xFC, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xEE, 0x7C, 0x03, 0xFC,
  0xE1, 0x80, 0x3F, 0x8C, 0x08, 0x03, 0xF0, 0xC0, 0x00, 0x3F, 0x1C, 0x00,
  0x03, 0xF1, 0xC0, 0x00, 0x3F, 0x1C, 0x00, 0x03, 0xF9, 0x80, 0x00, 0x3F,
  0xD8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0xEF, 0xF0, 0x00, 0x0C, 0x7F, 0x00,
  0x00, 0xC7, 0xF0, 0x00, 0x1C, 0x7F, 0x00, 0x01, 0xC7, 0xF0, 0x40, 0x1C,
  0x7F, 0x06, 0x01, 0x8F, 0xE0, 0x78, 0x18, 0xFE, 0x07, 0xE3, 0xBF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0x3E,
  0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xF0, 0x01, 0xF9,
  0xF8, 0x07, 0xE0, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x3F,
  0x00, 0x1F, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x0F, 0x81, 0xF8, 0x00, 0xF8,
  0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F, 0x1F,
  0x00, 0x03, 0xF0, 0x7C, 0x7E, 0x02, 0x07, 0xE0, 0xF8, 0xF8, 0x3F, 0x8F,
  0x83, 0xE3, 0xF0, 0xFF, 0x9F, 0x07, 0xC7, 0xC3, 0xFF, 0xBF, 0x1F, 0x9F,
  0x8F, 0xFF, 0x7E, 0x7E, 0x3E, 0x3F, 0x7E, 0x7F, 0xF8, 0xFC, 0x7C, 0x7C,
  0xFF, 0xF1, 0xF1, 0xF0, 0xF9, 0xFF, 0xC7, 0xE3, 0xE1, 0xF9, 0xFF, 0x0F,
  0x8F, 0x83, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x7E, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x7C, 0x00, 0x3F, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x83,
  0xE0, 0x01, 0xF8, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x0F, 0x8F, 0xC0, 0x07,
  0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x3F,
  0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xC3, 0xF8, 0x3F, 0xFF, 0x87,
  0xF0, 0xFF, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x3F, 0x87, 0xF0, 0xFE, 0x7F,
  0x0F, 0xC1, 0xFE, 0xFC, 0x3F, 0x81, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xE1,
  0xFC, 0x07, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F,
  0x01, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xF9, 0xFE, 0x07, 0xFF,
  0xC3, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE3,
  0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x81, 0xF8,
  0x07, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x7F, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0x7C, 0x03, 0xF9, 0xF8,
  0x1F, 0xE7, 0xF0, 0x3F, 0x0F, 0xC0, 0x78, 0x3F, 0x80, 0xE0, 0xFC, 0x01,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x1F, 0xDF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7F,
  0x80, 0x7F, 0x9F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFD, 0xF8, 0x7F, 0xBF, 0x8F, 0xF3, 0xF8, 0x7E,
  0x3F, 0x83, 0xC3, 0xF8, 0x18, 0x7F, 0x01, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE,
  0x7F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0x38, 0x07, 0xF8, 0x01, 0x80, 0x1F,
  0xC0, 0x08, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFC, 0xFF, 0xE0, 0x0F, 0x01, 0xFF, 0x00, 0x20, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x10, 0x00, 0x7F, 0xC0, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xE0,
  0x00, 0x3E, 0x7F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x01,
  0xF9, 0xFC, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xF8, 0x7F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7C, 0x3F, 0x80, 0x07, 0xC1, 0xFC, 0x00, 0x3E, 0x0F, 0xE0,
  0x03, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0x1F,
  0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x38, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x3F,
  0xC0, 0x80, 0x07, 0xFC, 0x0E, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF8, 0x30, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x78, 0x00, 0x7E, 0x3F,
  0xC0, 0x1F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC3, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFF, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x1F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x0F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xF8,
  0x1F, 0xF0, 0x7F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xC0, 0x3F, 0xF7, 0xF0, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x80,
  0x3F, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x30, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7C,
  0x3F, 0xC1, 0xC0, 0x7F, 0x04, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x10, 0x03, 0xE0, 0x7C, 0x03,
  0xFF, 0x07, 0xC0, 0xF8, 0x0F, 0xFF, 0x0F, 0x83, 0xE0, 0x3F, 0xFE, 0x1F,
  0x07, 0xC0, 0xFF, 0xFC, 0x3E, 0x1F, 0x03, 0xF1, 0xF8, 0x7C, 0x3E, 0x0F,
  0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x7C, 0x0F, 0x83,
  0xE3, 0xE0, 0xF8, 0x3F, 0x07, 0xC7, 0x83, 0xE0, 0x7C, 0x0F, 0x1F, 0x07,
  0xC0, 0xF8, 0x1E, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x7C, 0x3E, 0x07, 0xE0,
  0xF8, 0xF0, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0xF8, 0x1F, 0x03, 0xC7, 0xC1,
  0xF0, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0xFC, 0x1F, 0x1F, 0x0F, 0xC1, 0xF0,
  0x3C, 0x3E, 0x1F, 0x83, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0, 0xF0,
  0x7E, 0x1F, 0x87, 0xC1, 0xE0, 0xFC, 0x7F, 0x1F, 0x07, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0x81, 0xFF, 0xBF, 0xF8, 0x0F, 0x01, 0xFE, 0x3F, 0xE0, 0x1E,
  0x03, 0xF8, 0x7F, 0x00, 0x3E, 0x00, 0x80, 0x10, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFE,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xF9, 0xFC, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFF,
  0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBE, 0x00, 0x3F, 0xE0, 0x18, 0x01, 0xFF,
  0x00, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x04, 0x00, 0x7F, 0xE0,
  0x70, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0xFE, 0x03, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC,
  0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0x80,
  0x7F, 0x83, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xE7, 0xF8, 0x01,
  0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x80, 0x04, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0xE1, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0x80, 0xFF,
  0xF8, 0x3F, 0xC0, 0x7F, 0xFC, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xE0, 0x1F,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0x80,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xFB,
  0xF8, 0x03, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xC0, 0x3F, 0x7F,
  0x00, 0x3F, 0x3F, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xF0,
  0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0xFC, 0xFE, 0x00,
  0x7F, 0x3F, 0x03, 0xF3, 0xF8, 0x01, 0xF8, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xF0, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x0F, 0xC7, 0xF0, 0x03, 0xF0, 0xFC, 0x7E, 0x1F, 0xC0, 0x0F, 0xC3,
  0xF1, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xCF, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF7,
  0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xDF, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0xFC,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xFF, 0x81,
  0xFC, 0x00, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0x00, 0xFD, 0xF8, 0x0F, 0xE0, 0x07,
  0xEF, 0xC0, 0x7F, 0x00, 0x7F, 0x7E, 0x03, 0xF8, 0x03, 0xFB, 0xF8, 0x1F,
  0xC0, 0x1F, 0x8F, 0xC0, 0xFC, 0x00, 0xFC, 0x7E, 0x0F, 0xE0, 0x07, 0xE3,
  0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0x83, 0xF8, 0x03, 0xF8, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x7F, 0x00, 0x7F, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0x3F, 0x1F, 0x80, 0x1F,
  0x81, 0xFC, 0xFC, 0x00, 0xFC, 0x0F, 0xEF, 0xE0, 0x0F, 0xE0, 0x3F, 0x7F,
  0x00, 0x7F, 0x01, 0xFB, 0xF8, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0x1F, 0x80,
  0x7E, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0xFF, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x78, 0x01,
  0xFF, 0x00, 0x60, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x04, 0x00, 0x1F, 0xE0, 0x1C, 0x00, 0xFF, 0x00, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03,
  0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x8F,
  0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x7C, 0x07, 0xF0, 0x1F, 0xC0, 0xFD, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xF7, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0x03,
  0xF8, 0x07, 0xF0, 0x7E, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFB, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xCF, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x3F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFC, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xE3, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0x8F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x3F, 0x1F, 0xC0, 0x07,
  0xF3, 0xF0, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xC3, 0xF3, 0xF8, 0x00, 0x7F,
  0x7E, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x3F, 0x7F, 0x00, 0x07, 0xE7,
  0xE0, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3E, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xEF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x80,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF1, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x8F,
  0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x3F, 0x00, 0x7F, 0xE3,
  0xF0, 0x1F, 0xFF, 0x7F, 0x01, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFE, 0xFF, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x01,
  0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x7F,
  0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFC, 0x03, 0xFF, 0x9F,
  0x80, 0x1F, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC1,
  0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x1F, 0xDF, 0xFC, 0x01, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFE, 0x03, 0xFE,
  0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x07,
  0xFC, 0x0F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xF0, 0x0F, 0xCF, 0xFE, 0x00,
  0xF8, 0x7F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFE, 0x38, 0x07, 0xF8, 0x08, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x40, 0x7F, 0x81,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xE0, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0xF3, 0xF8,
  0x00, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xDF, 0x00, 0x0F, 0xFF, 0x7E, 0x00,
  0x0F, 0xFC, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF8,
  0x07, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0x3F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0x01, 0xFF, 0x03,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xEC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0xFF, 0xF7, 0xF0,
  0x03, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00,
  0x7F, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xBF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFC, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x06, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x04, 0x00, 0x1F, 0xE0, 0x0E, 0x00,
  0x7F, 0x80, 0x1F, 0xE7, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x7F, 0x3F, 0xE0, 0x0F, 0xEF, 0xFE,
  0x01, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8,
  0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x01,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01,
  0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xFC, 0x7F, 0xC1, 0xFF, 0x00, 0x7C, 0xFF, 0xE3, 0xFF, 0x80,
  0x3E, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0x7F, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF, 0xF3, 0xFE, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x1F, 0xF0, 0x07, 0xC7, 0xFF, 0x00,
  0xF9, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF,
  0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07,
  0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE7, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03,
  0xFC, 0x1F, 0xC1, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x8F, 0xF8,
  0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x3F, 0x7F, 0xFE,
  0x00, 0x3F, 0x7F, 0xFE, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xE0,
  0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xEF, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0x00, 0x0F, 0xE7, 0xFE, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xE0, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFE, 0x3F, 0x00,
  0x7F, 0xF3, 0xF0, 0x0F, 0xFF, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFC, 0x7F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xF0, 0x3F, 0xE0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFC, 0x03,
  0xFF, 0xDF, 0x80, 0x3F, 0xFB, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0x83,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF1, 0xFC,
  0x07, 0xE7, 0xF0, 0x0F, 0x9F, 0xE0, 0x3F, 0x7F, 0xC0, 0x7E, 0xFF, 0x80,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x3C, 0x07,
  0xF0, 0x0C, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x80, 0x0F, 0xF0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xCC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0x80,
  0x7F, 0xF9, 0xF8, 0x03, 0xFF, 0x1F, 0x00, 0x1F, 0xE1, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE,
  0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD,
  0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFD, 0xFC, 0x07, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xE0,
  0x1F, 0x9F, 0xC0, 0xFF, 0x80, 0xFE, 0x7F, 0x03, 0xFE, 0x03, 0xF9, 0xFC,
  0x0F, 0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0xE0, 0x7F, 0x1F, 0x81, 0xFF, 0x81,
  0xF8, 0x7E, 0x0F, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0xF8, 0x3F, 0x87, 0xE0,
  0xFB, 0xE0, 0xFC, 0x1F, 0x87, 0xEF, 0x87, 0xF0, 0x7E, 0x1F, 0x3E, 0x1F,
  0x81, 0xF8, 0x7D, 0xF8, 0xFE, 0x07, 0xE3, 0xF7, 0xE3, 0xF8, 0x1F, 0x8F,
  0x9F, 0x8F, 0xC0, 0x7E, 0x7E, 0x7E, 0x7F, 0x01, 0xF9, 0xF9, 0xF9, 0xF8,
  0x07, 0xE7, 0xC7, 0xE7, 0xE0, 0x1F, 0xBF, 0x1F, 0xBF, 0x80, 0x7E, 0xF8,
  0x7E, 0xFC, 0x01, 0xFB, 0xE1, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x7D, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x47, 0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x0D,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x20, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 47, 16, 0, -46 },
  { 107, 21, 16, 24, 6, -46 },
  { 149, 31, 46, 30, 0, -46 },
  { 328, 28, 53, 27, 0, -49 },
  { 514, 39, 48, 43, 3, -47 },
  { 748, 31, 48, 31, 0, -47 },
  { 934, 11, 16, 14, 6, -46 },
  { 956, 21, 57, 17, 1, -47 },
  { 1106, 21, 57, 17, -5, -47 },
  { 1256, 22, 25, 25, 6, -50 },
  { 1325, 25, 30, 29, 3, -38 },
  { 1419, 13, 17, 15, -3, -8 },
  { 1447, 16, 7, 18, 1, -21 },
  { 1461, 9, 10, 15, 0, -9 },
  { 1473, 32, 47, 23, -3, -47 },
  { 1661, 26, 48, 27, 1, -47 },
  { 1817, 20, 46, 27, 6, -46 },
  { 1932, 29, 47, 27, -2, -47 },
  { 2103, 29, 48, 27, -1, -47 },
  { 2277, 29, 47, 27, -1, -47 },
  { 2448, 28, 47, 27, 0, -46 },
  { 2613, 27, 48, 27, 2, -47 },
  { 2775, 28, 46, 27, 2, -46 },
  { 2936, 28, 48, 27, 0, -47 },
  { 3104, 27, 48, 27, 0, -47 },
  { 3266, 15, 37, 15, 0, -36 },
  { 3336, 18, 45, 15, -3, -36 },
  { 3438, 26, 30, 29, 2, -38 },
  { 3536, 25, 19, 29, 3, -32 },
  { 3596, 25, 30, 29, 3, -38 },
  { 3690, 22, 48, 21, 1, -47 },
  { 3822, 39, 52, 41, 1, -47 },
  { 4076, 29, 47, 29, -4, -47 },
  { 4247, 30, 46, 30, 0, -46 },
  { 4420, 30, 48, 27, 2, -47 },
  { 4600, 32, 46, 32, 0, -46 },
  { 4784, 28, 46, 25, 0, -46 },
  { 4945, 28, 46, 24, 0, -46 },
  { 5106, 33, 48, 33, 2, -47 },
  { 5304, 35, 46, 33, 0, -46 },
  { 5506, 27, 46, 19, -3, -46 },
  { 5662, 27, 59, 15, -10, -46 },
  { 5862, 34, 46, 29, 0, -46 },
  { 6058, 20, 46, 24, 0, -46 },
  { 6173, 46, 46, 44, 0, -46 },
  { 6438, 37, 46, 35, 0, -46 },
  { 6651, 32, 48, 34, 2, -47 },
  { 6843, 30, 46, 29, 0, -46 },
  { 7016, 32, 58, 34, 2, -47 },
  { 7248, 30, 46, 29, 0, -46 },
  { 7421, 30, 48, 26, -1, -47 },
  { 7601, 26, 46, 24, 4, -46 },
  { 7751, 33, 47, 32, 2, -46 },
  { 7945, 28, 46, 29, 6, -46 },
  { 8106, 46, 46, 44, 4, -46 },
  { 8371, 36, 46, 27, -4, -46 },
  { 8578, 27, 46, 26, 5, -46 },
  { 8734, 31, 46, 24, -3, -46 },
  { 8913, 25, 57, 18, -2, -47 },
  { 9092, 13, 47, 24, 6, -47 },
  { 9169, 26, 57, 18, -5, -47 },
  { 9355, 27, 26, 27, 0, -46 },
  { 9443, 21, 4, 21, -6, 6 },
  { 9454, 11, 11, 18, 9, -50 },
  { 9470, 28, 37, 29, 1, -36 },
  { 9600, 28, 50, 29, 0, -49 },
  { 9775, 24, 37, 23, 1, -36 },
  { 9886, 31, 50, 29, 1, -49 },
  { 10080, 25, 37, 26, 1, -36 },
  { 10196, 32, 66, 17, -8, -50 },
  { 10460, 31, 52, 29, -2, -36 },
  { 10662, 27, 49, 29, 0, -49 },
  { 10828, 17, 49, 14, 0, -49 },
  { 10933, 25, 65, 14, -8, -49 },
  { 11137, 29, 49, 26, 0, -49 },
  { 11315, 17, 49, 14, 0, -49 },
  { 11420, 41, 36, 42, 0, -36 },
  { 11605, 27, 36, 29, 0, -36 },
  { 11727, 26, 37, 28, 1, -36 },
  { 11848, 32, 51, 29, -4, -36 },
  { 12052, 28, 52, 29, 1, -36 },
  { 12234, 23, 36, 20, 0, -36 },
  { 12338, 24, 37, 22, -1, -36 },
  { 12449, 18, 44, 18, 2, -43 },
  { 12548, 28, 36, 28, 1, -35 },
  { 12674, 24, 35, 24, 4, -35 },
  { 12779, 38, 35, 38, 3, -35 },
  { 12946, 31, 35, 25, -3, -35 },
  { 13082, 33, 51, 25, -5, -35 },
  { 13293, 25, 35, 21, -2, -35 },
  { 13403, 25, 56, 22, 1, -46 },
  { 13578, 6, 65, 24, 9, -50 },
  { 13627, 25, 56, 22, -4, -46 },
  { 13802, 26, 10, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC65PT7B_H_
