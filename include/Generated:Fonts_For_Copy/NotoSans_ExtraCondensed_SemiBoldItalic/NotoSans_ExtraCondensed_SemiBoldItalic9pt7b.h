#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xB8, 0x37, 0x6F, 0xAA, 0x27, 0x46, 0x2E, 0x44, 0x21,
  0xAB, 0x2F, 0x74, 0xD5, 0x80, 0x25, 0x66, 0xBB, 0xD0, 0xC0, 0x69, 0x49,
  0x20, 0x24, 0x92, 0x56, 0x5F, 0x20, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x32,
  0x44, 0x88, 0x25, 0x59, 0xAA, 0xC0, 0x79, 0x25, 0x00, 0x25, 0x12, 0x4C,
  0xE0, 0x25, 0x16, 0x22, 0xE0, 0x32, 0x6B, 0xE2, 0x74, 0x62, 0x2E, 0x16,
  0x4E, 0xAA, 0xE0, 0x72, 0x24, 0x4C, 0x25, 0x56, 0xAA, 0xE0, 0x25, 0x5F,
  0x62, 0xC0, 0x40, 0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x2C,
  0xA4, 0x20, 0x39, 0x5B, 0x76, 0xBA, 0x07, 0x00, 0x13, 0x37, 0x5D, 0x75,
  0x69, 0x9E, 0x17, 0x4C, 0x88, 0x60, 0x75, 0x55, 0xBE, 0x74, 0x64, 0x8E,
  0x74, 0x64, 0x88, 0x13, 0x51, 0xAB, 0x49, 0xC0, 0x4A, 0x9C, 0xA9, 0x58,
  0x69, 0x25, 0x80, 0x24, 0x94, 0x94, 0x5B, 0x18, 0xCA, 0x50, 0x49, 0x29,
  0xC0, 0x65, 0xB6, 0xED, 0xBA, 0xA0, 0x6B, 0x5B, 0x6B, 0x48, 0x13, 0xD2,
  0xB9, 0x49, 0x80, 0x75, 0x56, 0x88, 0x13, 0xD2, 0xB9, 0x49, 0x84, 0x20,
  0x75, 0x7A, 0xAA, 0x25, 0x46, 0x22, 0xE0, 0xEA, 0x49, 0x00, 0x4A, 0x95,
  0x29, 0x30, 0xBA, 0xCC, 0xC8, 0xA6, 0xAE, 0xBC, 0xB2, 0xC0, 0x29, 0x8C,
  0x65, 0x68, 0xBB, 0x49, 0x00, 0x72, 0x44, 0x8E, 0x69, 0x49, 0x30, 0xAA,
  0x90, 0x31, 0x22, 0x22, 0xC0, 0x26, 0x90, 0xE0, 0xD0, 0x75, 0x9A, 0xE0,
  0x44, 0x75, 0x9A, 0xE0, 0x6A, 0x4E, 0x11, 0x75, 0x9A, 0xE0, 0x65, 0xE8,
  0xE0, 0x12, 0x72, 0x24, 0x44, 0xC0, 0x75, 0x9A, 0xE2, 0xC0, 0x44, 0x75,
  0x9A, 0xA0, 0x45, 0xA8, 0x20, 0x94, 0x92, 0x80, 0x44, 0x56, 0xEA, 0xA0,
  0x55, 0xA8, 0x7D, 0x5A, 0xAA, 0xA8, 0x75, 0x9A, 0xA0, 0x65, 0x9A, 0xE0,
  0x75, 0x9A, 0xE8, 0x80, 0x75, 0x9A, 0xE2, 0x20, 0x6A, 0x48, 0x79, 0x1C,
  0x5D, 0x29, 0x80, 0x55, 0xAA, 0xE0, 0xBB, 0x48, 0x76, 0xEB, 0x94, 0xD0,
  0x56, 0x4A, 0xA0, 0x29, 0x8C, 0x42, 0x23, 0x00, 0x65, 0x4C, 0x34, 0x48,
  0x44, 0x40, 0xFF, 0x80, 0x22, 0x21, 0x24, 0xC0, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 6, 7, 6, 0, -7 },
  { 17, 4, 7, 4, 0, -7 },
  { 21, 1, 2, 2, 1, -6 },
  { 22, 3, 7, 2, 0, -6 },
  { 25, 3, 8, 2, -1, -7 },
  { 28, 3, 4, 4, 1, -7 },
  { 30, 4, 4, 4, 0, -5 },
  { 32, 1, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 1, 1, 2, 0, -1 },
  { 35, 4, 6, 3, 0, -6 },
  { 38, 4, 7, 4, 0, -7 },
  { 42, 3, 6, 4, 1, -6 },
  { 45, 4, 7, 4, 0, -7 },
  { 49, 4, 7, 4, 0, -7 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 6, 4, 0, -6 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 2, 5, 2, 0, -5 },
  { 76, 2, 6, 2, 0, -5 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 4, 2, 4, 0, -4 },
  { 81, 4, 4, 4, 0, -5 },
  { 83, 3, 7, 3, 0, -7 },
  { 86, 6, 7, 6, 0, -6 },
  { 92, 4, 6, 4, -1, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 4, 7, 4, 0, -7 },
  { 102, 4, 6, 4, 0, -6 },
  { 105, 4, 6, 3, 0, -6 },
  { 108, 4, 6, 3, 0, -6 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 3, 6, 3, 0, -6 },
  { 123, 3, 8, 2, -1, -6 },
  { 126, 5, 6, 4, 0, -6 },
  { 130, 3, 6, 3, 0, -6 },
  { 133, 6, 6, 6, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 5, 9, 5, 0, -7 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 4, 7, 4, 0, -7 },
  { 163, 3, 6, 3, 1, -6 },
  { 166, 5, 6, 4, 0, -6 },
  { 170, 4, 6, 4, 1, -6 },
  { 173, 6, 6, 6, 1, -6 },
  { 178, 5, 6, 4, -1, -6 },
  { 182, 3, 6, 4, 1, -6 },
  { 185, 4, 6, 3, 0, -6 },
  { 188, 3, 7, 3, 0, -6 },
  { 191, 2, 6, 3, 1, -6 },
  { 193, 4, 7, 3, -1, -6 },
  { 197, 4, 3, 4, 0, -6 },
  { 199, 3, 1, 3, -1, 1 },
  { 200, 2, 2, 3, 1, -7 },
  { 201, 4, 5, 4, 0, -5 },
  { 204, 4, 7, 4, 0, -7 },
  { 208, 3, 5, 3, 0, -5 },
  { 210, 4, 7, 4, 0, -7 },
  { 214, 4, 5, 4, 0, -5 },
  { 217, 4, 9, 2, -1, -7 },
  { 222, 4, 7, 4, 0, -5 },
  { 226, 4, 7, 4, 0, -7 },
  { 230, 2, 7, 2, 0, -7 },
  { 232, 3, 9, 2, -1, -7 },
  { 236, 4, 7, 4, 0, -7 },
  { 240, 2, 7, 2, 0, -7 },
  { 242, 6, 5, 6, 0, -5 },
  { 246, 4, 5, 4, 0, -5 },
  { 249, 4, 5, 4, 0, -5 },
  { 252, 4, 7, 4, 0, -5 },
  { 256, 4, 7, 4, 0, -5 },
  { 260, 3, 5, 3, 0, -5 },
  { 262, 3, 5, 3, 0, -5 },
  { 264, 3, 6, 2, 0, -6 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 3, 5, 3, 1, -5 },
  { 272, 6, 5, 5, 0, -5 },
  { 276, 4, 5, 3, 0, -5 },
  { 279, 5, 7, 3, -1, -5 },
  { 284, 3, 5, 3, 0, -5 },
  { 286, 4, 7, 3, 0, -6 },
  { 290, 1, 9, 3, 1, -7 },
  { 292, 4, 7, 3, -1, -6 },
  { 296, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC9PT7B_H_
