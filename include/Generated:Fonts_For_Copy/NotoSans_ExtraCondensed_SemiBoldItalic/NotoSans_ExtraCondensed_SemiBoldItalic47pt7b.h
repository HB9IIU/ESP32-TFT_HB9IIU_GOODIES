#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC47PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x7E, 0x7E, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x3E, 0x3E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x1E, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0,
  0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x3C, 0x38,
  0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x8F, 0x00,
  0x0E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x3F,
  0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7C,
  0xCC, 0x0F, 0x98, 0x00, 0xF9, 0x80, 0x0F, 0x98, 0x00, 0xF9, 0x80, 0x0F,
  0xD0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x06, 0xF8,
  0x00, 0xCF, 0x80, 0x0C, 0xF8, 0x00, 0xCF, 0x84, 0x0C, 0xF8, 0x70, 0xDF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0x70, 0x0F, 0xF8, 0x0F,
  0x01, 0xFF, 0x81, 0xE0, 0x1E, 0x78, 0x1E, 0x03, 0xC7, 0x83, 0xC0, 0x3C,
  0x78, 0x3C, 0x03, 0x87, 0x87, 0x80, 0x78, 0x78, 0x78, 0x07, 0x87, 0x8F,
  0x00, 0x78, 0x78, 0xF0, 0x07, 0x87, 0x1E, 0x00, 0x70, 0xF1, 0xE0, 0x0F,
  0x0F, 0x3C, 0x10, 0xF0, 0xE3, 0xCF, 0xEF, 0x1E, 0x79, 0xFE, 0xF1, 0xE7,
  0x1F, 0xF7, 0xFC, 0xF3, 0xCF, 0x7F, 0x9E, 0x78, 0xF7, 0xF1, 0xE7, 0x8F,
  0x1E, 0x3C, 0x70, 0xF0, 0x03, 0xCF, 0x0F, 0x00, 0x78, 0xF0, 0xF0, 0x07,
  0x8F, 0x0F, 0x00, 0xF0, 0xE0, 0xE0, 0x0F, 0x1E, 0x1E, 0x01, 0xE1, 0xE1,
  0xE0, 0x1E, 0x1E, 0x1E, 0x03, 0xC1, 0xE3, 0xC0, 0x3C, 0x1E, 0x3C, 0x07,
  0x81, 0xE7, 0x80, 0x70, 0x0F, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE1, 0xF0, 0xFF, 0xC7, 0xC7, 0xDF, 0x1F, 0x3E, 0x7C, 0xF9, 0xF1,
  0xFB, 0xE7, 0xC3, 0xFF, 0x3E, 0x0F, 0xFC, 0xF8, 0x3F, 0xE3, 0xE0, 0x7F,
  0x8F, 0x81, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x3F, 0xC3, 0xF1, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xF3, 0xE0, 0xFF, 0x0F, 0xC0, 0x3E,
  0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xF3, 0xC7, 0x8F, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x61, 0xE0,
  0x79, 0xE1, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x07, 0xE0,
  0x1F, 0xE0, 0x3F, 0xF0, 0x7E, 0xF8, 0x7C, 0x78, 0x3C, 0x7C, 0x18, 0x78,
  0x00, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3C, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0x8F, 0x83, 0xF0, 0xF0, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x7E, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xFB, 0xF0, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x07, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0xCF, 0xFE, 0xFD, 0xF7, 0xCF,
  0x9C, 0xF8, 0x47, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0x83, 0xF0, 0x0C, 0x0F, 0xC0,
  0x20, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xC0, 0xFC, 0x04, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x08, 0x01, 0xF8, 0x78, 0x3F, 0x83, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1D, 0xE0, 0x01, 0xDF, 0x00, 0x1E,
  0xF8, 0x00, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x1F, 0x00,
  0x78, 0xF8, 0x07, 0x87, 0xC0, 0x38, 0x7C, 0x03, 0xC3, 0xE0, 0x3C, 0x1F,
  0x01, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x80, 0x7F, 0x0E, 0x0F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x08, 0x03,
  0xE7, 0xE0, 0x3E, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xF1, 0xF8,
  0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83,
  0xF0, 0xFC, 0x3E, 0x07, 0xCF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x08, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xE3, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x83, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFB, 0xF0,
  0x3F, 0x1F, 0x07, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC3,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xF1, 0xF0, 0x3F,
  0x1F, 0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x1F, 0x0F, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xF7, 0xC0, 0x7C, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x08,
  0x1F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x01, 0x80, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x00,
  0x00, 0x60, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x7F,
  0x08, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0xFC,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF0, 0x3F, 0x0F, 0x0F, 0x07, 0xFC,
  0x71, 0xE0, 0xFF, 0x87, 0x1E, 0x1E, 0x78, 0xF1, 0xC3, 0xC7, 0x8F, 0x3C,
  0x78, 0x78, 0xF3, 0x87, 0x87, 0x0F, 0x78, 0x70, 0xF0, 0xF7, 0x8F, 0x0F,
  0x0E, 0x70, 0xF0, 0xF0, 0xE7, 0x0E, 0x0E, 0x1E, 0x71, 0xE1, 0xE1, 0xCF,
  0x1E, 0x1E, 0x1C, 0xF1, 0xE1, 0xE3, 0xCF, 0x1E, 0x3E, 0x38, 0xF1, 0xE3,
  0xE7, 0x8F, 0x1F, 0xEE, 0xF0, 0xF0, 0xFE, 0xFE, 0x0F, 0x0F, 0xCF, 0xC0,
  0xF0, 0x30, 0x30, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01,
  0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C,
  0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x0F,
  0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0x0F,
  0xC1, 0xF1, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xF8, 0x30, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x40, 0x3F, 0x9E, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7C, 0x7F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00,
  0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC3, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0x03, 0x03, 0xF8, 0x02, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0xF9, 0xF8, 0x3F, 0xE3, 0xF0, 0x7F, 0xC7, 0xC0, 0xFF, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xE0, 0x7C,
  0x0F, 0xE1, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x11, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC7,
  0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xF9,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7C, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0,
  0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xF7, 0x80, 0xF7,
  0xC0, 0xFB, 0xC0, 0xFB, 0xE0, 0x7D, 0xE0, 0x7F, 0xE0, 0x3E, 0xF0, 0x3D,
  0xF0, 0x1F, 0x78, 0x3E, 0xF8, 0x0F, 0x3C, 0x1E, 0x7C, 0x0F, 0x9E, 0x1F,
  0x3E, 0x07, 0xCF, 0x0F, 0x3E, 0x03, 0xE7, 0xCF, 0x9F, 0x01, 0xF3, 0xE7,
  0x8F, 0x80, 0xF1, 0xF7, 0xC7, 0xC0, 0xF8, 0xFB, 0xC7, 0xC0, 0x7C, 0x7D,
  0xE3, 0xE0, 0x3E, 0x3F, 0xF1, 0xF0, 0x1F, 0x1F, 0xF0, 0xF8, 0x0F, 0x0F,
  0xF8, 0x7C, 0x0F, 0x87, 0xF8, 0x7C, 0x07, 0xC3, 0xFC, 0x3E, 0x03, 0xE1,
  0xFC, 0x1F, 0x01, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0xC0,
  0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3C, 0x07,
  0xFC, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x3E, 0x03, 0xDF, 0x07,
  0xC0, 0xFB, 0xE1, 0xF0, 0x1F, 0x3C, 0x3E, 0x03, 0xE7, 0x87, 0xC0, 0x7C,
  0xF0, 0xF8, 0x0F, 0x1F, 0x1E, 0x03, 0xE3, 0xE7, 0xC0, 0x7C, 0x7C, 0xF8,
  0x0F, 0x87, 0x9F, 0x01, 0xF0, 0xF3, 0xE0, 0x3C, 0x1E, 0x78, 0x0F, 0x83,
  0xFF, 0x01, 0xF0, 0x7F, 0xE0, 0x3E, 0x0F, 0xFC, 0x07, 0xC0, 0xFF, 0x80,
  0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F,
  0xF0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0,
  0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x7E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xF8, 0x01,
  0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF9,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0x87, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1F, 0x07,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C,
  0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF8,
  0x01, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xEF,
  0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF9, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF0, 0xFC, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7E,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xE1, 0xC0, 0x7E, 0x01, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x10, 0x07, 0xE0, 0x60, 0x3F, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x0F, 0xDF, 0x00, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x03, 0xE3, 0xE0, 0x3F, 0x01,
  0xF1, 0xF0, 0x3F, 0x81, 0xF8, 0xF8, 0x1F, 0xC0, 0xF8, 0x7C, 0x0F, 0xE0,
  0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0x87, 0xFC,
  0x1F, 0x07, 0xC3, 0xDE, 0x1F, 0x03, 0xE1, 0xEF, 0x0F, 0x81, 0xF1, 0xF7,
  0x8F, 0x80, 0xF8, 0xF3, 0xC7, 0xC0, 0x7C, 0x79, 0xE3, 0xE0, 0x3E, 0x78,
  0xF3, 0xE0, 0x1E, 0x3C, 0xF9, 0xF0, 0x0F, 0x3E, 0x7D, 0xF8, 0x07, 0x9E,
  0x3E, 0xF8, 0x03, 0xCF, 0x1F, 0x7C, 0x01, 0xEF, 0x8F, 0x7C, 0x00, 0xF7,
  0x87, 0xBE, 0x00, 0x7F, 0xC3, 0xDF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xDE, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xC7, 0xC1, 0xF8,
  0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81,
  0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xF0,
  0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x3C,
  0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x01,
  0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C,
  0x7E, 0x3E, 0x1E, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0x3F, 0x9F, 0x07, 0xFD,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xF0,
  0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0xC7, 0xF0,
  0xFF, 0xFF, 0x07, 0xFD, 0xE0, 0x7F, 0x9E, 0x03, 0xF1, 0xE0, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC7, 0x80, 0x7D, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xF7, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0,
  0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xF3,
  0xFC, 0x0F, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFC, 0x10, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x87, 0xE1, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x1F, 0x00, 0xFF, 0x7C, 0x07, 0xFD, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83,
  0xF0, 0x3F, 0x1F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0x78, 0x07, 0xFD, 0xE0,
  0x0F, 0xC7, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xCF, 0x87, 0xC1, 0xF1, 0xF0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x9F,
  0x03, 0xE7, 0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xF8,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x03, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x8F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xFD, 0xF0, 0x1F, 0xF7, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xFC, 0x7F, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xEF, 0x80, 0x3F, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x20, 0x0F, 0x80, 0xE0, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x7D, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1,
  0xF8, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x01,
  0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x27, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x02, 0x0F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xC1,
  0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03,
  0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7C,
  0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x78, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x81, 0xE0, 0x3C, 0xFE, 0x3F, 0x81, 0xEF, 0xFB, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xE1, 0xFC, 0x7C, 0x3F, 0x0F, 0xC3, 0xE1,
  0xF0, 0x7C, 0x1F, 0x1F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x07, 0xC7, 0xC1,
  0xF0, 0x3E, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x1F, 0x03, 0xE0,
  0xF8, 0xF8, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x3E, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x1F, 0x03, 0xE0, 0xF8, 0xF8, 0x1E, 0x07, 0xC7, 0xC1,
  0xF0, 0x3C, 0x3E, 0x0F, 0x83, 0xE1, 0xE0, 0x7C, 0x1F, 0x1F, 0x03, 0xE0,
  0xF8, 0xF8, 0x1E, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x79, 0xFC, 0x07, 0xBF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x81,
  0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x3F, 0x3F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x01, 0xE7, 0xF0, 0x03, 0xDF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xE7, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0xFC,
  0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xBF, 0xE0, 0x1F, 0x7F,
  0x80, 0x3E, 0x7E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xCF, 0x07, 0xFD, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x3F, 0x0F, 0xC7, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xBE, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x83,
  0xCF, 0x81, 0xEF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE1,
  0xFF, 0xE1, 0xF8, 0xE0, 0xF8, 0x10, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x88,
  0x0F, 0x86, 0x0F, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x7F,
  0xE7, 0xFF, 0x3F, 0xFB, 0xFF, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x07, 0xF8,
  0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF,
  0xDE, 0x07, 0xFB, 0xE0, 0x3F, 0x3C, 0x00, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE,
  0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E, 0x07, 0xDF,
  0x03, 0xEF, 0x01, 0xEF, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x1F, 0x81, 0xF7, 0xC1, 0xF8, 0x3E, 0x7C, 0x3F, 0x83, 0xE7,
  0xC3, 0xF8, 0x3C, 0x7C, 0x3F, 0x87, 0xC7, 0xC7, 0xF8, 0x7C, 0x7C, 0x7F,
  0x8F, 0x87, 0x87, 0xF8, 0xF8, 0x78, 0xF7, 0x8F, 0x07, 0x8F, 0x79, 0xF0,
  0x79, 0xE7, 0x9F, 0x07, 0x9E, 0x79, 0xE0, 0x79, 0xE7, 0xBE, 0x07, 0xBC,
  0x7B, 0xC0, 0x7B, 0xC7, 0xFC, 0x07, 0xBC, 0xF7, 0xC0, 0x7F, 0x8F, 0x78,
  0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xE0, 0x01,
  0xF3, 0xE0, 0x01, 0xF3, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0xF7, 0xC0, 0x00,
  0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x8F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x40, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x2F, 0xF8, 0x0F, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x01,
  0xFF, 0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 34, 11, 0, -34 },
  { 57, 15, 13, 18, 5, -34 },
  { 82, 23, 34, 21, 0, -34 },
  { 180, 20, 39, 19, 0, -36 },
  { 278, 28, 34, 31, 2, -34 },
  { 397, 22, 34, 23, 0, -34 },
  { 491, 7, 13, 10, 5, -34 },
  { 503, 15, 41, 12, 1, -34 },
  { 580, 16, 41, 13, -4, -34 },
  { 662, 16, 18, 18, 4, -36 },
  { 698, 18, 23, 21, 2, -28 },
  { 750, 9, 12, 11, -2, -6 },
  { 764, 11, 5, 13, 1, -15 },
  { 771, 7, 6, 11, 0, -6 },
  { 777, 23, 34, 17, -2, -34 },
  { 875, 19, 34, 19, 1, -34 },
  { 956, 13, 34, 20, 5, -34 },
  { 1012, 22, 34, 19, -2, -34 },
  { 1106, 21, 34, 19, -1, -34 },
  { 1196, 21, 34, 20, -1, -34 },
  { 1286, 20, 34, 19, 0, -34 },
  { 1371, 20, 34, 19, 1, -34 },
  { 1456, 21, 34, 19, 1, -34 },
  { 1546, 20, 34, 19, 0, -34 },
  { 1631, 20, 34, 19, 0, -34 },
  { 1716, 11, 26, 11, 0, -26 },
  { 1752, 13, 32, 11, -2, -26 },
  { 1804, 18, 22, 21, 2, -28 },
  { 1854, 18, 13, 21, 2, -23 },
  { 1884, 18, 22, 21, 2, -28 },
  { 1934, 16, 34, 15, 1, -34 },
  { 2002, 28, 38, 29, 1, -34 },
  { 2135, 21, 34, 21, -3, -34 },
  { 2225, 22, 34, 22, 0, -34 },
  { 2319, 21, 34, 20, 2, -34 },
  { 2409, 23, 34, 23, 0, -34 },
  { 2507, 20, 34, 18, 0, -34 },
  { 2592, 20, 34, 17, 0, -34 },
  { 2677, 23, 34, 24, 2, -34 },
  { 2775, 26, 34, 24, 0, -34 },
  { 2886, 19, 34, 14, -2, -34 },
  { 2967, 19, 44, 11, -7, -34 },
  { 3072, 25, 34, 21, 0, -34 },
  { 3179, 14, 34, 17, 0, -34 },
  { 3239, 33, 34, 32, 0, -34 },
  { 3380, 27, 34, 26, 0, -34 },
  { 3495, 22, 34, 25, 2, -34 },
  { 3589, 22, 34, 21, 0, -34 },
  { 3683, 22, 42, 25, 2, -34 },
  { 3799, 21, 34, 21, 0, -34 },
  { 3889, 22, 34, 19, -1, -34 },
  { 3983, 18, 34, 18, 3, -34 },
  { 4060, 23, 34, 23, 2, -34 },
  { 4158, 21, 34, 21, 4, -34 },
  { 4248, 33, 34, 32, 3, -34 },
  { 4389, 26, 34, 19, -3, -34 },
  { 4500, 19, 34, 19, 4, -34 },
  { 4581, 22, 34, 17, -2, -34 },
  { 4675, 19, 42, 13, -2, -34 },
  { 4775, 9, 34, 17, 5, -34 },
  { 4814, 18, 42, 13, -3, -34 },
  { 4909, 20, 20, 20, 0, -34 },
  { 4959, 15, 3, 15, -4, 4 },
  { 4965, 8, 8, 13, 7, -36 },
  { 4973, 20, 26, 21, 1, -26 },
  { 5038, 20, 36, 21, 0, -36 },
  { 5128, 17, 26, 16, 1, -26 },
  { 5184, 22, 36, 21, 1, -36 },
  { 5283, 18, 26, 19, 1, -26 },
  { 5342, 24, 47, 12, -6, -36 },
  { 5483, 22, 37, 21, -1, -26 },
  { 5585, 20, 36, 21, 0, -36 },
  { 5675, 12, 35, 10, 0, -35 },
  { 5728, 18, 46, 10, -6, -35 },
  { 5832, 21, 36, 19, 0, -36 },
  { 5927, 13, 36, 10, 0, -36 },
  { 5986, 29, 26, 31, 0, -26 },
  { 6081, 20, 26, 21, 0, -26 },
  { 6146, 18, 26, 20, 1, -26 },
  { 6205, 23, 37, 21, -3, -26 },
  { 6312, 20, 37, 21, 1, -26 },
  { 6405, 17, 26, 14, 0, -26 },
  { 6461, 17, 26, 16, 0, -26 },
  { 6517, 13, 31, 13, 1, -31 },
  { 6568, 20, 25, 21, 1, -25 },
  { 6631, 17, 25, 18, 3, -25 },
  { 6685, 28, 25, 28, 2, -25 },
  { 6773, 22, 25, 18, -2, -25 },
  { 6842, 24, 36, 18, -4, -25 },
  { 6950, 18, 25, 15, -2, -25 },
  { 7007, 18, 41, 16, 1, -34 },
  { 7100, 5, 47, 17, 6, -36 },
  { 7130, 18, 41, 16, -3, -34 },
  { 7223, 19, 7, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC47PT7B_H_
