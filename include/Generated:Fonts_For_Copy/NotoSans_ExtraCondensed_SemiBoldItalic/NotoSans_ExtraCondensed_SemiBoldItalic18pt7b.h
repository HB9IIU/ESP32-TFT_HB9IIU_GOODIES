#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCC, 0x63, 0x18, 0x8C, 0x60, 0x01, 0xCC, 0x00, 0xDF, 0x6D,
  0xB6, 0x90, 0x0D, 0x04, 0x86, 0xC3, 0x47, 0xF8, 0xB0, 0xD8, 0x4A, 0xFE,
  0x36, 0x12, 0x09, 0x0D, 0x80, 0x04, 0x04, 0x1F, 0x36, 0x28, 0x38, 0x38,
  0x1C, 0x1C, 0x16, 0x96, 0xFC, 0xF8, 0x20, 0x20, 0x30, 0x8F, 0x31, 0x64,
  0x6D, 0x89, 0x21, 0x29, 0xAF, 0x57, 0x5B, 0x1A, 0x42, 0x48, 0xCB, 0x11,
  0x66, 0x38, 0x0E, 0x0F, 0x0C, 0x86, 0xC3, 0x60, 0xE0, 0xE2, 0xF6, 0xCF,
  0x67, 0x33, 0x9F, 0xC7, 0x70, 0xFB, 0x68, 0x0C, 0x61, 0x8C, 0x31, 0x86,
  0x18, 0x43, 0x0C, 0x30, 0xC3, 0x04, 0x18, 0x18, 0xC2, 0x10, 0x84, 0x63,
  0x18, 0xCC, 0x63, 0x31, 0x18, 0x30, 0xCF, 0x7F, 0x73, 0x45, 0x80, 0x30,
  0x60, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x36, 0x6C, 0x7F, 0x80, 0xF8,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x10, 0x18, 0x18,
  0x0C, 0x0C, 0x00, 0x0E, 0x3C, 0xC9, 0x96, 0x2C, 0xD9, 0xB3, 0xC7, 0x9B,
  0x33, 0xC7, 0x00, 0x19, 0xDF, 0xEB, 0x18, 0xC6, 0x63, 0x18, 0xCC, 0x00,
  0x0F, 0x0F, 0x84, 0xE0, 0x60, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C,
  0x0F, 0xCF, 0xE0, 0x1E, 0x3F, 0x23, 0x03, 0x06, 0x0C, 0x38, 0x0C, 0x0E,
  0x0C, 0x0C, 0xFC, 0xF8, 0x07, 0x06, 0x0E, 0x1E, 0x16, 0x36, 0x2C, 0x4C,
  0xCC, 0xFE, 0x08, 0x18, 0x18, 0x1F, 0x3E, 0x30, 0x30, 0x20, 0x7C, 0x7C,
  0x0E, 0x06, 0x0C, 0x0C, 0xFC, 0xF8, 0x0F, 0x1F, 0x18, 0x30, 0x60, 0x7C,
  0x7E, 0x66, 0xE6, 0xC6, 0xCC, 0x7C, 0x78, 0x3F, 0x3F, 0x03, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x1E, 0x3F, 0x33, 0x33,
  0x36, 0x3C, 0x38, 0x6C, 0xC6, 0xC6, 0xC4, 0xFC, 0x78, 0x1E, 0x7C, 0xDB,
  0x16, 0x6C, 0xDB, 0xBF, 0x06, 0x18, 0x37, 0xCF, 0x00, 0x33, 0x20, 0x00,
  0x00, 0xCC, 0x18, 0xC4, 0x00, 0x00, 0x00, 0x73, 0x19, 0x80, 0x02, 0x0C,
  0x73, 0x8C, 0x1E, 0x0F, 0x07, 0x02, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81,
  0x83, 0xC1, 0xE0, 0xE3, 0x9C, 0x60, 0x80, 0x7C, 0x78, 0x18, 0x60, 0xC3,
  0x0C, 0x10, 0x60, 0x00, 0x03, 0x0C, 0x00, 0x07, 0x81, 0x88, 0x41, 0x99,
  0x92, 0x7A, 0xD2, 0x52, 0x4A, 0xDB, 0x5B, 0x5B, 0x7B, 0x36, 0x20, 0x06,
  0x00, 0x7C, 0x00, 0x07, 0x07, 0x0F, 0x0F, 0x1B, 0x1B, 0x1B, 0x33, 0x3F,
  0x63, 0x63, 0xE3, 0xC3, 0x1E, 0x3F, 0x33, 0x33, 0x33, 0x36, 0x7C, 0x66,
  0x66, 0x66, 0xC6, 0xFC, 0xF8, 0x1F, 0x3E, 0x70, 0x60, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xF8, 0x78, 0x1E, 0x1F, 0x8C, 0xE6, 0x33, 0x19,
  0x8D, 0x8E, 0xC6, 0x63, 0x33, 0xB9, 0x9F, 0x8F, 0x80, 0x1F, 0x3F, 0x30,
  0x30, 0x30, 0x3C, 0x7C, 0x60, 0x60, 0x60, 0xE0, 0xF8, 0xF8, 0x1F, 0x3F,
  0x30, 0x30, 0x30, 0x30, 0x7C, 0x7C, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x0F,
  0x9F, 0x9C, 0x4C, 0x0E, 0x06, 0x03, 0x3D, 0x9C, 0xC6, 0x63, 0x31, 0x9F,
  0xC7, 0xC0, 0x18, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xE7, 0xF1, 0x8C,
  0x63, 0x18, 0xCE, 0x33, 0x18, 0xC6, 0x00, 0x1F, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x38, 0x70,
  0xE0, 0x19, 0xCC, 0xE3, 0x30, 0xD8, 0x3E, 0x0B, 0x07, 0xC1, 0xF0, 0x6C,
  0x1B, 0x04, 0xC3, 0x38, 0xC6, 0x00, 0x19, 0x8C, 0x63, 0x19, 0x8C, 0x63,
  0x31, 0xFF, 0x80, 0x18, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0x8F, 0x14,
  0x59, 0xB7, 0x8D, 0xAC, 0x6F, 0x63, 0x73, 0x13, 0x99, 0x9D, 0x8C, 0xCC,
  0x00, 0x18, 0xCE, 0x33, 0x8C, 0xE3, 0x3C, 0x8B, 0x66, 0xD9, 0xB6, 0x65,
  0x99, 0xC4, 0x73, 0x1C, 0xC7, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x1E, 0x3F, 0x33, 0x33, 0x33,
  0x33, 0x7E, 0x7C, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x1E, 0x3F, 0x73, 0x63,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xCE, 0xFC, 0x78, 0x18, 0x18, 0x1C,
  0x1E, 0x3F, 0x33, 0x33, 0x33, 0x37, 0x7E, 0x7C, 0x6C, 0x6C, 0x4C, 0xCE,
  0xC6, 0x1F, 0x3F, 0x32, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0C, 0x0C, 0x8C,
  0xFC, 0xF8, 0x7F, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x83,
  0x0C, 0x00, 0x33, 0xB1, 0x98, 0xCC, 0x66, 0x37, 0x33, 0x19, 0x8C, 0xC6,
  0x63, 0x33, 0x1F, 0x8F, 0x80, 0xC7, 0x8F, 0x36, 0x6C, 0xDB, 0x36, 0x58,
  0xB1, 0x43, 0x87, 0x0C, 0x00, 0x43, 0x1A, 0x31, 0x91, 0x8C, 0x8C, 0x4C,
  0xE6, 0x65, 0x33, 0x6B, 0x1B, 0x58, 0xD2, 0xC7, 0x9C, 0x38, 0xE1, 0xC6,
  0x0E, 0x70, 0x00, 0x19, 0xC6, 0x61, 0xB0, 0x6C, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x0D, 0x86, 0x61, 0x98, 0xC6, 0x00, 0x63, 0x66, 0x64, 0x6C,
  0x68, 0x78, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0x1F, 0x8F, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0F, 0xCF, 0xC0,
  0x0E, 0x3C, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C,
  0x1C, 0x78, 0xDB, 0x6D, 0x92, 0x6D, 0xB6, 0x1E, 0x38, 0x30, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x3C, 0x70, 0x0C, 0x0C, 0x1C,
  0x16, 0x36, 0x66, 0x42, 0xC3, 0xFC, 0xD9, 0x80, 0x1B, 0x3F, 0x77, 0x66,
  0x66, 0x66, 0xC6, 0xCE, 0xFC, 0x7C, 0x18, 0x10, 0x30, 0x30, 0x3E, 0x3E,
  0x73, 0x63, 0x63, 0x66, 0x66, 0xE6, 0xEC, 0xF8, 0x1E, 0x79, 0xC3, 0x06,
  0x0C, 0x30, 0x60, 0x78, 0xF0, 0x01, 0x80, 0xC0, 0x40, 0x61, 0xB1, 0xF9,
  0xDC, 0xCC, 0x66, 0x33, 0x31, 0x99, 0xCF, 0xC3, 0xA0, 0x1C, 0x7D, 0x9B,
  0x37, 0xCE, 0x30, 0x60, 0x64, 0xF8, 0x03, 0x83, 0x81, 0x81, 0x80, 0xE0,
  0xF0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0xE0, 0x70, 0x00, 0x1F, 0x3F, 0x77, 0x66, 0x66, 0x66, 0xC6, 0xCE, 0xFC,
  0x7C, 0x0C, 0x0C, 0x98, 0xF0, 0x18, 0x20, 0xC1, 0x83, 0xE7, 0xCD, 0xB3,
  0x66, 0xCD, 0x9E, 0x2C, 0xD9, 0x80, 0x11, 0xC4, 0x03, 0x18, 0x8C, 0x63,
  0x19, 0x8C, 0x60, 0x04, 0x1C, 0x10, 0x00, 0xC1, 0x82, 0x0C, 0x18, 0x30,
  0x61, 0x83, 0x06, 0x0C, 0x18, 0xE1, 0xC0, 0x18, 0x10, 0x30, 0x30, 0x33,
  0x36, 0x2C, 0x6C, 0x78, 0x78, 0x68, 0xCC, 0xCC, 0xCC, 0x18, 0xCC, 0x63,
  0x18, 0x8C, 0x63, 0x19, 0x8C, 0x60, 0x3E, 0xE7, 0xFC, 0xDD, 0xB3, 0x36,
  0x66, 0xCC, 0xD9, 0x96, 0x66, 0xCC, 0xD9, 0x98, 0x2E, 0x7C, 0xDB, 0x36,
  0x6C, 0xD9, 0xE2, 0xCD, 0x98, 0x1C, 0x7D, 0x9B, 0x36, 0x68, 0xF1, 0xE7,
  0x7C, 0xF0, 0x1F, 0x0B, 0x86, 0x66, 0x33, 0x19, 0x98, 0xCC, 0xE6, 0x7E,
  0x3E, 0x18, 0x0C, 0x0C, 0x06, 0x00, 0x1F, 0x3F, 0x77, 0x66, 0x66, 0x46,
  0xC6, 0xCE, 0xFC, 0x7C, 0x0C, 0x0C, 0x08, 0x18, 0x3C, 0xB3, 0x18, 0x61,
  0x86, 0x30, 0xC3, 0x00, 0x3D, 0xF6, 0x18, 0x70, 0xE1, 0x86, 0xFB, 0xC0,
  0x22, 0x7F, 0x6C, 0xCC, 0xC8, 0xEE, 0x33, 0x33, 0x62, 0x66, 0x66, 0x66,
  0x66, 0xCC, 0xFC, 0x7C, 0xC7, 0x9B, 0x36, 0xCD, 0x9A, 0x3C, 0x70, 0xE1,
  0xC0, 0xCC, 0xF3, 0x3D, 0xCF, 0x56, 0xD5, 0xBD, 0x4E, 0x73, 0xBC, 0xEE,
  0x33, 0x80, 0x33, 0x8D, 0x87, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x6C,
  0x63, 0x00, 0x18, 0xC6, 0x61, 0x98, 0x6C, 0x1B, 0x06, 0x81, 0xE0, 0x78,
  0x1C, 0x03, 0x01, 0x80, 0x60, 0xB0, 0x3C, 0x00, 0x1E, 0x7C, 0x30, 0x61,
  0x83, 0x0C, 0x30, 0x7D, 0xF0, 0x06, 0x1C, 0x60, 0xC1, 0x83, 0x0C, 0x38,
  0xE0, 0x60, 0xC3, 0x06, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x18, 0x38, 0x30, 0x60, 0xC3, 0x06, 0x07, 0x1C, 0x30, 0xC1, 0x83, 0x06,
  0x38, 0x60, 0x63, 0xFE, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 13, 4, 0, -13 },
  { 10, 6, 5, 7, 2, -13 },
  { 14, 9, 13, 8, 0, -13 },
  { 29, 8, 15, 7, 0, -14 },
  { 44, 11, 13, 12, 1, -13 },
  { 62, 9, 13, 9, 0, -13 },
  { 77, 3, 5, 4, 2, -13 },
  { 79, 6, 16, 5, 0, -13 },
  { 91, 5, 16, 5, -1, -13 },
  { 101, 6, 7, 7, 2, -14 },
  { 107, 7, 9, 8, 1, -11 },
  { 115, 4, 4, 4, -1, -2 },
  { 117, 5, 2, 5, 0, -6 },
  { 119, 3, 2, 4, 0, -2 },
  { 120, 9, 13, 6, -1, -13 },
  { 135, 7, 13, 7, 0, -13 },
  { 147, 5, 13, 8, 2, -13 },
  { 156, 9, 13, 7, -1, -13 },
  { 171, 8, 13, 7, 0, -13 },
  { 184, 8, 13, 8, 0, -13 },
  { 197, 8, 13, 7, 0, -13 },
  { 210, 8, 13, 7, 0, -13 },
  { 223, 8, 13, 7, 0, -13 },
  { 236, 8, 13, 7, 0, -13 },
  { 249, 7, 13, 7, 0, -13 },
  { 261, 4, 10, 4, 0, -10 },
  { 266, 5, 12, 4, -1, -10 },
  { 274, 7, 9, 8, 1, -11 },
  { 282, 7, 5, 8, 1, -9 },
  { 287, 7, 9, 8, 1, -11 },
  { 295, 7, 13, 6, 0, -13 },
  { 307, 11, 14, 11, 0, -13 },
  { 327, 8, 13, 8, -1, -13 },
  { 340, 8, 13, 8, 0, -13 },
  { 353, 8, 13, 8, 1, -13 },
  { 366, 9, 13, 9, 0, -13 },
  { 381, 8, 13, 7, 0, -13 },
  { 394, 8, 13, 7, 0, -13 },
  { 407, 9, 13, 9, 1, -13 },
  { 422, 10, 13, 9, 0, -13 },
  { 439, 8, 13, 5, -1, -13 },
  { 452, 8, 17, 4, -3, -13 },
  { 469, 10, 13, 8, 0, -13 },
  { 486, 5, 13, 7, 0, -13 },
  { 495, 13, 13, 12, 0, -13 },
  { 517, 10, 13, 10, 0, -13 },
  { 534, 8, 13, 9, 1, -13 },
  { 547, 8, 13, 8, 0, -13 },
  { 560, 8, 16, 9, 1, -13 },
  { 576, 8, 13, 8, 0, -13 },
  { 589, 8, 13, 7, 0, -13 },
  { 602, 7, 13, 7, 1, -13 },
  { 614, 9, 13, 9, 1, -13 },
  { 629, 7, 13, 8, 2, -13 },
  { 641, 13, 13, 12, 1, -13 },
  { 663, 10, 13, 7, -1, -13 },
  { 680, 8, 13, 7, 1, -13 },
  { 693, 9, 13, 7, -1, -13 },
  { 708, 7, 16, 5, -1, -13 },
  { 722, 3, 13, 7, 2, -13 },
  { 727, 7, 16, 5, -1, -13 },
  { 741, 8, 8, 8, 0, -13 },
  { 749, 6, 1, 6, -2, 2 },
  { 750, 3, 3, 5, 3, -14 },
  { 752, 8, 10, 8, 0, -10 },
  { 762, 8, 14, 8, 0, -14 },
  { 776, 7, 10, 6, 0, -10 },
  { 785, 9, 14, 8, 0, -14 },
  { 801, 7, 10, 7, 0, -10 },
  { 810, 9, 18, 5, -2, -14 },
  { 831, 8, 14, 8, 0, -10 },
  { 845, 7, 14, 8, 0, -14 },
  { 858, 5, 14, 4, 0, -14 },
  { 867, 7, 18, 4, -2, -14 },
  { 883, 8, 14, 7, 0, -14 },
  { 897, 5, 14, 4, 0, -14 },
  { 906, 11, 10, 12, 0, -10 },
  { 920, 7, 10, 8, 0, -10 },
  { 929, 7, 10, 8, 0, -10 },
  { 938, 9, 14, 8, -1, -10 },
  { 954, 8, 14, 8, 0, -10 },
  { 968, 6, 10, 5, 0, -10 },
  { 976, 6, 10, 6, 0, -10 },
  { 984, 4, 12, 5, 1, -12 },
  { 990, 8, 10, 8, 0, -10 },
  { 1000, 7, 10, 7, 1, -10 },
  { 1009, 10, 10, 11, 1, -10 },
  { 1022, 9, 10, 7, -1, -10 },
  { 1034, 10, 14, 7, -2, -10 },
  { 1052, 7, 10, 6, -1, -10 },
  { 1061, 7, 16, 6, 0, -13 },
  { 1075, 2, 18, 7, 2, -14 },
  { 1080, 7, 16, 6, -1, -13 },
  { 1094, 7, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC18PT7B_H_
