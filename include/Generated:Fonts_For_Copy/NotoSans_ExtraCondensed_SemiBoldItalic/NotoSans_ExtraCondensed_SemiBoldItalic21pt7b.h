#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x31, 0x80, 0x00, 0x63, 0x8E,
  0x00, 0x6E, 0xDB, 0xB6, 0x6C, 0xC0, 0x06, 0xC3, 0x20, 0xD8, 0x26, 0x3F,
  0xDF, 0xF1, 0xB0, 0x4C, 0x32, 0x3F, 0xEF, 0xF9, 0x90, 0x6C, 0x13, 0x0C,
  0x80, 0x02, 0x01, 0x07, 0xE7, 0xF3, 0x51, 0xA0, 0xD0, 0x78, 0x1E, 0x07,
  0x83, 0xC1, 0x69, 0x77, 0xF3, 0xF0, 0x20, 0x30, 0x00, 0x38, 0x66, 0xC4,
  0x6C, 0xC4, 0xD8, 0xCD, 0x8C, 0xB0, 0xDB, 0x7D, 0x6D, 0x76, 0x90, 0xD9,
  0x09, 0xB1, 0x93, 0x11, 0x33, 0x1E, 0x61, 0xC0, 0x0F, 0x07, 0xC1, 0xB8,
  0x6C, 0x1B, 0x07, 0x81, 0xC0, 0xF3, 0x7D, 0xDB, 0xEC, 0x7B, 0x1C, 0xC7,
  0x3F, 0xC7, 0xB8, 0x6D, 0xEC, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x0C, 0x30,
  0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x70, 0x60, 0xC0, 0x0E, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x31,
  0xC0, 0x18, 0x33, 0x4F, 0xF3, 0x8F, 0x33, 0x24, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x33, 0x66, 0xEC, 0x7F, 0xC0, 0x7F,
  0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0F, 0x0F, 0x86, 0xE6,
  0x33, 0x3B, 0x9D, 0x8E, 0xC6, 0x63, 0x31, 0xB9, 0xDC, 0xCE, 0xE3, 0xE1,
  0xE0, 0x0C, 0x77, 0xFF, 0x58, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x71, 0x86,
  0x00, 0x0F, 0x87, 0xF1, 0x9C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xE0, 0x70, 0x1F, 0xCF, 0xF0, 0x1F, 0x1F, 0xC4, 0xE0,
  0x30, 0x38, 0x18, 0x78, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0xC8, 0xE7, 0xE3,
  0xE0, 0x03, 0x81, 0xC1, 0xC1, 0xE0, 0xB0, 0xD8, 0xDC, 0x4C, 0x66, 0x63,
  0x3F, 0xDF, 0xE0, 0xC0, 0x60, 0x30, 0x1F, 0x8F, 0xC6, 0x06, 0x03, 0x01,
  0x80, 0xF8, 0xFE, 0x07, 0x03, 0x81, 0xC0, 0xC8, 0xE7, 0xE3, 0xE0, 0x07,
  0x87, 0xC7, 0x03, 0x03, 0x01, 0xB1, 0xBC, 0xEE, 0x63, 0x31, 0x98, 0xDC,
  0xE6, 0x63, 0xF0, 0xF0, 0x7F, 0xBF, 0x80, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x00, 0x0F, 0x0F, 0xCC,
  0x66, 0x33, 0x39, 0xD8, 0x78, 0x78, 0x76, 0x33, 0xB1, 0xD8, 0xEC, 0x67,
  0xF1, 0xF0, 0x0F, 0x0F, 0x8C, 0xE6, 0x77, 0x3B, 0x1D, 0x8C, 0xEE, 0x3F,
  0x0B, 0x81, 0x80, 0xC0, 0xC7, 0xE3, 0xE0, 0x11, 0xCE, 0x20, 0x00, 0x00,
  0x03, 0x39, 0x80, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x18,
  0x63, 0x0C, 0x00, 0x03, 0x0F, 0x3E, 0xF8, 0xC0, 0x78, 0x3E, 0x0F, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x1E,
  0x78, 0xF0, 0xC0, 0x3E, 0x3E, 0x27, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x30, 0x40, 0x00, 0x60, 0x60, 0xE0, 0x03, 0xE0, 0x71, 0x82, 0x06, 0x30,
  0x33, 0x3D, 0x93, 0x6D, 0x93, 0x6D, 0x93, 0x4D, 0x92, 0x4C, 0x92, 0x6D,
  0x9D, 0xC4, 0x4C, 0x20, 0x01, 0x80, 0x07, 0xE0, 0x0E, 0x00, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x66, 0x33, 0x39, 0x9F, 0xCF, 0xEE, 0x36,
  0x1F, 0x0F, 0x06, 0x1F, 0x07, 0xE1, 0x9C, 0xE7, 0x31, 0xCC, 0x63, 0xF0,
  0xFC, 0x73, 0x18, 0xE6, 0x39, 0x8C, 0xE7, 0x3F, 0x8F, 0xC0, 0x0F, 0x8F,
  0xCE, 0x2E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0E,
  0x27, 0xE1, 0xF0, 0x1F, 0x07, 0xE1, 0x9C, 0xE3, 0x38, 0xCC, 0x33, 0x0C,
  0xC7, 0x71, 0xD8, 0x66, 0x39, 0x8E, 0xE7, 0x3F, 0x8F, 0x80, 0x1F, 0x8F,
  0xC6, 0x07, 0x03, 0x81, 0x80, 0xFC, 0x7C, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x7C,
  0x7E, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x00, 0x0F, 0xC7, 0xF3, 0x85,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x9E, 0xC7, 0xB0, 0xEC, 0x33, 0x0C, 0xE3,
  0x3F, 0xC7, 0xE0, 0x1C, 0x63, 0x0C, 0x63, 0x9C, 0x73, 0x8C, 0x61, 0x8F,
  0xF1, 0xFE, 0x71, 0xCC, 0x31, 0x86, 0x30, 0xCE, 0x39, 0xC7, 0x30, 0xC0,
  0x1F, 0x87, 0x83, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x03, 0xC3, 0xF0, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30,
  0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x78, 0x3C, 0x00, 0x18, 0xE3, 0x18, 0x66, 0x1D, 0xC3, 0x30, 0x6C, 0x0F,
  0x81, 0xE0, 0x7E, 0x0C, 0xC1, 0x98, 0x33, 0x06, 0x71, 0xCE, 0x31, 0xC0,
  0x18, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0xFF, 0xC0,
  0x1C, 0x1E, 0x38, 0x3C, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F,
  0x1E, 0x1A, 0x6C, 0x64, 0xD8, 0xCF, 0x31, 0x9E, 0xE3, 0x39, 0x86, 0x73,
  0x18, 0xE6, 0x31, 0x9C, 0x00, 0x1C, 0x31, 0xC3, 0x1C, 0x63, 0xC6, 0x34,
  0x63, 0x66, 0x36, 0xE3, 0x6C, 0x66, 0xC6, 0x6C, 0x63, 0xC6, 0x3C, 0x63,
  0x8C, 0x38, 0xC3, 0x80, 0x0F, 0x87, 0xE3, 0x9D, 0xC7, 0x61, 0xD8, 0x7E,
  0x1F, 0x87, 0xC1, 0xB0, 0x6C, 0x3B, 0x0C, 0xE7, 0x3F, 0x87, 0xC0, 0x1F,
  0x07, 0xE1, 0x9C, 0xE7, 0x39, 0xCC, 0x73, 0x18, 0xFE, 0x7F, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x0F, 0x87, 0xE3, 0x9D, 0xC7, 0x61,
  0xD8, 0x7E, 0x1F, 0x87, 0xC1, 0xB0, 0x6C, 0x3B, 0x0C, 0xE7, 0x3F, 0x87,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x07, 0xE1, 0x98, 0xE7, 0x31,
  0x8C, 0x63, 0x38, 0xFC, 0x7E, 0x1B, 0x86, 0x61, 0x98, 0x66, 0x39, 0xCC,
  0x70, 0x0F, 0x8F, 0xCE, 0x26, 0x03, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03,
  0x01, 0x80, 0xC8, 0xE7, 0xE3, 0xE0, 0x7F, 0xBF, 0x86, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x80, 0x30,
  0xCC, 0x73, 0x1D, 0xC6, 0x61, 0x98, 0x66, 0x3B, 0x8E, 0xE3, 0x30, 0xCC,
  0x33, 0x1C, 0xC6, 0x3F, 0x87, 0xC0, 0xC3, 0xE1, 0xB0, 0xD8, 0xEC, 0x66,
  0x73, 0x31, 0x98, 0xD8, 0x6C, 0x3E, 0x1E, 0x0F, 0x07, 0x03, 0x80, 0x61,
  0x86, 0xC7, 0x19, 0x8E, 0x33, 0x1C, 0xE6, 0x79, 0x8C, 0xF3, 0x1B, 0x6E,
  0x36, 0xD8, 0x6D, 0xB0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x1E,
  0x38, 0x38, 0x60, 0x00, 0x1C, 0xE3, 0x98, 0x37, 0x06, 0xC0, 0xF8, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xF8, 0x1B, 0x87, 0x30, 0xC6, 0x30,
  0xC0, 0xC3, 0xC6, 0xC6, 0xCC, 0xEC, 0xF8, 0x78, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xE0, 0xC0, 0xC0, 0x1F, 0xC7, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x3F, 0x8F, 0xE0, 0x0F,
  0x0F, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x60, 0x60, 0x60, 0x60, 0xF8, 0xCC, 0xC6, 0x66, 0x66, 0x66, 0x63, 0x33,
  0x30, 0x1F, 0x1E, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0xF0, 0x06, 0x07, 0x03, 0x83, 0x61,
  0xB1, 0x99, 0x8C, 0xC3, 0xC1, 0x80, 0xFE, 0xE6, 0x70, 0x0C, 0x0F, 0xCE,
  0xE6, 0x77, 0x3B, 0x19, 0x8C, 0xC6, 0xE7, 0x73, 0x9F, 0x8E, 0xC0, 0x1C,
  0x0C, 0x06, 0x03, 0x03, 0xA1, 0xB8, 0xEE, 0x63, 0x71, 0xB1, 0xD8, 0xEC,
  0x66, 0x37, 0x3B, 0xF9, 0xB8, 0x06, 0x1F, 0x3A, 0x30, 0x70, 0x60, 0x60,
  0x60, 0xE0, 0x64, 0x7C, 0x7C, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x0D, 0x87,
  0xE3, 0xB8, 0xCE, 0x73, 0x98, 0xC6, 0x31, 0x8C, 0xE7, 0x39, 0xC7, 0xE1,
  0xF8, 0x04, 0x1F, 0x3B, 0x33, 0x63, 0x7E, 0x7C, 0x60, 0xE0, 0x60, 0x7E,
  0x3C, 0x03, 0xC1, 0xE0, 0x60, 0x18, 0x06, 0x07, 0xC1, 0xF0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07,
  0x03, 0x80, 0xE0, 0x00, 0x06, 0x03, 0xF1, 0xDC, 0x67, 0x39, 0xCC, 0x63,
  0x18, 0xC6, 0x73, 0x9C, 0xE3, 0xF0, 0xEC, 0x03, 0x01, 0xC8, 0x63, 0xF8,
  0x7C, 0x00, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0xA1, 0xF8, 0xEE, 0x67, 0x73,
  0xB9, 0x98, 0xCC, 0x66, 0x77, 0x33, 0x19, 0x8C, 0x18, 0xC6, 0x00, 0x98,
  0xC6, 0x73, 0x98, 0xC6, 0x73, 0x18, 0x03, 0x03, 0x03, 0x00, 0x01, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x38, 0xF0, 0xE0, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x9C, 0xCC, 0x6C,
  0x3E, 0x3E, 0x1F, 0x0F, 0x86, 0xE7, 0x73, 0x19, 0x8C, 0x1C, 0x61, 0x86,
  0x38, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x30, 0x02, 0x31, 0xFB,
  0xCE, 0xFE, 0x67, 0x37, 0x31, 0xB1, 0x9D, 0x8C, 0xCC, 0x66, 0x66, 0x37,
  0x31, 0xB1, 0x9D, 0x8C, 0xC0, 0x02, 0x1B, 0x8E, 0xE6, 0x73, 0x3B, 0x99,
  0x8C, 0xC6, 0x67, 0x73, 0x31, 0x98, 0xC0, 0x04, 0x0F, 0x8E, 0xC6, 0x76,
  0x3B, 0x1D, 0x8C, 0xC6, 0xE7, 0x33, 0x1F, 0x87, 0x80, 0x01, 0x06, 0xE1,
  0xDC, 0x63, 0x18, 0xCC, 0x33, 0x1C, 0xC6, 0x31, 0x9C, 0xE7, 0xF1, 0xB8,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x0C, 0x0F, 0xCE, 0xE6, 0x76,
  0x3B, 0x19, 0x8C, 0xC6, 0xE7, 0x73, 0x9F, 0x8E, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x0C, 0x00, 0x02, 0x6C, 0xF9, 0xC7, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x86, 0x00, 0x0C, 0x3F, 0x72, 0x60, 0x70, 0x38, 0x3C, 0x1C, 0x0C, 0x8C,
  0xFC, 0xF8, 0x31, 0x8D, 0xF6, 0x31, 0x9C, 0xC6, 0x31, 0x8E, 0x70, 0x31,
  0x98, 0xCC, 0xEE, 0x66, 0x33, 0x19, 0x8C, 0xCE, 0xE6, 0x3F, 0x1D, 0x80,
  0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0xF0, 0xF0, 0xF0, 0x60, 0xC7,
  0x3C, 0xE7, 0xCE, 0x6C, 0xA6, 0xDA, 0xCD, 0xAC, 0xF6, 0xCF, 0x78, 0xE7,
  0x8E, 0x70, 0xE7, 0x00, 0x19, 0xC6, 0xE1, 0xB0, 0x78, 0x0E, 0x07, 0x01,
  0xE0, 0xD8, 0x36, 0x19, 0x8E, 0x70, 0x1C, 0xE3, 0x98, 0x73, 0x0E, 0xC0,
  0xD8, 0x1E, 0x03, 0xC0, 0x58, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x3C, 0x07, 0x00, 0x1F, 0x27, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30,
  0x70, 0x7C, 0xFC, 0x07, 0x0F, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x70,
  0xE0, 0x30, 0x30, 0x30, 0x30, 0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1C, 0x1E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0F,
  0x0E, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x30, 0xF0, 0xE0, 0xF1, 0xFF, 0x8F,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 7, 5, 8, 2, -15 },
  { 18, 10, 15, 10, 0, -15 },
  { 37, 9, 17, 9, 0, -16 },
  { 57, 12, 15, 14, 1, -15 },
  { 80, 10, 15, 10, 0, -15 },
  { 99, 3, 5, 5, 2, -15 },
  { 101, 7, 18, 6, 0, -15 },
  { 117, 7, 18, 6, -2, -15 },
  { 133, 7, 8, 8, 2, -16 },
  { 140, 8, 10, 9, 1, -12 },
  { 150, 4, 6, 5, -1, -3 },
  { 153, 5, 2, 6, 0, -7 },
  { 155, 3, 3, 5, 0, -3 },
  { 157, 10, 15, 8, -1, -15 },
  { 176, 9, 15, 9, 0, -15 },
  { 193, 6, 15, 9, 2, -15 },
  { 205, 10, 15, 9, -1, -15 },
  { 224, 9, 15, 9, 0, -15 },
  { 241, 9, 15, 9, 0, -15 },
  { 258, 9, 15, 9, 0, -15 },
  { 275, 9, 15, 9, 0, -15 },
  { 292, 9, 15, 9, 1, -15 },
  { 309, 9, 15, 9, 0, -15 },
  { 326, 9, 15, 9, 0, -15 },
  { 343, 5, 12, 5, 0, -12 },
  { 351, 6, 15, 5, -1, -12 },
  { 363, 8, 9, 9, 1, -12 },
  { 372, 8, 6, 9, 1, -10 },
  { 378, 8, 9, 9, 1, -12 },
  { 387, 8, 15, 7, 0, -15 },
  { 402, 13, 17, 13, 0, -15 },
  { 430, 9, 15, 9, -1, -15 },
  { 447, 10, 15, 10, 0, -15 },
  { 466, 9, 15, 9, 1, -15 },
  { 483, 10, 15, 10, 0, -15 },
  { 502, 9, 15, 8, 0, -15 },
  { 519, 9, 15, 8, 0, -15 },
  { 536, 10, 15, 11, 1, -15 },
  { 555, 11, 15, 11, 0, -15 },
  { 576, 9, 15, 6, -1, -15 },
  { 593, 9, 19, 5, -3, -15 },
  { 615, 11, 15, 9, 0, -15 },
  { 636, 6, 15, 8, 0, -15 },
  { 648, 15, 15, 14, 0, -15 },
  { 677, 12, 15, 11, 0, -15 },
  { 700, 10, 15, 11, 1, -15 },
  { 719, 10, 15, 9, 0, -15 },
  { 738, 10, 19, 11, 1, -15 },
  { 762, 10, 15, 9, 0, -15 },
  { 781, 9, 15, 8, 0, -15 },
  { 798, 9, 15, 8, 1, -15 },
  { 815, 10, 15, 10, 1, -15 },
  { 834, 9, 15, 9, 2, -15 },
  { 851, 15, 15, 14, 1, -15 },
  { 880, 11, 15, 9, -1, -15 },
  { 901, 8, 15, 8, 2, -15 },
  { 916, 10, 15, 8, -1, -15 },
  { 935, 8, 18, 6, -1, -15 },
  { 953, 4, 15, 8, 2, -15 },
  { 961, 8, 18, 6, -1, -15 },
  { 979, 9, 9, 9, 0, -15 },
  { 990, 7, 1, 7, -2, 2 },
  { 991, 4, 3, 6, 3, -16 },
  { 993, 9, 12, 9, 0, -12 },
  { 1007, 9, 16, 9, 0, -16 },
  { 1025, 8, 12, 7, 0, -12 },
  { 1037, 10, 16, 9, 0, -16 },
  { 1057, 8, 12, 9, 0, -12 },
  { 1069, 10, 21, 5, -2, -16 },
  { 1096, 10, 17, 9, -1, -12 },
  { 1118, 9, 16, 9, 0, -16 },
  { 1136, 5, 16, 5, 0, -16 },
  { 1146, 8, 21, 5, -3, -16 },
  { 1167, 9, 16, 8, 0, -16 },
  { 1185, 6, 16, 4, 0, -16 },
  { 1197, 13, 12, 14, 0, -12 },
  { 1217, 9, 12, 9, 0, -12 },
  { 1231, 9, 12, 9, 0, -12 },
  { 1245, 10, 17, 9, -1, -12 },
  { 1267, 9, 17, 9, 0, -12 },
  { 1287, 7, 12, 6, 0, -12 },
  { 1298, 8, 12, 7, 0, -12 },
  { 1310, 5, 14, 6, 1, -14 },
  { 1319, 9, 11, 9, 0, -11 },
  { 1332, 8, 11, 8, 1, -11 },
  { 1343, 12, 11, 12, 1, -11 },
  { 1360, 10, 11, 8, -1, -11 },
  { 1374, 11, 16, 8, -2, -11 },
  { 1396, 8, 11, 7, -1, -11 },
  { 1407, 8, 18, 7, 0, -15 },
  { 1425, 2, 21, 8, 3, -16 },
  { 1431, 8, 18, 7, -1, -15 },
  { 1449, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC21PT7B_H_
