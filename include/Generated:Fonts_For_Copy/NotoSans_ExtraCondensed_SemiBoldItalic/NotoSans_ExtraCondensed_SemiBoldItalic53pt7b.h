#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80,
  0x0C, 0x00, 0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xE3,
  0xE1, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1E, 0x0F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x1F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x03, 0xC3,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x01,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x80, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1,
  0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xEC, 0xF0, 0x1F, 0x98, 0x60, 0x3E, 0x30, 0x00,
  0x7C, 0x60, 0x00, 0xF9, 0xC0, 0x01, 0xF3, 0x00, 0x03, 0xF6, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x6F, 0xC0, 0x00, 0xCF, 0xC0, 0x03, 0x9F, 0x80, 0x06, 0x3E,
  0x08, 0x0C, 0x7C, 0x10, 0x19, 0xF8, 0x38, 0x33, 0xF0, 0x7E, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x07,
  0xC0, 0x3F, 0xE0, 0x0F, 0x00, 0xFF, 0xE0, 0x3E, 0x01, 0xE3, 0xC0, 0x78,
  0x07, 0x87, 0x81, 0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x3E, 0x1E, 0x0F, 0x80,
  0x78, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0xF0, 0x07,
  0xC3, 0xE3, 0xC0, 0x0F, 0x07, 0x8F, 0x80, 0x1E, 0x0F, 0x1E, 0x00, 0x3C,
  0x3E, 0x7C, 0x00, 0x78, 0x78, 0xF0, 0xFC, 0xF0, 0xF3, 0xE3, 0xFD, 0xE3,
  0xE7, 0x8F, 0xFB, 0xC7, 0x9F, 0x3F, 0xFF, 0xFF, 0x3C, 0xF9, 0xFF, 0xFC,
  0xF9, 0xE1, 0xEF, 0xF1, 0xE3, 0xC3, 0xCF, 0xC7, 0xCF, 0x07, 0x80, 0x0F,
  0x1E, 0x1F, 0x00, 0x3C, 0x7C, 0x3E, 0x00, 0x78, 0xF8, 0x78, 0x01, 0xE1,
  0xE0, 0xF0, 0x07, 0xC3, 0xC1, 0xE0, 0x0F, 0x07, 0x87, 0xC0, 0x3E, 0x0F,
  0x0F, 0x80, 0x78, 0x3E, 0x1E, 0x01, 0xF0, 0x7C, 0x3C, 0x03, 0xC0, 0xF8,
  0xF0, 0x0F, 0x80, 0xF3, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF,
  0x00, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x8F,
  0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xF0,
  0xFF, 0xE1, 0xF8, 0xFD, 0xF8, 0xF8, 0xFC, 0xFC, 0xFC, 0x7E, 0x7E, 0x7E,
  0x7E, 0x1F, 0xBE, 0x3E, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0x1F, 0x81, 0xFF,
  0x8F, 0xC0, 0xFF, 0x87, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F,
  0xE0, 0xFC, 0x1F, 0xF0, 0x7F, 0xBF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xBF, 0x03, 0xFF, 0x9F, 0xC0, 0xFF, 0x07, 0xE0, 0x08, 0x00, 0x00, 0x3F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8,
  0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x41, 0xF0, 0x18, 0x7C, 0x07, 0x9E, 0x07, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x81, 0xF9, 0xF0, 0xFE, 0x7C, 0x0F, 0x0F, 0x81, 0x83, 0xE0,
  0x20, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x3E, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0x18,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3E,
  0x01, 0xF9, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x87, 0xE0, 0xFC, 0x7E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFC, 0x7F, 0x7C, 0xFE, 0xFC, 0x7C, 0xFC, 0x38, 0xF8, 0x30,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x7F, 0x00, 0xE0, 0x3F,
  0x00, 0x40, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xE0, 0xFF, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x0F, 0xE0, 0xE0, 0x1F, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0E, 0xFC,
  0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xF8, 0x00, 0x79, 0xF8,
  0x00, 0xF1, 0xF8, 0x00, 0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xE3, 0xF0,
  0x03, 0xC3, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0xE0,
  0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF7, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x79, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x40, 0x0F, 0xE0, 0xC0, 0x3F, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC7, 0xE0,
  0x1F, 0xBF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F,
  0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x1F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0,
  0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x3F, 0x00, 0xFD, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x0F, 0xC1, 0xFE, 0x7F, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x83, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8,
  0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xF7, 0xC0, 0xFF, 0xBF,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x01, 0xE0, 0x3F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0x7C, 0x03, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0x83, 0xF0, 0x80, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0xFE, 0x0F, 0x0F, 0x83,
  0xFF, 0x8F, 0x0F, 0x07, 0xFF, 0x0F, 0x0F, 0x0F, 0xCF, 0x0F, 0x1E, 0x0F,
  0x0F, 0x0F, 0x1E, 0x1E, 0x1F, 0x0F, 0x3C, 0x1E, 0x1E, 0x0E, 0x3C, 0x3C,
  0x1E, 0x1E, 0x3C, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x3E, 0x1E, 0x78, 0x78,
  0x3C, 0x1E, 0x78, 0x78, 0x3C, 0x1C, 0x78, 0x78, 0x3C, 0x3C, 0x78, 0xF8,
  0x7C, 0x3C, 0xF8, 0xF8, 0x78, 0x38, 0xF0, 0xF0, 0xF8, 0x78, 0xF0, 0xF0,
  0xF8, 0x70, 0xF0, 0xF9, 0xF8, 0xF0, 0xF0, 0xFF, 0xBF, 0xE0, 0xF0, 0x7F,
  0xBF, 0xC0, 0xF0, 0x7F, 0x1F, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x10, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9,
  0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F,
  0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0,
  0x1F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC3, 0xF8, 0x07,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x1F, 0x83, 0xF8, 0x0F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x1F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF0,
  0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xF0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFC, 0x1C, 0x07, 0xF8, 0x08,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x83, 0xF8, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01,
  0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0,
  0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xF8, 0x3F, 0xC0, 0x7E, 0x7F, 0xE0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x0F, 0x00, 0xFE, 0x00, 0x40, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xE1, 0xF8, 0x1F, 0xFC,
  0x7F, 0x03, 0xFF, 0x0F, 0xE0, 0x7F, 0xE1, 0xF8, 0x0F, 0xFC, 0x3F, 0x02,
  0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xF8, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1B, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01,
  0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xF0,
  0x1F, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x7C, 0xF8, 0x0F, 0xDF, 0x03,
  0xEF, 0xC0, 0x7E, 0xF8, 0x3E, 0x7E, 0x03, 0xE7, 0xC1, 0xF3, 0xF0, 0x1F,
  0x3E, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0xF9, 0xF8, 0x0F, 0xCF, 0x87, 0xCF,
  0xC0, 0x7E, 0x7C, 0x7C, 0x7E, 0x03, 0xE1, 0xE3, 0xE3, 0xE0, 0x1F, 0x0F,
  0x3E, 0x1F, 0x00, 0xF8, 0x7D, 0xF1, 0xF8, 0x0F, 0xC3, 0xFF, 0x0F, 0xC0,
  0x7E, 0x1F, 0xF8, 0x7E, 0x03, 0xE0, 0xFF, 0xC3, 0xE0, 0x1F, 0x07, 0xFC,
  0x1F, 0x00, 0xF8, 0x3F, 0xE1, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F, 0xC0, 0x7E,
  0x0F, 0xF0, 0x7E, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x1F, 0x03, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xF8, 0x01, 0xF0, 0x1F,
  0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0xF8, 0x07, 0xF8,
  0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0x01,
  0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x3F, 0xF0, 0x1F, 0x00, 0xFF, 0xC0, 0xFC,
  0x07, 0xEF, 0x83, 0xF0, 0x1F, 0x3E, 0x0F, 0x80, 0x7C, 0xF8, 0x3E, 0x01,
  0xF3, 0xE0, 0xF8, 0x0F, 0xCF, 0x87, 0xE0, 0x3F, 0x3E, 0x1F, 0x80, 0xF8,
  0x7C, 0x7C, 0x03, 0xE1, 0xF1, 0xF0, 0x0F, 0x87, 0xC7, 0xC0, 0x7E, 0x1F,
  0x3F, 0x01, 0xF8, 0x7C, 0xFC, 0x07, 0xC1, 0xF3, 0xE0, 0x1F, 0x03, 0xEF,
  0x80, 0x7C, 0x0F, 0xBE, 0x03, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0,
  0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x1F,
  0x80, 0x7F, 0xC0, 0x7E, 0x01, 0xFE, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xC0,
  0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0,
  0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xCF, 0xF8, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE3, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB,
  0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0xFF,
  0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x3E, 0x03, 0xF8, 0x04, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x40, 0x07, 0xE0, 0x60, 0x0F, 0xE0,
  0x78, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x1F,
  0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00,
  0xF9, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3F, 0x80, 0x7E, 0x3E, 0x01, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0xE0,
  0x3F, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xF8, 0x0F, 0x87, 0xE0,
  0x7F, 0xC0, 0xFC, 0x3F, 0x03, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xFC, 0x1F, 0x03, 0xF0, 0xFB,
  0xE1, 0xF8, 0x1F, 0x87, 0xDF, 0x0F, 0xC0, 0xFC, 0x3E, 0xF8, 0xFC, 0x07,
  0xE3, 0xE7, 0xC7, 0xE0, 0x3F, 0x1F, 0x3C, 0x3E, 0x01, 0xF8, 0xF1, 0xE3,
  0xF0, 0x0F, 0xCF, 0x8F, 0x1F, 0x80, 0x7E, 0x7C, 0x78, 0xF8, 0x03, 0xE7,
  0xC3, 0xCF, 0xC0, 0x1F, 0x3E, 0x1E, 0x7C, 0x00, 0xF9, 0xE0, 0xF7, 0xE0,
  0x07, 0xDF, 0x07, 0xBF, 0x00, 0x3E, 0xF8, 0x3D, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFD, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1,
  0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00,
  0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xF8, 0xFC, 0x7E, 0x3F, 0x8F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x80,
  0x00, 0xFC, 0x3E, 0x03, 0xFC, 0xFC, 0x0F, 0xFD, 0xF0, 0x3F, 0xFB, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x03,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x7F, 0xC0,
  0xFF, 0xFF, 0x81, 0xFF, 0xBE, 0x01, 0xFE, 0x7C, 0x01, 0xF8, 0xF8, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x1F, 0x80, 0x3E, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x81, 0xF8, 0x7E, 0x03,
  0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x7F,
  0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xFF,
  0xF8, 0x1F, 0x7F, 0xF0, 0x3E, 0x7F, 0xC0, 0x78, 0x7E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xC1, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x60, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0xF7, 0xE0, 0x1F, 0xFB, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x0F, 0xE3, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07,
  0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00,
  0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x07, 0xF0, 0x1F, 0xCF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xBE, 0x00, 0x3F, 0x1F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC,
  0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x3F, 0x03, 0xF3, 0xF0, 0x3E, 0x3E,
  0x07, 0xE7, 0xE0, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x10, 0x7F, 0x07,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x9F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F,
  0x80, 0x3F, 0xE7, 0xC0, 0x3F, 0xF7, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFE, 0xF8, 0x01, 0xFE, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x10, 0x07,
  0xF0, 0x0F, 0x07, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x03, 0xEF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7D, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x0F,
  0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8,
  0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x00,
  0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x1B, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07,
  0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x0F, 0xBF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xC7, 0xF0, 0x7E, 0x01, 0xE7, 0xFC, 0xFF, 0x81,
  0xF7, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0x8F, 0xF8, 0xFC, 0x1F, 0x83, 0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x07,
  0xC3, 0xF0, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x81,
  0xF8, 0x7C, 0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xE0, 0x7C, 0x3F, 0x03, 0xF0,
  0x3E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x87, 0xC0, 0x7C,
  0x0F, 0xC3, 0xE0, 0x7E, 0x07, 0xC3, 0xF0, 0x3F, 0x03, 0xE1, 0xF8, 0x1F,
  0x03, 0xF0, 0xF8, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC0, 0xF8, 0x7E, 0x07,
  0xE0, 0x7C, 0x3F, 0x03, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x3F, 0x0F, 0x81,
  0xF8, 0x1F, 0x80, 0x03, 0xC3, 0xF0, 0x0F, 0x3F, 0xE0, 0x7D, 0xFF, 0x81,
  0xF7, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xE1, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x3F, 0x00, 0xF9,
  0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC3, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x1E, 0x7F,
  0xC0, 0x0F, 0x9F, 0xF0, 0x03, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0x87, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xF0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7E, 0xFF,
  0x80, 0x1F, 0x9F, 0xC0, 0x07, 0xC0, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x3E, 0x03, 0xFE, 0x7C, 0x0F, 0xFD, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xF8, 0x7F, 0x83, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x01,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xE1,
  0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0x7F, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xBE, 0x01, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x00, 0x83,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xC7, 0xE0, 0x79, 0xF8, 0x1F, 0x7F, 0x03, 0xEF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x83, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x20, 0x1F, 0x84, 0x07, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xCF, 0xFF, 0x7F,
  0xFD, 0xFF, 0xE7, 0xFF, 0x87, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x02, 0x00,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFE, 0xF8, 0x1F, 0xF3, 0xE0, 0x3F, 0x8F, 0x00, 0x10, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF,
  0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x7D, 0xF0, 0x07, 0x9F, 0x00, 0x7B, 0xF0, 0x07, 0xBE,
  0x00, 0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFB, 0xF0, 0x3F, 0x83, 0xF7,
  0xE0, 0xFF, 0x07, 0xCF, 0xC1, 0xFC, 0x0F, 0x9F, 0x87, 0xF8, 0x3F, 0x3F,
  0x0F, 0xF0, 0x7C, 0x7E, 0x1F, 0xE0, 0xF8, 0xF8, 0x7F, 0xC3, 0xE1, 0xF0,
  0xF7, 0x87, 0xC3, 0xE3, 0xEF, 0x1F, 0x87, 0xC7, 0xDE, 0x3E, 0x0F, 0x8F,
  0x3C, 0x7C, 0x1F, 0x3E, 0x79, 0xF0, 0x3E, 0x79, 0xF3, 0xE0, 0x7C, 0xF3,
  0xEF, 0xC0, 0xFB, 0xE7, 0xDF, 0x01, 0xF7, 0x8F, 0xBE, 0x03, 0xFF, 0x1F,
  0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xE0, 0x0F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xE0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x08, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x09, 0xFE, 0x00, 0x5F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0xD0, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 39, 13, 0, -38 },
  { 75, 17, 14, 20, 5, -38 },
  { 105, 26, 38, 24, 0, -38 },
  { 229, 23, 43, 22, 0, -40 },
  { 353, 31, 38, 35, 3, -38 },
  { 501, 25, 39, 26, 0, -38 },
  { 623, 8, 14, 12, 5, -38 },
  { 637, 17, 46, 14, 1, -38 },
  { 735, 17, 46, 14, -4, -38 },
  { 833, 18, 21, 21, 5, -41 },
  { 881, 21, 25, 24, 2, -31 },
  { 947, 11, 14, 12, -3, -7 },
  { 967, 13, 6, 15, 1, -17 },
  { 977, 7, 8, 12, 0, -7 },
  { 984, 26, 38, 19, -3, -38 },
  { 1108, 21, 39, 22, 1, -38 },
  { 1211, 16, 38, 22, 5, -38 },
  { 1287, 24, 38, 22, -2, -38 },
  { 1401, 24, 39, 22, -1, -38 },
  { 1518, 24, 38, 22, -1, -38 },
  { 1632, 23, 39, 22, 0, -38 },
  { 1745, 23, 39, 22, 1, -38 },
  { 1858, 24, 38, 22, 1, -38 },
  { 1972, 23, 39, 22, 0, -38 },
  { 2085, 22, 39, 22, 0, -38 },
  { 2193, 12, 30, 12, 0, -29 },
  { 2238, 15, 36, 12, -3, -29 },
  { 2306, 21, 24, 24, 2, -31 },
  { 2369, 21, 15, 24, 2, -26 },
  { 2409, 21, 24, 24, 2, -31 },
  { 2472, 18, 38, 17, 1, -38 },
  { 2558, 32, 42, 33, 1, -38 },
  { 2726, 23, 38, 24, -3, -38 },
  { 2836, 25, 38, 24, 0, -38 },
  { 2955, 24, 39, 22, 2, -38 },
  { 3072, 26, 38, 26, 0, -38 },
  { 3196, 23, 38, 20, 0, -38 },
  { 3306, 23, 38, 20, 0, -38 },
  { 3416, 27, 39, 27, 2, -38 },
  { 3548, 29, 38, 27, 0, -38 },
  { 3686, 22, 38, 16, -2, -38 },
  { 3791, 22, 49, 12, -8, -38 },
  { 3926, 28, 38, 23, 0, -38 },
  { 4059, 16, 38, 19, 0, -38 },
  { 4135, 37, 38, 36, 0, -38 },
  { 4311, 30, 38, 29, 0, -38 },
  { 4454, 25, 39, 28, 2, -38 },
  { 4576, 25, 38, 23, 0, -38 },
  { 4695, 25, 47, 28, 2, -38 },
  { 4842, 24, 38, 24, 0, -38 },
  { 4956, 24, 39, 21, -1, -38 },
  { 5073, 20, 38, 20, 4, -38 },
  { 5168, 26, 39, 26, 2, -38 },
  { 5295, 23, 38, 23, 5, -38 },
  { 5405, 37, 38, 36, 4, -38 },
  { 5581, 29, 38, 22, -3, -38 },
  { 5719, 22, 38, 21, 4, -38 },
  { 5824, 25, 38, 20, -2, -38 },
  { 5943, 21, 46, 15, -2, -38 },
  { 6064, 10, 38, 19, 5, -38 },
  { 6112, 21, 46, 15, -4, -38 },
  { 6233, 22, 22, 22, 0, -38 },
  { 6294, 18, 3, 17, -5, 5 },
  { 6301, 9, 9, 15, 8, -41 },
  { 6312, 23, 30, 24, 1, -29 },
  { 6399, 23, 41, 23, 0, -40 },
  { 6517, 19, 30, 18, 1, -29 },
  { 6589, 25, 41, 24, 1, -40 },
  { 6718, 20, 30, 22, 1, -29 },
  { 6793, 26, 54, 14, -6, -41 },
  { 6969, 25, 42, 24, -1, -29 },
  { 7101, 22, 40, 23, 0, -40 },
  { 7211, 14, 40, 11, 0, -40 },
  { 7281, 21, 53, 11, -7, -40 },
  { 7421, 24, 40, 21, 0, -40 },
  { 7541, 14, 40, 11, 0, -40 },
  { 7611, 33, 29, 34, 0, -29 },
  { 7731, 22, 29, 23, 0, -29 },
  { 7811, 21, 30, 23, 1, -29 },
  { 7890, 26, 42, 23, -3, -29 },
  { 8027, 23, 42, 24, 1, -29 },
  { 8148, 19, 29, 16, 0, -29 },
  { 8217, 19, 30, 18, 0, -29 },
  { 8289, 14, 36, 14, 2, -35 },
  { 8352, 22, 30, 23, 1, -29 },
  { 8435, 20, 29, 20, 3, -29 },
  { 8508, 31, 29, 31, 3, -29 },
  { 8621, 25, 29, 20, -3, -29 },
  { 8712, 27, 42, 20, -4, -29 },
  { 8854, 21, 29, 17, -2, -29 },
  { 8931, 20, 46, 18, 1, -38 },
  { 9046, 5, 53, 20, 7, -41 },
  { 9080, 20, 46, 18, -3, -38 },
  { 9195, 21, 8, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC53PT7B_H_
