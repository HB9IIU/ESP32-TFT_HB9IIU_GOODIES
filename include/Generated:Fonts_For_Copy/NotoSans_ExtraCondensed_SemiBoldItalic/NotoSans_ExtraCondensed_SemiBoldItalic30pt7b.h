#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x73, 0xDC,
  0xE7, 0x3B, 0x8E, 0xE7, 0x39, 0xCE, 0x70, 0x01, 0x9C, 0x07, 0x38, 0x0C,
  0x60, 0x18, 0xC0, 0x73, 0x87, 0xFF, 0xCF, 0xFF, 0x1F, 0xFE, 0x0E, 0x60,
  0x18, 0xC0, 0x33, 0x80, 0xE6, 0x0F, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0x18,
  0xC0, 0x33, 0x80, 0xE7, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x70, 0x00, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0x76, 0x43, 0xA0,
  0x1D, 0x00, 0xE8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0xDC, 0x04, 0xE4, 0x27, 0x39, 0x79, 0xFF, 0x8F, 0xF8, 0x0E, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x06, 0x00, 0x07, 0xC1, 0xC3, 0xF0, 0x60, 0xCE,
  0x38, 0x33, 0x8C, 0x1C, 0xE7, 0x06, 0x31, 0x81, 0x8C, 0xE0, 0x67, 0x30,
  0x39, 0xD9, 0xE6, 0x6E, 0xFD, 0xFB, 0x33, 0x7D, 0xDC, 0xCE, 0x66, 0x30,
  0x39, 0x8C, 0x0C, 0xE7, 0x07, 0x39, 0xC1, 0x8C, 0x60, 0xE3, 0x38, 0x30,
  0xEE, 0x1C, 0x3F, 0x0E, 0x07, 0x80, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x03,
  0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00,
  0xF0, 0x07, 0xE7, 0x3F, 0x9D, 0xEE, 0xE7, 0x3F, 0xB8, 0x7E, 0xE1, 0xF3,
  0x87, 0x8E, 0x1E, 0x3F, 0xFC, 0xFF, 0xF1, 0xF9, 0xE0, 0x7B, 0x9C, 0xEE,
  0x73, 0x80, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xE0,
  0xE0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x00, 0x0E, 0x03, 0x88, 0xE3, 0xB1,
  0xFF, 0xDF, 0xF1, 0xF8, 0xF8, 0x77, 0x39, 0xC2, 0x38, 0x10, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x1E, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0x70, 0x7F, 0x7F, 0xFE, 0x7F, 0xFF, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0xFC, 0x3F, 0x8F, 0x73, 0xCE, 0x71, 0xCE,
  0x3B, 0x87, 0x70, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xB8, 0x77,
  0x1E, 0xE3, 0x9C, 0x73, 0x9E, 0x7F, 0x8F, 0xE0, 0xF8, 0x00, 0x07, 0x87,
  0x87, 0xC7, 0xEF, 0x77, 0x79, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x00, 0x00, 0xE0,
  0x1F, 0xC0, 0xFF, 0x83, 0x9E, 0x04, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF,
  0x00, 0x01, 0xC0, 0x7F, 0x87, 0xFC, 0x19, 0xF0, 0x87, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0x7C, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x20, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x01, 0xB8, 0x0F,
  0xC0, 0xDC, 0x0E, 0xE0, 0x67, 0x06, 0x38, 0x73, 0x83, 0x1C, 0x38, 0xE3,
  0x87, 0x1F, 0xFE, 0xFF, 0xE7, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xC4, 0x1E, 0x3F, 0xE1, 0xFF, 0x0F, 0xE0, 0x00,
  0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x73, 0x87, 0x7C, 0x7F, 0xCF, 0x9E, 0xF1, 0xEE, 0x1E, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x3C, 0xE3, 0x8F, 0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0x83,
  0xFE, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0x8E, 0x1E, 0xE0, 0x7F,
  0x03, 0xE0, 0x3F, 0x03, 0xFC, 0x3C, 0xF1, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x79, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x01, 0xC0, 0x7E, 0x0F,
  0xF1, 0xE7, 0x1C, 0x73, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x38,
  0xF3, 0xFF, 0x3F, 0xF1, 0xEE, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07,
  0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0x1E, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x1E, 0x3C, 0x70, 0x07, 0x83, 0xC1, 0xE0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xE0, 0xF0,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0,
  0x0C, 0x00, 0x07, 0x1F, 0xE3, 0xFC, 0xCF, 0x01, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x06, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x3C,
  0xF0, 0x1C, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x63, 0x87, 0x9C, 0xC7, 0xE7,
  0x73, 0x99, 0xD8, 0xCE, 0x66, 0x73, 0x9B, 0x98, 0xC6, 0xC6, 0x31, 0xB3,
  0x9C, 0xCC, 0xE7, 0x33, 0x39, 0x9C, 0xCE, 0xFE, 0x31, 0xEF, 0x0C, 0x21,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x08, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x77, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0xFC, 0x7F,
  0xE3, 0xFF, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x1C,
  0x0F, 0xF0, 0x3F, 0xE0, 0xE7, 0xC3, 0x8F, 0x1E, 0x1C, 0x70, 0xF1, 0xC3,
  0xC7, 0x1E, 0x1D, 0xF0, 0xFF, 0x83, 0xFE, 0x0E, 0x3C, 0x38, 0x70, 0xE1,
  0xC7, 0x87, 0x1C, 0x1C, 0x70, 0xF1, 0xC7, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF,
  0x00, 0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0x83, 0xC4, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x04, 0x1F, 0xE0,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE1,
  0xE1, 0xC3, 0xC3, 0xC7, 0x07, 0x8E, 0x0F, 0x1C, 0x1C, 0x78, 0x38, 0xF0,
  0x71, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x1E, 0x1E, 0x38, 0x38, 0x70, 0xF0,
  0xE3, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xFF, 0x0F,
  0xF0, 0x7F, 0x83, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF8,
  0x7C, 0xE1, 0xE0, 0x47, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC3, 0xF7, 0x87, 0xCF, 0x1F, 0x9E, 0x07, 0x3C, 0x1E, 0x78, 0x38,
  0xF0, 0x71, 0xE0, 0xE3, 0xC3, 0xC3, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0x07, 0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E, 0x0E,
  0x1C, 0x1E, 0x1C, 0x1E, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x3C,
  0x38, 0x3C, 0x38, 0x38, 0x78, 0x38, 0x78, 0x78, 0x70, 0x78, 0x70, 0x70,
  0xF0, 0x70, 0xF0, 0x70, 0xE0, 0xF0, 0x0F, 0xF0, 0xFE, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x0F,
  0x0E, 0x1E, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x78, 0x1C, 0xF0, 0x1C, 0xE0,
  0x1D, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x39, 0xC0, 0x79, 0xC0, 0x71, 0xC0, 0x71, 0xE0, 0x71, 0xE0, 0xF1, 0xE0,
  0xF0, 0xE0, 0xE0, 0xE0, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E,
  0x1F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1D, 0xC3, 0xF0,
  0xFE, 0x1F, 0x86, 0xE1, 0xDC, 0x77, 0x0E, 0xE3, 0x38, 0x77, 0x3B, 0xC3,
  0xB9, 0xDC, 0x1C, 0xDC, 0xE1, 0xC6, 0xE7, 0x0E, 0x3E, 0x38, 0x71, 0xF3,
  0xC3, 0x8F, 0x1C, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0x00,
  0x0F, 0x03, 0x87, 0xC1, 0xC3, 0xE1, 0xE1, 0xF0, 0xE1, 0xF8, 0x70, 0xFC,
  0x38, 0x76, 0x1C, 0x3B, 0x9C, 0x1D, 0xCE, 0x1C, 0xE7, 0x0E, 0x73, 0x87,
  0x39, 0xC3, 0x8D, 0xC1, 0xC7, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC,
  0x38, 0x7C, 0x3C, 0x1E, 0x1C, 0x0F, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x0F,
  0xE0, 0xFF, 0xC3, 0xCF, 0x1E, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x78,
  0x1D, 0xC0, 0x77, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC,
  0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x1E, 0x1F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F, 0x1E, 0x1C, 0x78, 0x71, 0xC3,
  0xC7, 0x0F, 0x1C, 0x38, 0xF1, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x0F, 0xE0, 0xFF, 0xC3, 0xCF, 0x1E, 0x1C, 0xF0, 0x73,
  0x81, 0xDE, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x1E, 0x1F, 0xF8,
  0x7F, 0xC0, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xE7, 0x83, 0x8F, 0x1E, 0x3C, 0x70, 0xF1,
  0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xF7, 0xC3, 0xFE, 0x0F, 0xF0, 0x3B, 0xC0,
  0xEF, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x8F, 0x1E, 0x3C, 0x38,
  0xE0, 0xE0, 0x00, 0x60, 0x0F, 0xF0, 0x7F, 0xC3, 0xEE, 0x0F, 0x08, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x84, 0x1E, 0x1F,
  0xF0, 0xFF, 0xC1, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x00, 0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x70, 0xE0, 0xE3, 0xC3, 0xC7, 0x87,
  0x8E, 0x0E, 0x1C, 0x1C, 0x78, 0x38, 0xF0, 0xF1, 0xC1, 0xE3, 0x83, 0x87,
  0x07, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0x78, 0xE0, 0xE1, 0xE3, 0xC3, 0xFF,
  0x03, 0xFC, 0x03, 0xF0, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE,
  0x1E, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x3C, 0x39, 0xC1, 0xDE,
  0x0E, 0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x7B, 0x83, 0x83, 0x9C, 0x3C, 0x1C,
  0xE1, 0xE1, 0xC7, 0x1F, 0x0E, 0x78, 0xF8, 0xF3, 0xC7, 0xC7, 0x1E, 0x7E,
  0x38, 0xF3, 0xF3, 0xC7, 0x3B, 0x9C, 0x39, 0xDD, 0xE1, 0xCC, 0xEE, 0x0E,
  0xE7, 0x70, 0x77, 0x3F, 0x83, 0xB1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x00,
  0x07, 0x87, 0x83, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0x80, 0x3B, 0xC0, 0x1D,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xF0,
  0x1E, 0x78, 0x0E, 0x1C, 0x0F, 0x0E, 0x0F, 0x07, 0x00, 0x70, 0x7B, 0x87,
  0x9C, 0x38, 0xE3, 0xC7, 0x1C, 0x39, 0xC1, 0xEE, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFE, 0x0F, 0xC0,
  0xFC, 0x00, 0xE3, 0x8E, 0x38, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x30,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x70, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x6E, 0x07, 0x70, 0x73, 0x83,
  0x8C, 0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0x70, 0xFF, 0xC0, 0xF3, 0x8E,
  0x71, 0x80, 0x06, 0x08, 0xFB, 0x8F, 0xFC, 0x7B, 0xE7, 0x8F, 0x38, 0x79,
  0xC3, 0x9E, 0x1C, 0xE0, 0xE7, 0x0F, 0x38, 0x71, 0xC3, 0x8E, 0x3C, 0x71,
  0xE3, 0xFF, 0x1F, 0xF0, 0x7B, 0x80, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x79, 0x03, 0xBE, 0x1F, 0xF0, 0xF3, 0xCF, 0x1E,
  0x78, 0xF3, 0x87, 0x9C, 0x3C, 0xE1, 0xCF, 0x0E, 0x70, 0x73, 0x87, 0x9C,
  0x38, 0xE3, 0xCF, 0xFC, 0x7F, 0xE3, 0xBC, 0x00, 0x01, 0x03, 0xF1, 0xFC,
  0xF2, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x4F, 0xE3, 0xF8, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x47, 0x87, 0xDC, 0x1F, 0xF0, 0xF7, 0xC7,
  0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xF0, 0xF7, 0xC3, 0xF6, 0x07, 0x98, 0x00, 0x01,
  0x01, 0xF8, 0x7F, 0x9C, 0x77, 0x8E, 0xE1, 0xDC, 0x77, 0x7E, 0xFF, 0x9F,
  0x83, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x43, 0xF8, 0x7F, 0x00, 0x00,
  0x1E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x01, 0xFC, 0x03, 0xF8, 0x0B, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x82, 0x0F, 0xB8,
  0x1F, 0xF0, 0x7B, 0xE1, 0xE3, 0xC3, 0x87, 0x87, 0x0E, 0x1E, 0x1C, 0x38,
  0x38, 0x70, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x8F, 0x07, 0x1E, 0x0F, 0xFC,
  0x1F, 0xF0, 0x1E, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x08, 0x3C, 0x1F,
  0xF8, 0x3F, 0xE0, 0x3F, 0x00, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x41, 0xDF, 0x1F, 0xF1, 0xEF, 0x3C, 0x73, 0xC7, 0x38,
  0x73, 0x87, 0x38, 0x77, 0x8F, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0xF1,
  0xCE, 0x1C, 0xE1, 0xC0, 0x02, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x02, 0x1C,
  0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70,
  0xF0, 0xE0, 0xE0, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x0F, 0xC0, 0xF8, 0x0F, 0x00,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x8F, 0x1C, 0x70, 0xE7, 0x07, 0x78, 0x73, 0x83, 0xB8, 0x1F, 0x80, 0xFE,
  0x0F, 0xF0, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x8E, 0x3C, 0x70, 0xE3,
  0x87, 0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0,
  0xE0, 0x00, 0x41, 0x03, 0xBE, 0xF8, 0x7F, 0xFF, 0x8F, 0x7E, 0xF1, 0xC7,
  0x9E, 0x78, 0xE3, 0xCE, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0xE1, 0xCF, 0x1C,
  0x39, 0xC3, 0x8F, 0x38, 0x71, 0xC7, 0x1E, 0x38, 0xE3, 0x87, 0x3C, 0x70,
  0xE7, 0x0E, 0x38, 0xE1, 0xC7, 0x00, 0x00, 0x41, 0xDF, 0x1F, 0xF1, 0xEF,
  0x1C, 0x73, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x77, 0x8F, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x1E, 0xF1, 0xCE, 0x1C, 0xE1, 0xC0, 0x03, 0x01, 0xF8, 0x7F,
  0x9E, 0xF7, 0x8E, 0xE1, 0xDC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0,
  0xEE, 0x1D, 0xC7, 0xBF, 0xE3, 0xF8, 0x7E, 0x00, 0x00, 0x10, 0x0E, 0xF8,
  0x1F, 0xF0, 0x3C, 0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0x87, 0x87, 0x0F, 0x0E,
  0x1C, 0x3C, 0x38, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x8F, 0x0F, 0xFC,
  0x1D, 0xF8, 0x3B, 0xE0, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x02, 0x08, 0x7D, 0x87, 0xFC, 0x7B, 0xE7,
  0x8F, 0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x71, 0xC3,
  0x8E, 0x1C, 0x71, 0xE3, 0xFF, 0x1F, 0xF0, 0x7B, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x00, 0x63, 0xB8, 0x7F,
  0x0F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x03, 0xFC, 0xFF,
  0x1E, 0x63, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x79, 0x0F, 0x3F, 0xC7, 0xF8, 0xFE, 0x00, 0x0C, 0x0C, 0x1C, 0x1C,
  0x7F, 0x7F, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xE0, 0xF8, 0xF8, 0x78, 0x38, 0x73, 0x87, 0x38, 0xF7, 0x8E, 0x70, 0xE7,
  0x0E, 0x70, 0xE7, 0x1E, 0xF1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0xCF,
  0xF8, 0xFF, 0x87, 0xB8, 0xE1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE, 0x39, 0xCE,
  0x39, 0xC7, 0x70, 0xEE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xE3, 0xC3, 0xF1, 0xE3, 0xB8, 0xF1, 0xDC, 0xF8, 0xEE, 0x6C,
  0xE7, 0x7E, 0x73, 0xBF, 0x71, 0xDB, 0xB8, 0xFD, 0xDC, 0x7E, 0xFC, 0x36,
  0x7E, 0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xC3, 0xC0,
  0x1E, 0x3C, 0x39, 0xE0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x39, 0xC1, 0xC7,
  0x0F, 0x1C, 0x38, 0x70, 0x0E, 0x1E, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xC0,
  0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xFF, 0x3F, 0xE7, 0xF8, 0x01, 0xF0,
  0x3F, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x1E, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1E, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0xF8, 0x1F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xF0, 0x0E, 0x07, 0xC1, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x07, 0xE0, 0xF8, 0x18,
  0x00, 0x38, 0x1F, 0xE3, 0xFF, 0xF8, 0x7F, 0x80, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 10, 7, 11, 3, -21 },
  { 31, 15, 21, 14, 0, -21 },
  { 71, 13, 25, 12, 0, -23 },
  { 112, 18, 22, 20, 1, -22 },
  { 162, 14, 22, 14, 0, -22 },
  { 201, 5, 7, 7, 3, -21 },
  { 206, 10, 27, 8, 0, -22 },
  { 240, 9, 27, 8, -2, -22 },
  { 271, 10, 12, 12, 3, -23 },
  { 286, 12, 15, 14, 1, -18 },
  { 309, 7, 8, 7, -2, -4 },
  { 316, 8, 3, 8, 0, -10 },
  { 319, 4, 4, 7, 0, -4 },
  { 321, 15, 22, 11, -2, -22 },
  { 363, 11, 22, 12, 1, -22 },
  { 394, 9, 21, 13, 3, -21 },
  { 418, 14, 22, 12, -1, -22 },
  { 457, 13, 22, 12, 0, -22 },
  { 493, 13, 22, 13, 0, -22 },
  { 529, 13, 21, 12, 0, -21 },
  { 564, 12, 22, 12, 1, -22 },
  { 597, 13, 21, 12, 1, -21 },
  { 632, 13, 22, 12, 0, -22 },
  { 668, 12, 22, 12, 0, -22 },
  { 701, 7, 16, 7, 0, -16 },
  { 715, 9, 20, 7, -2, -16 },
  { 738, 12, 14, 14, 1, -18 },
  { 759, 12, 9, 14, 1, -15 },
  { 773, 12, 14, 14, 1, -18 },
  { 794, 10, 22, 10, 1, -22 },
  { 822, 18, 24, 19, 1, -22 },
  { 876, 13, 22, 13, -2, -22 },
  { 912, 14, 21, 14, 0, -21 },
  { 949, 14, 22, 13, 1, -22 },
  { 988, 15, 21, 15, 0, -21 },
  { 1028, 13, 21, 12, 0, -21 },
  { 1063, 13, 21, 11, 0, -21 },
  { 1098, 15, 22, 15, 1, -22 },
  { 1140, 16, 21, 15, 0, -21 },
  { 1182, 12, 21, 9, -1, -21 },
  { 1214, 13, 27, 7, -5, -21 },
  { 1258, 16, 21, 13, 0, -21 },
  { 1300, 9, 21, 11, 0, -21 },
  { 1324, 21, 21, 20, 0, -21 },
  { 1380, 17, 21, 16, 0, -21 },
  { 1425, 14, 22, 16, 1, -22 },
  { 1464, 14, 21, 13, 0, -21 },
  { 1501, 14, 27, 16, 1, -22 },
  { 1549, 14, 21, 13, 0, -21 },
  { 1586, 14, 22, 12, -1, -22 },
  { 1625, 12, 21, 11, 2, -21 },
  { 1657, 15, 21, 15, 1, -21 },
  { 1697, 13, 21, 13, 3, -21 },
  { 1732, 21, 21, 20, 2, -21 },
  { 1788, 17, 21, 12, -2, -21 },
  { 1833, 13, 21, 12, 2, -21 },
  { 1868, 14, 21, 11, -1, -21 },
  { 1905, 12, 27, 8, -1, -22 },
  { 1946, 6, 22, 11, 3, -22 },
  { 1963, 12, 27, 8, -2, -22 },
  { 2004, 13, 12, 13, 0, -21 },
  { 2024, 10, 1, 9, -3, 3 },
  { 2026, 5, 5, 8, 4, -23 },
  { 2030, 13, 17, 13, 1, -17 },
  { 2058, 13, 23, 13, 0, -23 },
  { 2096, 10, 17, 10, 1, -17 },
  { 2118, 14, 23, 13, 1, -23 },
  { 2159, 11, 17, 12, 1, -17 },
  { 2183, 15, 30, 8, -4, -23 },
  { 2240, 15, 24, 13, -1, -17 },
  { 2285, 12, 23, 13, 0, -23 },
  { 2320, 8, 23, 6, 0, -23 },
  { 2343, 12, 30, 6, -4, -23 },
  { 2388, 13, 23, 12, 0, -23 },
  { 2426, 8, 23, 6, 0, -23 },
  { 2449, 19, 17, 19, 0, -17 },
  { 2490, 12, 17, 13, 0, -17 },
  { 2516, 11, 17, 13, 1, -17 },
  { 2540, 15, 24, 13, -2, -17 },
  { 2585, 13, 24, 13, 1, -17 },
  { 2624, 11, 17, 9, 0, -17 },
  { 2648, 11, 17, 10, 0, -17 },
  { 2672, 8, 20, 8, 1, -20 },
  { 2692, 12, 16, 13, 1, -16 },
  { 2716, 11, 16, 11, 2, -16 },
  { 2738, 17, 16, 18, 2, -16 },
  { 2772, 14, 16, 11, -1, -16 },
  { 2800, 15, 23, 11, -2, -16 },
  { 2844, 11, 16, 10, -1, -16 },
  { 2866, 12, 26, 10, 0, -21 },
  { 2905, 3, 30, 11, 4, -23 },
  { 2917, 11, 26, 10, -2, -21 },
  { 2953, 12, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC30PT7B_H_
