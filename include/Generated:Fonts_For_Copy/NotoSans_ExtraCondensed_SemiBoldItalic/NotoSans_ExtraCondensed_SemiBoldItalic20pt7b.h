#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC20PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x63, 0x00, 0x8E, 0x60, 0x6F, 0xBC,
  0xF2, 0xD8, 0x0C, 0x83, 0x60, 0x98, 0x64, 0x7F, 0xC4, 0xC1, 0x20, 0xD8,
  0xFF, 0x3F, 0xC6, 0xC1, 0xB0, 0x48, 0x36, 0x00, 0x02, 0x03, 0x07, 0xE7,
  0xA3, 0x41, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x05, 0x92, 0xCF, 0xE7, 0xE0,
  0x40, 0x40, 0x38, 0xE6, 0x8C, 0x49, 0x8C, 0x90, 0xDB, 0x0D, 0xA6, 0xD6,
  0xFF, 0x5B, 0x0D, 0x30, 0x93, 0x1B, 0x21, 0x36, 0x33, 0x66, 0x1C, 0x0F,
  0x06, 0xC1, 0xB0, 0x6C, 0x1E, 0x07, 0x81, 0xC5, 0xF6, 0x6D, 0xB3, 0xCC,
  0x73, 0x18, 0xFF, 0x1E, 0xC0, 0x6F, 0x6C, 0x0E, 0x38, 0x61, 0x83, 0x06,
  0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x0C, 0x08,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x18,
  0x31, 0xC0, 0x19, 0x23, 0xFB, 0xF7, 0x9F, 0x13, 0x00, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x33, 0x66, 0xCC, 0xFF, 0xC0,
  0x7F, 0x00, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x00, 0x0F, 0x1F, 0x33, 0x33,
  0x73, 0x63, 0x63, 0x63, 0x67, 0xE6, 0xC6, 0xEC, 0x7C, 0x78, 0x1C, 0xE7,
  0xB6, 0x98, 0xE3, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x80, 0x0F, 0x8F, 0xC4,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x07, 0xF7,
  0xF0, 0x3F, 0x1F, 0x80, 0xE0, 0x60, 0x30, 0x30, 0xF0, 0x7C, 0x06, 0x03,
  0x01, 0x91, 0xCF, 0xC7, 0xC0, 0x03, 0x83, 0x83, 0xC1, 0x61, 0xE0, 0xB0,
  0x98, 0xCC, 0x46, 0x7F, 0xBF, 0xC1, 0x80, 0xC0, 0xE0, 0x1F, 0x8F, 0x8C,
  0x06, 0x03, 0x01, 0xE1, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x91, 0xCF, 0xC7,
  0xC0, 0x02, 0x07, 0xC7, 0x23, 0x03, 0x01, 0x81, 0xB8, 0xFE, 0x67, 0x33,
  0x99, 0xDC, 0xC6, 0x63, 0xE1, 0xF0, 0x7F, 0x7F, 0x06, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xC0, 0x1F, 0x1D, 0xCC, 0xE6,
  0x63, 0x31, 0xF0, 0x70, 0x7C, 0x66, 0x63, 0x31, 0x98, 0xCF, 0xE3, 0xE0,
  0x04, 0x1F, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x67, 0x7F, 0x3E, 0x06, 0x0E,
  0x0C, 0xF8, 0xF0, 0x33, 0x30, 0x00, 0x00, 0x4E, 0xC0, 0x18, 0x71, 0x80,
  0x00, 0x00, 0x00, 0x31, 0xC6, 0x18, 0xC3, 0x00, 0x01, 0x07, 0x1E, 0x78,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x3C, 0xF0, 0xC0, 0x80, 0x3E, 0x4C,
  0x18, 0x30, 0xC3, 0x86, 0x18, 0x20, 0xC0, 0x03, 0x06, 0x1C, 0x00, 0x07,
  0xE0, 0xC3, 0x18, 0x13, 0x19, 0x27, 0xD6, 0x49, 0x6D, 0x94, 0x9B, 0x49,
  0xB5, 0x92, 0xCF, 0xEC, 0xC8, 0x40, 0x06, 0x00, 0x3F, 0x00, 0xC0, 0x07,
  0x83, 0xC1, 0x61, 0xB0, 0xD8, 0xCC, 0x66, 0x73, 0x3F, 0x9F, 0xDC, 0xEC,
  0x7E, 0x3E, 0x1C, 0x1F, 0x0F, 0xCE, 0x66, 0x33, 0x19, 0x98, 0xF8, 0xEE,
  0x63, 0x31, 0x98, 0xDC, 0xEF, 0xE7, 0xE0, 0x04, 0x0F, 0xCF, 0xC6, 0x07,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xE1, 0xF0,
  0x1F, 0x07, 0xE3, 0x9C, 0xC7, 0x31, 0xCC, 0x73, 0x1D, 0xC6, 0x61, 0x98,
  0xE6, 0x33, 0x9C, 0xFE, 0x3E, 0x00, 0x1F, 0x8F, 0x8E, 0x06, 0x03, 0x01,
  0x80, 0xF8, 0xFC, 0x60, 0x30, 0x18, 0x1C, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0x8E, 0x06, 0x03, 0x01, 0x80, 0xF8, 0xFC, 0x60, 0x30, 0x18, 0x1C, 0x0E,
  0x06, 0x00, 0x02, 0x07, 0xF3, 0xF8, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x1E,
  0xCF, 0x30, 0xCC, 0x33, 0x0C, 0xE7, 0x3F, 0x87, 0xE0, 0x18, 0xE3, 0x18,
  0xE3, 0x18, 0x63, 0x0C, 0x63, 0x8F, 0xE3, 0xFC, 0x61, 0x8C, 0x31, 0x8E,
  0x71, 0x8E, 0x31, 0x86, 0x00, 0x1F, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x30, 0x78, 0xFC, 0x03, 0x03, 0x07, 0x06, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0xF0,
  0xE0, 0x18, 0xE3, 0x30, 0xEE, 0x19, 0x83, 0x60, 0x7C, 0x0F, 0x03, 0xE0,
  0x7E, 0x0D, 0xC1, 0x98, 0x33, 0x0C, 0x61, 0x8E, 0x00, 0x18, 0x63, 0x8C,
  0x30, 0xC3, 0x1C, 0x61, 0x86, 0x38, 0xFF, 0xF0, 0x1C, 0x1C, 0x70, 0xF3,
  0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0x63, 0xCD, 0x9B, 0x2C, 0x6D, 0xB1,
  0xB6, 0xC6, 0xF3, 0x1B, 0xDC, 0xCE, 0x63, 0x39, 0x80, 0x1C, 0x63, 0x8C,
  0xF1, 0x9E, 0x33, 0xCC, 0x69, 0x8D, 0xB3, 0x36, 0x66, 0xCC, 0xF1, 0x9E,
  0x31, 0xCC, 0x39, 0x87, 0x00, 0x1F, 0x1F, 0xCC, 0x6C, 0x36, 0x1F, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xCF, 0xE3, 0xE0, 0x1F, 0x0F, 0xCE,
  0x66, 0x33, 0x19, 0x8C, 0xCC, 0xFE, 0x7C, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x00, 0x1F, 0x1F, 0xCC, 0x6C, 0x36, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1,
  0xB1, 0xD8, 0xCF, 0xE3, 0xE0, 0x60, 0x38, 0x0C, 0x00, 0x1F, 0x0F, 0xCE,
  0x66, 0x33, 0x19, 0x9C, 0xFC, 0xFC, 0x6C, 0x37, 0x19, 0x8C, 0xCC, 0x66,
  0x38, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03,
  0x01, 0x91, 0xCF, 0xC7, 0xC0, 0x7F, 0x7F, 0x18, 0x18, 0x38, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x31, 0xCC, 0x67, 0x19, 0x86,
  0x63, 0x98, 0xCE, 0x33, 0x8C, 0xC3, 0x31, 0xCC, 0x63, 0x38, 0xFC, 0x1E,
  0x00, 0xC3, 0xE3, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0x71, 0xB0, 0xD8, 0x78,
  0x3C, 0x1C, 0x0E, 0x07, 0x00, 0x63, 0x0D, 0x8C, 0x76, 0x31, 0x99, 0xC6,
  0x65, 0x31, 0xB4, 0xC6, 0xF3, 0x1A, 0xD8, 0x7B, 0x61, 0x6F, 0x0F, 0x3C,
  0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x00, 0x18, 0xE3, 0xB8, 0x36, 0x07, 0xC0,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xD8, 0x3B, 0x06, 0x71,
  0x86, 0x00, 0xC7, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xC0, 0xC0, 0xC0, 0x1F, 0xC7, 0xE0, 0x38, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x7E, 0x3F, 0x80, 0x0F, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60,
  0x60, 0x78, 0xF0, 0xCC, 0xCC, 0x66, 0x66, 0x66, 0x62, 0x33, 0x1E, 0x0C,
  0x18, 0x30, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x78,
  0xF0, 0x06, 0x0E, 0x1E, 0x1E, 0x33, 0x23, 0x63, 0xC3, 0xFE, 0xED, 0x80,
  0x1D, 0x9F, 0xCC, 0xEE, 0x66, 0x33, 0x19, 0x9D, 0xCC, 0xE6, 0x3F, 0x1D,
  0x80, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x71, 0xF8, 0xCC, 0xE7, 0x63, 0x31,
  0x98, 0xCC, 0xEE, 0x67, 0xF3, 0x70, 0x1F, 0x3E, 0x30, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0x7C, 0x7C, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x1D, 0x8F,
  0xE3, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0x98, 0xE6, 0x1F, 0x87, 0x60,
  0x0E, 0x3F, 0x33, 0x63, 0x66, 0x7C, 0x60, 0xE0, 0xE0, 0x7C, 0x7C, 0x03,
  0xC1, 0xE0, 0x60, 0x18, 0x0F, 0x07, 0xC0, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x0E, 0x03, 0x00,
  0x1D, 0x9F, 0xCC, 0xEE, 0x66, 0x33, 0x19, 0x9D, 0xCC, 0xE6, 0x3F, 0x1D,
  0x81, 0xC0, 0xC4, 0xE3, 0xE1, 0xE0, 0x18, 0x18, 0x18, 0x30, 0x37, 0x3F,
  0x33, 0x33, 0x63, 0x63, 0x67, 0x66, 0xE6, 0xC6, 0xCE, 0x18, 0xC4, 0x03,
  0x18, 0xCE, 0x63, 0x18, 0xCE, 0x63, 0x00, 0x03, 0x03, 0x02, 0x00, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x30, 0xF0, 0xE0, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x39, 0x98, 0xD8, 0x78,
  0x7C, 0x3E, 0x1F, 0x0D, 0x8C, 0xC6, 0x73, 0x18, 0x18, 0xC6, 0x73, 0x18,
  0xC6, 0x63, 0x18, 0xCE, 0x63, 0x00, 0x37, 0x71, 0xFF, 0x8C, 0xEE, 0x66,
  0x66, 0x33, 0x31, 0x99, 0x98, 0xCC, 0xCE, 0xE6, 0x66, 0x33, 0x33, 0x98,
  0x37, 0x3F, 0x33, 0x33, 0x63, 0x63, 0x67, 0x66, 0xE6, 0xC6, 0xCE, 0x1E,
  0x3F, 0x33, 0x63, 0x63, 0x63, 0x63, 0xE7, 0x66, 0x7E, 0x7C, 0x1B, 0x87,
  0xE1, 0x98, 0x67, 0x31, 0x8C, 0x63, 0x18, 0xCE, 0x73, 0x1F, 0xC6, 0xE1,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0x1D, 0x9F, 0xCC, 0xEC, 0x66, 0x33,
  0x19, 0x8D, 0xCC, 0xE6, 0x3F, 0x1D, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x36, 0x7C, 0xE3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x00, 0x3E, 0x7D,
  0x83, 0x07, 0x07, 0x07, 0x0E, 0x1D, 0xF3, 0xE0, 0x31, 0x9F, 0xF6, 0x33,
  0x98, 0xC6, 0x31, 0xCE, 0x00, 0x31, 0x99, 0x8C, 0xCE, 0x66, 0x33, 0x19,
  0x98, 0xCC, 0xE6, 0x7F, 0x1D, 0x80, 0xC7, 0xC6, 0xCE, 0xCC, 0xCC, 0xD8,
  0xD8, 0xF0, 0xF0, 0xE0, 0xE0, 0xC6, 0x3C, 0xE6, 0xCE, 0x6C, 0xEC, 0xDE,
  0xCD, 0x6C, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x00, 0x39, 0x8D,
  0xC6, 0xC3, 0xC1, 0xE0, 0x60, 0x70, 0x7C, 0x36, 0x33, 0x39, 0x80, 0x18,
  0xE3, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0x36, 0x02, 0xC0, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x1F, 0x3F, 0x06,
  0x0E, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x7C, 0xFC, 0x07, 0x0F, 0x0C, 0x1C,
  0x18, 0x18, 0x18, 0x70, 0xE0, 0x70, 0x30, 0x30, 0x30, 0x60, 0x60, 0x78,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0x06, 0x38, 0x61, 0xC3, 0x06, 0x0C, 0x78, 0xE0, 0x41, 0xFB, 0x9F,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 10, 14, 9, 0, -14 },
  { 32, 9, 16, 8, 0, -15 },
  { 50, 12, 14, 13, 1, -14 },
  { 71, 10, 14, 10, 0, -14 },
  { 89, 3, 5, 4, 2, -14 },
  { 91, 7, 17, 5, 0, -14 },
  { 106, 7, 18, 5, -2, -15 },
  { 122, 7, 7, 8, 2, -15 },
  { 129, 8, 10, 9, 1, -12 },
  { 139, 4, 6, 4, -1, -3 },
  { 142, 5, 2, 6, 0, -6 },
  { 144, 3, 3, 4, 0, -3 },
  { 146, 10, 14, 7, -1, -14 },
  { 164, 8, 14, 8, 0, -14 },
  { 178, 6, 14, 8, 2, -14 },
  { 189, 9, 14, 8, -1, -14 },
  { 205, 9, 14, 8, 0, -14 },
  { 221, 9, 14, 8, 0, -14 },
  { 237, 9, 14, 8, 0, -14 },
  { 253, 9, 15, 8, 0, -15 },
  { 270, 8, 14, 8, 1, -14 },
  { 284, 9, 14, 8, 0, -14 },
  { 300, 8, 15, 8, 0, -15 },
  { 315, 4, 11, 5, 0, -11 },
  { 321, 6, 14, 5, -1, -11 },
  { 332, 8, 10, 9, 1, -12 },
  { 342, 8, 6, 9, 1, -10 },
  { 348, 8, 10, 9, 1, -12 },
  { 358, 7, 14, 6, 0, -14 },
  { 371, 12, 16, 13, 0, -14 },
  { 395, 9, 14, 9, -1, -14 },
  { 411, 9, 14, 9, 0, -14 },
  { 427, 9, 15, 8, 1, -15 },
  { 444, 10, 14, 10, 0, -14 },
  { 462, 9, 14, 8, 0, -14 },
  { 478, 9, 14, 7, 0, -14 },
  { 494, 10, 15, 10, 1, -15 },
  { 513, 11, 14, 10, 0, -14 },
  { 533, 8, 14, 6, -1, -14 },
  { 547, 8, 18, 5, -3, -14 },
  { 565, 11, 14, 9, 0, -14 },
  { 585, 6, 14, 7, 0, -14 },
  { 596, 14, 14, 14, 0, -14 },
  { 621, 11, 14, 11, 0, -14 },
  { 641, 9, 14, 11, 1, -14 },
  { 657, 9, 14, 9, 0, -14 },
  { 673, 9, 17, 11, 1, -14 },
  { 693, 9, 14, 9, 0, -14 },
  { 709, 9, 14, 8, 0, -14 },
  { 725, 8, 14, 8, 1, -14 },
  { 739, 10, 14, 10, 1, -14 },
  { 757, 9, 14, 9, 2, -14 },
  { 773, 14, 14, 14, 1, -14 },
  { 798, 11, 14, 8, -1, -14 },
  { 818, 8, 14, 8, 2, -14 },
  { 832, 10, 14, 7, -1, -14 },
  { 850, 8, 17, 6, -1, -14 },
  { 867, 4, 14, 7, 2, -14 },
  { 874, 7, 17, 6, -1, -14 },
  { 889, 8, 8, 8, 0, -14 },
  { 897, 7, 1, 6, -2, 2 },
  { 898, 3, 3, 6, 3, -15 },
  { 900, 9, 11, 9, 0, -11 },
  { 913, 9, 15, 9, 0, -15 },
  { 930, 8, 11, 7, 0, -11 },
  { 941, 10, 15, 9, 0, -15 },
  { 960, 8, 11, 8, 0, -11 },
  { 971, 10, 20, 5, -2, -15 },
  { 996, 9, 16, 9, 0, -11 },
  { 1014, 8, 15, 9, 0, -15 },
  { 1029, 5, 15, 4, 0, -15 },
  { 1039, 8, 20, 4, -3, -15 },
  { 1059, 9, 15, 8, 0, -15 },
  { 1076, 5, 15, 4, 0, -15 },
  { 1086, 13, 11, 13, 0, -11 },
  { 1104, 8, 11, 9, 0, -11 },
  { 1115, 8, 11, 9, 0, -11 },
  { 1126, 10, 16, 9, -1, -11 },
  { 1146, 9, 16, 9, 0, -11 },
  { 1164, 7, 11, 6, 0, -11 },
  { 1174, 7, 11, 7, 0, -11 },
  { 1184, 5, 13, 5, 1, -13 },
  { 1193, 9, 11, 9, 0, -11 },
  { 1206, 8, 11, 8, 1, -11 },
  { 1217, 12, 11, 12, 1, -11 },
  { 1234, 9, 11, 8, -1, -11 },
  { 1247, 11, 16, 8, -2, -11 },
  { 1269, 8, 11, 6, -1, -11 },
  { 1280, 8, 17, 7, 0, -14 },
  { 1297, 2, 20, 7, 3, -15 },
  { 1302, 7, 17, 7, -1, -14 },
  { 1317, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC20PT7B_H_
