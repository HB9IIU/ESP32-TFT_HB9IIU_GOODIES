#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x79, 0xF7,
  0x9E, 0x71, 0xEF, 0x1C, 0xF1, 0xCF, 0x3C, 0xE3, 0xCE, 0x38, 0xE3, 0x80,
  0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x38, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x81, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xC7, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x00, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x30, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x0E, 0x64, 0x1E, 0x40, 0x1E, 0x40, 0x1E, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0x7C, 0x01,
  0x7C, 0x01, 0x3C, 0x03, 0x3C, 0x43, 0x78, 0xF2, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xC0, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x00, 0x7E, 0x03, 0x81, 0xFC, 0x1C, 0x0E, 0x70, 0x70, 0x79, 0xC3,
  0x81, 0xC7, 0x0E, 0x07, 0x1C, 0x70, 0x38, 0x73, 0xC0, 0xE3, 0xCE, 0x03,
  0x8E, 0x78, 0x0E, 0x39, 0xC0, 0x38, 0xEE, 0x3C, 0xE7, 0x39, 0xFB, 0x9D,
  0xCF, 0xEF, 0xE7, 0x7B, 0xDF, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0x07, 0x38,
  0xE0, 0x1C, 0xE3, 0x80, 0xE3, 0x8E, 0x03, 0x8E, 0x38, 0x1C, 0x38, 0xE0,
  0xF0, 0xE7, 0x03, 0x83, 0x9C, 0x1E, 0x0E, 0xE0, 0x70, 0x3F, 0x83, 0x80,
  0x7C, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x07, 0x3C, 0x01, 0xEE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x11, 0xFE, 0x78,
  0xF7, 0x9E, 0x3D, 0xE7, 0x9E, 0x3F, 0xCF, 0x0F, 0xF3, 0xC3, 0xF8, 0xF0,
  0x7E, 0x3C, 0x1F, 0x0F, 0x0F, 0xC3, 0xE7, 0xF0, 0xFF, 0xFE, 0x1F, 0xF7,
  0x83, 0xF1, 0xF0, 0x7B, 0xDE, 0xEF, 0x7B, 0xDC, 0xE0, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0x80, 0x1C, 0x11, 0xE0, 0xCF, 0x07, 0xF3, 0xFF, 0xFC, 0xFF,
  0xE1, 0xFF, 0x1F, 0x81, 0xFE, 0x1E, 0x70, 0x73, 0xC1, 0x1C, 0x00, 0x40,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0x7F, 0xDF, 0xE7, 0xFB,
  0xFE, 0x7B, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3,
  0xFF, 0x0F, 0x3C, 0x78, 0xF1, 0xE1, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF7,
  0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE0, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0x7B,
  0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x3D, 0xF0,
  0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xE3,
  0xFD, 0xFF, 0x3D, 0xE3, 0x3C, 0x47, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x70, 0xF0, 0x30, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x30, 0xF8, 0x10, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE2, 0x01, 0xE1, 0xC3, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xB8, 0x01, 0xFC, 0x01, 0xDE, 0x00, 0xEF, 0x00,
  0xE7, 0x80, 0x63, 0x80, 0x73, 0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x38, 0x78,
  0x38, 0x78, 0x1C, 0x3C, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE4, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x80, 0x1F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x10, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x80, 0xF0, 0xE3, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF7,
  0x83, 0xDF, 0x87, 0xFF, 0x8F, 0xFF, 0x3F, 0x1E, 0x7C, 0x3C, 0xF8, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x7D,
  0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3E, 0xF8, 0x7C, 0x78, 0x78, 0x78, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xE7, 0xCF, 0xCF, 0xFF, 0x0F, 0xFE, 0x1F,
  0xBC, 0x04, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x43, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0x0F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x00,
  0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x07,
  0xC1, 0xFE, 0x3F, 0xF3, 0xFF, 0x10, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x78, 0x1C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC7,
  0x03, 0x07, 0x1C, 0x3F, 0x9C, 0xE1, 0xFE, 0x73, 0x8E, 0x71, 0xCC, 0x71,
  0xC7, 0x71, 0xC7, 0x1D, 0xCE, 0x1C, 0x66, 0x38, 0xE3, 0xB8, 0xE3, 0x8E,
  0xE3, 0x8E, 0x3B, 0x8C, 0x38, 0xCE, 0x71, 0xC7, 0x39, 0xE7, 0x18, 0xE3,
  0xFF, 0xE3, 0x8F, 0x9F, 0x0E, 0x1C, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x40, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x77, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xEF, 0x01, 0xEF, 0x01,
  0xCF, 0x03, 0xCF, 0x03, 0xCF, 0x07, 0x8F, 0x07, 0x8F, 0x0F, 0x8F, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x07, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0xF1, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x0F, 0x8F, 0x07, 0x87, 0x8F, 0x83, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F,
  0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC3, 0xE1, 0xE7, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7C, 0x20, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFD, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1E, 0x7E,
  0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7,
  0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE3, 0xE0,
  0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0xF8,
  0x78, 0x3E, 0x1E, 0x3F, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7C, 0x1C, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x83, 0xF8, 0xF0, 0x7F, 0x1E, 0x1F, 0xE7, 0xC3, 0xF8,
  0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xE0,
  0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xF1, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x3C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x3E, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x4F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x10, 0x00, 0x07, 0xC1, 0xF0, 0x78,
  0x3C, 0x07, 0x87, 0xC0, 0x78, 0xF8, 0x0F, 0x8F, 0x00, 0xF1, 0xF0, 0x0F,
  0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xEF, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF8, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8,
  0x3F, 0x81, 0xDC, 0x0E, 0xE0, 0xFF, 0x07, 0xB8, 0x3B, 0xC1, 0xEE, 0x1E,
  0xF0, 0x7B, 0x87, 0xBC, 0x1E, 0xE1, 0xDE, 0x07, 0x38, 0xF7, 0x83, 0xCE,
  0x39, 0xE0, 0xF3, 0x9E, 0x78, 0x3C, 0xE7, 0x1E, 0x0F, 0x3F, 0xCF, 0x03,
  0x8F, 0xE3, 0xC1, 0xE3, 0xF8, 0xF0, 0x78, 0xFE, 0x3C, 0x1E, 0x3F, 0x0E,
  0x07, 0x0F, 0xC7, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x3C, 0x3C,
  0x1E, 0x00, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xF8, 0x1E, 0x0F, 0xC1,
  0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x83, 0xC1, 0xDC, 0x1C, 0x0E,
  0xF1, 0xE0, 0xF7, 0x8F, 0x07, 0xBC, 0x78, 0x3C, 0xE3, 0xC1, 0xE7, 0x1C,
  0x0E, 0x39, 0xE0, 0xF1, 0xEF, 0x07, 0x8F, 0x78, 0x3C, 0x7B, 0xC1, 0xE1,
  0xDC, 0x0E, 0x0F, 0xE0, 0xF0, 0x7F, 0x07, 0x83, 0xF8, 0x3C, 0x1F, 0xC1,
  0xC0, 0xFC, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xC7, 0xC3, 0xC1,
  0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D,
  0xF0, 0x0F, 0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F,
  0x87, 0x87, 0xC1, 0xFB, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xF1, 0xF0, 0xF8, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x83, 0xC3,
  0xC3, 0xE1, 0xE7, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xC7, 0xC3, 0xC1, 0xF1, 0xF0, 0x3C,
  0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x7C,
  0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87, 0x87, 0xC1,
  0xFB, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0xF8, 0xF8, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC3, 0xC7,
  0xC1, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x0F, 0x1F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x7C, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7C, 0x30, 0x7C, 0x08, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE1, 0x03, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x07,
  0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1E,
  0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x3F, 0x7E, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF3, 0xC0, 0xF3,
  0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xF7, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x07,
  0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x03, 0xDE, 0x07, 0x81, 0xEF, 0x07, 0xC1,
  0xE7, 0x83, 0xE0, 0xF3, 0xC3, 0xF0, 0x79, 0xE1, 0xF8, 0x78, 0xF0, 0xFC,
  0x3C, 0x78, 0xFE, 0x3C, 0x3C, 0x77, 0x1E, 0x1E, 0x7B, 0x8F, 0x0F, 0x39,
  0xCF, 0x07, 0x9C, 0xE7, 0x83, 0xDE, 0x73, 0xC1, 0xEE, 0x3B, 0xC0, 0xFF,
  0x1D, 0xE0, 0x77, 0x0F, 0xE0, 0x3B, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x3F, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x03, 0xC1, 0xF0, 0x3C, 0x1E,
  0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF,
  0x00, 0x1E, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7B, 0x80, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xC0, 0x78, 0x3E, 0x0F, 0x03, 0xE0,
  0xF0, 0x3F, 0xF0, 0x79, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E,
  0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0xE3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xF1,
  0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x0F,
  0x3C, 0x0F, 0x3C, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x1E, 0x78, 0x1E, 0x78,
  0x0E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0xF0, 0xF1, 0xE1,
  0xC1, 0xC0, 0x07, 0xCF, 0x0F, 0xEE, 0x1F, 0xFE, 0x3E, 0x7E, 0x3C, 0x3E,
  0x3C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0,
  0xFF, 0xF0, 0x7E, 0xF0, 0x7C, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x7C,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x7C, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0xE7, 0xC0, 0x07, 0xF8, 0x7F, 0xC7, 0xFC, 0x3C, 0x23, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x87, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x07, 0xCF, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xCF,
  0xC3, 0xC3, 0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78,
  0x1E, 0x3C, 0x0E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xE1,
  0xE1, 0xE0, 0xF1, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0x9C, 0x00, 0x03,
  0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x8F, 0x3C, 0x3D, 0xE0, 0xE7, 0x87, 0x9E,
  0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x21, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xF2, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0xFE, 0xE0, 0x7F, 0xF8, 0x1E, 0x7E, 0x0F, 0x0F, 0x83, 0xC3, 0xE1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0xFC,
  0x0F, 0xFF, 0x03, 0xFB, 0xC0, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x80, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x7C, 0x1F, 0xFC, 0x3F,
  0xF8, 0xFC, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x1E,
  0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C,
  0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x80, 0x01, 0x81, 0xF0,
  0x7C, 0x1E, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x0F, 0x87, 0x8F, 0x03, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0xF7, 0x80,
  0x73, 0xC0, 0x3B, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC0, 0x0E, 0x7C, 0x7C, 0x1D, 0xFD, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFC, 0xFC, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3, 0xC7, 0x87,
  0x87, 0x9E, 0x0F, 0x0F, 0x3C, 0x3C, 0x1C, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE1, 0xE7, 0x83, 0x83, 0xCF, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x70, 0x78, 0x79, 0xE0, 0xE0, 0xE3, 0xC3, 0xC3, 0xC7,
  0x87, 0x87, 0x80, 0x0E, 0x7C, 0x1D, 0xFC, 0x3F, 0xF8, 0xFC, 0xF1, 0xF1,
  0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1,
  0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0,
  0xF3, 0xC1, 0xE7, 0x87, 0x80, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x9F,
  0x3C, 0x3D, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBC, 0x3C, 0xF9, 0xF1, 0xFF,
  0x87, 0xFC, 0x0F, 0xE0, 0x03, 0x9F, 0x00, 0xEF, 0xE0, 0x3F, 0xF8, 0x1F,
  0x9F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x78, 0x1F, 0x3E, 0x0F, 0xFF, 0x03, 0xDF, 0x80, 0xF7,
  0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xCF,
  0x0F, 0xEE, 0x1F, 0xFE, 0x1E, 0x7E, 0x3C, 0x3E, 0x3C, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF9, 0xF0, 0xFF, 0xF0, 0xFE, 0xF0,
  0x7C, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x78, 0x77, 0xC3,
  0xFC, 0x3F, 0xE1, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0xC7, 0xFC, 0x7C, 0x23,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x90, 0x7C, 0xC7, 0xC7, 0xFE, 0x3F, 0xE1,
  0xFE, 0x00, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1F, 0xDF, 0xF7, 0xFC, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0x8F, 0xE1, 0xF8, 0x1E, 0x1E, 0x3C, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1E, 0x78,
  0x38, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C,
  0x78, 0xF8, 0xF3, 0xF1, 0xFF, 0xE3, 0xFB, 0x83, 0xE7, 0x00, 0xF0, 0x3F,
  0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x70,
  0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0x77, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x78, 0x7F,
  0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xBC, 0x7E, 0x3C, 0xF1, 0xF8, 0xF3, 0xC7,
  0xE3, 0x8F, 0x3B, 0x9E, 0x3C, 0xEE, 0x78, 0xF7, 0xBB, 0xC3, 0xDC, 0xEF,
  0x0F, 0x77, 0xB8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83, 0xB9, 0xDC, 0x0F,
  0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87,
  0xC0, 0x3C, 0x1F, 0x00, 0x07, 0x87, 0xC1, 0xE3, 0xE0, 0x78, 0xF0, 0x1E,
  0x78, 0x03, 0x9E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xF7, 0x00, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x83, 0xE1,
  0xF0, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xC3, 0xC0, 0x38,
  0x78, 0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0x78, 0x03, 0x9E, 0x00, 0x73,
  0xC0, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x00, 0x7C, 0x07,
  0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x0F, 0xE0, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7F, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xC0, 0x1E, 0x01,
  0xF8, 0x0F, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xC0, 0x38, 0x00, 0x1C, 0x02, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 12, 9, 14, 4, -26 },
  { 48, 18, 26, 17, 0, -26 },
  { 107, 16, 30, 15, 0, -28 },
  { 167, 22, 27, 25, 2, -27 },
  { 242, 18, 27, 18, 0, -27 },
  { 303, 5, 9, 8, 4, -26 },
  { 309, 12, 33, 10, 1, -27 },
  { 359, 12, 33, 10, -3, -27 },
  { 409, 13, 14, 15, 3, -28 },
  { 432, 15, 18, 17, 1, -22 },
  { 466, 8, 10, 8, -2, -5 },
  { 476, 10, 4, 10, 0, -12 },
  { 481, 5, 5, 8, 0, -5 },
  { 485, 18, 27, 13, -2, -27 },
  { 546, 14, 27, 15, 1, -27 },
  { 594, 11, 26, 15, 4, -26 },
  { 630, 17, 27, 15, -1, -27 },
  { 688, 17, 27, 15, -1, -27 },
  { 746, 17, 27, 15, -1, -27 },
  { 804, 16, 26, 15, 0, -26 },
  { 856, 15, 27, 15, 1, -27 },
  { 907, 16, 26, 15, 1, -26 },
  { 959, 16, 27, 15, 0, -27 },
  { 1013, 15, 27, 15, 0, -27 },
  { 1064, 8, 20, 8, 0, -20 },
  { 1084, 10, 25, 8, -2, -20 },
  { 1116, 15, 17, 17, 1, -22 },
  { 1148, 15, 10, 17, 1, -18 },
  { 1167, 15, 17, 17, 1, -22 },
  { 1199, 12, 27, 12, 1, -27 },
  { 1240, 22, 30, 23, 1, -27 },
  { 1323, 16, 27, 16, -2, -27 },
  { 1377, 17, 26, 17, 0, -26 },
  { 1433, 17, 27, 15, 1, -27 },
  { 1491, 18, 26, 18, 0, -26 },
  { 1550, 16, 26, 14, 0, -26 },
  { 1602, 16, 26, 14, 0, -26 },
  { 1654, 19, 27, 19, 1, -27 },
  { 1719, 20, 26, 19, 0, -26 },
  { 1784, 16, 26, 11, -2, -26 },
  { 1836, 16, 34, 9, -6, -26 },
  { 1904, 20, 26, 16, 0, -26 },
  { 1969, 11, 26, 14, 0, -26 },
  { 2005, 26, 26, 25, 0, -26 },
  { 2090, 21, 26, 20, 0, -26 },
  { 2159, 18, 27, 19, 1, -27 },
  { 2220, 17, 26, 16, 0, -26 },
  { 2276, 18, 33, 19, 1, -27 },
  { 2351, 17, 26, 17, 0, -26 },
  { 2407, 17, 27, 15, -1, -27 },
  { 2465, 14, 26, 14, 3, -26 },
  { 2511, 19, 26, 18, 1, -26 },
  { 2573, 16, 26, 16, 3, -26 },
  { 2625, 25, 26, 25, 3, -26 },
  { 2707, 20, 26, 15, -2, -26 },
  { 2772, 15, 26, 15, 3, -26 },
  { 2821, 17, 26, 14, -1, -26 },
  { 2877, 14, 33, 10, -1, -27 },
  { 2935, 7, 27, 13, 4, -27 },
  { 2959, 15, 33, 10, -3, -27 },
  { 3021, 16, 15, 16, 0, -26 },
  { 3051, 12, 3, 12, -3, 3 },
  { 3056, 7, 6, 10, 5, -28 },
  { 3062, 16, 20, 17, 1, -20 },
  { 3102, 16, 28, 16, 0, -28 },
  { 3158, 13, 20, 13, 1, -20 },
  { 3191, 17, 28, 17, 1, -28 },
  { 3251, 14, 20, 15, 1, -20 },
  { 3286, 18, 37, 10, -4, -28 },
  { 3370, 18, 29, 17, -1, -20 },
  { 3436, 15, 28, 16, 0, -28 },
  { 3489, 10, 28, 8, 0, -28 },
  { 3524, 15, 37, 8, -5, -28 },
  { 3594, 17, 28, 15, 0, -28 },
  { 3654, 10, 28, 8, 0, -28 },
  { 3689, 23, 20, 24, 0, -20 },
  { 3747, 15, 20, 16, 0, -20 },
  { 3785, 14, 20, 16, 1, -20 },
  { 3820, 18, 29, 16, -2, -20 },
  { 3886, 16, 29, 16, 1, -20 },
  { 3944, 13, 20, 11, 0, -20 },
  { 3977, 13, 20, 13, 0, -20 },
  { 4010, 10, 24, 10, 1, -24 },
  { 4040, 15, 20, 16, 1, -20 },
  { 4078, 14, 20, 14, 2, -20 },
  { 4113, 22, 20, 22, 2, -20 },
  { 4168, 18, 20, 14, -2, -20 },
  { 4213, 19, 29, 14, -3, -20 },
  { 4282, 14, 20, 12, -1, -20 },
  { 4317, 14, 32, 12, 1, -26 },
  { 4373, 3, 37, 14, 5, -28 },
  { 4387, 14, 32, 12, -2, -26 },
  { 4443, 15, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC37PT7B_H_
