#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0x1F, 0x3E, 0x1F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C,
  0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x70,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x01, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x87, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xF6, 0xF8,
  0x1F, 0x98, 0x40, 0x7C, 0x60, 0x01, 0xE3, 0x00, 0x07, 0x8C, 0x00, 0x1E,
  0x30, 0x00, 0x78, 0xC0, 0x01, 0xF7, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xDF, 0x00, 0x06,
  0x3E, 0x00, 0x18, 0xF8, 0x00, 0x63, 0xE0, 0x01, 0x8F, 0x00, 0x0C, 0x3C,
  0x10, 0x31, 0xF0, 0xF0, 0xCF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x3F, 0x80, 0x1C, 0x03, 0xFE, 0x01, 0xE0, 0x3C, 0xF0, 0x0E,
  0x01, 0xC7, 0x80, 0xF0, 0x1E, 0x1C, 0x0F, 0x00, 0xE0, 0xE0, 0x78, 0x0F,
  0x07, 0x07, 0x80, 0x78, 0x78, 0x3C, 0x03, 0x83, 0xC3, 0xC0, 0x3C, 0x1E,
  0x1E, 0x01, 0xE0, 0xF1, 0xE0, 0x0F, 0x07, 0x8F, 0x00, 0x78, 0x78, 0xF0,
  0x03, 0x83, 0xC7, 0x80, 0x1C, 0x1E, 0x78, 0x7C, 0xE1, 0xE3, 0xC7, 0xF7,
  0x0F, 0x3C, 0x7F, 0xB8, 0xF1, 0xE7, 0x9F, 0xE7, 0x9E, 0x78, 0xFF, 0xF8,
  0xE3, 0xC7, 0xBF, 0x8F, 0x3C, 0x3D, 0xF8, 0x71, 0xE1, 0xE0, 0x07, 0x8E,
  0x0F, 0x00, 0x78, 0xF0, 0x78, 0x03, 0xC7, 0x83, 0xC0, 0x3C, 0x3C, 0x1C,
  0x01, 0xE1, 0xE1, 0xE0, 0x1E, 0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x78, 0x0F,
  0x07, 0x83, 0x80, 0x78, 0x3C, 0x3C, 0x07, 0x81, 0xE1, 0xE0, 0x3C, 0x0F,
  0x1E, 0x03, 0xC0, 0x39, 0xF0, 0x1E, 0x01, 0xFF, 0x01, 0xE0, 0x0F, 0xF0,
  0x1F, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFD, 0xF0, 0x00, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01,
  0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xE3, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0x0F, 0xFC, 0x3E, 0x1F,
  0x3E, 0x3E, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x1F, 0x7C, 0x7C,
  0x1F, 0x78, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8,
  0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0xE0, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFB, 0xF0, 0x7F, 0xF1, 0xF0, 0x1F,
  0xE1, 0xF8, 0x07, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x04, 0x1E, 0x03, 0x0F, 0x01, 0xE7, 0x83, 0xFF, 0xDF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xF9,
  0xE0, 0xF8, 0xF0, 0x3C, 0x7C, 0x0C, 0x1F, 0x02, 0x0C, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x08, 0x79, 0xFB, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xF3, 0xF0, 0x3E, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x07, 0xCF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x1F,
  0xFC, 0x7E, 0xF9, 0xF9, 0xF1, 0xE3, 0xE1, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0x87,
  0xE0, 0x1C, 0x07, 0xC0, 0x10, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0x0F, 0xC0, 0x18, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x80, 0x1F, 0xC1, 0xC0,
  0x7F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1D, 0xF0, 0x00, 0x7B,
  0xE0, 0x01, 0xE7, 0x80, 0x03, 0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0x7C,
  0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x80,
  0x3C, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x0E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x80,
  0x3F, 0x83, 0x01, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFC, 0x08, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE3, 0xF0,
  0x0F, 0x9F, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFC, 0xFC, 0x1F,
  0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1E, 0x07, 0xE0, 0x7C,
  0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7E, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE1, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01,
  0xF8, 0xF8, 0x1F, 0x87, 0xC1, 0xFC, 0x3F, 0x1F, 0xE0, 0xFF, 0xFF, 0x07,
  0xFE, 0xF8, 0x1F, 0xEF, 0x80, 0x7C, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x04, 0x07, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0x80, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0xE1, 0xF8, 0x40, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x03, 0xF0, 0x70,
  0x78, 0x1F, 0xF8, 0xF0, 0xF0, 0x7F, 0xE1, 0xE1, 0xC1, 0xF3, 0xC3, 0xC7,
  0x83, 0x87, 0x87, 0x0E, 0x0F, 0x0F, 0x0E, 0x3C, 0x3C, 0x1C, 0x1C, 0x78,
  0x78, 0x78, 0x38, 0xE0, 0xE0, 0xF0, 0xF1, 0xC3, 0xC1, 0xE1, 0xE7, 0x87,
  0x83, 0x83, 0x8F, 0x0E, 0x0F, 0x07, 0x1C, 0x3C, 0x1E, 0x1E, 0x38, 0x78,
  0x3C, 0x3C, 0x70, 0xF0, 0xF0, 0x71, 0xE1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC3,
  0xC3, 0x87, 0x87, 0x8F, 0x8F, 0x0F, 0x0F, 0x3F, 0xBC, 0x1E, 0x0F, 0xEF,
  0xF0, 0x3C, 0x1F, 0x8F, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x04, 0x00, 0x07, 0xC0, 0x38, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0x7C, 0x00, 0x3D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF1, 0xFE,
  0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0x8F, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0x7C, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xC3, 0x80, 0x7F, 0x01, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x0C, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0x83, 0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0,
  0x7C, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0x00, 0xFE, 0x00, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x7F, 0xE3, 0xF0, 0x1F, 0xF8, 0xFC, 0x07, 0xFC, 0x3F, 0x01, 0xFF,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF0,
  0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x8F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x9F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xBE, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xBC, 0x03, 0xDE, 0x00,
  0x7F, 0xC0, 0x3D, 0xE0, 0x0F, 0xFC, 0x07, 0xDE, 0x00, 0xF7, 0xC0, 0x7D,
  0xE0, 0x1F, 0x7C, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3E, 0xF8,
  0x0F, 0x9E, 0x03, 0xCF, 0x80, 0xF9, 0xE0, 0x7C, 0xF8, 0x0F, 0x9E, 0x07,
  0x8F, 0x00, 0xF9, 0xE0, 0xF9, 0xF0, 0x0F, 0x1E, 0x0F, 0x1F, 0x01, 0xF1,
  0xF0, 0xF1, 0xF0, 0x1F, 0x1F, 0x1F, 0x1F, 0x01, 0xF1, 0xF1, 0xE1, 0xE0,
  0x1F, 0x1F, 0x3E, 0x3E, 0x01, 0xE1, 0xF3, 0xC3, 0xE0, 0x3E, 0x1F, 0x7C,
  0x3E, 0x03, 0xE1, 0xF7, 0x83, 0xE0, 0x3E, 0x1F, 0xF8, 0x7C, 0x03, 0xC0,
  0xFF, 0x07, 0xC0, 0x3C, 0x0F, 0xF0, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xC0,
  0x7C, 0x0F, 0xE0, 0x78, 0x07, 0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7F,
  0x00, 0x3E, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x0F, 0x00, 0xFF, 0x00,
  0xF8, 0x07, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x3E, 0x03, 0xFE, 0x01, 0xF0,
  0x1E, 0xF0, 0x0F, 0x00, 0xF7, 0x80, 0xF8, 0x07, 0xBE, 0x07, 0xC0, 0x7D,
  0xF0, 0x3E, 0x03, 0xE7, 0x81, 0xE0, 0x1F, 0x3C, 0x1F, 0x00, 0xF1, 0xE0,
  0xF8, 0x0F, 0x8F, 0x07, 0xC0, 0x7C, 0x7C, 0x3E, 0x03, 0xE3, 0xE1, 0xE0,
  0x1F, 0x0F, 0x1F, 0x00, 0xF0, 0x78, 0xF8, 0x0F, 0x83, 0xC7, 0xC0, 0x7C,
  0x1E, 0x3E, 0x03, 0xE0, 0xF9, 0xE0, 0x1F, 0x07, 0xDF, 0x00, 0xF0, 0x1E,
  0xF8, 0x0F, 0x80, 0xF7, 0xC0, 0x7C, 0x07, 0xBC, 0x03, 0xE0, 0x3D, 0xE0,
  0x1E, 0x01, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x3F, 0xC0, 0x7C,
  0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xE0, 0x1E, 0x00, 0x7F, 0x01, 0xF0, 0x03,
  0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F,
  0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8,
  0x0F, 0x83, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFC, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x07,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFE, 0x7C, 0x03, 0xF8, 0x0C, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x80, 0x0F, 0xC0, 0xE0,
  0x1F, 0xC0, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E,
  0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xF3,
  0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0,
  0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xF7, 0x80, 0x1F, 0x00, 0x3E, 0x78,
  0x01, 0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x00, 0x7C, 0x78, 0x03, 0xF0, 0x07,
  0xC7, 0x80, 0x3F, 0x00, 0x7C, 0xF8, 0x07, 0xF0, 0x0F, 0x8F, 0x80, 0x7F,
  0x00, 0xF8, 0xF8, 0x07, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0xF8,
  0x0F, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0x03, 0xE0, 0xF8, 0x1E, 0xF0, 0x3E,
  0x0F, 0x81, 0xEF, 0x07, 0xC0, 0xF8, 0x3E, 0xF0, 0x7C, 0x0F, 0x83, 0xCF,
  0x07, 0xC0, 0xF8, 0x3C, 0xF0, 0xF8, 0x0F, 0x87, 0x8F, 0x0F, 0x80, 0xF8,
  0x78, 0xF1, 0xF0, 0x0F, 0x8F, 0x8F, 0x1F, 0x00, 0xF8, 0xF0, 0xF1, 0xF0,
  0x0F, 0x8F, 0x1F, 0x3E, 0x00, 0xF9, 0xE1, 0xF3, 0xE0, 0x0F, 0x9E, 0x1F,
  0x3C, 0x00, 0xFB, 0xE1, 0xE7, 0xC0, 0x0F, 0xBC, 0x1E, 0x7C, 0x00, 0xFB,
  0xC1, 0xEF, 0x80, 0x0F, 0xFC, 0x1E, 0xF8, 0x00, 0xF7, 0x81, 0xEF, 0x00,
  0x0F, 0x78, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xC0,
  0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x04, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF0,
  0x00, 0xFB, 0xC0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0x78, 0x03,
  0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x3C, 0x1F, 0x00,
  0xF0, 0x78, 0x03, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x7C,
  0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFC, 0xFC,
  0x7C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x07, 0xF8, 0xF0,
  0x3F, 0xF7, 0xC1, 0xFF, 0xDE, 0x07, 0xE7, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0xF8, 0x0F, 0xF3, 0xC0, 0x1F,
  0x8F, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF9, 0xF8, 0x03, 0xCF, 0xF0, 0x1F, 0x7F, 0xE0, 0x7F, 0xFF, 0x81, 0xFE,
  0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x03, 0xE1,
  0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0xC3, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0x3F, 0xE0, 0x3C, 0x7F, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xF1, 0x83, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x18, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x1F, 0xE7, 0xC0, 0x1F,
  0xFB, 0xE0, 0x1F, 0xFD, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xE0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0x78, 0x00, 0xFF, 0x3C, 0x00, 0x3F, 0x1E, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x7C, 0x3E, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0xF8, 0x0F, 0x1E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xE7, 0xC7, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x02, 0x0F, 0xF7, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x80,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x7F, 0x9F, 0x00, 0xFF,
  0xDF, 0x01, 0xFF, 0xDE, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFB,
  0xE0, 0x0F, 0xF7, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x80, 0x1F, 0x00, 0xC0, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x3C, 0xFF, 0x03, 0xEF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0x3F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x78,
  0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0xC0,
  0x03, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC7, 0xE0,
  0xFC, 0x03, 0xCF, 0xF1, 0xFE, 0x07, 0xDF, 0xF3, 0xFE, 0x07, 0xBF, 0xFF,
  0xFF, 0x07, 0xF1, 0xFF, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xFC,
  0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0x80, 0xF0,
  0x1F, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0x3E, 0x1F, 0x01, 0xF0,
  0x3E, 0x1F, 0x01, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x3E, 0x1F, 0x03, 0xE0,
  0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xC0,
  0x7C, 0x3E, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC0,
  0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0x80, 0xF8, 0x7C, 0x0F, 0x80,
  0xF0, 0x78, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x01,
  0xF0, 0xF8, 0x1F, 0x01, 0xF0, 0x03, 0xC7, 0xE0, 0x1E, 0x7F, 0x81, 0xE7,
  0xFC, 0x0F, 0x7F, 0xF0, 0x7F, 0x9F, 0x83, 0xF0, 0x7C, 0x1F, 0x03, 0xE1,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xC0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xE7, 0xE0, 0xF8,
  0x3F, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0xFF, 0x00, 0x1E, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0x71, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xE1, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xDF,
  0xF8, 0x03, 0xEF, 0xF8, 0x01, 0xF3, 0xF8, 0x00, 0xF8, 0x60, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x3C, 0x07, 0xFC, 0xF0, 0x3F, 0xF7, 0xC1, 0xFF, 0xFE, 0x07, 0xE7, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x07,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80,
  0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x3F, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0xF0,
  0x0F, 0xF7, 0xC0, 0x1F, 0x9F, 0x00, 0x10, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC7, 0xC0, 0xF3, 0xF0, 0x7D,
  0xF8, 0x1E, 0xFE, 0x07, 0xBF, 0x81, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xC3, 0x87,
  0xC0, 0x41, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC2, 0x01, 0xF0, 0xC0, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7F, 0xC7, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE3, 0xFF, 0x83, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x03, 0xF8, 0x02, 0x00, 0x07,
  0xC0, 0x78, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x78, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0x80, 0x78, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x1F,
  0x07, 0xF0, 0xFC, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFB, 0xC0, 0xFF, 0x9E,
  0x03, 0xF8, 0xE0, 0x02, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0x7E, 0x07, 0xFE, 0x07,
  0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x1F, 0x7C, 0x1F, 0xC0,
  0xF3, 0xE0, 0xFE, 0x0F, 0x9F, 0x0F, 0xF0, 0x7C, 0xF8, 0x7F, 0x83, 0xC7,
  0xC3, 0xFC, 0x3E, 0x3E, 0x3D, 0xE1, 0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x9E,
  0x78, 0xF8, 0x7C, 0xF3, 0xC7, 0x83, 0xE7, 0x9E, 0x7C, 0x1F, 0x78, 0xF3,
  0xC0, 0xF3, 0xC7, 0x9E, 0x07, 0x9E, 0x3D, 0xF0, 0x3D, 0xE1, 0xEF, 0x01,
  0xEF, 0x0F, 0xF8, 0x0F, 0x70, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x0F, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0xF9, 0xF0,
  0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0B,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x17, 0xFE, 0x03, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFE, 0x80, 0x07, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 38, 13, 0, -38 },
  { 68, 16, 14, 19, 5, -38 },
  { 96, 25, 38, 23, 0, -38 },
  { 215, 22, 43, 21, 0, -40 },
  { 334, 29, 39, 34, 3, -38 },
  { 476, 24, 39, 24, 0, -38 },
  { 593, 8, 14, 11, 5, -38 },
  { 607, 16, 46, 14, 1, -38 },
  { 699, 17, 46, 14, -4, -38 },
  { 797, 17, 19, 20, 5, -41 },
  { 838, 20, 25, 23, 2, -31 },
  { 901, 10, 13, 11, -3, -6 },
  { 918, 12, 5, 14, 1, -17 },
  { 926, 7, 7, 11, 0, -7 },
  { 933, 25, 38, 18, -3, -38 },
  { 1052, 20, 39, 21, 1, -38 },
  { 1150, 15, 38, 21, 5, -38 },
  { 1222, 23, 38, 21, -2, -38 },
  { 1332, 23, 39, 21, -1, -38 },
  { 1445, 23, 38, 21, -1, -38 },
  { 1555, 22, 39, 21, 0, -38 },
  { 1663, 22, 39, 21, 1, -38 },
  { 1771, 22, 38, 21, 2, -38 },
  { 1876, 22, 39, 21, 0, -38 },
  { 1984, 21, 39, 21, 0, -38 },
  { 2087, 11, 29, 11, 0, -29 },
  { 2127, 14, 36, 11, -3, -29 },
  { 2190, 20, 24, 23, 2, -31 },
  { 2250, 20, 15, 23, 2, -26 },
  { 2288, 20, 24, 23, 2, -31 },
  { 2348, 17, 38, 16, 1, -38 },
  { 2429, 31, 42, 32, 1, -38 },
  { 2592, 22, 38, 22, -3, -38 },
  { 2697, 24, 38, 23, 0, -38 },
  { 2811, 23, 39, 21, 2, -38 },
  { 2924, 25, 38, 25, 0, -38 },
  { 3043, 22, 38, 20, 0, -38 },
  { 3148, 22, 38, 19, 0, -38 },
  { 3253, 26, 39, 27, 2, -38 },
  { 3380, 28, 38, 26, 0, -38 },
  { 3513, 22, 38, 15, -3, -38 },
  { 3618, 21, 49, 11, -8, -38 },
  { 3747, 27, 38, 22, 0, -38 },
  { 3876, 15, 38, 19, 0, -38 },
  { 3948, 36, 38, 35, 0, -38 },
  { 4119, 29, 38, 28, 0, -38 },
  { 4257, 24, 39, 27, 2, -38 },
  { 4374, 24, 38, 22, 0, -38 },
  { 4488, 24, 47, 27, 2, -38 },
  { 4629, 23, 38, 23, 0, -38 },
  { 4739, 24, 39, 20, -1, -38 },
  { 4856, 19, 38, 19, 4, -38 },
  { 4947, 25, 39, 26, 2, -38 },
  { 5069, 22, 38, 22, 5, -38 },
  { 5174, 36, 38, 35, 4, -38 },
  { 5345, 27, 38, 21, -3, -38 },
  { 5474, 21, 38, 20, 4, -38 },
  { 5574, 24, 38, 19, -2, -38 },
  { 5688, 21, 46, 15, -2, -38 },
  { 5809, 10, 38, 19, 5, -38 },
  { 5857, 21, 46, 15, -4, -38 },
  { 5978, 22, 21, 22, 0, -38 },
  { 6036, 17, 4, 16, -5, 4 },
  { 6045, 8, 9, 14, 8, -41 },
  { 6054, 22, 30, 23, 1, -29 },
  { 6137, 22, 41, 23, 0, -40 },
  { 6250, 18, 30, 18, 1, -29 },
  { 6318, 25, 41, 23, 1, -40 },
  { 6447, 19, 30, 21, 1, -29 },
  { 6519, 25, 54, 13, -6, -41 },
  { 6688, 24, 42, 23, -1, -29 },
  { 6814, 21, 40, 23, 0, -40 },
  { 6919, 13, 39, 11, 0, -39 },
  { 6983, 20, 52, 11, -7, -39 },
  { 7113, 23, 40, 20, 0, -40 },
  { 7228, 13, 40, 11, 0, -40 },
  { 7293, 32, 29, 33, 0, -29 },
  { 7409, 21, 29, 23, 0, -29 },
  { 7486, 20, 30, 22, 1, -29 },
  { 7561, 25, 41, 23, -3, -29 },
  { 7690, 22, 42, 23, 1, -29 },
  { 7806, 18, 29, 15, 0, -29 },
  { 7872, 18, 30, 17, 0, -29 },
  { 7940, 14, 36, 13, 1, -35 },
  { 8003, 21, 30, 23, 1, -29 },
  { 8082, 19, 29, 19, 3, -29 },
  { 8151, 29, 29, 30, 3, -29 },
  { 8257, 23, 29, 19, -2, -29 },
  { 8341, 27, 42, 19, -5, -29 },
  { 8483, 19, 29, 16, -2, -29 },
  { 8552, 20, 46, 18, 1, -38 },
  { 8667, 5, 53, 20, 7, -41 },
  { 8701, 19, 46, 17, -3, -38 },
  { 8811, 20, 7, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC53PT7B_H_
