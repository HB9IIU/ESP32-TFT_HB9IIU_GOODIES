#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x80, 0x7F, 0x60, 0x4D, 0x2C, 0x6D, 0x76, 0x4B, 0xE0, 0x80,
  0x6A, 0x80, 0xF8, 0xB8, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A, 0x40, 0xFF,
  0xF0, 0xD7, 0x57, 0x7D, 0xF7, 0x7B, 0x60, 0x69, 0x40, 0xEB, 0x60, 0xF7,
  0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F, 0x00, 0xDA, 0x7F, 0xAC, 0x40, 0x7F,
  0x7A, 0xE0, 0x72, 0x60, 0x76, 0xE0, 0x7A, 0x60, 0x7A, 0x40, 0x72, 0xF0,
  0x7E, 0xD0, 0x6A, 0x55, 0xC0, 0x6B, 0x60, 0x6B, 0x57, 0xFD, 0x6E, 0xD0,
  0x76, 0xE0, 0x77, 0x40, 0x76, 0xE4, 0x77, 0x60, 0xF1, 0x60, 0xE9, 0x40,
  0xB6, 0xE0, 0xEA, 0xBB, 0xEA, 0x69, 0x60, 0xA9, 0x40, 0x5B, 0x6A, 0x80,
  0xF0, 0x56, 0x80, 0x70, 0xC0, 0x80, 0xFB, 0x00, 0x6F, 0xC0, 0xEC, 0x2E,
  0xEC, 0xEC, 0x25, 0x25, 0x80, 0xFB, 0x60, 0x6F, 0xC0, 0x70, 0x15, 0xC0,
  0x55, 0x6C, 0x5A, 0x80, 0xFD, 0xE0, 0xFC, 0xFC, 0xFE, 0xFB, 0x20, 0xE8,
  0xDC, 0x6A, 0xBB, 0x00, 0xF8, 0xDA, 0xA0, 0xDC, 0x6D, 0x60, 0xE8, 0x5A,
  0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 2, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 3, 2, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 3, 4, 2, 0, -4 },
  { 23, 2, 4, 2, 0, -4 },
  { 24, 1, 4, 2, 1, -4 },
  { 25, 2, 4, 2, 0, -4 },
  { 26, 2, 4, 2, 0, -4 },
  { 27, 2, 4, 2, 0, -4 },
  { 28, 2, 4, 2, 0, -4 },
  { 29, 3, 4, 2, 0, -4 },
  { 31, 3, 4, 2, 0, -4 },
  { 33, 3, 4, 2, 0, -4 },
  { 35, 2, 4, 2, 0, -4 },
  { 36, 1, 3, 1, 0, -3 },
  { 37, 1, 4, 1, 0, -3 },
  { 38, 3, 3, 3, 0, -4 },
  { 40, 3, 2, 3, 0, -3 },
  { 41, 3, 3, 3, 0, -4 },
  { 43, 2, 4, 2, 0, -4 },
  { 44, 4, 5, 4, 0, -4 },
  { 47, 2, 4, 3, 0, -4 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 3, 4, 2, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 2, 0, -4 },
  { 56, 3, 4, 2, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 1, -1, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 3, 4, 3, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 5, 3, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 3, 4, 2, 0, -4 },
  { 82, 3, 4, 2, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 2, 4, 3, 1, -4 },
  { 87, 4, 4, 4, 0, -4 },
  { 89, 3, 4, 2, 0, -4 },
  { 91, 3, 4, 2, 0, -4 },
  { 93, 2, 4, 2, 0, -4 },
  { 94, 2, 5, 2, 0, -4 },
  { 96, 1, 4, 2, 1, -4 },
  { 97, 2, 5, 2, 0, -4 },
  { 99, 2, 2, 2, 0, -4 },
  { 100, 2, 1, 2, -1, 0 },
  { 101, 1, 1, 2, 1, -5 },
  { 102, 3, 3, 3, 0, -3 },
  { 104, 2, 5, 3, 0, -5 },
  { 106, 2, 3, 2, 0, -3 },
  { 107, 3, 5, 3, 0, -5 },
  { 109, 2, 3, 2, 0, -3 },
  { 110, 3, 6, 1, -1, -5 },
  { 113, 3, 4, 3, 0, -3 },
  { 115, 2, 5, 3, 0, -5 },
  { 117, 1, 4, 1, 0, -4 },
  { 118, 2, 5, 1, -1, -4 },
  { 120, 3, 5, 2, 0, -5 },
  { 122, 2, 5, 1, 0, -5 },
  { 124, 4, 3, 4, 0, -3 },
  { 126, 2, 3, 3, 0, -3 },
  { 127, 2, 3, 3, 0, -3 },
  { 128, 2, 4, 3, 0, -3 },
  { 129, 3, 4, 3, 0, -3 },
  { 131, 2, 3, 2, 0, -3 },
  { 132, 2, 3, 2, 0, -3 },
  { 133, 2, 4, 2, 0, -4 },
  { 134, 3, 3, 3, 0, -3 },
  { 136, 2, 3, 2, 0, -3 },
  { 137, 4, 3, 3, 0, -3 },
  { 139, 2, 3, 2, 0, -3 },
  { 140, 3, 4, 2, -1, -3 },
  { 142, 2, 3, 2, 0, -3 },
  { 143, 2, 5, 2, 0, -4 },
  { 145, 1, 6, 2, 1, -5 },
  { 146, 2, 5, 2, 0, -4 },
  { 148, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC6PT7B_H_
