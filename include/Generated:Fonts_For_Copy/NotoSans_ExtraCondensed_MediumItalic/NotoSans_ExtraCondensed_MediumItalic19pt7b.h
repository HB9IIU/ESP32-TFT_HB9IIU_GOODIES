#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC4, 0x63, 0x18, 0x84, 0x63, 0x00, 0x0C, 0x60, 0x6F, 0x2D,
  0xB6, 0x90, 0x0D, 0x84, 0x82, 0x43, 0x67, 0xFB, 0xFC, 0xD8, 0x48, 0x25,
  0x7F, 0x1A, 0x09, 0x04, 0x86, 0xC0, 0x04, 0x1E, 0x3F, 0x28, 0x28, 0x38,
  0x38, 0x1C, 0x16, 0x16, 0x16, 0xDC, 0xF8, 0x20, 0x20, 0x30, 0x8F, 0x11,
  0x24, 0x6D, 0x89, 0xA1, 0x2C, 0x25, 0x77, 0xEB, 0x6B, 0x43, 0x48, 0x49,
  0x19, 0x62, 0x28, 0xC7, 0x00, 0x0C, 0x1E, 0x12, 0x32, 0x36, 0x1C, 0x18,
  0x39, 0x6B, 0xCF, 0xCE, 0xCE, 0xDE, 0x76, 0x6B, 0x6C, 0x04, 0x21, 0x84,
  0x30, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x04, 0x10, 0x60, 0x18, 0x60,
  0x82, 0x08, 0x30, 0x82, 0x18, 0x61, 0x84, 0x30, 0x86, 0x10, 0xC0, 0x20,
  0xCB, 0x3F, 0x73, 0x45, 0x80, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08,
  0x10, 0x36, 0x64, 0xC0, 0x7F, 0x80, 0xF0, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0x0C,
  0x1E, 0x33, 0x33, 0x23, 0x63, 0x62, 0x66, 0x46, 0xC6, 0xC4, 0xCC, 0x78,
  0x70, 0x19, 0xDF, 0xAB, 0x18, 0xC6, 0x23, 0x18, 0xC6, 0x60, 0x06, 0x0F,
  0x84, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x04, 0x07,
  0xE7, 0xF0, 0x0C, 0x3E, 0x23, 0x03, 0x02, 0x06, 0x3C, 0x3C, 0x0C, 0x06,
  0x04, 0x0C, 0x9C, 0xF8, 0x03, 0x07, 0x06, 0x0E, 0x1E, 0x16, 0x26, 0x64,
  0x4C, 0xCC, 0xFE, 0x08, 0x08, 0x18, 0x1F, 0x1F, 0x30, 0x30, 0x20, 0x20,
  0x7C, 0x0E, 0x06, 0x06, 0x06, 0x0C, 0x9C, 0xF8, 0x07, 0x0F, 0x18, 0x30,
  0x20, 0x6C, 0x7E, 0x66, 0x66, 0x46, 0xC6, 0x44, 0x6C, 0x78, 0x7F, 0x7E,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0,
  0x0E, 0x3F, 0x33, 0x23, 0x23, 0x36, 0x1C, 0x3C, 0x6C, 0xC6, 0xC6, 0xC6,
  0xCC, 0x78, 0x0C, 0x1E, 0x33, 0x63, 0x63, 0x63, 0x66, 0x7E, 0x3E, 0x06,
  0x0C, 0x0C, 0xB8, 0xF0, 0x33, 0x00, 0x00, 0x00, 0xCC, 0x18, 0xC0, 0x00,
  0x00, 0x00, 0x33, 0x11, 0x88, 0x00, 0x02, 0x1C, 0xE7, 0x0C, 0x0E, 0x07,
  0x03, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x81, 0xC0, 0xE0, 0x70, 0xE7,
  0xBC, 0x60, 0x80, 0x18, 0x79, 0x18, 0x20, 0xC1, 0x06, 0x18, 0x20, 0xC0,
  0x00, 0x0E, 0x18, 0x00, 0x03, 0x81, 0xD8, 0x60, 0x88, 0x12, 0x7A, 0x4B,
  0x52, 0x4A, 0x49, 0x5B, 0x6B, 0x6B, 0x77, 0x66, 0xC4, 0x00, 0x80, 0x0F,
  0x80, 0x40, 0x07, 0x07, 0x07, 0x0F, 0x0B, 0x1B, 0x1B, 0x13, 0x3F, 0x3F,
  0x63, 0x63, 0xC3, 0xC3, 0x1C, 0x0F, 0x8C, 0xE6, 0x33, 0x11, 0x98, 0xF8,
  0xFC, 0x62, 0x31, 0x18, 0x88, 0xCF, 0xE7, 0xC0, 0x0E, 0x1F, 0x30, 0x60,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE8, 0x78, 0x1C, 0x0F,
  0x8C, 0xE6, 0x33, 0x19, 0x8C, 0x86, 0xC3, 0x63, 0x31, 0x98, 0xC8, 0xCF,
  0xC7, 0xC0, 0x1F, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x7C, 0x60, 0x60,
  0x60, 0x40, 0xF8, 0xF8, 0x1F, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x20, 0x7C,
  0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x0F, 0x0F, 0xCC, 0x2C, 0x06, 0x06,
  0x03, 0x01, 0x9E, 0xC3, 0x61, 0x31, 0x98, 0xCE, 0xE3, 0xE0, 0x18, 0xC4,
  0x33, 0x08, 0xC6, 0x31, 0x8C, 0x63, 0xF9, 0xFC, 0x63, 0x18, 0xC6, 0x31,
  0x0C, 0xC2, 0x31, 0x80, 0x1F, 0x1E, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x30, 0xF0, 0xE0,
  0x18, 0xC4, 0x63, 0x30, 0xCC, 0x36, 0x0F, 0x02, 0x81, 0xF0, 0x6C, 0x1B,
  0x06, 0xC1, 0x30, 0xC6, 0x31, 0x80, 0x18, 0x8C, 0x63, 0x18, 0x8C, 0x63,
  0x18, 0x8F, 0xFC, 0x18, 0x38, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x14,
  0x78, 0xA2, 0xCD, 0xB6, 0x6D, 0x23, 0x7B, 0x13, 0x98, 0x9C, 0xCC, 0xE4,
  0x66, 0x60, 0x18, 0x63, 0x08, 0xE3, 0x1C, 0x63, 0xCC, 0x59, 0x0B, 0x23,
  0x2C, 0x65, 0x8C, 0xB1, 0x1C, 0x23, 0x8C, 0x71, 0x86, 0x00, 0x0E, 0x1F,
  0x33, 0x61, 0x61, 0xC1, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFC, 0x78,
  0x1C, 0x1F, 0x33, 0x31, 0x31, 0x33, 0x23, 0x7E, 0x7C, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0x0E, 0x1F, 0x33, 0x61, 0x61, 0xC1, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC6, 0xC6, 0xFC, 0x78, 0x18, 0x18, 0x1C, 0x1C, 0x1F, 0x33, 0x33, 0x33,
  0x33, 0x27, 0x7E, 0x6C, 0x6C, 0x4C, 0x4C, 0xC6, 0xC6, 0x0E, 0x3F, 0x31,
  0x20, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0xFC, 0xF8, 0x7E,
  0xFE, 0x61, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x00,
  0x31, 0x90, 0xD8, 0x4C, 0x66, 0x33, 0x1B, 0x09, 0x8C, 0xC6, 0x63, 0x21,
  0x99, 0x8D, 0xC7, 0xC0, 0x83, 0x86, 0x86, 0x8C, 0x8C, 0x88, 0x98, 0x98,
  0xB0, 0xB0, 0xA0, 0xE0, 0xC0, 0xC0, 0x43, 0x1A, 0x18, 0xD1, 0xC4, 0x8E,
  0x64, 0x73, 0x27, 0xB1, 0x2D, 0x9B, 0x48, 0xDA, 0xC6, 0x96, 0x3C, 0xA1,
  0xC7, 0x0E, 0x30, 0x71, 0x80, 0x18, 0xC6, 0x61, 0x98, 0x6C, 0x0A, 0x03,
  0x80, 0xC0, 0x30, 0x1C, 0x0D, 0x03, 0x61, 0x98, 0x66, 0x31, 0x80, 0x43,
  0x66, 0x66, 0x6C, 0x6C, 0x78, 0x78, 0x70, 0x30, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0x1F, 0x8F, 0xC0, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18,
  0x0C, 0x0C, 0x07, 0xC7, 0xE0, 0x0F, 0x0E, 0x08, 0x18, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0xF0, 0xDB, 0x6C,
  0x92, 0x6D, 0xB6, 0x40, 0x1E, 0x3C, 0x18, 0x20, 0xC1, 0x83, 0x04, 0x08,
  0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0xF0, 0x04, 0x0C, 0x1C, 0x16, 0x36,
  0x22, 0x62, 0xC3, 0xFC, 0xD9, 0x80, 0x1D, 0x33, 0x63, 0x62, 0x62, 0x46,
  0xC6, 0xC6, 0x6C, 0x74, 0x18, 0x10, 0x30, 0x30, 0x3E, 0x33, 0x23, 0x63,
  0x63, 0x62, 0x46, 0xC6, 0xEC, 0xF8, 0x1E, 0x65, 0x83, 0x06, 0x08, 0x30,
  0x60, 0x68, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x21, 0xF1, 0x99, 0x8C, 0xC4,
  0x62, 0x23, 0x31, 0x98, 0xC6, 0xC3, 0xA0, 0x1E, 0x65, 0x8B, 0x37, 0xC8,
  0x30, 0x60, 0x64, 0xF8, 0x01, 0x03, 0xC1, 0x80, 0x80, 0xC0, 0xF0, 0x30,
  0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x38, 0x10, 0x00, 0x1D, 0x33, 0x63, 0x62, 0x62, 0x46, 0xC6, 0xC6, 0x6C,
  0x7C, 0x0C, 0x0C, 0x98, 0xF8, 0x60, 0x18, 0x10, 0x30, 0x30, 0x3E, 0x33,
  0x22, 0x62, 0x66, 0x66, 0x46, 0xC4, 0xC4, 0xCC, 0x18, 0x80, 0x03, 0x10,
  0x8C, 0x63, 0x11, 0x8C, 0x60, 0x06, 0x08, 0x00, 0x00, 0xC1, 0x82, 0x0C,
  0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x61, 0xC2, 0x00, 0x18, 0x10,
  0x30, 0x30, 0x33, 0x26, 0x2C, 0x78, 0x78, 0x68, 0x48, 0x4C, 0xCC, 0xCC,
  0x18, 0x8C, 0x63, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x60, 0x3E, 0xE3, 0x33,
  0x22, 0x26, 0x66, 0x66, 0x66, 0x66, 0x46, 0x6C, 0x44, 0xCC, 0xCC, 0xCC,
  0x3E, 0x33, 0x22, 0x62, 0x66, 0x66, 0x46, 0xC4, 0xC4, 0xCC, 0x1E, 0x36,
  0x63, 0x62, 0x42, 0x46, 0xC6, 0xC6, 0x6C, 0x78, 0x1F, 0x0C, 0xC4, 0x66,
  0x33, 0x19, 0x88, 0x8C, 0x46, 0x76, 0x3E, 0x18, 0x08, 0x0C, 0x06, 0x00,
  0x1D, 0x33, 0x63, 0x62, 0x62, 0x46, 0xC6, 0xC6, 0x6C, 0x7C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x2C, 0xF3, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x00, 0x3E,
  0xC9, 0x83, 0x03, 0x03, 0x06, 0x0C, 0x99, 0xE0, 0x10, 0x8C, 0xF3, 0x11,
  0x8C, 0x62, 0x11, 0xA7, 0x00, 0x33, 0x23, 0x22, 0x62, 0x66, 0x66, 0x46,
  0x4C, 0xEC, 0x7C, 0xC7, 0x9B, 0x36, 0xCD, 0x9A, 0x3C, 0x70, 0xE1, 0x80,
  0xCC, 0x79, 0x9B, 0x73, 0x6A, 0xCD, 0x59, 0xEA, 0x39, 0xC7, 0x38, 0xC6,
  0x18, 0xC0, 0x33, 0x89, 0x87, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x58, 0x64,
  0x63, 0x00, 0x18, 0xC6, 0x61, 0x98, 0x6C, 0x1B, 0x06, 0x81, 0xE0, 0x70,
  0x1C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x3C, 0x04, 0x00, 0x3E, 0x0C, 0x30,
  0x61, 0x82, 0x0C, 0x30, 0x65, 0xF0, 0x03, 0x0E, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x60, 0xE0, 0x30, 0x30, 0x20, 0x60, 0x60, 0x70, 0x30, 0xFF,
  0xFF, 0xE0, 0x10, 0x38, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x0E, 0x38, 0x60,
  0x83, 0x06, 0x0C, 0x70, 0xC0, 0xE3, 0xFE, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 9, 14, 8, 0, -14 },
  { 30, 8, 15, 8, 0, -14 },
  { 45, 11, 14, 12, 1, -14 },
  { 65, 8, 14, 9, 0, -14 },
  { 79, 3, 5, 4, 2, -14 },
  { 81, 6, 17, 5, 0, -14 },
  { 94, 6, 17, 5, -1, -14 },
  { 107, 6, 7, 7, 2, -15 },
  { 113, 7, 9, 8, 1, -11 },
  { 121, 4, 5, 4, -1, -2 },
  { 124, 5, 2, 5, 0, -6 },
  { 126, 2, 2, 4, 0, -2 },
  { 127, 9, 14, 7, -1, -14 },
  { 143, 8, 14, 8, 0, -14 },
  { 157, 5, 14, 8, 2, -14 },
  { 166, 9, 14, 8, -1, -14 },
  { 182, 8, 14, 8, 0, -14 },
  { 196, 8, 14, 8, 0, -14 },
  { 210, 8, 14, 8, 0, -14 },
  { 224, 8, 14, 8, 0, -14 },
  { 238, 8, 14, 8, 1, -14 },
  { 252, 8, 14, 8, 0, -14 },
  { 266, 8, 14, 8, 0, -14 },
  { 280, 4, 10, 4, 0, -10 },
  { 285, 5, 13, 4, -1, -10 },
  { 294, 7, 9, 8, 1, -11 },
  { 302, 7, 5, 8, 1, -9 },
  { 307, 7, 9, 8, 1, -11 },
  { 315, 7, 14, 6, 0, -14 },
  { 328, 11, 16, 11, 0, -14 },
  { 350, 8, 14, 8, -1, -14 },
  { 364, 9, 14, 8, 0, -14 },
  { 380, 8, 14, 8, 1, -14 },
  { 394, 9, 14, 9, 0, -14 },
  { 410, 8, 14, 7, 0, -14 },
  { 424, 8, 14, 7, 0, -14 },
  { 438, 9, 14, 10, 1, -14 },
  { 454, 10, 14, 9, 0, -14 },
  { 472, 8, 14, 5, -1, -14 },
  { 486, 8, 18, 4, -3, -14 },
  { 504, 10, 14, 8, 0, -14 },
  { 522, 5, 14, 7, 0, -14 },
  { 531, 13, 14, 13, 0, -14 },
  { 554, 11, 14, 10, 0, -14 },
  { 574, 8, 14, 10, 1, -14 },
  { 588, 8, 14, 8, 0, -14 },
  { 602, 8, 17, 10, 1, -14 },
  { 619, 8, 14, 8, 0, -14 },
  { 633, 8, 14, 7, 0, -14 },
  { 647, 7, 14, 7, 1, -14 },
  { 660, 9, 14, 9, 1, -14 },
  { 676, 8, 14, 8, 2, -14 },
  { 690, 13, 14, 13, 1, -14 },
  { 713, 10, 14, 7, -1, -14 },
  { 731, 8, 14, 7, 1, -14 },
  { 745, 9, 14, 7, -1, -14 },
  { 761, 8, 17, 5, -1, -14 },
  { 778, 3, 14, 7, 2, -14 },
  { 784, 7, 17, 5, -1, -14 },
  { 799, 8, 8, 8, 0, -14 },
  { 807, 6, 1, 6, -2, 2 },
  { 808, 3, 3, 5, 3, -15 },
  { 810, 8, 10, 8, 0, -10 },
  { 820, 8, 14, 8, 0, -14 },
  { 834, 7, 10, 6, 0, -10 },
  { 843, 9, 14, 8, 0, -14 },
  { 859, 7, 10, 7, 0, -10 },
  { 868, 9, 20, 5, -2, -15 },
  { 891, 8, 15, 8, 0, -10 },
  { 906, 8, 14, 8, 0, -14 },
  { 920, 5, 14, 4, 0, -14 },
  { 929, 7, 19, 4, -2, -14 },
  { 946, 8, 14, 7, 0, -14 },
  { 960, 5, 14, 4, 0, -14 },
  { 969, 12, 10, 12, 0, -10 },
  { 984, 8, 10, 8, 0, -10 },
  { 994, 8, 10, 8, 0, -10 },
  { 1004, 9, 14, 8, -1, -10 },
  { 1020, 8, 15, 8, 0, -10 },
  { 1035, 6, 10, 6, 0, -10 },
  { 1043, 7, 10, 6, 0, -10 },
  { 1052, 5, 13, 5, 0, -13 },
  { 1061, 8, 10, 8, 0, -10 },
  { 1071, 7, 10, 7, 1, -10 },
  { 1080, 11, 10, 11, 1, -10 },
  { 1094, 9, 10, 7, -1, -10 },
  { 1106, 10, 15, 7, -2, -10 },
  { 1125, 7, 10, 6, -1, -10 },
  { 1134, 8, 17, 6, 0, -14 },
  { 1151, 1, 19, 7, 3, -15 },
  { 1154, 7, 17, 6, -1, -14 },
  { 1169, 7, 3, 8, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC19PT7B_H_
