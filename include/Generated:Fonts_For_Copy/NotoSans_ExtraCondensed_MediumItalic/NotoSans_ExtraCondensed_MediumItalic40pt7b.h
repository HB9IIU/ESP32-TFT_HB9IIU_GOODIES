#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x0F, 0x83, 0xE0,
  0x70, 0x00, 0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x9E, 0x71, 0xE7, 0x1E, 0x71,
  0xCF, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x01, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xC7, 0x00,
  0x70, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xC7, 0x00, 0x30, 0xE0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x0E, 0x38, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x04, 0x00, 0x1F,
  0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0x9C, 0x1E, 0x42, 0x0E, 0x60, 0x0F,
  0x30, 0x07, 0x98, 0x01, 0xC8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x6F, 0x00, 0x37, 0x80, 0x11,
  0xC0, 0x08, 0xE0, 0x0C, 0xF1, 0x06, 0x78, 0xF3, 0x78, 0x7F, 0xF8, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18, 0x00,
  0x07, 0x80, 0x70, 0x3F, 0x01, 0x81, 0xFC, 0x0E, 0x0E, 0x70, 0x70, 0x39,
  0xC1, 0xC1, 0xC7, 0x0E, 0x07, 0x1C, 0x38, 0x1C, 0x71, 0xC0, 0x61, 0xC7,
  0x03, 0x87, 0x38, 0x0E, 0x1C, 0xE0, 0x38, 0xE7, 0x08, 0xE3, 0x9C, 0xFB,
  0x8E, 0xE7, 0xFE, 0x73, 0xB9, 0xFF, 0x9C, 0xE7, 0x7E, 0x77, 0x1C, 0xE3,
  0x9C, 0x70, 0x0E, 0x71, 0xC0, 0x73, 0x87, 0x01, 0x8E, 0x1C, 0x0E, 0x38,
  0x60, 0x70, 0xE3, 0x81, 0xC3, 0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x39, 0xC1,
  0xC0, 0xEF, 0x07, 0x03, 0xF8, 0x38, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0xE0,
  0x1C, 0x78, 0x07, 0x1C, 0x01, 0xEF, 0x00, 0x7B, 0x80, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x8F, 0x1D, 0xE3, 0x8F, 0x39,
  0xE7, 0x8F, 0x79, 0xC3, 0xDC, 0xF0, 0xFF, 0x3C, 0x1F, 0x8F, 0x07, 0xE3,
  0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0x78, 0x3F,
  0x1F, 0x00, 0x3C, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0xF3, 0x8E, 0x00, 0x00,
  0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x00, 0x04, 0x00, 0x3C,
  0x01, 0xC1, 0x0E, 0x0E, 0x70, 0x7F, 0x9B, 0xFF, 0xC3, 0xFF, 0x0F, 0x00,
  0xFC, 0x0E, 0xE1, 0xF3, 0x87, 0x1E, 0x10, 0xE0, 0x04, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3B, 0xFF, 0xF7, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0xF1, 0xE1,
  0xC3, 0xC7, 0x83, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x7B, 0xC0,
  0xF7, 0x81, 0xEF, 0x03, 0x9E, 0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B,
  0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x70, 0x78, 0xF1,
  0xE1, 0xE7, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x7C,
  0x1F, 0x07, 0xE1, 0xFC, 0x7F, 0x9E, 0xF7, 0x9C, 0x67, 0x88, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xF0, 0x30, 0x78,
  0x10, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x79, 0xF0,
  0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x80, 0x7C, 0x60, 0x7C, 0x3F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0xFE, 0x00, 0xEF,
  0x00, 0x67, 0x00, 0x73, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x38, 0xF0, 0x38,
  0x70, 0x1C, 0x38, 0x1C, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x0E, 0x07, 0x07,
  0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x80, 0xF8,
  0x60, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xF2, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x39, 0xF0, 0x7B, 0xF8, 0x7F,
  0xF8, 0x7E, 0x7C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF9,
  0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E,
  0x1C, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0xC7, 0x81, 0xF7, 0x80, 0x7F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x1E,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0xF1, 0xE0, 0x78,
  0xF0, 0x38, 0x78, 0x3C, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xDF, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x3E, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xDE, 0x02,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0x0F, 0x0F,
  0x0F, 0x0F, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x00, 0xC0, 0x78, 0x0F, 0x81,
  0xE0, 0x3C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00,
  0xC0, 0x01, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x39, 0xF1, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x03,
  0x07, 0x00, 0x07, 0x1C, 0x1F, 0xCE, 0x38, 0x7F, 0x1C, 0xE1, 0xCE, 0x39,
  0xC7, 0x1C, 0x73, 0x0E, 0x38, 0xEE, 0x38, 0x61, 0x9C, 0x71, 0xC3, 0x30,
  0xC3, 0x8E, 0x63, 0x87, 0x1D, 0xC7, 0x0C, 0x33, 0x8E, 0x38, 0x67, 0x1C,
  0x71, 0xCE, 0x39, 0xE3, 0x1C, 0x73, 0xCE, 0x38, 0xFD, 0xF8, 0x70, 0xF3,
  0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x83, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0xE0,
  0x1C, 0x70, 0x1E, 0x38, 0x0F, 0x1C, 0x0F, 0x0E, 0x07, 0x87, 0x03, 0x83,
  0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF,
  0x80, 0x78, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07,
  0x87, 0xC1, 0xE0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x3F, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C,
  0x0F, 0x0E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x1C, 0x3F,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xC1, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x0C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x78, 0x7C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0xF0, 0x70, 0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78,
  0x7C, 0x0F, 0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x08, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x20, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xBE, 0x07, 0xC0, 0x60, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x3F, 0xC7, 0x83, 0xF8, 0x78, 0x3F, 0x87, 0x80, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F, 0x00, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0xE0, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xE0, 0x1C,
  0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1, 0xE0,
  0x1C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1C, 0x03,
  0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1C,
  0x03, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x3C, 0x03, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0xF0,
  0x3C, 0x1F, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x78,
  0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00, 0x3C,
  0x78, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x38, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0x78,
  0x3B, 0x81, 0xEE, 0x07, 0x78, 0x3B, 0xC1, 0xEF, 0x07, 0x78, 0x3D, 0xE1,
  0xCF, 0x07, 0xBC, 0x39, 0xC0, 0xE7, 0x8F, 0x38, 0x1C, 0xF1, 0xCF, 0x07,
  0x8E, 0x79, 0xE0, 0xF1, 0xCE, 0x3C, 0x1E, 0x3B, 0xC7, 0x03, 0x87, 0x71,
  0xE0, 0x70, 0xEE, 0x3C, 0x1E, 0x1F, 0x87, 0x83, 0xC3, 0xF0, 0xF0, 0x70,
  0x7C, 0x1C, 0x0E, 0x0F, 0x87, 0x83, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x80, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x03,
  0xC1, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x83,
  0xFC, 0x1E, 0x0F, 0xF0, 0x70, 0x3D, 0xC1, 0xC0, 0xE7, 0x0F, 0x03, 0x9C,
  0x3C, 0x1E, 0x70, 0xF0, 0x79, 0xE3, 0x81, 0xE7, 0x8E, 0x07, 0x0E, 0x78,
  0x1C, 0x39, 0xE0, 0xF0, 0xE7, 0x83, 0xC3, 0x9C, 0x0F, 0x0F, 0x70, 0x38,
  0x3F, 0xC0, 0xE0, 0x7F, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x70, 0x1F,
  0x81, 0xC0, 0x7E, 0x0F, 0x01, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x78, 0x3C,
  0x1F, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F,
  0x8F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x78,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x38, 0x1E,
  0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xE3, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xFC, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x78, 0x3C, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03,
  0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0xF0,
  0x78, 0x3E, 0x0F, 0x8F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFE, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x70, 0x3C, 0x3C, 0x0F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1E, 0x1E, 0x0F, 0x07, 0x87,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xF1, 0xC0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xC1, 0x83, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x40, 0x7C, 0x3C, 0x3E, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x70,
  0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x0E,
  0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0x83,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xE0, 0x70, 0x1E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x87,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x07, 0xF8,
  0x03, 0xDC, 0x03, 0xCE, 0x01, 0xE7, 0x00, 0xE3, 0x80, 0xF1, 0xC0, 0x78,
  0xE0, 0x78, 0x70, 0x3C, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x0F,
  0x03, 0x87, 0x81, 0xC7, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xE0, 0x1C,
  0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x70,
  0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x78, 0x0F, 0x78, 0x0F, 0x01,
  0xEF, 0x03, 0xE0, 0x39, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xE7, 0x83,
  0xF0, 0x78, 0xF0, 0x7E, 0x0F, 0x1E, 0x0F, 0xC1, 0xC3, 0xC3, 0xB8, 0x78,
  0x78, 0x77, 0x0F, 0x0F, 0x1E, 0xE3, 0xC1, 0xE3, 0x9C, 0x78, 0x3C, 0x73,
  0x8E, 0x07, 0x9C, 0x73, 0xC0, 0xF3, 0x8E, 0x78, 0x1E, 0xF1, 0xDE, 0x03,
  0xDC, 0x3B, 0xC0, 0x7B, 0x87, 0x70, 0x0E, 0xE0, 0xFE, 0x01, 0xDC, 0x1F,
  0xC0, 0x3F, 0x87, 0x70, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC1, 0xE0, 0x1C, 0x1E, 0x01,
  0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00,
  0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xB8,
  0x00, 0x7B, 0x80, 0x07, 0x3C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x1C, 0x07, 0x01, 0xE0, 0xF0,
  0x1E, 0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x38,
  0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xE0, 0x79, 0xE0, 0x39, 0xC0,
  0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xE1, 0xE3, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF1,
  0xE3, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x3C, 0x78, 0xF0, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7F, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0x9C, 0x07, 0x1C, 0x0F, 0x1E, 0x0E,
  0x1E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFE, 0xF3, 0xC7, 0x9E, 0x38, 0xF1, 0xC0, 0x03, 0xC7,
  0x07, 0xF7, 0x0F, 0xF7, 0x1F, 0x3F, 0x1E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF1, 0xF8,
  0xFF, 0xF0, 0x7F, 0x70, 0x3E, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x3C,
  0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xCF, 0x0F, 0x0F, 0x1F, 0x07, 0x1E, 0x07,
  0x1E, 0x07, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x7C, 0x78,
  0xFF, 0xF8, 0xEF, 0xF0, 0xE7, 0xE0, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x3F,
  0x21, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x10, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x03, 0xC7, 0x01, 0xFD, 0xC0, 0xFF, 0xF0, 0x7C, 0xFC, 0x1E, 0x1F, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x07, 0x01,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x1F, 0x83, 0xFF, 0xC0, 0x7F, 0x70, 0x0F,
  0x9C, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xCF, 0x1E, 0x1C, 0xF0,
  0x73, 0x81, 0xDE, 0x0F, 0x78, 0x79, 0xC7, 0xCF, 0xFE, 0x3F, 0xF0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x02, 0x1F,
  0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF9, 0xC0, 0x7F, 0x70,
  0x3F, 0xDC, 0x1F, 0x3F, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x83,
  0xC7, 0xE0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xEF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x82, 0x03, 0xC0, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x3C, 0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xDF, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x70,
  0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x01, 0x80, 0xF0, 0x7C, 0x1E,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x30, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1,
  0xC3, 0xC0, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3D, 0xE0, 0x1D, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xE7, 0x00, 0xE3,
  0x80, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x1C, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x87, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x0E, 0x3C, 0x3C, 0x0E, 0xFE, 0x7E,
  0x0E, 0xFF, 0xFF, 0x0F, 0x9F, 0xCF, 0x0F, 0x0F, 0x8F, 0x1F, 0x0F, 0x0F,
  0x1E, 0x0F, 0x0F, 0x1E, 0x0E, 0x0F, 0x1C, 0x1E, 0x0F, 0x1C, 0x1E, 0x0E,
  0x3C, 0x1E, 0x0E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C, 0x1E, 0x38, 0x3C, 0x1E,
  0x78, 0x3C, 0x1C, 0x78, 0x3C, 0x3C, 0x78, 0x38, 0x3C, 0x70, 0x38, 0x3C,
  0x70, 0x78, 0x38, 0xF0, 0x78, 0x38, 0xF0, 0x70, 0x78, 0xF0, 0x70, 0x78,
  0x0E, 0x3C, 0x0E, 0x7E, 0x0E, 0xFF, 0x0F, 0xDF, 0x0F, 0x0F, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x38, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38,
  0x70, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x01, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0xF9, 0xE1, 0xE1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xE3, 0xC7, 0xC3, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x00, 0x03, 0x8F, 0x00, 0xE7, 0xE0, 0x3B, 0xFC, 0x0F, 0x8F, 0x03,
  0xC3, 0xC1, 0xF0, 0x70, 0x78, 0x1C, 0x1E, 0x07, 0x07, 0x03, 0xC1, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x81, 0xE0, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xE0, 0xFF, 0xF8, 0x3D,
  0xFC, 0x0F, 0x7E, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE7, 0x07, 0xF7, 0x0F, 0xF7, 0x1F, 0x3F, 0x1E, 0x1F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xF1, 0xF8, 0xFF, 0xF0, 0x7F, 0x70, 0x3E, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x38, 0x73, 0xC3, 0xBE, 0x1F, 0xF0, 0xF8,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x87, 0x8E, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x88,
  0x3C, 0x3F, 0xF0, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0F, 0xCF, 0xF7, 0xFD, 0xFF, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xF8, 0xFE, 0x1F, 0x80, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E,
  0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x38, 0x1C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0x70, 0xFF, 0x70, 0x7E, 0xE0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F,
  0x3C, 0x38, 0x71, 0xE1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x77, 0x81, 0xDC,
  0x07, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x70, 0x7C, 0x1F, 0xE0, 0xF0, 0x7B, 0xC1, 0xE0, 0xF7,
  0x87, 0xC1, 0xCF, 0x0F, 0x87, 0x9E, 0x3F, 0x0E, 0x3C, 0x7E, 0x1C, 0x78,
  0xFC, 0x78, 0xF3, 0xB8, 0xE1, 0xE7, 0x73, 0xC3, 0xCE, 0xE7, 0x07, 0xB9,
  0xCE, 0x0F, 0x73, 0xBC, 0x1F, 0xC7, 0x70, 0x3B, 0x8E, 0xE0, 0x77, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0,
  0x78, 0x78, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x0F,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x07, 0x9E, 0x03,
  0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x38, 0x3C, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x01, 0xC0, 0xF0, 0x1C, 0x1E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C,
  0x01, 0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x70, 0x01, 0xCF,
  0x00, 0x1C, 0xF0, 0x01, 0xCE, 0x00, 0x1D, 0xE0, 0x01, 0xDC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x02, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x01,
  0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xFE, 0x0F, 0xFF,
  0xFE, 0x7F, 0xF8, 0x1F, 0xD0, 0x06, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 29, 10, 0, -29 },
  { 38, 12, 11, 14, 4, -29 },
  { 55, 19, 29, 18, 0, -29 },
  { 124, 17, 32, 16, 0, -30 },
  { 192, 22, 29, 25, 2, -29 },
  { 272, 18, 29, 18, 0, -29 },
  { 338, 6, 11, 8, 4, -29 },
  { 347, 12, 35, 10, 1, -29 },
  { 400, 12, 35, 10, -3, -29 },
  { 453, 13, 15, 15, 4, -31 },
  { 478, 15, 19, 18, 2, -24 },
  { 514, 8, 10, 8, -2, -5 },
  { 524, 9, 4, 11, 1, -13 },
  { 529, 5, 5, 8, 0, -5 },
  { 533, 19, 29, 14, -2, -29 },
  { 602, 15, 29, 16, 1, -29 },
  { 657, 11, 29, 16, 4, -29 },
  { 697, 17, 29, 16, -1, -29 },
  { 759, 17, 29, 16, -1, -29 },
  { 821, 17, 29, 16, -1, -29 },
  { 883, 17, 29, 16, 0, -29 },
  { 945, 16, 29, 16, 1, -29 },
  { 1003, 17, 29, 16, 1, -29 },
  { 1065, 17, 29, 16, 0, -29 },
  { 1127, 16, 29, 16, 0, -29 },
  { 1185, 8, 22, 9, 0, -22 },
  { 1207, 11, 27, 9, -2, -22 },
  { 1245, 15, 18, 18, 2, -23 },
  { 1279, 15, 12, 18, 2, -20 },
  { 1302, 15, 18, 18, 2, -23 },
  { 1336, 13, 29, 12, 1, -29 },
  { 1384, 23, 32, 24, 1, -29 },
  { 1476, 17, 29, 17, -3, -29 },
  { 1538, 18, 29, 18, 0, -29 },
  { 1604, 18, 29, 16, 1, -29 },
  { 1670, 19, 29, 19, 0, -29 },
  { 1739, 17, 29, 15, 0, -29 },
  { 1801, 17, 29, 14, 0, -29 },
  { 1863, 20, 29, 20, 1, -29 },
  { 1936, 21, 29, 20, 0, -29 },
  { 2013, 16, 29, 11, -2, -29 },
  { 2071, 16, 37, 9, -6, -29 },
  { 2145, 20, 29, 17, 0, -29 },
  { 2218, 11, 29, 14, 0, -29 },
  { 2258, 27, 29, 26, 0, -29 },
  { 2356, 22, 29, 21, 0, -29 },
  { 2436, 19, 29, 20, 1, -29 },
  { 2505, 18, 29, 17, 0, -29 },
  { 2571, 19, 36, 20, 1, -29 },
  { 2657, 18, 29, 17, 0, -29 },
  { 2723, 18, 29, 15, -1, -29 },
  { 2789, 14, 29, 14, 3, -29 },
  { 2840, 20, 29, 19, 1, -29 },
  { 2913, 17, 29, 17, 3, -29 },
  { 2975, 27, 29, 27, 3, -29 },
  { 3073, 20, 29, 16, -2, -29 },
  { 3146, 16, 29, 15, 3, -29 },
  { 3204, 19, 29, 14, -2, -29 },
  { 3273, 15, 35, 11, -1, -29 },
  { 3339, 7, 29, 14, 4, -29 },
  { 3365, 16, 35, 11, -3, -29 },
  { 3435, 16, 16, 16, 0, -29 },
  { 3467, 13, 3, 12, -4, 3 },
  { 3472, 6, 7, 11, 6, -31 },
  { 3478, 16, 22, 17, 1, -22 },
  { 3522, 16, 30, 17, 0, -30 },
  { 3582, 13, 22, 13, 1, -22 },
  { 3618, 18, 30, 17, 1, -30 },
  { 3686, 14, 22, 16, 1, -22 },
  { 3725, 19, 41, 10, -5, -31 },
  { 3823, 18, 32, 17, -1, -22 },
  { 3895, 16, 30, 17, 0, -30 },
  { 3955, 10, 30, 8, 0, -30 },
  { 3993, 15, 40, 8, -5, -30 },
  { 4068, 17, 30, 15, 0, -30 },
  { 4132, 10, 30, 8, 0, -30 },
  { 4170, 24, 22, 25, 0, -22 },
  { 4236, 16, 22, 17, 0, -22 },
  { 4280, 15, 22, 17, 1, -22 },
  { 4322, 18, 31, 17, -2, -22 },
  { 4392, 16, 32, 17, 1, -22 },
  { 4456, 13, 22, 12, 0, -22 },
  { 4492, 14, 22, 13, 0, -22 },
  { 4531, 10, 26, 10, 1, -26 },
  { 4564, 16, 22, 17, 1, -22 },
  { 4608, 14, 22, 14, 2, -22 },
  { 4647, 23, 22, 23, 2, -22 },
  { 4711, 18, 22, 14, -2, -22 },
  { 4761, 20, 32, 14, -4, -22 },
  { 4841, 14, 22, 12, -1, -22 },
  { 4880, 15, 35, 13, 1, -29 },
  { 4946, 3, 40, 15, 6, -31 },
  { 4961, 14, 35, 13, -2, -29 },
  { 5023, 15, 6, 18, 2, -17 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC40PT7B_H_
