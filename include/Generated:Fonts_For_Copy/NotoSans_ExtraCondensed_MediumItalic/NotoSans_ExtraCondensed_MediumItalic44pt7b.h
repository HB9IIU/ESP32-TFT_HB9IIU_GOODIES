#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x78, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x70, 0x00,
  0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x03,
  0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x8E, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0xF1, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF1,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0x80,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x8C, 0x0F, 0x30, 0x01,
  0xE6, 0x00, 0x3C, 0xC0, 0x07, 0x98, 0x00, 0xF2, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0D, 0xE0, 0x01, 0x3C, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x01,
  0x9E, 0x10, 0x33, 0xC3, 0x84, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x1E, 0x03, 0xF8,
  0x0E, 0x03, 0x9C, 0x0F, 0x03, 0xCE, 0x07, 0x01, 0xC7, 0x87, 0x80, 0xE3,
  0x83, 0x80, 0xE1, 0xC3, 0xC0, 0x70, 0xE1, 0xC0, 0x38, 0x71, 0xE0, 0x1C,
  0x38, 0xE0, 0x1E, 0x1C, 0xE0, 0x0E, 0x1C, 0x70, 0x07, 0x0E, 0x71, 0xF3,
  0x87, 0x39, 0xFD, 0xC7, 0x39, 0xFE, 0xF7, 0x9C, 0xE7, 0xBF, 0x9C, 0xE1,
  0xDF, 0x8E, 0x70, 0xE7, 0x8E, 0x38, 0xF0, 0x0F, 0x38, 0x70, 0x07, 0x1C,
  0x38, 0x07, 0x8E, 0x1C, 0x03, 0x87, 0x0E, 0x03, 0xC7, 0x0F, 0x01, 0xC3,
  0x87, 0x01, 0xE1, 0xC3, 0x80, 0xE0, 0xE3, 0xC0, 0xF0, 0x71, 0xC0, 0x70,
  0x3F, 0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0x87, 0x80, 0x38, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x03, 0x8E, 0x00,
  0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x11, 0xFF, 0x1E, 0x1E, 0xF1, 0xE3, 0xCF, 0x9E, 0x78, 0x7B,
  0xC7, 0x87, 0xBC, 0xF0, 0x7F, 0x8F, 0x03, 0xF8, 0xF0, 0x3F, 0x0F, 0x03,
  0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xF0, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xCF, 0x83, 0xF8, 0x78, 0x3E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x3C, 0x70,
  0xE3, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x00, 0x02, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x63, 0x81, 0xEE, 0x1F, 0xFF, 0xDF, 0xFF,
  0x0F, 0xFC, 0x3E, 0x01, 0xFC, 0x0F, 0x78, 0x7C, 0xE1, 0xE3, 0xC1, 0x0F,
  0x00, 0x10, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x1F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x11, 0xE7, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7C, 0xF0, 0x7C, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0xBE, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0xBE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0x1F, 0x07, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0xFD, 0xE7,
  0x9E, 0x33, 0xE2, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xE1,
  0xF0, 0x18, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x38, 0x3E, 0x02, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x40, 0x1F, 0x0F, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x0E, 0xF0,
  0x03, 0x9E, 0x00, 0x73, 0xC0, 0x1C, 0x78, 0x07, 0x9E, 0x00, 0xE3, 0xC0,
  0x38, 0x78, 0x0F, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0x78, 0x0E, 0x0F, 0x03,
  0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x80,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x21, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x08, 0x07, 0xC3, 0x87, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0xF8, 0x0F, 0x7F, 0x07, 0xBF, 0xE1,
  0xFF, 0xF8, 0x7E, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF8,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0x7D, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x3E, 0x3E, 0x07, 0x9F, 0x01, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xE3, 0xC0, 0xF0,
  0xF8, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x7C, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x7C, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x07, 0xC7, 0x83, 0xE1, 0xE0, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E, 0x03,
  0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE3,
  0xE0, 0xF8, 0xF8, 0x7E, 0x1F, 0x3F, 0x87, 0xFF, 0xC1, 0xFE, 0xF0, 0x3F,
  0x3C, 0x01, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x83, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFC, 0x00, 0x03, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x00, 0xE0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x38, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF,
  0x18, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x07, 0xF1, 0xC7, 0x07, 0xF8, 0xE3,
  0x87, 0x9C, 0x73, 0x87, 0x8E, 0x39, 0xC3, 0x8F, 0x1C, 0xE3, 0x87, 0x0E,
  0xE1, 0xC3, 0x87, 0x70, 0xE1, 0xC3, 0x38, 0xE1, 0xE3, 0x9C, 0x70, 0xE1,
  0xDC, 0x38, 0x70, 0xEE, 0x1C, 0x78, 0xE7, 0x0E, 0x3C, 0x73, 0x87, 0x1C,
  0x31, 0xC3, 0x9F, 0x38, 0xE1, 0xFF, 0xF8, 0x70, 0xFC, 0xF8, 0x38, 0x3C,
  0x78, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3C, 0x3E, 0x03, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x0F,
  0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1E, 0x1F, 0x01, 0xE0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x78,
  0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x0F,
  0x87, 0x80, 0xF0, 0x78, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7E, 0x08, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE7,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0x9F, 0xC0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3,
  0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x07,
  0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x81, 0xF0, 0x7C,
  0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x07, 0x03,
  0xE0, 0x08, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xFC, 0xF8, 0x3F, 0xC7, 0x81, 0xFE, 0x3C, 0x0F, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x07,
  0xE1, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xE0,
  0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F,
  0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1F, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x01, 0x1F, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x02, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F,
  0x00, 0xF0, 0x7C, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x78, 0x7C, 0x01,
  0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF,
  0x00, 0x0F, 0x78, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x3C,
  0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3E,
  0x01, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFE,
  0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x01, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0, 0x3B, 0xC0, 0xF7,
  0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3D, 0xE0, 0x3D, 0xE0,
  0xF7, 0x81, 0xE7, 0x87, 0x9E, 0x07, 0x9E, 0x1E, 0x78, 0x1E, 0x78, 0x71,
  0xE0, 0x79, 0xE3, 0xCF, 0x01, 0xE7, 0x8E, 0x3C, 0x0F, 0x1E, 0x78, 0xF0,
  0x3C, 0x79, 0xC3, 0xC0, 0xF1, 0xEF, 0x1F, 0x03, 0xC3, 0xBC, 0x78, 0x0E,
  0x0F, 0xE1, 0xE0, 0x78, 0x3F, 0x87, 0x81, 0xE0, 0xFC, 0x1E, 0x07, 0x83,
  0xF0, 0xF0, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x0F,
  0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x0F, 0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x1E,
  0x07, 0xF8, 0x1E, 0x07, 0xF8, 0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0x78, 0x3C,
  0x0F, 0x38, 0x3C, 0x0F, 0x38, 0x3C, 0x0F, 0x3C, 0x3C, 0x0F, 0x3C, 0x78,
  0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x1C, 0x78, 0x1E, 0x1C, 0x78,
  0x1E, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0,
  0x3C, 0x0E, 0xE0, 0x38, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xE0,
  0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E,
  0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07,
  0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x83,
  0xE0, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3C, 0x7E, 0x03, 0xC3, 0xE0,
  0x7C, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x1E,
  0x0F, 0x81, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x0F,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFE, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x0F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F,
  0x0F, 0x83, 0xE0, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xE3, 0xF0, 0x3C, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0,
  0xF0, 0x7C, 0x1E, 0x1F, 0x07, 0xCF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C,
  0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xF1, 0xC0, 0x7C, 0x04,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x04, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x83,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xE0,
  0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x1E,
  0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x3E, 0x03,
  0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x07, 0x83, 0xE0, 0x1F, 0xBF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x70,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x7D, 0xE0,
  0x1E, 0x01, 0xE7, 0x80, 0xF8, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0x78, 0x0F,
  0x80, 0xF1, 0xE0, 0x7E, 0x07, 0xC7, 0x81, 0xF8, 0x1E, 0x1E, 0x0F, 0xE0,
  0x78, 0x78, 0x3B, 0x83, 0xC1, 0xE0, 0xEE, 0x0F, 0x07, 0x87, 0xF8, 0x7C,
  0x1E, 0x1D, 0xE1, 0xE0, 0x70, 0xF7, 0x87, 0x83, 0xC3, 0xDE, 0x3C, 0x0F,
  0x0E, 0x78, 0xF0, 0x3C, 0x79, 0xE3, 0xC0, 0xF1, 0xC7, 0x9E, 0x03, 0xC7,
  0x1E, 0x78, 0x0F, 0x3C, 0x7B, 0xC0, 0x3C, 0xE1, 0xEF, 0x00, 0xF7, 0x87,
  0x3C, 0x03, 0xDE, 0x1D, 0xE0, 0x0F, 0x70, 0x77, 0x80, 0x3F, 0xC1, 0xDE,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1,
  0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x7C,
  0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0, 0x00, 0x78, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0x70,
  0x38, 0x1E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x39, 0xE0, 0x0F, 0xF0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3,
  0x80, 0x01, 0xF1, 0xC1, 0xFE, 0xF0, 0x7F, 0xBC, 0x3F, 0xFE, 0x1F, 0x0F,
  0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x07, 0xC3, 0xC1, 0xF0, 0xF8, 0xFC,
  0x1F, 0xEF, 0x07, 0xFB, 0x80, 0xF8, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE7, 0xC0, 0x7B, 0xF8, 0x3D, 0xFE, 0x0F, 0xEF,
  0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1E, 0x3C, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x78, 0x7C, 0x3E,
  0x1F, 0x9F, 0x0F, 0xFF, 0xC3, 0xDF, 0xE0, 0xE3, 0xF0, 0x00, 0x01, 0xFC,
  0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0xE1, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0xC6, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x1F, 0x3C, 0x07, 0xFB, 0xC0, 0x7F,
  0xBC, 0x0F, 0xDF, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F,
  0x80, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x8F, 0xC0, 0x7F, 0xFC,
  0x07, 0xFB, 0x80, 0x3F, 0x38, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE,
  0x0F, 0x9F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x7F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x10,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x70, 0x0F, 0xEF, 0x01, 0xFE,
  0xF0, 0x3F, 0xFE, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E,
  0x03, 0xC3, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x0F, 0x83,
  0xC0, 0xF8, 0x3C, 0x1F, 0x03, 0xC1, 0xF0, 0x3E, 0x7F, 0x01, 0xFE, 0xF0,
  0x1F, 0xFE, 0x00, 0xFD, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x08, 0x07, 0xC0, 0xC0, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE7, 0xC0, 0x7F, 0xF8, 0x3D, 0xFE,
  0x0F, 0xFF, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x07, 0x87,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x00,
  0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x1F, 0x0F, 0x80, 0xEF, 0xF7, 0xF8, 0x3F, 0xFE, 0xFF, 0x07,
  0xF7, 0xFF, 0xF0, 0xF8, 0x7E, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF8, 0x3C, 0x1E, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x78, 0x78,
  0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x0F,
  0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x78, 0x1E, 0x0F, 0x0F, 0x03,
  0xC1, 0xE1, 0xE0, 0x78, 0x3C, 0x3C, 0x1E, 0x07, 0x87, 0x83, 0xC0, 0xF1,
  0xE0, 0x78, 0x3C, 0x3C, 0x0F, 0x07, 0x87, 0x83, 0xC0, 0xF0, 0x07, 0x1F,
  0x01, 0xDF, 0xE0, 0xF7, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC3, 0xE1, 0xE0,
  0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xBF,
  0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F,
  0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x78, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xC7, 0xC0, 0x1C, 0xFE, 0x03, 0xDF, 0xE0,
  0x3F, 0x9F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x1F, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC1, 0xF0,
  0x3C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x9F, 0x03, 0xDF, 0xF0, 0x3D,
  0xFE, 0x03, 0xCF, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF1, 0xC0, 0xFE, 0xF0, 0x7F, 0xBC,
  0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x3C,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3,
  0xC1, 0xF0, 0xF8, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFD, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x1E, 0x0E, 0xF8, 0x3D, 0xF0, 0x7F, 0xE0, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF8, 0xF8, 0xE1, 0xE0, 0x43, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC4, 0x0F, 0x8C, 0x3E,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xE1, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x10, 0xFE, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC3, 0xF0, 0xF9,
  0xF8, 0x3F, 0xEE, 0x07, 0xF3, 0x81, 0xF9, 0xE0, 0xF0, 0x1F, 0xE0, 0x7B,
  0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xF1,
  0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x1E, 0x0E, 0x38, 0x1C, 0xF0, 0x39, 0xE0,
  0x77, 0x80, 0xEF, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x1E, 0x07, 0xBC, 0x1F, 0x07, 0x9E,
  0x0F, 0x83, 0xCF, 0x0F, 0xC1, 0xE7, 0x87, 0xE1, 0xE3, 0xC3, 0xF0, 0xF1,
  0xC3, 0xB8, 0x70, 0xE1, 0xDC, 0x78, 0x71, 0xEE, 0x3C, 0x38, 0xEF, 0x3C,
  0x1C, 0x77, 0x9E, 0x0E, 0x7B, 0xCE, 0x07, 0x39, 0xEF, 0x03, 0xBC, 0xF7,
  0x83, 0xDC, 0x7B, 0x81, 0xEE, 0x3B, 0xC0, 0xFF, 0x1D, 0xC0, 0x7F, 0x0E,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x3C,
  0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x01,
  0xCF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C,
  0x07, 0xC3, 0xC0, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x08,
  0x00, 0xBF, 0x80, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF4, 0x07, 0xF2,
  0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 31, 11, 0, -31 },
  { 48, 14, 11, 16, 4, -31 },
  { 68, 20, 31, 19, 0, -31 },
  { 146, 19, 36, 18, 0, -33 },
  { 232, 25, 32, 28, 2, -32 },
  { 332, 20, 32, 20, 0, -32 },
  { 412, 7, 11, 9, 4, -31 },
  { 422, 13, 39, 11, 1, -32 },
  { 486, 13, 39, 11, -3, -32 },
  { 550, 14, 16, 17, 4, -34 },
  { 578, 16, 21, 19, 2, -26 },
  { 620, 8, 11, 9, -2, -5 },
  { 631, 10, 4, 12, 1, -14 },
  { 636, 6, 6, 9, 0, -6 },
  { 641, 21, 32, 15, -2, -32 },
  { 725, 17, 32, 18, 1, -32 },
  { 793, 12, 31, 18, 4, -31 },
  { 840, 20, 32, 18, -2, -32 },
  { 920, 19, 32, 18, -1, -32 },
  { 996, 19, 32, 18, -1, -32 },
  { 1072, 18, 31, 18, 0, -31 },
  { 1142, 18, 32, 18, 1, -32 },
  { 1214, 19, 31, 18, 1, -31 },
  { 1288, 18, 32, 18, 0, -32 },
  { 1360, 18, 32, 18, 0, -32 },
  { 1432, 9, 24, 9, 0, -24 },
  { 1459, 11, 30, 9, -2, -24 },
  { 1501, 17, 20, 19, 2, -26 },
  { 1544, 16, 13, 19, 2, -22 },
  { 1570, 17, 20, 19, 2, -26 },
  { 1613, 14, 32, 13, 1, -32 },
  { 1669, 25, 36, 27, 1, -32 },
  { 1782, 19, 32, 19, -3, -32 },
  { 1858, 20, 31, 19, 0, -31 },
  { 1936, 19, 32, 18, 2, -32 },
  { 2012, 21, 31, 21, 0, -31 },
  { 2094, 19, 31, 17, 0, -31 },
  { 2168, 19, 31, 16, 0, -31 },
  { 2242, 21, 32, 22, 2, -32 },
  { 2326, 23, 31, 22, 0, -31 },
  { 2416, 17, 31, 12, -2, -31 },
  { 2482, 18, 40, 9, -7, -31 },
  { 2572, 22, 31, 19, 0, -31 },
  { 2658, 13, 31, 15, 0, -31 },
  { 2709, 30, 31, 29, 0, -31 },
  { 2826, 24, 31, 23, 0, -31 },
  { 2919, 20, 32, 22, 2, -32 },
  { 2999, 20, 31, 19, 0, -31 },
  { 3077, 20, 39, 22, 2, -32 },
  { 3175, 19, 31, 19, 0, -31 },
  { 3249, 20, 32, 17, -1, -32 },
  { 3329, 16, 31, 16, 3, -31 },
  { 3391, 22, 31, 21, 1, -31 },
  { 3477, 18, 31, 19, 4, -31 },
  { 3547, 30, 31, 29, 3, -31 },
  { 3664, 23, 31, 17, -3, -31 },
  { 3754, 17, 31, 17, 3, -31 },
  { 3820, 20, 31, 15, -2, -31 },
  { 3898, 16, 39, 12, -1, -32 },
  { 3976, 8, 32, 15, 4, -32 },
  { 4008, 17, 39, 12, -3, -32 },
  { 4091, 18, 17, 18, 0, -31 },
  { 4130, 14, 2, 14, -4, 4 },
  { 4134, 7, 7, 12, 6, -34 },
  { 4141, 18, 24, 19, 1, -24 },
  { 4195, 18, 33, 19, 0, -33 },
  { 4270, 15, 24, 15, 1, -24 },
  { 4315, 20, 33, 19, 1, -33 },
  { 4398, 16, 24, 17, 1, -24 },
  { 4446, 21, 45, 11, -5, -34 },
  { 4565, 20, 35, 19, -1, -24 },
  { 4653, 18, 33, 19, 0, -33 },
  { 4728, 11, 33, 9, 0, -33 },
  { 4774, 17, 44, 9, -6, -33 },
  { 4868, 19, 33, 17, 0, -33 },
  { 4947, 11, 33, 9, 0, -33 },
  { 4993, 27, 24, 28, 0, -24 },
  { 5074, 18, 24, 19, 0, -24 },
  { 5128, 16, 24, 18, 1, -24 },
  { 5176, 20, 34, 19, -2, -24 },
  { 5261, 18, 35, 19, 1, -24 },
  { 5340, 15, 24, 13, 0, -24 },
  { 5385, 15, 24, 14, 0, -24 },
  { 5430, 12, 29, 11, 1, -29 },
  { 5474, 18, 24, 19, 1, -24 },
  { 5528, 15, 24, 16, 3, -24 },
  { 5573, 25, 24, 25, 2, -24 },
  { 5648, 20, 24, 16, -2, -24 },
  { 5708, 22, 35, 16, -4, -24 },
  { 5805, 17, 24, 13, -2, -24 },
  { 5856, 16, 38, 15, 1, -31 },
  { 5932, 4, 44, 16, 6, -34 },
  { 5954, 17, 38, 15, -3, -31 },
  { 6035, 17, 7, 19, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC44PT7B_H_
