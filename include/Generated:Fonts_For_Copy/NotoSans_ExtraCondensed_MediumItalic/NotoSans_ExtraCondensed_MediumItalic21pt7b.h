#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x00, 0x43, 0x8C,
  0x00, 0x6D, 0xB4, 0xF2, 0xD8, 0x04, 0xC3, 0x20, 0xD8, 0x24, 0x3F, 0xDF,
  0xF1, 0x20, 0xC8, 0x36, 0x3F, 0xCF, 0xF1, 0xB0, 0x4C, 0x12, 0x0D, 0x80,
  0x02, 0x02, 0x07, 0xE7, 0xE3, 0x41, 0xA0, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0x82, 0x49, 0x67, 0xF3, 0xE0, 0x20, 0x20, 0x00, 0x38, 0x66, 0x8C, 0x48,
  0x84, 0x98, 0xC9, 0x0D, 0xB0, 0xDA, 0xED, 0x6B, 0xE5, 0xB0, 0xD3, 0x19,
  0x21, 0xB2, 0x33, 0x62, 0x34, 0x61, 0xC0, 0x0F, 0x0D, 0x86, 0xC2, 0x61,
  0x20, 0xF0, 0x70, 0x70, 0x6D, 0xB6, 0xF3, 0xD8, 0xEC, 0x67, 0xF9, 0xEC,
  0x6D, 0x6C, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x06,
  0x0C, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x31, 0xC0, 0x18, 0x23,
  0x4B, 0xF3, 0x1F, 0x13, 0x00, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x36, 0x64, 0xC0, 0x7F, 0xC0, 0x5F, 0x00, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0F, 0x1F, 0x19, 0x31, 0x31, 0x63, 0x63,
  0x63, 0x63, 0x63, 0xC6, 0xC6, 0xCC, 0x7C, 0x78, 0x1C, 0xF7, 0xB6, 0x58,
  0x63, 0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x00, 0x0F, 0x87, 0xE1, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x1F, 0xCF, 0xE0, 0x1F, 0x1F, 0x88, 0xE0, 0x30, 0x30, 0x18, 0x78, 0x78,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE7, 0xE3, 0xE0, 0x03, 0x81, 0x81, 0xC1,
  0xE0, 0xB0, 0x90, 0xD8, 0x4C, 0x66, 0x63, 0x3F, 0xDF, 0xE0, 0xC0, 0x60,
  0x30, 0x1F, 0x8F, 0x84, 0x06, 0x03, 0x01, 0x81, 0xF8, 0x5C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xE7, 0xE3, 0xE0, 0x0F, 0x1F, 0x30, 0x60, 0x60, 0x48,
  0xFC, 0xEE, 0xC6, 0xC6, 0x86, 0x8C, 0xCC, 0xF8, 0xF8, 0x7F, 0x7F, 0x03,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0,
  0x1F, 0x0D, 0xCC, 0x66, 0x33, 0x31, 0x98, 0x78, 0x38, 0x76, 0x73, 0x31,
  0x98, 0xCC, 0x67, 0x71, 0xF0, 0x1F, 0x1F, 0x33, 0x33, 0x63, 0x63, 0x63,
  0x67, 0x3F, 0x12, 0x06, 0x06, 0x0C, 0xF8, 0xF0, 0x33, 0x00, 0x00, 0x00,
  0x4E, 0xC0, 0x1C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x18, 0xC3,
  0x00, 0x03, 0x0F, 0x1C, 0x70, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x0E, 0x38, 0xE0,
  0x80, 0x3E, 0x7C, 0x18, 0x30, 0x61, 0x86, 0x08, 0x30, 0x41, 0x80, 0x04,
  0x1C, 0x38, 0x00, 0x03, 0xE0, 0x71, 0x86, 0x04, 0x20, 0x23, 0x3D, 0x93,
  0x49, 0x92, 0x49, 0x92, 0x49, 0x92, 0x49, 0x92, 0x49, 0x9F, 0xC4, 0x48,
  0x20, 0x01, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x03, 0x03, 0x81, 0xC1, 0xA0,
  0xD0, 0x68, 0x64, 0x32, 0x31, 0x1F, 0xCF, 0xEC, 0x36, 0x1E, 0x0F, 0x0E,
  0x1F, 0x0F, 0xC6, 0x66, 0x33, 0x19, 0x8C, 0xFC, 0x7C, 0x63, 0x31, 0x98,
  0xCC, 0x64, 0x77, 0xF3, 0xF0, 0x0F, 0x8F, 0x8C, 0x0E, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xE1, 0xF0, 0x1F, 0x07,
  0xE1, 0x9C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC7, 0x61, 0x98, 0x66, 0x39,
  0x8C, 0x67, 0x3F, 0x8F, 0x80, 0x1F, 0x8F, 0xC6, 0x06, 0x03, 0x01, 0x80,
  0xF8, 0x7C, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC6, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7C, 0x7E, 0x30, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x00, 0x0F, 0xC7, 0xF3, 0x81, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x1E, 0xC7, 0xB0, 0xCC, 0x33, 0x0C, 0xC3, 0x3F, 0x87, 0xE0, 0x18, 0x63,
  0x0C, 0x63, 0x18, 0x63, 0x0C, 0x61, 0x8F, 0xF1, 0xFC, 0x61, 0x8C, 0x31,
  0x86, 0x30, 0xC6, 0x31, 0x86, 0x30, 0xC0, 0x1F, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0xF8, 0x03, 0x03,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0xF0, 0xE0, 0x18, 0xE3, 0x38, 0x66, 0x19, 0x83, 0x70,
  0x6C, 0x0F, 0x01, 0xE0, 0x7C, 0x0D, 0x81, 0x98, 0x33, 0x04, 0x61, 0x8C,
  0x31, 0xC0, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x63,
  0xFF, 0xC0, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x0F, 0x3C, 0x28, 0xF1,
  0xE3, 0xC5, 0x8B, 0x36, 0x6C, 0x99, 0xB6, 0xC6, 0x5B, 0x19, 0xCC, 0x47,
  0x33, 0x18, 0xCC, 0x66, 0x00, 0x1C, 0x31, 0xC6, 0x1C, 0x63, 0xC6, 0x3C,
  0x63, 0x44, 0x36, 0xC2, 0x6C, 0x66, 0xC6, 0x6C, 0x66, 0x86, 0x38, 0x43,
  0x8C, 0x38, 0xC3, 0x80, 0x0F, 0x0F, 0xCC, 0x6C, 0x36, 0x1B, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0xD8, 0x6C, 0x67, 0xF1, 0xE0, 0x1F, 0x0F, 0xC6,
  0x66, 0x33, 0x19, 0x8C, 0xCE, 0x6E, 0x7E, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x00, 0x0F, 0x0F, 0xCC, 0x6C, 0x36, 0x1B, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0xD8, 0x6C, 0x67, 0xF1, 0xF0, 0x30, 0x1C, 0x06, 0x03, 0x00,
  0x1F, 0x0F, 0xC6, 0x66, 0x33, 0x19, 0x8C, 0xCC, 0x7E, 0x7C, 0x36, 0x19,
  0x8C, 0xC4, 0x66, 0x33, 0x1C, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0x80, 0xC8, 0xE7, 0xE3, 0xE0, 0x7F, 0x7F,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0x30, 0xCC, 0x63, 0x19, 0x86, 0x61, 0x98, 0x66, 0x33, 0x0C, 0xC3,
  0x30, 0xCC, 0x33, 0x18, 0xC6, 0x3F, 0x07, 0x80, 0xC3, 0xE1, 0xB1, 0xD8,
  0xCC, 0x66, 0x63, 0x31, 0xB0, 0xD8, 0x6C, 0x3C, 0x1E, 0x0E, 0x07, 0x03,
  0x00, 0x61, 0x86, 0xC7, 0x19, 0x8E, 0x33, 0x1C, 0xC6, 0x71, 0x8C, 0xA3,
  0x1B, 0x4C, 0x36, 0x98, 0x49, 0x60, 0xB2, 0xC1, 0x45, 0x83, 0x8E, 0x07,
  0x1C, 0x1C, 0x30, 0x38, 0xE0, 0x00, 0x18, 0xE3, 0x18, 0x36, 0x06, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xD8, 0x1B, 0x06, 0x60,
  0xCC, 0x30, 0xC0, 0xC7, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0x70, 0x70, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0xC7, 0xE0, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x3F, 0x8F,
  0xE0, 0x0F, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0xF8, 0xCC, 0xC4, 0x46, 0x66, 0x66,
  0x62, 0x23, 0x30, 0x1F, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0xF0, 0x06, 0x07, 0x03,
  0x83, 0x43, 0x31, 0x99, 0x8D, 0x83, 0xFE, 0xCD, 0x80, 0x08, 0x0F, 0xCC,
  0xE6, 0x76, 0x33, 0x19, 0x8C, 0xC6, 0xC6, 0x33, 0x1B, 0x8E, 0xC0, 0x18,
  0x0C, 0x06, 0x02, 0x03, 0x21, 0xF8, 0xEE, 0x63, 0x21, 0xB1, 0x98, 0xCC,
  0x66, 0x37, 0x33, 0xB9, 0xF8, 0x04, 0x1F, 0x3A, 0x30, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0x60, 0x7C, 0x7C, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x09, 0x87,
  0xE3, 0x38, 0xCE, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0xC6, 0x31, 0x86, 0xE1,
  0xD8, 0x04, 0x1F, 0x33, 0x33, 0x63, 0x6E, 0x7C, 0x40, 0xC0, 0x40, 0x64,
  0x3C, 0x01, 0xE0, 0x78, 0x0C, 0x01, 0x80, 0x30, 0x1F, 0x01, 0x80, 0x30,
  0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x78, 0x0E, 0x00, 0x04, 0x0F, 0xCC, 0xE6, 0x76, 0x33,
  0x19, 0x8C, 0xC6, 0xC6, 0x73, 0x1B, 0x8E, 0xC0, 0x60, 0x60, 0x31, 0xF0,
  0xF0, 0x00, 0x18, 0x18, 0x18, 0x18, 0x32, 0x3F, 0x3B, 0x33, 0x33, 0x63,
  0x63, 0x63, 0x66, 0xC6, 0xC6, 0xC6, 0x08, 0xC6, 0x00, 0x18, 0xC6, 0x23,
  0x18, 0xC6, 0x63, 0x18, 0x01, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0,
  0xE0, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x09, 0x98, 0xCC, 0x6C, 0x2C, 0x3E,
  0x1F, 0x0D, 0x86, 0xC6, 0x63, 0x31, 0x8C, 0x18, 0xC6, 0x33, 0x18, 0xC6,
  0x23, 0x18, 0xC6, 0x63, 0x18, 0x02, 0x21, 0xFB, 0x8E, 0xE6, 0x66, 0x32,
  0x31, 0x31, 0x99, 0x8C, 0xCC, 0xC6, 0x66, 0x36, 0x31, 0x31, 0x99, 0x88,
  0xC0, 0x02, 0x3F, 0x3B, 0x33, 0x33, 0x63, 0x63, 0x62, 0x66, 0xC6, 0xC6,
  0xC6, 0x04, 0x1F, 0x33, 0x33, 0x63, 0x63, 0x63, 0x43, 0xC3, 0x46, 0x6C,
  0x78, 0x01, 0x07, 0xE1, 0xDC, 0x63, 0x18, 0xCC, 0x23, 0x18, 0xC6, 0x31,
  0x9C, 0xC7, 0xF1, 0xB8, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x04,
  0x0F, 0xCC, 0xE6, 0x76, 0x33, 0x19, 0x8C, 0xC6, 0xC6, 0x63, 0x1B, 0x8E,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x02, 0x7C, 0xF9, 0x83, 0x0C,
  0x18, 0x30, 0x61, 0x83, 0x06, 0x00, 0x08, 0x7D, 0x8B, 0x06, 0x06, 0x0E,
  0x0E, 0x0C, 0x1B, 0xE7, 0xC0, 0x31, 0x89, 0xF6, 0x31, 0x98, 0xC6, 0x31,
  0x0E, 0x70, 0x31, 0x98, 0xCC, 0xC4, 0x66, 0x33, 0x19, 0x88, 0xCC, 0xC6,
  0x3F, 0x1D, 0x80, 0xC7, 0xC6, 0xCC, 0xCC, 0xC8, 0xD8, 0xD8, 0xF0, 0xF0,
  0xE0, 0xE0, 0xC6, 0x3C, 0xE6, 0xCA, 0x6C, 0xE4, 0xDE, 0xCD, 0x6C, 0xF7,
  0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xC7, 0x00, 0x19, 0x8D, 0x86, 0xC3, 0xC0,
  0xC0, 0xE0, 0x70, 0x68, 0x36, 0x33, 0x31, 0x80, 0x18, 0xE3, 0x18, 0x66,
  0x0C, 0xC1, 0x90, 0x16, 0x02, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x3C, 0x07, 0x00, 0x1F, 0x26, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x30, 0x60, 0x7C, 0xFC, 0x07, 0x0F, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x70, 0xE0, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x70, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x38, 0x18, 0x20, 0xC1, 0x83, 0x06,
  0x0E, 0x1C, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x71, 0xC0, 0x61, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 6, 5, 7, 2, -15 },
  { 17, 10, 15, 9, 0, -15 },
  { 36, 9, 17, 8, 0, -16 },
  { 56, 12, 15, 13, 1, -15 },
  { 79, 9, 15, 10, 0, -15 },
  { 96, 3, 5, 4, 2, -15 },
  { 98, 7, 18, 5, 0, -15 },
  { 114, 7, 18, 5, -2, -15 },
  { 130, 7, 7, 8, 2, -16 },
  { 137, 8, 10, 9, 1, -12 },
  { 147, 4, 5, 4, -1, -2 },
  { 150, 5, 2, 6, 0, -7 },
  { 152, 3, 3, 4, 0, -3 },
  { 154, 10, 15, 7, -1, -15 },
  { 173, 8, 15, 8, 0, -15 },
  { 188, 6, 15, 8, 2, -15 },
  { 200, 10, 15, 8, -1, -15 },
  { 219, 9, 15, 8, 0, -15 },
  { 236, 9, 15, 8, 0, -15 },
  { 253, 9, 15, 8, 0, -15 },
  { 270, 8, 15, 8, 1, -15 },
  { 285, 8, 15, 8, 1, -15 },
  { 300, 9, 15, 8, 0, -15 },
  { 317, 8, 15, 8, 0, -15 },
  { 332, 4, 11, 5, 0, -11 },
  { 338, 6, 14, 5, -1, -11 },
  { 349, 8, 9, 9, 1, -12 },
  { 358, 8, 6, 9, 1, -10 },
  { 364, 8, 9, 9, 1, -12 },
  { 373, 7, 15, 6, 0, -15 },
  { 387, 13, 17, 13, 0, -15 },
  { 415, 9, 15, 9, -1, -15 },
  { 432, 9, 15, 9, 0, -15 },
  { 449, 9, 15, 8, 1, -15 },
  { 466, 10, 15, 10, 0, -15 },
  { 485, 9, 15, 8, 0, -15 },
  { 502, 9, 15, 7, 0, -15 },
  { 519, 10, 15, 11, 1, -15 },
  { 538, 11, 15, 10, 0, -15 },
  { 559, 8, 15, 6, -1, -15 },
  { 574, 8, 19, 5, -3, -15 },
  { 593, 11, 15, 9, 0, -15 },
  { 614, 6, 15, 7, 0, -15 },
  { 626, 14, 15, 14, 0, -15 },
  { 653, 12, 15, 11, 0, -15 },
  { 676, 9, 15, 11, 1, -15 },
  { 693, 9, 15, 9, 0, -15 },
  { 710, 9, 19, 11, 1, -15 },
  { 732, 9, 15, 9, 0, -15 },
  { 749, 9, 15, 8, 0, -15 },
  { 766, 8, 15, 8, 1, -15 },
  { 781, 10, 15, 10, 1, -15 },
  { 800, 9, 15, 9, 2, -15 },
  { 817, 15, 15, 14, 1, -15 },
  { 846, 11, 15, 8, -1, -15 },
  { 867, 8, 15, 8, 2, -15 },
  { 882, 10, 15, 7, -1, -15 },
  { 901, 8, 18, 6, -1, -15 },
  { 919, 4, 15, 7, 2, -15 },
  { 927, 8, 18, 6, -1, -15 },
  { 945, 9, 8, 9, 0, -15 },
  { 954, 7, 1, 6, -2, 2 },
  { 955, 3, 3, 6, 3, -16 },
  { 957, 9, 12, 9, 0, -12 },
  { 971, 9, 16, 9, 0, -16 },
  { 989, 8, 12, 7, 0, -12 },
  { 1001, 10, 16, 9, 0, -16 },
  { 1021, 8, 12, 8, 0, -12 },
  { 1033, 11, 21, 5, -3, -16 },
  { 1062, 9, 17, 9, 0, -12 },
  { 1082, 8, 16, 9, 0, -16 },
  { 1098, 5, 16, 4, 0, -16 },
  { 1108, 8, 21, 4, -3, -16 },
  { 1129, 9, 16, 8, 0, -16 },
  { 1147, 5, 16, 4, 0, -16 },
  { 1157, 13, 12, 13, 0, -12 },
  { 1177, 8, 12, 9, 0, -12 },
  { 1189, 8, 12, 9, 0, -12 },
  { 1201, 10, 17, 9, -1, -12 },
  { 1223, 9, 17, 9, 0, -12 },
  { 1243, 7, 12, 6, 0, -12 },
  { 1254, 7, 12, 7, 0, -12 },
  { 1265, 5, 14, 5, 1, -14 },
  { 1274, 9, 11, 9, 0, -11 },
  { 1287, 8, 11, 7, 1, -11 },
  { 1298, 12, 11, 12, 1, -11 },
  { 1315, 9, 11, 8, -1, -11 },
  { 1328, 11, 16, 8, -2, -11 },
  { 1350, 8, 11, 6, -1, -11 },
  { 1361, 8, 18, 7, 0, -15 },
  { 1379, 2, 21, 8, 3, -16 },
  { 1385, 7, 18, 7, -1, -15 },
  { 1401, 8, 3, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC21PT7B_H_
