#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0,
  0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x63, 0x98, 0xCE, 0x33, 0x9C, 0x01, 0xCE,
  0x03, 0x18, 0x06, 0x30, 0x1C, 0xC0, 0x31, 0x80, 0x63, 0x01, 0xCE, 0x1F,
  0xFF, 0x3F, 0xFE, 0x1C, 0xE0, 0x31, 0x80, 0x63, 0x01, 0xCE, 0x03, 0x18,
  0x3F, 0xFE, 0x7F, 0xF8, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x98, 0x06,
  0x30, 0x0C, 0x60, 0x39, 0xC0, 0x00, 0x00, 0x40, 0x01, 0x00, 0x1E, 0x01,
  0xFF, 0x0F, 0xF8, 0x72, 0x41, 0xC8, 0x06, 0x60, 0x1D, 0x00, 0x74, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xB8, 0x06, 0xE0,
  0x13, 0x88, 0x4E, 0x39, 0x78, 0xFF, 0xC3, 0xFE, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x60, 0x00, 0x1E, 0x07, 0x1F, 0x83, 0x1D, 0xC3, 0x0C, 0x63,
  0x86, 0x31, 0x87, 0x39, 0xC3, 0x1C, 0xC1, 0x8C, 0xE0, 0xC6, 0x60, 0x67,
  0x73, 0xB3, 0x33, 0xF9, 0xBB, 0x3F, 0x99, 0x9B, 0x9D, 0x8C, 0x0C, 0xC6,
  0x0E, 0x63, 0x06, 0x71, 0x86, 0x31, 0xC3, 0x18, 0xC3, 0x0C, 0x61, 0x86,
  0x71, 0x83, 0xF1, 0xC0, 0xF0, 0x01, 0xE0, 0x1F, 0xC0, 0x77, 0x03, 0x8C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xB8, 0x0E, 0xC0, 0x3F, 0x00, 0x78,
  0x07, 0xC0, 0x3F, 0x9C, 0xEE, 0x77, 0x3B, 0xB8, 0x7E, 0xE1, 0xF3, 0x87,
  0xCE, 0x0E, 0x38, 0x78, 0xF3, 0xF3, 0xFD, 0xC7, 0xE7, 0x80, 0x7B, 0x9C,
  0xE7, 0x31, 0x9C, 0x01, 0xC0, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03,
  0x80, 0x0E, 0x03, 0x84, 0xE3, 0xF3, 0xFF, 0xC7, 0xF1, 0xE0, 0xF8, 0xF7,
  0x18, 0xE0, 0x20, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x1E, 0x38, 0x71, 0xC3, 0x86, 0x1C, 0x70, 0x7F, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x7E, 0x0F, 0xF1, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x70, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x78, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x03,
  0x83, 0xC3, 0xC7, 0xE7, 0xF7, 0xB9, 0x9C, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81,
  0xC0, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC1, 0x87, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x7F, 0xE3, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0xC0,
  0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x20, 0x78, 0xE7, 0xC3, 0xFF, 0x07, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x1B, 0x80,
  0xCE, 0x03, 0x70, 0x19, 0xC0, 0xE7, 0x03, 0x1C, 0x18, 0x70, 0xE3, 0x83,
  0x0E, 0x1C, 0x38, 0x7F, 0xF9, 0xFF, 0xE8, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xFC, 0x0F, 0xF0, 0x37, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x79, 0x07,
  0x8E, 0xF8, 0x7F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x81, 0xF4, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x71, 0x03, 0xBE, 0x1F, 0xF1,
  0xF3, 0xCF, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0x0E, 0x38,
  0x71, 0xC7, 0x8F, 0x78, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0xE0,
  0x3F, 0xC3, 0xDE, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8E, 0x1C,
  0x70, 0x7F, 0x03, 0xF0, 0x1F, 0x01, 0xFC, 0x1C, 0xF1, 0xC3, 0x9C, 0x1C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x3C, 0x3F, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x3F, 0x83, 0xFC, 0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x79, 0xC3, 0xCE, 0x1C, 0x71, 0xE3, 0xFF, 0x0F, 0xB8, 0x33,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x08, 0xF0, 0x7F, 0x03,
  0xF0, 0x00, 0x1E, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x3C, 0x78, 0xE0, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x38,
  0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F,
  0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x8F, 0xF3, 0xBC, 0x87,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x18, 0x06, 0x0C, 0x01, 0xC7,
  0x00, 0x31, 0x87, 0x8C, 0xC3, 0xF3, 0x31, 0x98, 0xD8, 0xC6, 0x36, 0x31,
  0x8D, 0x9C, 0xE7, 0xE6, 0x31, 0xB1, 0x8C, 0x6C, 0x63, 0x1B, 0x39, 0xCC,
  0xC6, 0x73, 0x31, 0xFF, 0x8C, 0x7B, 0xC3, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xE3, 0x80, 0x3F, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0D, 0x80, 0xEC, 0x07, 0x60, 0x73,
  0x03, 0x98, 0x1C, 0xC1, 0xC6, 0x0E, 0x30, 0xE1, 0x87, 0xFC, 0x7F, 0xE3,
  0xFF, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0x77, 0x03, 0xB8, 0x1F, 0x80,
  0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71,
  0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x71, 0xE1, 0xFE, 0x0F, 0xF8, 0x38, 0xF0,
  0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x70, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x3C,
  0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x83,
  0xC2, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x7D, 0x80, 0xFE, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x71, 0xE0, 0xE1, 0xE1, 0xC1, 0xC7, 0x83,
  0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x79, 0xC0, 0xF3, 0x81, 0xC7,
  0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0xF1, 0xC3, 0xC3, 0x8F,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFE,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0xF8, 0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x7F, 0xC3, 0xFC, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x02, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0xFC, 0xF0,
  0xFC, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xF0,
  0x70, 0x70, 0x70, 0x7C, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0x03, 0x83,
  0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x78, 0x78, 0x38,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0x81,
  0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x0E, 0x0E, 0x07, 0x0F, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x17, 0x80, 0xF8, 0x0F, 0x80, 0x00,
  0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x78,
  0x1C, 0x70, 0x1C, 0xE0, 0x1D, 0xC0, 0x1D, 0xC0, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3D, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x71, 0xC0, 0x71, 0xC0,
  0x71, 0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0x07, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0x80, 0x7C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x07, 0xE1, 0xD8, 0x1B, 0x87, 0x60, 0xFC, 0x1D, 0x83,
  0xF0, 0x76, 0x1D, 0xC1, 0x98, 0x77, 0x0E, 0x61, 0x9C, 0x39, 0x8E, 0xE0,
  0xE6, 0x33, 0x83, 0x99, 0xCE, 0x0C, 0x66, 0x38, 0x71, 0xB8, 0xC1, 0xC7,
  0xC7, 0x07, 0x1F, 0x1C, 0x1C, 0x7C, 0x70, 0xE1, 0xE1, 0xC3, 0x87, 0x8E,
  0x0E, 0x1C, 0x38, 0x00, 0x07, 0x01, 0xC1, 0xE0, 0x60, 0xF8, 0x38, 0x3E,
  0x0E, 0x0F, 0x83, 0x83, 0x60, 0xE1, 0xD8, 0x70, 0x77, 0x1C, 0x1D, 0xC7,
  0x07, 0x71, 0xC1, 0x9C, 0x70, 0xE3, 0x38, 0x38, 0xCE, 0x0E, 0x3B, 0x83,
  0x8E, 0xE0, 0xC3, 0xB0, 0x70, 0xFC, 0x1C, 0x1F, 0x07, 0x07, 0xC1, 0xC1,
  0xF0, 0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x07, 0x80, 0x01, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x70, 0xF1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x78,
  0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x0F,
  0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x87, 0x07, 0xFE, 0x0F,
  0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0x8F, 0x0E,
  0x1C, 0x38, 0x71, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0xC7, 0x8E,
  0x7C, 0x3F, 0xE0, 0xFF, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x70, 0xF1, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07,
  0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0xB8,
  0x0F, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0xF3, 0x81, 0xC7, 0x87, 0x87, 0xFE,
  0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0x8F, 0x0E, 0x1C, 0x38,
  0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0xFC, 0x3F,
  0xC0, 0xFE, 0x03, 0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x1E, 0x1C,
  0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF0, 0x78, 0x40, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x82, 0x0F, 0x07, 0xFE, 0x1F, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xE0, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x00, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC1, 0xE3,
  0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x71, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x83, 0x87, 0x87, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0xE0, 0x3F,
  0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0xE1,
  0xC7, 0x1C, 0x38, 0xE1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0xC0,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x70, 0x38, 0x1D, 0xC0, 0xE0, 0xE7, 0x07, 0x83, 0x9C, 0x1E, 0x0E, 0x70,
  0xF8, 0x71, 0xC3, 0xE1, 0xC7, 0x0F, 0x0E, 0x1C, 0x7C, 0x38, 0x61, 0xB0,
  0xE1, 0x8E, 0xC7, 0x06, 0x3B, 0x1C, 0x38, 0xCC, 0xE0, 0xE7, 0x33, 0x83,
  0x98, 0xCE, 0x0E, 0xE3, 0x70, 0x3B, 0x8D, 0xC0, 0xEC, 0x37, 0x03, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xF0,
  0x0F, 0x07, 0x80, 0x00, 0x07, 0x87, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x71,
  0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x03, 0x70, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x87,
  0x03, 0x83, 0x83, 0xC1, 0xC0, 0x70, 0x7B, 0x83, 0x9C, 0x3C, 0xE1, 0xC7,
  0x1E, 0x38, 0xE1, 0xCE, 0x06, 0x70, 0x37, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xFE, 0x0F, 0xC0, 0xE3, 0x86, 0x18, 0x61, 0xC7, 0x1C,
  0x71, 0xC3, 0x0C, 0x30, 0xE3, 0x8E, 0x38, 0xE1, 0x86, 0x18, 0x71, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0xC0, 0x7E, 0x03, 0x70, 0x39, 0x83, 0x8E, 0x1C, 0x71, 0xC1, 0x8C, 0x0C,
  0xE0, 0x7E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xEF, 0x73, 0x30, 0x02, 0x00,
  0x7D, 0xC7, 0xEE, 0x79, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0xE0,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x8F, 0x1E, 0xF8,
  0xFD, 0xC3, 0xCC, 0x00, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x39, 0x03, 0xBE, 0x1F, 0xF8, 0xF1, 0xC7, 0x0E, 0x38, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE1,
  0xC7, 0x0E, 0x7C, 0xE3, 0xFF, 0x19, 0xF0, 0x01, 0x01, 0xFC, 0x7F, 0x1E,
  0x23, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x98, 0x7F, 0x0F, 0xC0, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x23, 0x83, 0xEE, 0x1F, 0xF8,
  0xF3, 0xC3, 0x87, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0x8E, 0x0E, 0x38, 0x38,
  0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x9F, 0x0F, 0xDC,
  0x1E, 0x60, 0x01, 0x01, 0xF8, 0x7F, 0x9E, 0x73, 0x8E, 0xE1, 0xDC, 0x3F,
  0x0E, 0xFF, 0x9F, 0xE3, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x8C,
  0x7F, 0x87, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x05, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x07, 0xDC, 0x1F,
  0xF8, 0x79, 0xE0, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x38, 0x38,
  0x70, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x3C, 0x1E,
  0xF8, 0x3F, 0x70, 0x3D, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x20, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x39, 0x03, 0xBE, 0x1F, 0xF8, 0xF3,
  0xC7, 0x0E, 0x38, 0x73, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x30, 0x73,
  0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x87, 0x1C, 0x38, 0x06,
  0x07, 0x0F, 0x0E, 0x00, 0x00, 0x02, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x00,
  0x60, 0x07, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x20, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0x80, 0xF8, 0x0E, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x47,
  0x0E, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x06, 0x70, 0x3B, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x71, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0x00, 0x40, 0x83, 0xBE, 0x7C, 0x7F, 0xDF,
  0x8F, 0x3E, 0x71, 0xC3, 0x8E, 0x38, 0xF1, 0xCE, 0x1C, 0x39, 0xC3, 0x87,
  0x38, 0x70, 0xE7, 0x0E, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x1C,
  0xE1, 0xC3, 0x9C, 0x30, 0xE7, 0x0E, 0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x70,
  0x00, 0x40, 0xEF, 0x87, 0xFE, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0xE1, 0xC7,
  0x0E, 0x38, 0x71, 0xC3, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC3,
  0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x00, 0x03, 0x00, 0xFC, 0x1F, 0xE3, 0xCE,
  0x38, 0x77, 0x07, 0x70, 0x77, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE1, 0xEE, 0x1C, 0xE3, 0xCF, 0x78, 0x7F, 0x03, 0xE0, 0x00, 0x10, 0x0E,
  0xF8, 0x1F, 0xF8, 0x3C, 0x70, 0x70, 0xE0, 0xE1, 0xC3, 0x83, 0x87, 0x07,
  0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x07,
  0x0E, 0x1F, 0x38, 0x3F, 0xF0, 0x77, 0xC0, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x7D, 0xC7,
  0xFE, 0x79, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xCE, 0x0C, 0xE0, 0xE7, 0x07,
  0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0xF8, 0xFD, 0xC3,
  0xDC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x00, 0x43, 0xBC, 0x7F, 0x0F, 0xE1, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0x02, 0x01, 0xFC, 0x7F, 0x1C, 0x23, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x01,
  0xE6, 0x78, 0xFF, 0x1F, 0xC0, 0x0C, 0x0C, 0x1C, 0x1C, 0x7F, 0x7F, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE4,
  0xF8, 0xF8, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x07, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x06, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71,
  0xE3, 0xDE, 0x1F, 0xB0, 0x79, 0x80, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xCE,
  0x39, 0xC6, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0xE1, 0xC3, 0xF8, 0xF0, 0xEE, 0x3C,
  0x3B, 0x8F, 0x1C, 0xE7, 0xC7, 0x39, 0xB3, 0x8E, 0x6C, 0xE3, 0xBB, 0x38,
  0xEC, 0xDC, 0x3F, 0x37, 0x0D, 0x8D, 0x83, 0x63, 0xE0, 0xF8, 0xF8, 0x3C,
  0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x0E,
  0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xCC, 0x03, 0x9C, 0x0E,
  0x38, 0x3C, 0x70, 0xF0, 0xE0, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0xF0, 0x1E,
  0x03, 0xE0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xC0,
  0x3C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x7C, 0x07, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1F,
  0x01, 0xF0, 0x3E, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0x00, 0x0B, 0xF0,
  0x7F, 0xFF, 0x8F, 0xE8, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 23, 8, 0, -23 },
  { 24, 10, 8, 11, 3, -23 },
  { 34, 15, 23, 14, 0, -23 },
  { 78, 14, 26, 13, 0, -24 },
  { 124, 17, 23, 20, 2, -23 },
  { 173, 14, 23, 15, 0, -23 },
  { 214, 5, 8, 7, 3, -23 },
  { 219, 10, 28, 8, 1, -23 },
  { 254, 10, 28, 8, -2, -23 },
  { 289, 10, 11, 12, 3, -24 },
  { 303, 12, 15, 14, 1, -19 },
  { 326, 7, 8, 7, -2, -4 },
  { 333, 8, 3, 9, 0, -10 },
  { 336, 4, 4, 7, 0, -4 },
  { 338, 16, 23, 11, -2, -23 },
  { 384, 12, 23, 13, 1, -23 },
  { 419, 9, 23, 13, 3, -23 },
  { 445, 14, 23, 13, -1, -23 },
  { 486, 14, 23, 13, -1, -23 },
  { 527, 14, 23, 13, -1, -23 },
  { 568, 13, 23, 13, 0, -23 },
  { 606, 13, 23, 13, 1, -23 },
  { 644, 13, 23, 13, 1, -23 },
  { 682, 13, 23, 13, 0, -23 },
  { 720, 13, 23, 13, 0, -23 },
  { 758, 7, 17, 7, 0, -17 },
  { 773, 9, 21, 7, -2, -17 },
  { 797, 12, 15, 14, 1, -19 },
  { 820, 12, 9, 14, 1, -16 },
  { 834, 13, 15, 14, 1, -19 },
  { 859, 10, 23, 10, 1, -23 },
  { 888, 18, 26, 19, 1, -23 },
  { 947, 13, 23, 14, -2, -23 },
  { 985, 14, 23, 14, 0, -23 },
  { 1026, 14, 23, 13, 1, -23 },
  { 1067, 15, 23, 15, 0, -23 },
  { 1111, 13, 23, 12, 0, -23 },
  { 1149, 13, 23, 11, 0, -23 },
  { 1187, 16, 23, 16, 1, -23 },
  { 1233, 17, 23, 16, 0, -23 },
  { 1282, 13, 23, 9, -2, -23 },
  { 1320, 13, 29, 7, -5, -23 },
  { 1368, 16, 23, 14, 0, -23 },
  { 1414, 9, 23, 11, 0, -23 },
  { 1440, 22, 23, 21, 0, -23 },
  { 1504, 18, 23, 17, 0, -23 },
  { 1556, 15, 23, 16, 1, -23 },
  { 1600, 14, 23, 13, 0, -23 },
  { 1641, 15, 28, 16, 1, -23 },
  { 1694, 14, 23, 14, 0, -23 },
  { 1735, 15, 23, 12, -1, -23 },
  { 1779, 12, 23, 11, 2, -23 },
  { 1814, 15, 23, 16, 1, -23 },
  { 1858, 13, 23, 14, 3, -23 },
  { 1896, 22, 23, 21, 2, -23 },
  { 1960, 17, 23, 13, -2, -23 },
  { 2009, 13, 23, 12, 2, -23 },
  { 2047, 14, 23, 11, -1, -23 },
  { 2088, 12, 28, 9, -1, -23 },
  { 2130, 6, 23, 11, 3, -23 },
  { 2148, 12, 28, 9, -2, -23 },
  { 2190, 13, 13, 13, 0, -23 },
  { 2212, 10, 2, 10, -3, 3 },
  { 2215, 4, 5, 8, 5, -24 },
  { 2218, 13, 18, 14, 1, -18 },
  { 2248, 13, 24, 14, 0, -24 },
  { 2287, 11, 18, 11, 1, -18 },
  { 2312, 14, 24, 14, 1, -24 },
  { 2354, 11, 18, 13, 1, -18 },
  { 2379, 16, 32, 8, -4, -24 },
  { 2443, 15, 26, 14, -1, -18 },
  { 2492, 13, 24, 14, 0, -24 },
  { 2531, 8, 24, 7, 0, -24 },
  { 2555, 12, 32, 7, -4, -24 },
  { 2603, 14, 24, 12, 0, -24 },
  { 2645, 8, 24, 6, 0, -24 },
  { 2669, 19, 18, 20, 0, -18 },
  { 2712, 13, 18, 14, 0, -18 },
  { 2742, 12, 18, 13, 1, -18 },
  { 2769, 15, 25, 14, -2, -18 },
  { 2816, 13, 26, 14, 1, -18 },
  { 2859, 11, 18, 9, 0, -18 },
  { 2884, 11, 18, 11, 0, -18 },
  { 2909, 8, 21, 8, 1, -21 },
  { 2930, 13, 17, 14, 1, -17 },
  { 2958, 11, 17, 11, 2, -17 },
  { 2982, 18, 17, 18, 2, -17 },
  { 3021, 15, 17, 12, -2, -17 },
  { 3053, 16, 25, 11, -3, -17 },
  { 3103, 12, 17, 10, -1, -17 },
  { 3129, 12, 28, 11, 1, -23 },
  { 3171, 3, 31, 12, 4, -24 },
  { 3183, 12, 28, 11, -2, -23 },
  { 3225, 13, 5, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC32PT7B_H_
