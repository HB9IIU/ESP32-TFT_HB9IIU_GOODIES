#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x3C, 0x79, 0xE3, 0xCF,
  0x3E, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F,
  0x38, 0x70, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0x71, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x01, 0xC3,
  0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0x87, 0x00, 0x38,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0E,
  0x1C, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1C, 0x38, 0x01,
  0xC7, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0x5E, 0x0F, 0x30, 0x83, 0xCC, 0x00, 0xE3, 0x00, 0x38, 0x80, 0x0F,
  0x60, 0x03, 0xD8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x27, 0x80, 0x19, 0xE0,
  0x06, 0x78, 0x01, 0x9E, 0x20, 0x47, 0x8C, 0x13, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x07, 0xC0, 0x3C, 0x0F, 0xE0, 0x38, 0x1F,
  0xE0, 0x78, 0x1C, 0xE0, 0x70, 0x38, 0xE0, 0xE0, 0x38, 0xE0, 0xE0, 0x70,
  0xE1, 0xC0, 0x70, 0xE1, 0xC0, 0x70, 0xE3, 0x80, 0x70, 0xE3, 0x80, 0xE1,
  0xE7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x7E, 0xE3,
  0x9C, 0xFF, 0xE7, 0xBC, 0xE7, 0xFF, 0x39, 0xC7, 0x7E, 0x79, 0xC7, 0x3C,
  0x73, 0x87, 0x00, 0xF3, 0x87, 0x00, 0xE3, 0x87, 0x01, 0xE7, 0x0F, 0x01,
  0xC7, 0x0E, 0x03, 0x87, 0x0E, 0x03, 0x87, 0x0E, 0x07, 0x07, 0x1C, 0x07,
  0x07, 0x1C, 0x0E, 0x07, 0x3C, 0x0E, 0x07, 0xF8, 0x1C, 0x07, 0xF0, 0x3C,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xE3, 0x80,
  0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xC0, 0x1E, 0x78, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE1, 0xE3, 0xDE, 0x3C, 0xF3, 0xCF, 0x3C,
  0x79, 0xE7, 0x87, 0xB9, 0xE0, 0xFF, 0x3C, 0x1F, 0xC7, 0x81, 0xF8, 0xF0,
  0x3E, 0x1E, 0x07, 0xC3, 0xC1, 0xF8, 0x7C, 0x7F, 0x8F, 0xFE, 0xF0, 0xFF,
  0x9E, 0x0F, 0xE3, 0xE0, 0x3C, 0xF3, 0xCF, 0x79, 0xE7, 0x9C, 0x71, 0xCF,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x10, 0xE0,
  0x63, 0x83, 0xEE, 0x7F, 0xFF, 0xCF, 0xFF, 0x07, 0xFC, 0x7E, 0x03, 0xDC,
  0x1F, 0x70, 0x79, 0xE0, 0xC3, 0xC1, 0x0C, 0x00, 0x20, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x79, 0xFF, 0xBE, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xFB, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xE1, 0xFE, 0x7D, 0xEF, 0x9E, 0x73, 0xC2, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xBF, 0x03, 0x83, 0xC0, 0x40, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xF7, 0xE0,
  0x30, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC2, 0x00, 0xF0, 0x70, 0x7E, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00,
  0x77, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x07,
  0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x0E, 0x1E, 0x03, 0x83, 0xC0, 0x70,
  0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x08, 0x0F, 0xC3, 0x87, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0x30, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x84, 0x03, 0xDF, 0x81, 0xDF, 0xE1, 0xFF, 0xF0,
  0xFC, 0x7C, 0x7C, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x3C,
  0x1E, 0x0F, 0x3E, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x1F, 0x1F, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x1E, 0x3C, 0x07,
  0xBE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xDF,
  0x03, 0xC3, 0xC1, 0xE0, 0xF8, 0x78, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xE1, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C,
  0xF8, 0x7E, 0x3C, 0x7E, 0x1F, 0xFF, 0x0F, 0xF7, 0x83, 0xF3, 0xC0, 0xF3,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x10, 0x7C, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x87,
  0xC3, 0xC0, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x07, 0xE0,
  0x7F, 0xE1, 0xFF, 0x87, 0xBF, 0x10, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x0E, 0x07, 0x83, 0x8E, 0x0F, 0xF1,
  0xC7, 0x0F, 0xF8, 0xE3, 0x0F, 0x38, 0x73, 0x87, 0x1C, 0x31, 0xC7, 0x0E,
  0x19, 0xC3, 0x87, 0x1C, 0xE3, 0x87, 0x0E, 0x71, 0xC3, 0x87, 0x38, 0xE1,
  0xC3, 0x98, 0x70, 0xE3, 0x9C, 0x30, 0xE1, 0xCE, 0x38, 0x70, 0xC7, 0x1C,
  0x78, 0xE3, 0x8E, 0x3C, 0x61, 0xC3, 0xF7, 0xF0, 0xE1, 0xFB, 0xF0, 0x70,
  0x78, 0xF0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0x70, 0x03, 0xDC, 0x00,
  0xF7, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x07, 0x9C, 0x03, 0xC7, 0x00, 0xF1,
  0xC0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x03, 0xC1, 0xC0, 0xF0, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xF0, 0x3C, 0x7C,
  0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03,
  0xDE, 0x00, 0xFF, 0x80, 0x3C, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3C, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F,
  0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x78,
  0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xC1, 0xE0,
  0x78, 0x3E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0, 0x83, 0xE0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xFE, 0x03, 0xC3, 0xE0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78,
  0x1F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1,
  0xE0, 0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x7C,
  0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x7E,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x06, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0xFF, 0x1E, 0x07,
  0xF8, 0xF0, 0x3F, 0xC7, 0x81, 0xFE, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC0, 0xFC, 0x3C, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x78,
  0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0xF8, 0x0F,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x11, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x40, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0,
  0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE3, 0xE0,
  0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F,
  0x78, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0x70, 0x0F,
  0xF0, 0x3D, 0xC0, 0x3B, 0xC0, 0xF7, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0x78,
  0x0F, 0x70, 0x3D, 0xE0, 0x3D, 0xC0, 0xE7, 0x81, 0xE7, 0x07, 0x9C, 0x07,
  0x9C, 0x1C, 0xF0, 0x1E, 0x78, 0xF3, 0xC0, 0x79, 0xE3, 0xCF, 0x01, 0xC7,
  0x9E, 0x3C, 0x0F, 0x1E, 0x79, 0xE0, 0x3C, 0x79, 0xC7, 0x80, 0xF1, 0xEF,
  0x1E, 0x03, 0xC7, 0xB8, 0x78, 0x0E, 0x1F, 0xE1, 0xE0, 0x78, 0x7F, 0x0F,
  0x01, 0xE1, 0xFC, 0x3C, 0x07, 0x87, 0xE0, 0xF0, 0x1E, 0x1F, 0x83, 0xC0,
  0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x03, 0xC1, 0xE0, 0x00,
  0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xF0, 0x1E, 0x03, 0xF0, 0x1E,
  0x03, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x3C,
  0x07, 0x70, 0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x78, 0x38,
  0x0F, 0x38, 0x78, 0x0E, 0x38, 0x78, 0x1E, 0x38, 0x78, 0x1E, 0x3C, 0x78,
  0x1E, 0x3C, 0xF0, 0x1E, 0x3C, 0xF0, 0x1C, 0x1C, 0xF0, 0x3C, 0x1C, 0xF0,
  0x3C, 0x1C, 0xE0, 0x3C, 0x1E, 0xE0, 0x3C, 0x1F, 0xE0, 0x38, 0x1F, 0xE0,
  0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xC0, 0x78, 0x0F, 0xC0, 0x78, 0x0F, 0xC0,
  0xF0, 0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC1, 0xF0, 0x78, 0x0F,
  0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0,
  0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x78,
  0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87,
  0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3C, 0x7E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F,
  0x87, 0xC3, 0xE0, 0xF1, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xC1, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0,
  0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3C,
  0xF8, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x7C, 0x1F,
  0x07, 0xE7, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3C, 0x7C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07,
  0x81, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x07, 0xC7, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x79,
  0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x0F, 0x81,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x7E, 0x0C, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC1, 0x01, 0xF0, 0x7E, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x07,
  0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x1F, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0, 0x3C, 0x1F, 0x01,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x7B, 0xC0, 0x3C,
  0x03, 0xDE, 0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x1F,
  0x3C, 0x0F, 0xC0, 0xF1, 0xE0, 0x7E, 0x07, 0x8E, 0x07, 0xF0, 0x78, 0x70,
  0x3F, 0x03, 0xC3, 0x81, 0xF8, 0x3E, 0x3C, 0x1F, 0xC1, 0xE1, 0xE0, 0xEE,
  0x0F, 0x0F, 0x0F, 0x70, 0xF0, 0x78, 0x73, 0x87, 0x83, 0xC3, 0x9C, 0x3C,
  0x1E, 0x3C, 0xE3, 0xC0, 0xF1, 0xC7, 0x1E, 0x07, 0x9E, 0x39, 0xE0, 0x3C,
  0xF1, 0xCF, 0x01, 0xE7, 0x0E, 0x78, 0x0F, 0x78, 0x77, 0x80, 0x7B, 0x83,
  0xBC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x3E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F,
  0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81,
  0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0xF0, 0x3C, 0x78,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0x70,
  0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38, 0x38, 0x38, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0F, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x21,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x0F, 0x78, 0x03, 0x8E, 0x01, 0xE3, 0x80,
  0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x07, 0x07, 0x01, 0xE3, 0xC0, 0x79, 0xE0,
  0x1E, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF1, 0xE1, 0xE3,
  0xC3, 0x83, 0x80, 0x00, 0x40, 0x00, 0xFC, 0xF0, 0x7F, 0xB8, 0x3F, 0xFE,
  0x1F, 0x1F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0xF8, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xF0,
  0xF8, 0xFC, 0x1F, 0xEE, 0x07, 0xF3, 0x80, 0xF8, 0xE0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE1, 0x00, 0x7B, 0xF0, 0x3D, 0xFE,
  0x0F, 0xFF, 0x83, 0xF1, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1F, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x78,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xDF, 0xE0, 0xE3, 0xE0, 0x00,
  0x00, 0x60, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1, 0xF0, 0x83, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x84, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0C, 0x3C, 0x03, 0xF3,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xF1, 0xF8, 0x1E, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0E, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x7C, 0x0F, 0x8F, 0x80,
  0x7F, 0xB8, 0x07, 0xFB, 0x80, 0x3E, 0x38, 0x00, 0x00, 0x60, 0x03, 0xF8,
  0x1F, 0xF8, 0x7F, 0xF1, 0xF1, 0xE3, 0xC1, 0xCF, 0x03, 0x9E, 0x0F, 0x78,
  0x1E, 0xF0, 0x79, 0xE3, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xC0, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x83, 0x0F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x09, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xCF, 0x01, 0xFE,
  0xE0, 0x3F, 0xFE, 0x07, 0xC7, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x38, 0x1E,
  0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC3, 0xF0, 0x3E, 0x7F, 0x03, 0xFF, 0xE0,
  0x1F, 0xDE, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x08, 0x07, 0x80, 0xE1, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC6, 0x01, 0xEF, 0xC1, 0xEF, 0xF0, 0xFF, 0xF8, 0x7E, 0x3C,
  0x3E, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x3C,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x7C, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x9F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xE0, 0x38, 0xF0, 0x1E, 0x78, 0x07,
  0xBE, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x0C,
  0x06, 0x01, 0xCF, 0xC7, 0xE0, 0xF7, 0xF3, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0x8F, 0xE3, 0xC3, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x3C, 0x78, 0x1E, 0x0F,
  0x1E, 0x07, 0x03, 0xC7, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x70, 0x3C,
  0x1E, 0x3C, 0x0F, 0x07, 0x8F, 0x07, 0x81, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0,
  0x78, 0x3C, 0x78, 0x1E, 0x0F, 0x1E, 0x07, 0x03, 0xC7, 0x83, 0xC0, 0xE1,
  0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x3C, 0x0F, 0x07, 0x8F, 0x03, 0x81,
  0xE3, 0xC1, 0xE0, 0xF0, 0x00, 0x08, 0x03, 0x9F, 0x83, 0xDF, 0xE1, 0xFF,
  0xF0, 0xFC, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0x87, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38,
  0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x83,
  0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x00, 0x60, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8,
  0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x1C, 0xFC,
  0x03, 0xDF, 0xE0, 0x3F, 0xFE, 0x03, 0xF1, 0xE0, 0x3E, 0x1F, 0x03, 0xC0,
  0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x03,
  0xFF, 0xE0, 0x3D, 0xFE, 0x03, 0xCF, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFC,
  0xF0, 0x7F, 0xB8, 0x3F, 0xFE, 0x1F, 0x1F, 0x87, 0x83, 0xE3, 0xE0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0x78,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF8, 0xFC, 0x3F, 0xEE, 0x07, 0xF7, 0x80,
  0xF9, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x1C, 0xF0, 0xF7, 0xC3, 0xFF, 0x0F, 0xF8, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x3F,
  0xF8, 0xFF, 0xE1, 0xE0, 0x83, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC4, 0x0F, 0x0C, 0x3E, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x3F,
  0xCF, 0xFB, 0xFF, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x0F, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1,
  0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E, 0x1F,
  0x3F, 0x0F, 0xFF, 0x83, 0xFB, 0xC1, 0xF9, 0xC0, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xB8, 0x1E, 0xE0, 0xF3, 0x83, 0xCE, 0x0F, 0x38, 0x78, 0xE1, 0xE3,
  0x8F, 0x0E, 0x3C, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x3B, 0xC0,
  0xEE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x78, 0x3E, 0x0F, 0x70, 0x3E, 0x0F, 0x70, 0x7E, 0x1E, 0x70, 0x7E,
  0x1E, 0x70, 0xFE, 0x1E, 0x70, 0xFC, 0x3C, 0x70, 0xFC, 0x3C, 0x71, 0xFC,
  0x38, 0x71, 0xDC, 0x78, 0x71, 0xDC, 0x78, 0xF3, 0x9C, 0xF0, 0xF3, 0x9C,
  0xF0, 0xF7, 0x9C, 0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFE, 0x1D,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E,
  0x00, 0x77, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0x78, 0x03, 0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0xF0, 0x78, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x02, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xE7, 0xFF,
  0x80, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 31, 10, 0, -31 },
  { 44, 13, 11, 15, 4, -31 },
  { 62, 20, 31, 19, 0, -31 },
  { 140, 18, 36, 17, 0, -33 },
  { 221, 24, 31, 27, 2, -31 },
  { 314, 19, 31, 20, 0, -31 },
  { 388, 6, 11, 9, 4, -31 },
  { 397, 13, 38, 11, 1, -31 },
  { 459, 13, 38, 11, -3, -31 },
  { 521, 14, 16, 16, 4, -33 },
  { 549, 16, 20, 19, 2, -25 },
  { 589, 8, 11, 9, -2, -5 },
  { 600, 10, 4, 12, 1, -14 },
  { 605, 6, 5, 9, 0, -5 },
  { 609, 20, 31, 15, -2, -31 },
  { 687, 16, 31, 17, 1, -31 },
  { 749, 12, 31, 17, 4, -31 },
  { 796, 18, 31, 17, -1, -31 },
  { 866, 19, 31, 17, -1, -31 },
  { 940, 19, 31, 17, -1, -31 },
  { 1014, 18, 31, 17, 0, -31 },
  { 1084, 17, 31, 17, 1, -31 },
  { 1150, 18, 31, 17, 1, -31 },
  { 1220, 18, 31, 17, 0, -31 },
  { 1290, 17, 31, 17, 0, -31 },
  { 1356, 9, 23, 9, 0, -23 },
  { 1382, 11, 29, 9, -2, -23 },
  { 1422, 16, 19, 19, 2, -25 },
  { 1460, 16, 12, 19, 2, -21 },
  { 1484, 16, 19, 19, 2, -25 },
  { 1522, 14, 31, 13, 1, -31 },
  { 1577, 25, 35, 26, 1, -31 },
  { 1687, 18, 31, 18, -3, -31 },
  { 1757, 19, 31, 19, 0, -31 },
  { 1831, 18, 31, 17, 2, -31 },
  { 1901, 20, 31, 21, 0, -31 },
  { 1979, 18, 31, 16, 0, -31 },
  { 2049, 18, 31, 15, 0, -31 },
  { 2119, 21, 31, 22, 2, -31 },
  { 2201, 22, 31, 21, 0, -31 },
  { 2287, 17, 31, 12, -2, -31 },
  { 2353, 17, 40, 9, -6, -31 },
  { 2438, 22, 31, 18, 0, -31 },
  { 2524, 12, 31, 15, 0, -31 },
  { 2571, 30, 31, 28, 0, -31 },
  { 2688, 24, 31, 23, 0, -31 },
  { 2781, 20, 31, 22, 1, -31 },
  { 2859, 19, 31, 18, 0, -31 },
  { 2933, 20, 38, 22, 1, -31 },
  { 3028, 19, 31, 19, 0, -31 },
  { 3102, 19, 31, 17, -1, -31 },
  { 3176, 16, 31, 15, 3, -31 },
  { 3238, 21, 31, 21, 1, -31 },
  { 3320, 18, 31, 18, 4, -31 },
  { 3390, 29, 31, 29, 3, -31 },
  { 3503, 23, 31, 17, -3, -31 },
  { 3593, 17, 31, 16, 3, -31 },
  { 3659, 20, 31, 15, -2, -31 },
  { 3737, 16, 38, 12, -1, -31 },
  { 3813, 8, 31, 15, 4, -31 },
  { 3844, 17, 38, 12, -3, -31 },
  { 3925, 18, 17, 18, 0, -31 },
  { 3964, 14, 2, 13, -4, 4 },
  { 3968, 7, 7, 11, 6, -33 },
  { 3975, 18, 24, 19, 1, -24 },
  { 4029, 18, 33, 18, 0, -33 },
  { 4104, 15, 24, 14, 1, -24 },
  { 4149, 20, 33, 19, 1, -33 },
  { 4232, 15, 24, 17, 1, -24 },
  { 4277, 20, 43, 10, -5, -33 },
  { 4385, 20, 34, 19, -1, -24 },
  { 4470, 17, 33, 18, 0, -33 },
  { 4541, 10, 32, 9, 0, -32 },
  { 4581, 16, 42, 9, -6, -32 },
  { 4665, 18, 33, 16, 0, -33 },
  { 4740, 11, 33, 9, 0, -33 },
  { 4786, 26, 24, 27, 0, -24 },
  { 4864, 17, 24, 18, 0, -24 },
  { 4915, 16, 24, 18, 1, -24 },
  { 4963, 20, 34, 18, -2, -24 },
  { 5048, 18, 34, 19, 1, -24 },
  { 5125, 14, 24, 12, 0, -24 },
  { 5167, 15, 24, 14, 0, -24 },
  { 5212, 11, 28, 11, 1, -28 },
  { 5251, 17, 23, 18, 1, -23 },
  { 5300, 14, 23, 15, 3, -23 },
  { 5341, 24, 23, 24, 2, -23 },
  { 5410, 19, 23, 16, -2, -23 },
  { 5465, 22, 33, 15, -4, -23 },
  { 5556, 16, 23, 13, -2, -23 },
  { 5602, 16, 38, 14, 1, -31 },
  { 5678, 4, 43, 16, 6, -33 },
  { 5700, 16, 38, 14, -3, -31 },
  { 5776, 16, 6, 19, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC43PT7B_H_
