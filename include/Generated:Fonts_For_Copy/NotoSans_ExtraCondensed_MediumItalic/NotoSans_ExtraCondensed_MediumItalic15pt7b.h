#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x26, 0x44, 0x0C, 0xC0, 0x7A, 0xD5, 0xA0, 0x1A, 0x28,
  0x53, 0xF2, 0x85, 0x1A, 0x7E, 0x50, 0xA2, 0xC0, 0x08, 0xF7, 0x5C, 0x70,
  0xC1, 0x8A, 0xAB, 0xE2, 0x10, 0x62, 0x52, 0x94, 0xAC, 0xAA, 0xBD, 0xD5,
  0x29, 0x29, 0x4A, 0x4E, 0x18, 0x78, 0xB1, 0x43, 0x86, 0x15, 0xEE, 0x99,
  0x33, 0xF0, 0xEA, 0x08, 0x88, 0x46, 0x21, 0x18, 0xC6, 0x31, 0x84, 0x00,
  0x10, 0x84, 0x31, 0x88, 0x42, 0x31, 0x08, 0x8C, 0x00, 0x37, 0x4E, 0xA5,
  0x80, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x2D, 0x60, 0xFE, 0xF0, 0x02, 0x0C,
  0x10, 0x60, 0x83, 0x04, 0x10, 0x20, 0x83, 0x00, 0x18, 0xF2, 0x59, 0x45,
  0x3C, 0xF2, 0xCB, 0x47, 0x00, 0x36, 0xEA, 0x64, 0x44, 0xCC, 0x80, 0x0C,
  0x2C, 0x08, 0x30, 0x41, 0x82, 0x08, 0x20, 0xC3, 0xF0, 0x38, 0xB0, 0x41,
  0x08, 0xC1, 0x82, 0x0A, 0x6F, 0x00, 0x04, 0x31, 0xC6, 0x29, 0x25, 0xBF,
  0xF8, 0x41, 0x00, 0x3C, 0xF2, 0x18, 0x71, 0xE0, 0x82, 0x0A, 0x6F, 0x00,
  0x0C, 0x52, 0x18, 0x59, 0xA4, 0xF2, 0xCB, 0x67, 0x00, 0x3E, 0xF8, 0x10,
  0x60, 0x83, 0x04, 0x18, 0x20, 0xC3, 0x00, 0x18, 0x96, 0x59, 0x28, 0xC5,
  0xB2, 0x8B, 0x67, 0x00, 0x18, 0xB6, 0x51, 0x4D, 0x37, 0x82, 0x18, 0xCE,
  0x00, 0x6C, 0x00, 0x36, 0x13, 0x00, 0x00, 0x26, 0x4C, 0x08, 0xDD, 0x8E,
  0x1C, 0x20, 0xF8, 0x01, 0xF0, 0x86, 0x1C, 0x33, 0x72, 0x00, 0x3A, 0xC2,
  0x31, 0x11, 0x88, 0x02, 0x30, 0x0E, 0x08, 0x88, 0x25, 0xD5, 0xAA, 0xA5,
  0x55, 0x2A, 0x9F, 0x40, 0x10, 0x0F, 0x80, 0x0C, 0x30, 0xC5, 0x14, 0xD2,
  0x4F, 0x65, 0x1C, 0x40, 0x3C, 0x5C, 0x99, 0x36, 0xCF, 0x13, 0x26, 0x4D,
  0x93, 0xC0, 0x1C, 0xD4, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x4F, 0x00, 0x38,
  0x7C, 0x99, 0x36, 0x6C, 0xD1, 0xA2, 0x4D, 0xB3, 0xC0, 0x3C, 0xF2, 0x08,
  0x61, 0xE4, 0x10, 0x43, 0x0F, 0x00, 0x3C, 0xF2, 0x08, 0x61, 0xE4, 0x10,
  0x43, 0x0C, 0x00, 0x1C, 0x6D, 0x86, 0x0C, 0x13, 0xA3, 0x46, 0x89, 0x93,
  0xE0, 0x33, 0x23, 0x22, 0x22, 0x66, 0x7E, 0x46, 0x44, 0x44, 0xCC, 0xCC,
  0x3C, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x8F, 0x00, 0x0C, 0x20, 0x82,
  0x18, 0x61, 0x04, 0x10, 0xC3, 0x08, 0xE3, 0x00, 0x33, 0x26, 0x24, 0x28,
  0x78, 0x70, 0x70, 0x58, 0x58, 0xC8, 0x88, 0x32, 0x22, 0x66, 0x44, 0x4C,
  0xF0, 0x30, 0xCC, 0x33, 0x1C, 0xC7, 0x73, 0x94, 0xA5, 0x69, 0x56, 0x55,
  0xB6, 0x49, 0x90, 0x31, 0x31, 0x33, 0x33, 0x7A, 0x4A, 0x4A, 0x4E, 0x4E,
  0xCC, 0x8C, 0x19, 0xB4, 0x71, 0xC6, 0x18, 0x63, 0x8A, 0x6F, 0x00, 0x38,
  0x78, 0x99, 0x36, 0x4D, 0x9E, 0x20, 0x41, 0x83, 0x00, 0x19, 0xB4, 0x71,
  0xC6, 0x18, 0x63, 0x8A, 0x6F, 0x0C, 0x30, 0x40, 0x38, 0x78, 0x99, 0x26,
  0x4F, 0x9C, 0x2C, 0x59, 0x92, 0x20, 0x1C, 0xF6, 0x18, 0x60, 0xC1, 0x86,
  0x1A, 0x6F, 0x00, 0xFF, 0xE2, 0x08, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x00,
  0x33, 0x22, 0x22, 0x22, 0x66, 0x66, 0x44, 0x44, 0xCC, 0x48, 0x78, 0xC7,
  0x8B, 0x36, 0x4D, 0x9A, 0x34, 0x70, 0xE1, 0xC3, 0x00, 0xC4, 0x73, 0x3C,
  0xCB, 0x72, 0xD5, 0xB5, 0x4A, 0x72, 0xB8, 0xEE, 0x33, 0x8C, 0xC0, 0x13,
  0x12, 0x16, 0x14, 0x1C, 0x18, 0x18, 0x38, 0x28, 0x4C, 0xCC, 0xCF, 0x25,
  0x94, 0x71, 0x86, 0x10, 0x43, 0x0C, 0x00, 0x1E, 0x7C, 0x10, 0x60, 0x83,
  0x04, 0x10, 0x60, 0x83, 0xE0, 0x39, 0x08, 0x46, 0x21, 0x08, 0x46, 0x21,
  0x0E, 0x00, 0xC9, 0x24, 0x9B, 0x24, 0x80, 0x1C, 0x20, 0x82, 0x08, 0x61,
  0x04, 0x10, 0xC3, 0x08, 0xE0, 0x08, 0x63, 0x8A, 0x4F, 0x10, 0xF8, 0xD0,
  0x3E, 0xD9, 0x12, 0x6C, 0xD9, 0x36, 0x34, 0x30, 0x82, 0x0F, 0x65, 0x94,
  0x53, 0xCF, 0x2B, 0x00, 0x3B, 0x10, 0x8C, 0x63, 0x4E, 0x02, 0x0C, 0x19,
  0xE6, 0xC8, 0x93, 0x66, 0xC9, 0xB1, 0xA0, 0x39, 0xB4, 0xDE, 0xC3, 0x0C,
  0x1C, 0x06, 0x18, 0x20, 0xE1, 0x83, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x02,
  0x1C, 0x30, 0x00, 0x3E, 0xD9, 0x12, 0x6C, 0xD9, 0x36, 0x34, 0x18, 0x23,
  0xC2, 0x00, 0x30, 0x82, 0x0F, 0x65, 0xB4, 0xD2, 0xCB, 0x29, 0x80, 0x32,
  0x02, 0x64, 0x44, 0xCC, 0x80, 0x0C, 0x20, 0x02, 0x18, 0x61, 0x04, 0x30,
  0xC2, 0x08, 0x23, 0x8C, 0x00, 0x30, 0x82, 0x0B, 0x69, 0x47, 0x1C, 0x53,
  0x69, 0x80, 0x32, 0x22, 0x66, 0x44, 0x4C, 0x80, 0x3F, 0xB6, 0x5B, 0x29,
  0xB4, 0x96, 0x4B, 0x25, 0x36, 0x3D, 0x96, 0xD3, 0x4B, 0x2C, 0xA6, 0x39,
  0xB4, 0x53, 0xCF, 0x2D, 0x9C, 0x1E, 0x64, 0xC9, 0x12, 0x64, 0xD9, 0x2C,
  0x40, 0x83, 0x06, 0x00, 0x3E, 0xD9, 0x12, 0x6C, 0xD9, 0x36, 0x34, 0x18,
  0x20, 0x40, 0x80, 0x3B, 0x18, 0x84, 0x23, 0x10, 0x7A, 0x10, 0xC3, 0x0A,
  0xDC, 0x22, 0x76, 0x64, 0x44, 0xC6, 0x25, 0x94, 0xD3, 0x4B, 0x2D, 0x9A,
  0x9C, 0xA5, 0x6A, 0x73, 0x18, 0x99, 0x9B, 0xAA, 0xAE, 0xAC, 0xDC, 0xDC,
  0xD8, 0x36, 0x68, 0x60, 0xC3, 0x85, 0x1A, 0x64, 0x22, 0x48, 0x91, 0x62,
  0x87, 0x0C, 0x18, 0x20, 0x43, 0x04, 0x00, 0x3C, 0x21, 0x84, 0x30, 0x84,
  0x3E, 0x0C, 0x61, 0x04, 0x30, 0xCE, 0x18, 0x61, 0x84, 0x10, 0x60, 0xFF,
  0xFE, 0x10, 0x60, 0x86, 0x18, 0x41, 0xC6, 0x30, 0x82, 0x08, 0xE0, 0xFC,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 5, 1, -11 },
  { 10, 7, 11, 7, 0, -11 },
  { 20, 6, 12, 6, 0, -11 },
  { 29, 8, 11, 10, 1, -11 },
  { 40, 7, 11, 7, 0, -11 },
  { 50, 2, 4, 3, 2, -11 },
  { 51, 5, 13, 4, 0, -11 },
  { 60, 5, 13, 4, -1, -11 },
  { 69, 5, 5, 6, 1, -11 },
  { 73, 5, 7, 7, 1, -9 },
  { 78, 3, 4, 3, -1, -2 },
  { 80, 4, 2, 4, 0, -5 },
  { 81, 2, 2, 3, 0, -2 },
  { 82, 7, 11, 5, -1, -11 },
  { 92, 6, 11, 6, 0, -11 },
  { 101, 4, 11, 6, 2, -11 },
  { 107, 7, 11, 6, -1, -11 },
  { 117, 6, 11, 6, 0, -11 },
  { 126, 6, 11, 6, 0, -11 },
  { 135, 6, 11, 6, 0, -11 },
  { 144, 6, 11, 6, 0, -11 },
  { 153, 7, 11, 6, 0, -11 },
  { 163, 6, 11, 6, 0, -11 },
  { 172, 6, 11, 6, 0, -11 },
  { 181, 3, 8, 3, 0, -8 },
  { 184, 4, 10, 3, -1, -8 },
  { 189, 5, 7, 7, 1, -9 },
  { 194, 5, 4, 7, 1, -7 },
  { 197, 5, 7, 7, 1, -9 },
  { 202, 5, 11, 5, 0, -11 },
  { 209, 9, 12, 9, 0, -11 },
  { 223, 6, 11, 6, -1, -11 },
  { 232, 7, 11, 7, 0, -11 },
  { 242, 6, 11, 6, 1, -11 },
  { 251, 7, 11, 7, 0, -11 },
  { 261, 6, 11, 6, 0, -11 },
  { 270, 6, 11, 5, 0, -11 },
  { 279, 7, 11, 8, 1, -11 },
  { 289, 8, 11, 7, 0, -11 },
  { 300, 6, 11, 4, -1, -11 },
  { 309, 6, 14, 3, -2, -11 },
  { 320, 8, 11, 6, 0, -11 },
  { 331, 4, 11, 5, 0, -11 },
  { 337, 10, 11, 10, 0, -11 },
  { 351, 8, 11, 8, 0, -11 },
  { 362, 6, 11, 8, 1, -11 },
  { 371, 7, 11, 6, 0, -11 },
  { 381, 6, 14, 8, 1, -11 },
  { 392, 7, 11, 6, 0, -11 },
  { 402, 6, 11, 6, 0, -11 },
  { 411, 6, 11, 5, 1, -11 },
  { 420, 8, 11, 7, 0, -11 },
  { 431, 7, 11, 6, 1, -11 },
  { 441, 10, 11, 10, 1, -11 },
  { 455, 8, 11, 6, -1, -11 },
  { 466, 6, 11, 6, 1, -11 },
  { 475, 7, 11, 5, -1, -11 },
  { 485, 5, 13, 4, 0, -11 },
  { 494, 3, 11, 5, 1, -11 },
  { 499, 6, 13, 4, -1, -11 },
  { 509, 6, 6, 6, 0, -11 },
  { 514, 5, 1, 5, -1, 1 },
  { 515, 2, 2, 4, 2, -11 },
  { 516, 7, 8, 7, 0, -8 },
  { 523, 6, 11, 6, 0, -11 },
  { 532, 5, 8, 5, 0, -8 },
  { 537, 7, 11, 7, 0, -11 },
  { 547, 6, 8, 6, 0, -8 },
  { 553, 7, 15, 4, -2, -11 },
  { 567, 7, 12, 7, 0, -8 },
  { 578, 6, 11, 6, 0, -11 },
  { 587, 4, 11, 3, 0, -11 },
  { 593, 6, 15, 3, -2, -11 },
  { 605, 6, 11, 6, 0, -11 },
  { 614, 4, 11, 3, 0, -11 },
  { 620, 9, 8, 9, 0, -8 },
  { 629, 6, 8, 6, 0, -8 },
  { 635, 6, 8, 6, 0, -8 },
  { 641, 7, 12, 6, -1, -8 },
  { 652, 7, 12, 7, 0, -8 },
  { 663, 5, 8, 4, 0, -8 },
  { 668, 5, 8, 5, 0, -8 },
  { 673, 4, 10, 4, 0, -10 },
  { 678, 6, 8, 6, 0, -8 },
  { 684, 5, 8, 5, 1, -8 },
  { 689, 8, 8, 8, 1, -8 },
  { 697, 7, 8, 5, -1, -8 },
  { 704, 7, 12, 5, -1, -8 },
  { 715, 6, 8, 4, -1, -8 },
  { 721, 6, 13, 5, 0, -11 },
  { 731, 1, 15, 6, 2, -11 },
  { 733, 6, 13, 5, -1, -11 },
  { 743, 5, 2, 7, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC15PT7B_H_
