#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x3E, 0x3E,
  0x78, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C,
  0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x0E, 0x0E, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03,
  0x87, 0x80, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70,
  0xF0, 0x01, 0xE1, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC0, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80,
  0x07, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0xF0, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3C,
  0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0,
  0x03, 0xC3, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xCC, 0x60, 0x3C, 0x61, 0x03, 0xE6, 0x00, 0x1E, 0x30, 0x00,
  0xF1, 0x80, 0x07, 0xCC, 0x00, 0x3E, 0x60, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0D, 0xF0, 0x00, 0x47, 0x80, 0x06, 0x3C,
  0x00, 0x31, 0xE0, 0x01, 0x8F, 0x08, 0x0C, 0xF8, 0x30, 0xC7, 0x83, 0xE6,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xF0, 0x07, 0x80, 0x7F, 0x00, 0x70, 0x0F, 0xF8, 0x0F, 0x01,
  0xE7, 0x80, 0xE0, 0x1C, 0x38, 0x1E, 0x03, 0xC3, 0x83, 0xC0, 0x3C, 0x38,
  0x3C, 0x03, 0x87, 0x87, 0x80, 0x78, 0x78, 0x78, 0x07, 0x87, 0x8F, 0x00,
  0x70, 0x78, 0xE0, 0x07, 0x07, 0x1E, 0x00, 0x70, 0x71, 0xC0, 0x0F, 0x0F,
  0x3C, 0x00, 0xF0, 0xE3, 0x8F, 0xCF, 0x0E, 0x79, 0xFE, 0xF1, 0xE7, 0x1F,
  0xE7, 0x3C, 0xF3, 0xCE, 0x7F, 0xCE, 0x78, 0xF7, 0xF9, 0xE7, 0x0F, 0x3F,
  0x1C, 0x70, 0xF0, 0x03, 0xCF, 0x0F, 0x00, 0x38, 0xE0, 0xE0, 0x07, 0x8E,
  0x0E, 0x00, 0xF1, 0xE0, 0xE0, 0x0F, 0x1E, 0x1E, 0x01, 0xE1, 0xE1, 0xE0,
  0x1E, 0x1C, 0x1C, 0x03, 0xC1, 0xC3, 0xC0, 0x38, 0x1C, 0x3C, 0x07, 0x81,
  0xC3, 0x80, 0x70, 0x1E, 0x78, 0x0F, 0x01, 0xFF, 0x00, 0xE0, 0x0F, 0xE0,
  0x1E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00,
  0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF9,
  0xE0, 0x03, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xC7, 0xDE, 0x1E, 0x3E,
  0x7C, 0x78, 0xF1, 0xF3, 0xE7, 0xC3, 0xCF, 0x1E, 0x0F, 0xFC, 0xF8, 0x3F,
  0xE3, 0xE0, 0x7F, 0x8F, 0x01, 0xFC, 0x3C, 0x07, 0xE0, 0xF0, 0x0F, 0x83,
  0xC0, 0x7E, 0x0F, 0x83, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0x8F, 0x83, 0xFC, 0x3E, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C,
  0x79, 0xE3, 0xC7, 0x8F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x02, 0x1E, 0x0E,
  0x3C, 0x1F, 0x70, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xFE, 0x1F, 0x80, 0x7F,
  0x01, 0xFF, 0x07, 0xCF, 0x1F, 0x1E, 0x1E, 0x3E, 0x08, 0x38, 0x00, 0x40,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1,
  0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3D, 0xF7, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0x3E, 0x3C, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE3,
  0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C,
  0x03, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8,
  0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xF0,
  0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xF8,
  0xFF, 0xCF, 0xBE, 0xF9, 0xE3, 0x8F, 0x08, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xE0,
  0xFC, 0x03, 0x01, 0xF0, 0x08, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1C,
  0x1F, 0x80, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x40, 0x0F, 0xC3, 0x00, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0E,
  0xF8, 0x00, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x0F, 0x00,
  0x78, 0xF8, 0x03, 0x87, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x1C, 0x0F,
  0x01, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF7, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xE7,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x08, 0x03, 0xF0, 0x80, 0x7E, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE7, 0xE0, 0x3C, 0xFF, 0x03, 0xDF, 0xF0,
  0x7F, 0xFF, 0x87, 0xF0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0x78, 0x7C, 0x07,
  0x87, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0x7C,
  0x7E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x07,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1F, 0x07, 0x81, 0xF0,
  0x78, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xFB, 0xF0, 0x3F, 0x1F,
  0x03, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0xF8,
  0x1F, 0x0F, 0xE7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE3,
  0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E,
  0x03, 0xE1, 0xE0, 0x7E, 0x1F, 0x07, 0xE1, 0xF0, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xBC, 0x0F, 0xF7, 0xC0, 0x7E, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0x81, 0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xE0,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xC3, 0xF0, 0xFC, 0x3E,
  0x0F, 0x80, 0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x0C, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xC0, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x70, 0x1F, 0x07, 0x0F,
  0x07, 0xFC, 0x70, 0xE0, 0xFF, 0x87, 0x1C, 0x1E, 0x38, 0x71, 0xC3, 0xC3,
  0x87, 0x3C, 0x38, 0x78, 0x73, 0x87, 0x87, 0x07, 0x38, 0x70, 0x70, 0xF7,
  0x87, 0x0F, 0x0E, 0x70, 0xF0, 0xF0, 0xE7, 0x0E, 0x0E, 0x0E, 0x70, 0xE0,
  0xE0, 0xE7, 0x0E, 0x1E, 0x1C, 0xF1, 0xE1, 0xE1, 0xCF, 0x1E, 0x1E, 0x3C,
  0xF1, 0xE3, 0xC3, 0x8E, 0x1E, 0x3C, 0x70, 0xE0, 0xFE, 0xFF, 0x0E, 0x0F,
  0xEF, 0xE0, 0xE0, 0x7C, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x40, 0x03, 0xE0, 0x18, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00,
  0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7C,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3E, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x03,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x80,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x7E, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0xF8, 0x0F,
  0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07,
  0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x10, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3E, 0x3F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3F,
  0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x0F, 0x81, 0xE0, 0x3F, 0x07, 0xC0, 0xFC,
  0x0F, 0x83, 0xF0, 0x1F, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xF8, 0x1C, 0x07, 0xE0, 0x04, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F,
  0xF0, 0xF8, 0x11, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xC0, 0xFC, 0x03, 0xC0, 0x7E, 0x07, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x7C,
  0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x7C, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x78, 0x0F,
  0x80, 0x3C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x78, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x07, 0xBE, 0x03, 0xEF, 0x01, 0xEF, 0x80, 0xFB, 0xC0, 0xFB, 0xE0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x0F, 0x3C, 0x0F, 0x3C, 0x03, 0xCF, 0x07, 0x9F, 0x01,
  0xF3, 0xC1, 0xE7, 0xC0, 0x7C, 0xF0, 0xF1, 0xE0, 0x1E, 0x3C, 0x3C, 0x78,
  0x07, 0x8F, 0x1E, 0x1E, 0x01, 0xE3, 0xC7, 0x8F, 0x80, 0xF8, 0x73, 0xC3,
  0xE0, 0x3E, 0x1E, 0xF0, 0xF0, 0x0F, 0x07, 0xBC, 0x3C, 0x03, 0xC1, 0xFE,
  0x1F, 0x00, 0xF0, 0x7F, 0x87, 0xC0, 0x7C, 0x1F, 0xC1, 0xF0, 0x1E, 0x07,
  0xF0, 0x78, 0x07, 0x81, 0xF8, 0x1E, 0x01, 0xE0, 0x7E, 0x0F, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x00,
  0x01, 0xF8, 0x01, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFC,
  0x01, 0xE0, 0x3F, 0x80, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xFF, 0x01, 0xF0,
  0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1E, 0xF0,
  0x3E, 0x03, 0xCF, 0x07, 0xC0, 0x79, 0xE0, 0xF0, 0x1F, 0x3C, 0x1E, 0x03,
  0xE7, 0x83, 0xC0, 0x78, 0xF0, 0xF8, 0x0F, 0x1E, 0x1F, 0x01, 0xE1, 0xE3,
  0xC0, 0x7C, 0x3C, 0x78, 0x0F, 0x87, 0x8F, 0x01, 0xE0, 0xF3, 0xE0, 0x3C,
  0x1E, 0x7C, 0x07, 0x83, 0xCF, 0x01, 0xF0, 0x3D, 0xE0, 0x3E, 0x07, 0xBC,
  0x07, 0x80, 0xFF, 0x80, 0xF0, 0x1F, 0xE0, 0x1E, 0x03, 0xFC, 0x07, 0xC0,
  0x7F, 0x80, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0xFE, 0x03, 0xC0, 0x1F, 0x80,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE0,
  0xFC, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0,
  0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1E, 0x07, 0x80, 0xF8,
  0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3C,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F,
  0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3E,
  0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78,
  0x3E, 0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x78, 0x0F, 0x87, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x0F, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF8,
  0x07, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0x78,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF0, 0x70, 0x0F, 0x80,
  0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0x00, 0x7C, 0x0F, 0x03, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00,
  0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1F,
  0x07, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x7C,
  0x0F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0x80, 0x1F, 0x7C, 0x00,
  0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x78,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xDF, 0x00, 0x78,
  0x03, 0xE7, 0xC0, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x3C, 0x7C, 0x03,
  0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x03, 0xE1, 0xF0,
  0x1F, 0x80, 0xF8, 0x7C, 0x0F, 0xE0, 0x3C, 0x1E, 0x03, 0xB8, 0x1F, 0x07,
  0x81, 0xFE, 0x07, 0xC1, 0xE0, 0x7F, 0x81, 0xE0, 0x78, 0x1D, 0xE0, 0xF8,
  0x1E, 0x0F, 0x78, 0x3C, 0x07, 0x83, 0xDE, 0x1F, 0x01, 0xE1, 0xE7, 0x87,
  0xC0, 0x78, 0x79, 0xE1, 0xE0, 0x1E, 0x1E, 0x78, 0xF8, 0x07, 0x8F, 0x1E,
  0x3C, 0x01, 0xE3, 0xC7, 0x9F, 0x00, 0x79, 0xE1, 0xE7, 0xC0, 0x1E, 0x78,
  0x79, 0xE0, 0x07, 0x9E, 0x1E, 0xF8, 0x01, 0xEF, 0x07, 0xBC, 0x00, 0x7B,
  0xC1, 0xEF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1D, 0xE0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x7C, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1E, 0x3C,
  0x07, 0xC7, 0x80, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xE1, 0xF0, 0x7C,
  0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x00, 0x7B,
  0xE0, 0x0F, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x3E,
  0x78, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1F,
  0x01, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0xF8, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7C, 0x7C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x00, 0xF8, 0x00, 0x1F, 0xCF, 0x03, 0xFE, 0xF0, 0x7F, 0xFF, 0x0F,
  0xC7, 0xF0, 0xF8, 0x7E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7F, 0x07, 0xFF,
  0xE0, 0x7F, 0xDE, 0x07, 0xFD, 0xE0, 0x3F, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC7,
  0x80, 0x7D, 0xFC, 0x07, 0xBF, 0xE0, 0x7F, 0xFE, 0x07, 0xE3, 0xF0, 0xFC,
  0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7E, 0x1F, 0x07, 0xF7, 0xF0, 0xF7, 0xFE,
  0x0F, 0x7F, 0xC0, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFC, 0x20, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x40, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE3, 0xC0,
  0x0F, 0xE7, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xF1, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x1F, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x80,
  0xF8, 0x3F, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFE, 0xF0, 0x03,
  0xF1, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0x87, 0x83, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1E, 0x3E, 0x07, 0x8F,
  0x03, 0xE7, 0xC1, 0xF1, 0xF1, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x41, 0xF8, 0x70, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x9F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC,
  0xF0, 0x0F, 0xFB, 0xC0, 0x7F, 0xEF, 0x03, 0xF1, 0xFC, 0x0F, 0x87, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF0,
  0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1E,
  0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE1, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xF7, 0x80, 0x7F, 0xDE, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x02, 0x00, 0xF8, 0x0E, 0x0F, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x7D,
  0xFC, 0x07, 0xBF, 0xE0, 0x7F, 0xFE, 0x07, 0xF3, 0xE0, 0xFC, 0x1F, 0x0F,
  0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x02, 0x7C,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x02, 0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x03, 0xC1, 0xF0, 0x1E,
  0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF8, 0x03, 0xCF, 0x80,
  0x1E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x03,
  0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0x78, 0x3E,
  0x03, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0x81, 0xE0,
  0x1E, 0x7F, 0x1F, 0xC0, 0x7B, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07,
  0xE3, 0xFC, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0xF8, 0x1F, 0x07, 0xC3, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xE0, 0x78, 0x3C, 0x0F, 0x81, 0xE1, 0xF0, 0x3C,
  0x0F, 0x87, 0xC0, 0xF0, 0x3E, 0x1E, 0x03, 0xC0, 0xF0, 0x78, 0x1F, 0x03,
  0xC1, 0xE0, 0x7C, 0x0F, 0x0F, 0x81, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xF0,
  0xF0, 0x1E, 0x07, 0x83, 0xC0, 0xF8, 0x1E, 0x1F, 0x03, 0xE0, 0x78, 0x7C,
  0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x0F, 0x87, 0x81, 0xF0, 0x3C, 0x1E, 0x07,
  0xC0, 0xF0, 0xF8, 0x1E, 0x07, 0xC3, 0xE0, 0x78, 0x1F, 0x0F, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x79, 0xFC, 0x07, 0xBF, 0xE0, 0x7F, 0xFE,
  0x07, 0xE3, 0xE0, 0xFC, 0x1F, 0x0F, 0xC1, 0xE0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0,
  0x3C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x78, 0x3C,
  0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x07,
  0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xC7, 0xC3, 0xC1, 0xF1,
  0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x3D, 0xF0,
  0x0F, 0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x0F, 0x87,
  0x83, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x01, 0xE7, 0xF0, 0x03, 0xDF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xC3, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3E,
  0xFF, 0x00, 0x78, 0xFC, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xCF, 0x03, 0xFE, 0xF0, 0x7F, 0xEF, 0x0F,
  0xC7, 0xE0, 0xF8, 0x7E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x7C,
  0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7F, 0x0F, 0xFF,
  0xE0, 0x7F, 0xDE, 0x07, 0xFD, 0xE0, 0x3F, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x83, 0xCF, 0x81, 0xEF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x60,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC2,
  0x03, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7F, 0xE7, 0xFF,
  0x3F, 0xF0, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xD0, 0x7F, 0x81,
  0xFC, 0x0F, 0xE0, 0x0F, 0x81, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87,
  0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xFF, 0xFE,
  0x07, 0xFD, 0xE0, 0x7F, 0x9C, 0x03, 0xF1, 0xC0, 0xF0, 0x0F, 0xF8, 0x07,
  0xBC, 0x07, 0xDE, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0,
  0xF0, 0xF0, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07,
  0x9F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xFE, 0x07, 0xE0, 0x7B, 0xC0,
  0xFC, 0x1F, 0x78, 0x1F, 0x83, 0xCF, 0x07, 0xF0, 0x79, 0xE0, 0xFE, 0x1F,
  0x3C, 0x3F, 0xC3, 0xC7, 0x87, 0xF8, 0x78, 0xF0, 0xEF, 0x1E, 0x1E, 0x3D,
  0xE3, 0xC3, 0xC7, 0x3C, 0xF8, 0x79, 0xE7, 0x9E, 0x0F, 0x3C, 0xF3, 0xC1,
  0xE7, 0x1E, 0xF0, 0x3D, 0xE3, 0x9E, 0x07, 0xBC, 0x73, 0xC0, 0xF7, 0x0E,
  0xF0, 0x1F, 0xE1, 0xDE, 0x03, 0xF8, 0x3B, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0xFC, 0x0F,
  0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x9F,
  0x00, 0x1E, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x1F,
  0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01,
  0xF1, 0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x00,
  0xF3, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x8F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x10, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x2F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0x80, 0xFF, 0xA0, 0x07, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 35, 12, 0, -35 },
  { 58, 15, 13, 17, 5, -35 },
  { 83, 23, 35, 22, 0, -35 },
  { 184, 21, 40, 20, 0, -37 },
  { 289, 28, 35, 31, 2, -35 },
  { 412, 22, 35, 22, 0, -35 },
  { 509, 7, 13, 10, 5, -35 },
  { 521, 15, 43, 13, 1, -35 },
  { 602, 16, 43, 13, -4, -35 },
  { 688, 15, 17, 18, 5, -37 },
  { 720, 19, 23, 22, 2, -29 },
  { 775, 9, 13, 10, -2, -6 },
  { 790, 11, 4, 13, 1, -15 },
  { 796, 6, 6, 10, 0, -6 },
  { 801, 23, 35, 17, -2, -35 },
  { 902, 19, 35, 20, 1, -35 },
  { 986, 13, 35, 20, 5, -35 },
  { 1043, 22, 35, 20, -2, -35 },
  { 1140, 21, 35, 20, -1, -35 },
  { 1232, 21, 35, 20, -1, -35 },
  { 1324, 20, 35, 20, 0, -35 },
  { 1412, 20, 35, 20, 1, -35 },
  { 1500, 21, 35, 20, 1, -35 },
  { 1592, 20, 35, 20, 0, -35 },
  { 1680, 20, 35, 20, 0, -35 },
  { 1768, 10, 27, 11, 0, -27 },
  { 1802, 14, 34, 11, -3, -27 },
  { 1862, 19, 23, 22, 2, -29 },
  { 1917, 19, 14, 22, 2, -24 },
  { 1951, 19, 23, 22, 2, -29 },
  { 2006, 16, 35, 15, 1, -35 },
  { 2076, 28, 39, 30, 1, -35 },
  { 2213, 21, 35, 21, -3, -35 },
  { 2305, 22, 35, 22, 0, -35 },
  { 2402, 21, 36, 20, 2, -36 },
  { 2497, 23, 35, 23, 0, -35 },
  { 2598, 21, 35, 18, 0, -35 },
  { 2690, 21, 35, 17, 0, -35 },
  { 2782, 24, 36, 25, 2, -36 },
  { 2890, 26, 35, 24, 0, -35 },
  { 3004, 19, 35, 14, -2, -35 },
  { 3088, 19, 45, 11, -7, -35 },
  { 3195, 25, 35, 21, 0, -35 },
  { 3305, 14, 35, 17, 0, -35 },
  { 3367, 34, 35, 32, 0, -35 },
  { 3516, 27, 35, 26, 0, -35 },
  { 3635, 22, 35, 25, 2, -35 },
  { 3732, 22, 35, 21, 0, -35 },
  { 3829, 22, 43, 25, 2, -35 },
  { 3948, 21, 35, 21, 0, -35 },
  { 4040, 22, 35, 19, -1, -35 },
  { 4137, 18, 35, 18, 3, -35 },
  { 4216, 23, 35, 24, 2, -35 },
  { 4317, 21, 35, 21, 4, -35 },
  { 4409, 34, 35, 33, 3, -35 },
  { 4558, 26, 35, 19, -3, -35 },
  { 4672, 19, 35, 18, 4, -35 },
  { 4756, 22, 35, 17, -2, -35 },
  { 4853, 19, 43, 14, -2, -35 },
  { 4956, 8, 35, 17, 5, -35 },
  { 4991, 18, 43, 14, -3, -35 },
  { 5088, 20, 19, 20, 0, -35 },
  { 5136, 15, 3, 15, -4, 4 },
  { 5142, 8, 7, 13, 7, -37 },
  { 5149, 20, 27, 21, 1, -27 },
  { 5217, 20, 37, 21, 0, -37 },
  { 5310, 17, 27, 16, 1, -27 },
  { 5368, 23, 37, 21, 1, -37 },
  { 5475, 18, 27, 19, 1, -27 },
  { 5536, 24, 49, 12, -6, -37 },
  { 5683, 22, 39, 21, -1, -27 },
  { 5791, 20, 37, 21, 0, -37 },
  { 5884, 12, 36, 10, 0, -36 },
  { 5938, 18, 48, 10, -6, -36 },
  { 6046, 21, 37, 19, 0, -37 },
  { 6144, 12, 37, 10, 0, -37 },
  { 6200, 30, 27, 31, 0, -27 },
  { 6302, 20, 27, 21, 0, -27 },
  { 6370, 18, 27, 21, 1, -27 },
  { 6431, 23, 38, 21, -3, -27 },
  { 6541, 20, 39, 21, 1, -27 },
  { 6639, 17, 27, 14, 0, -27 },
  { 6697, 17, 27, 16, 0, -27 },
  { 6755, 13, 32, 12, 1, -32 },
  { 6807, 20, 26, 21, 1, -26 },
  { 6872, 17, 26, 17, 3, -26 },
  { 6928, 27, 26, 28, 3, -26 },
  { 7016, 22, 26, 18, -2, -26 },
  { 7088, 24, 38, 18, -4, -26 },
  { 7202, 18, 26, 15, -2, -26 },
  { 7261, 18, 43, 16, 1, -35 },
  { 7358, 4, 48, 18, 7, -37 },
  { 7382, 18, 43, 16, -3, -35 },
  { 7479, 19, 7, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC49PT7B_H_
