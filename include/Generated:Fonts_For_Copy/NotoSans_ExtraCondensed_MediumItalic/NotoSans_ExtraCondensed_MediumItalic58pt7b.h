#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x3F, 0x1F, 0x9F, 0x0F,
  0xCF, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x78, 0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x07, 0xC7,
  0x83, 0xC3, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x3E, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xBE, 0x03, 0xF3, 0x0C, 0x03, 0xE3, 0x00, 0x07,
  0xC3, 0x00, 0x07, 0xC7, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xC6, 0x00, 0x07,
  0xC6, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3B, 0xF0, 0x00,
  0x39, 0xF0, 0x00, 0x31, 0xF0, 0x00, 0x31, 0xF0, 0x00, 0x31, 0xF0, 0x00,
  0x71, 0xF0, 0x00, 0x61, 0xF0, 0x40, 0x63, 0xF0, 0x70, 0x67, 0xE0, 0xFE,
  0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x08,
  0x03, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0xFC, 0x01, 0xE0,
  0x0F, 0x3E, 0x01, 0xE0, 0x1E, 0x1E, 0x03, 0xC0, 0x3E, 0x1E, 0x03, 0xC0,
  0x3C, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x0F, 0x00,
  0x78, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x3E, 0x00,
  0xF8, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x7C, 0x00, 0xF0, 0x7C, 0x78, 0x00,
  0xF0, 0x78, 0xF8, 0x00, 0xF0, 0x78, 0xF0, 0xFC, 0xF0, 0xF9, 0xF1, 0xFE,
  0xF0, 0xF1, 0xE3, 0xFE, 0xF1, 0xF3, 0xC7, 0xDF, 0xF1, 0xE3, 0xC7, 0x8F,
  0xFF, 0xE7, 0x8F, 0x0F, 0x7F, 0xC7, 0x8F, 0x0F, 0x7F, 0x8F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x00, 0x1E, 0x3E, 0x0F, 0x00, 0x3E, 0x3C, 0x0F,
  0x00, 0x3C, 0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x1E,
  0x00, 0xF8, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1E, 0x01, 0xF0, 0x78, 0x3C,
  0x01, 0xE0, 0x78, 0x3C, 0x03, 0xE0, 0x78, 0x7C, 0x03, 0xC0, 0x78, 0x78,
  0x07, 0xC0, 0x78, 0xF8, 0x07, 0x80, 0x7D, 0xF0, 0x0F, 0x00, 0x3F, 0xE0,
  0x0F, 0x00, 0x3F, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x9F,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0xFC, 0x3F, 0xFC, 0x3E, 0x1F, 0x9F, 0x0F, 0x8F, 0xC7, 0xC7,
  0xC3, 0xE1, 0xF9, 0xF1, 0xF8, 0x3E, 0x7C, 0x7C, 0x0F, 0xBE, 0x3F, 0x03,
  0xFF, 0x8F, 0x80, 0x7F, 0xC3, 0xE0, 0x1F, 0xF0, 0xF8, 0x07, 0xF8, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF8,
  0x3F, 0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF3, 0xF0, 0x3F, 0xF8,
  0xFC, 0x07, 0xFC, 0x1F, 0x80, 0x30, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x02, 0x0F,
  0x80, 0xF1, 0xE0, 0x1F, 0xBC, 0x1B, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xEF,
  0x01, 0xF9, 0xF0, 0x7E, 0x1E, 0x03, 0x83, 0xE0, 0x30, 0x78, 0x00, 0x06,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0xFD,
  0xFB, 0xFF, 0xEF, 0xDF, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xE0, 0x0F,
  0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F,
  0x00, 0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xC0, 0x7C,
  0x3F, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7C, 0x7E,
  0xFC, 0xFC, 0xFC, 0x78, 0xF8, 0x70, 0xF8, 0x21, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xE1, 0xFC,
  0x01, 0xC0, 0x7E, 0x00, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0x81, 0xF8,
  0x03, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x10, 0x00, 0xFC, 0x0C, 0x00, 0xFE,
  0x07, 0xC3, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xE7,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x78,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x3C,
  0x1F, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x03, 0xF0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xDC, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x06, 0x0F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x80, 0x0F, 0xC0, 0x80, 0x1F, 0xC0, 0xF0, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x1F, 0xC0, 0x1F, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3E,
  0xFF, 0xF0, 0x3F, 0xE7, 0xF0, 0x3F, 0x83, 0xF0, 0x7F, 0x01, 0xF0, 0x7F,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x3F, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03,
  0xF0, 0xFC, 0x03, 0xF1, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xEF, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x7E,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xE0,
  0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3,
  0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0xF8, 0x0F,
  0xF9, 0xF0, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x18, 0x3F, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x07, 0x80, 0x20, 0x00, 0x00, 0x08, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0E, 0x0F, 0xC1, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x60, 0x0E, 0x07, 0x80, 0xFF, 0xC3, 0x81, 0xE0, 0x7F, 0xF0, 0xF0, 0xF0,
  0x3F, 0xF8, 0x3C, 0x3C, 0x1F, 0x1E, 0x0E, 0x1E, 0x07, 0x87, 0x83, 0x87,
  0x83, 0xC1, 0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C, 0x1E,
  0x3C, 0x1E, 0x0F, 0x07, 0x8F, 0x0F, 0x03, 0xC1, 0xE3, 0x83, 0xC1, 0xF0,
  0x71, 0xE0, 0xF0, 0x78, 0x3C, 0x78, 0x7C, 0x1E, 0x0F, 0x1E, 0x1E, 0x07,
  0x83, 0xC7, 0x87, 0x83, 0xE1, 0xE1, 0xE1, 0xE0, 0xF0, 0x78, 0x70, 0x78,
  0x3C, 0x1C, 0x3C, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0x8F, 0xC3, 0x83, 0xC1,
  0xF3, 0xF1, 0xE0, 0xF0, 0x7F, 0xDF, 0xF0, 0x3C, 0x0F, 0xE7, 0xF8, 0x0F,
  0x01, 0xF0, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x01, 0xF8, 0x03,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x3F, 0xC0,
  0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F,
  0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C,
  0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xF8, 0x30, 0x07, 0xF0, 0x08, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x08, 0x01, 0xFE, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x3E, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x0F,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x81, 0xF0, 0x07,
  0xF0, 0x01, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0x00, 0xFF, 0xC1, 0xF0, 0x0F, 0xFE,
  0x1F, 0x80, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0x07, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x3B, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E,
  0x3F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E,
  0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x7D, 0xF8, 0x07, 0xEF, 0x80, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0x0F,
  0xCF, 0x81, 0xF3, 0xF0, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x0F, 0x8F, 0x83,
  0xE3, 0xE0, 0x0F, 0x8F, 0x83, 0xC3, 0xE0, 0x0F, 0x8F, 0x87, 0xC7, 0xE0,
  0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x1F, 0x0F,
  0x8F, 0x87, 0xC0, 0x1F, 0x0F, 0x9F, 0x07, 0xC0, 0x1F, 0x0F, 0x9F, 0x0F,
  0xC0, 0x3F, 0x07, 0xBE, 0x0F, 0x80, 0x3E, 0x07, 0xBE, 0x0F, 0x80, 0x3E,
  0x07, 0xBC, 0x0F, 0x80, 0x3E, 0x07, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xF8, 0x1F, 0x00,
  0x7C, 0x07, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0x00,
  0x3E, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0x03, 0xEF, 0x80,
  0xFC, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xE7, 0x80, 0xF8, 0x03, 0xE7, 0x80,
  0xF8, 0x07, 0xC7, 0xC1, 0xF8, 0x07, 0xC7, 0xC1, 0xF8, 0x07, 0xC7, 0xC1,
  0xF0, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0xC3, 0xC1, 0xF0, 0x0F, 0x83, 0xC3,
  0xF0, 0x0F, 0x83, 0xE3, 0xE0, 0x0F, 0x83, 0xE3, 0xE0, 0x0F, 0x83, 0xE3,
  0xE0, 0x1F, 0x83, 0xE3, 0xE0, 0x1F, 0x01, 0xE7, 0xE0, 0x1F, 0x01, 0xE7,
  0xC0, 0x1F, 0x01, 0xF7, 0xC0, 0x1F, 0x01, 0xF7, 0xC0, 0x3F, 0x01, 0xF7,
  0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0xFF,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x07,
  0xE0, 0x3F, 0x07, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0x8F,
  0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3E,
  0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8,
  0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xC7, 0xC0, 0x1F, 0xC0, 0x30, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x03,
  0x00, 0x1F, 0x80, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0xBF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF9,
  0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFB,
  0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0xF8, 0x00, 0xFC, 0x00, 0xFD, 0xF0, 0x01, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0x7F, 0x00, 0x7E, 0x3E, 0x00, 0xFE, 0x00, 0xF8, 0x7C,
  0x03, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xF0,
  0x0F, 0x83, 0xE0, 0x3F, 0xE0, 0x3F, 0x07, 0xC0, 0x7B, 0xC0, 0x7C, 0x0F,
  0x81, 0xF7, 0x81, 0xF8, 0x1F, 0x03, 0xEF, 0x03, 0xF0, 0x3E, 0x07, 0x9E,
  0x07, 0xC0, 0x7C, 0x1F, 0x3C, 0x1F, 0x80, 0xF8, 0x3C, 0x78, 0x3E, 0x01,
  0xF0, 0xF9, 0xF0, 0x7C, 0x03, 0xE1, 0xF3, 0xE1, 0xF8, 0x07, 0xC3, 0xC7,
  0xC3, 0xE0, 0x0F, 0x8F, 0x8F, 0x8F, 0xC0, 0x3F, 0x1F, 0x1F, 0x1F, 0x00,
  0x7E, 0x7C, 0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x7C, 0xFC, 0x01, 0xF9, 0xE0,
  0xF9, 0xF0, 0x03, 0xE7, 0xC1, 0xF7, 0xE0, 0x07, 0xCF, 0x83, 0xEF, 0x80,
  0x0F, 0x9E, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x0F, 0xFE, 0x00, 0x3E, 0xF0,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x3D, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x3F, 0x00,
  0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x03, 0xF0,
  0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x1E, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x1F, 0x01, 0xFF, 0x9F, 0x03,
  0xFF, 0xDF, 0x03, 0xFF, 0xFE, 0x07, 0xF1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7E,
  0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F,
  0xC7, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0xF0, 0x03, 0xF3, 0xF8, 0x03,
  0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x7E, 0x07,
  0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x7F,
  0x07, 0xE0, 0x7F, 0x8F, 0xE0, 0x7B, 0xFF, 0xC0, 0xFB, 0xFF, 0x80, 0xF9,
  0xFF, 0x00, 0xF0, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x04, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x02, 0x07, 0xF1, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xC1, 0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0xE7, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x01, 0xF8,
  0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF1, 0xFE, 0x00, 0x7F, 0xFB,
  0xC0, 0x0F, 0xFE, 0x78, 0x00, 0xFF, 0x9F, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xBF, 0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F,
  0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x3E, 0x1F, 0x07, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x20, 0xFC, 0x06, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE, 0x40,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xF9, 0xF0,
  0x07, 0xFE, 0x7C, 0x01, 0xFF, 0xDF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x1F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00,
  0x7C, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x7E, 0x3F, 0xE0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x7C, 0x00, 0xFF, 0x9F, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x02,
  0x00, 0x7E, 0x00, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x7E, 0xFF, 0x00, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3,
  0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x08, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0x00, 0x7C, 0xFF, 0x0F, 0xF0, 0x0F, 0xBF, 0xF3, 0xFF, 0x01, 0xEF,
  0xFE, 0xFF, 0xF0, 0x3D, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0xF8, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF0, 0x1F, 0x87, 0xE0, 0x3E,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x0F, 0x83,
  0xE0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xFC,
  0x07, 0xC1, 0xF0, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0x1F,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xCF, 0xF0, 0x0F,
  0x3F, 0xF0, 0x1E, 0xFF, 0xF0, 0x3D, 0xFF, 0xE0, 0xFF, 0x0F, 0xC1, 0xFC,
  0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00,
  0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3E, 0x7C, 0x00, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0xFC, 0x01, 0xF3, 0xF0,
  0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x1F,
  0x07, 0xC0, 0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x0F, 0x8F, 0xE0, 0x01, 0xF3, 0xFE, 0x00, 0x3E, 0xFF, 0xE0, 0x07, 0xBF,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F,
  0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x3E, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x83, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x07, 0xCF, 0xF8, 0x00, 0xF8, 0xFE, 0x00, 0x1F, 0x06, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0x9F, 0x00, 0xFF, 0xDF, 0x01, 0xFF, 0xDF, 0x03, 0xFF, 0xFE, 0x07,
  0xF1, 0xFE, 0x07, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F, 0xCF, 0xC0, 0x02, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x7E, 0x03, 0xCF, 0xE0, 0x3C, 0xFE,
  0x03, 0xDF, 0xC0, 0x7F, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xF0, 0x30, 0x1F, 0x00, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x30, 0x0F, 0xC1, 0xE1, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x87, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF1, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x02, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF0,
  0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xF0,
  0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0x80, 0x7F, 0xE7, 0x80, 0x3F, 0xC7, 0x80,
  0x06, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xF9, 0xF8,
  0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0,
  0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3D, 0xF0,
  0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x07, 0xF0, 0x1F, 0xBE, 0x03, 0xF0, 0x0F, 0x9F, 0x01, 0xF8,
  0x0F, 0x8F, 0x81, 0xFC, 0x07, 0xC7, 0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0xFF,
  0x03, 0xE1, 0xF0, 0x7F, 0x81, 0xF0, 0xF8, 0x3F, 0xC1, 0xF0, 0xF8, 0x3D,
  0xE0, 0xF8, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E, 0x1F, 0x78, 0x7C, 0x1F, 0x0F,
  0x3C, 0x3E, 0x0F, 0x87, 0x9E, 0x3E, 0x07, 0xC7, 0xCF, 0x1F, 0x03, 0xE3,
  0xC7, 0x8F, 0x81, 0xF3, 0xE3, 0xCF, 0x80, 0xF9, 0xE1, 0xE7, 0xC0, 0x7C,
  0xF0, 0xF3, 0xC0, 0x3E, 0xF8, 0xFB, 0xE0, 0x1F, 0x78, 0x7D, 0xF0, 0x0F,
  0xBC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xFC,
  0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xA0, 0x03, 0xFC, 0x40,
  0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 42, 14, 0, -41 },
  { 80, 17, 15, 21, 6, -41 },
  { 112, 27, 41, 25, 0, -41 },
  { 251, 24, 47, 23, 0, -44 },
  { 392, 32, 43, 37, 3, -42 },
  { 564, 26, 43, 26, 0, -42 },
  { 704, 8, 15, 12, 6, -41 },
  { 719, 18, 51, 15, 1, -42 },
  { 834, 18, 51, 15, -4, -42 },
  { 949, 19, 20, 22, 5, -44 },
  { 997, 22, 27, 26, 2, -34 },
  { 1072, 11, 15, 12, -3, -7 },
  { 1093, 13, 5, 16, 1, -18 },
  { 1102, 7, 8, 12, 0, -7 },
  { 1109, 28, 42, 20, -3, -42 },
  { 1256, 22, 43, 23, 1, -42 },
  { 1375, 16, 41, 23, 6, -41 },
  { 1457, 25, 42, 23, -2, -42 },
  { 1589, 25, 43, 23, -1, -42 },
  { 1724, 25, 42, 23, -1, -42 },
  { 1856, 24, 42, 23, 0, -41 },
  { 1982, 24, 43, 23, 1, -42 },
  { 2111, 24, 41, 23, 2, -41 },
  { 2234, 24, 43, 23, 0, -42 },
  { 2363, 23, 43, 23, 0, -42 },
  { 2487, 12, 33, 12, 0, -32 },
  { 2537, 15, 40, 12, -3, -32 },
  { 2612, 22, 27, 26, 2, -34 },
  { 2687, 22, 17, 26, 2, -29 },
  { 2734, 23, 27, 26, 2, -34 },
  { 2812, 19, 43, 18, 1, -42 },
  { 2915, 34, 47, 35, 1, -42 },
  { 3115, 25, 42, 25, -4, -42 },
  { 3247, 26, 41, 26, 0, -41 },
  { 3381, 25, 43, 23, 2, -42 },
  { 3516, 27, 41, 28, 0, -41 },
  { 3655, 24, 41, 22, 0, -41 },
  { 3778, 24, 41, 21, 0, -41 },
  { 3901, 29, 43, 29, 2, -42 },
  { 4057, 30, 41, 29, 0, -41 },
  { 4211, 23, 41, 16, -3, -41 },
  { 4329, 23, 52, 12, -9, -41 },
  { 4479, 29, 41, 24, 0, -41 },
  { 4628, 17, 41, 20, 0, -41 },
  { 4716, 40, 41, 38, 0, -41 },
  { 4921, 32, 41, 31, 0, -41 },
  { 5085, 27, 43, 30, 2, -42 },
  { 5231, 26, 41, 24, 0, -41 },
  { 5365, 27, 52, 30, 2, -42 },
  { 5541, 25, 41, 25, 0, -41 },
  { 5670, 26, 43, 22, -1, -42 },
  { 5810, 21, 41, 21, 4, -41 },
  { 5918, 28, 42, 28, 2, -41 },
  { 6065, 24, 41, 24, 5, -41 },
  { 6188, 39, 41, 39, 4, -41 },
  { 6388, 30, 41, 23, -3, -41 },
  { 6542, 22, 41, 22, 5, -41 },
  { 6655, 26, 41, 20, -2, -41 },
  { 6789, 22, 51, 16, -2, -42 },
  { 6930, 10, 42, 20, 6, -42 },
  { 6983, 22, 51, 16, -4, -42 },
  { 7124, 24, 23, 24, 0, -41 },
  { 7193, 19, 4, 18, -5, 5 },
  { 7203, 9, 9, 15, 8, -44 },
  { 7214, 24, 33, 25, 1, -32 },
  { 7313, 24, 45, 25, 0, -44 },
  { 7448, 20, 33, 19, 1, -32 },
  { 7531, 27, 45, 25, 1, -44 },
  { 7683, 21, 33, 23, 1, -32 },
  { 7770, 28, 58, 14, -7, -44 },
  { 7973, 26, 46, 25, -1, -32 },
  { 8123, 23, 44, 25, 0, -44 },
  { 8250, 14, 43, 12, 0, -43 },
  { 8326, 21, 57, 12, -7, -43 },
  { 8476, 25, 44, 22, 0, -44 },
  { 8614, 15, 44, 12, 0, -44 },
  { 8697, 35, 32, 37, 0, -32 },
  { 8837, 23, 32, 25, 0, -32 },
  { 8929, 22, 33, 24, 1, -32 },
  { 9020, 27, 46, 25, -3, -32 },
  { 9176, 24, 46, 25, 1, -32 },
  { 9314, 20, 32, 17, 0, -32 },
  { 9394, 21, 33, 19, -1, -32 },
  { 9481, 15, 39, 15, 2, -38 },
  { 9555, 24, 32, 25, 1, -31 },
  { 9651, 21, 31, 21, 3, -31 },
  { 9733, 33, 31, 33, 3, -31 },
  { 9861, 26, 31, 21, -3, -31 },
  { 9962, 29, 45, 21, -5, -31 },
  { 10126, 21, 31, 17, -2, -31 },
  { 10208, 22, 50, 19, 1, -41 },
  { 10346, 5, 58, 21, 8, -44 },
  { 10383, 21, 50, 19, -3, -41 },
  { 10515, 23, 8, 26, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC58PT7B_H_
