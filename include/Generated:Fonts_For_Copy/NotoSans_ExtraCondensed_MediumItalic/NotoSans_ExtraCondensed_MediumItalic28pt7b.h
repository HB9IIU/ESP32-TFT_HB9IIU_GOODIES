#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3,
  0x06, 0x00, 0x00, 0x20, 0xE3, 0x87, 0x00, 0x77, 0x67, 0xE6, 0xE6, 0xC6,
  0xCE, 0xCC, 0x03, 0x18, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x66, 0x03, 0x30,
  0xFF, 0xE7, 0xFF, 0x0C, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x0F, 0xFE, 0x7F,
  0xF0, 0xCC, 0x06, 0x60, 0x63, 0x03, 0x30, 0x19, 0x81, 0x9C, 0x00, 0x00,
  0x80, 0x18, 0x07, 0xE0, 0xFF, 0x1D, 0x61, 0x90, 0x3B, 0x03, 0xA0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x5C, 0x05, 0xC0, 0x5C, 0x89,
  0x8F, 0xF8, 0xFF, 0x03, 0xC0, 0x18, 0x01, 0x00, 0x10, 0x00, 0x1E, 0x0C,
  0x3E, 0x0C, 0x33, 0x18, 0x63, 0x18, 0x63, 0x30, 0x66, 0x70, 0x66, 0x60,
  0xC6, 0xC0, 0xC6, 0xCE, 0xCD, 0x9F, 0x7D, 0xB3, 0x7B, 0x33, 0x03, 0x63,
  0x06, 0x63, 0x06, 0x66, 0x0C, 0x66, 0x0C, 0x66, 0x18, 0x6C, 0x18, 0x7C,
  0x30, 0x78, 0x07, 0xC0, 0x7E, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCC, 0x0D,
  0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x3E, 0x33, 0x77, 0x67, 0x7E, 0x36, 0xE3,
  0xEC, 0x3C, 0xC3, 0xCE, 0x7C, 0xFE, 0xC7, 0xCE, 0x76, 0x6E, 0xEC, 0xC0,
  0x03, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xE0, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x03,
  0x03, 0x03, 0x81, 0x81, 0xC1, 0xC0, 0x1C, 0x0E, 0x36, 0x1F, 0xE7, 0xF9,
  0xE1, 0xF1, 0xDC, 0x46, 0x02, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x39, 0x9C, 0xC6, 0x63, 0x00, 0x7E, 0xFF, 0xF8, 0x27, 0xFE,
  0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x00, 0x07, 0x83, 0xF1,
  0xDC, 0xE3, 0x30, 0xDC, 0x37, 0x0D, 0x87, 0x61, 0xF8, 0x7E, 0x1F, 0x86,
  0xC3, 0xB0, 0xEC, 0x33, 0x1C, 0xC7, 0x3B, 0x8F, 0xC1, 0xE0, 0x06, 0x3C,
  0xFB, 0xFE, 0xD9, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0xE1, 0xC3, 0x00, 0x03, 0xE0, 0xFF, 0x0C, 0x70, 0x83, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xFF, 0xCF, 0xF8, 0x0F, 0xC3,
  0xFC, 0x63, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x0E, 0x07, 0x83, 0xC0,
  0x7E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x90, 0xF3, 0xFC,
  0x7E, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x6C, 0x04,
  0xC0, 0xDC, 0x19, 0xC1, 0x98, 0x31, 0x86, 0x18, 0x63, 0x8F, 0xFC, 0xFF,
  0xCF, 0xFC, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0F, 0xF0, 0xFE, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x88, 0x78, 0xFF,
  0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0xB0, 0x6F, 0x9F, 0xF3, 0xC6, 0x70, 0xCE, 0x19, 0x83, 0x30, 0xE6, 0x1C,
  0xC3, 0x1C, 0xE3, 0xF8, 0x3E, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0x07, 0xC0, 0xFE, 0x1C, 0x71, 0x87, 0x18, 0x71, 0x86, 0x18, 0xE1, 0xDC,
  0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xB8, 0x71, 0xCE, 0x1C, 0xE1, 0xCC, 0x1C,
  0xE1, 0xCE, 0x38, 0x7F, 0x07, 0xE0, 0x07, 0xC1, 0xFC, 0x73, 0x8C, 0x33,
  0x86, 0x70, 0xCC, 0x39, 0x87, 0x30, 0xE6, 0x3C, 0xFF, 0x9F, 0x61, 0xDC,
  0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xE3, 0xF8, 0x7C, 0x00, 0x1C, 0x71,
  0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xE3, 0x8E, 0x00, 0x0E, 0x1C,
  0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x86, 0x1C, 0x30,
  0xE1, 0x83, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x78, 0x3C, 0x1F, 0x0F, 0x83, 0xC0, 0x60, 0x00,
  0x1F, 0x8F, 0xE1, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x01,
  0x80, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x06, 0x1C, 0x06, 0x18, 0x02, 0x30,
  0xE3, 0x33, 0xF3, 0x63, 0x33, 0x66, 0x63, 0x46, 0x62, 0xCC, 0x66, 0xCC,
  0x66, 0xCC, 0xC6, 0xCC, 0xCC, 0xCD, 0xCC, 0xCF, 0x78, 0xC6, 0x70, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x71, 0xC0, 0x3F, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1B, 0x01, 0xB0, 0x3B, 0x03, 0x30, 0x73, 0x07, 0x30, 0x67,
  0x0E, 0x70, 0xC7, 0x1F, 0xF1, 0xFF, 0x38, 0x73, 0x87, 0x30, 0x77, 0x07,
  0x70, 0x7E, 0x07, 0x0F, 0xE0, 0x7F, 0x83, 0x1C, 0x38, 0x71, 0xC3, 0x8E,
  0x18, 0x61, 0xC3, 0x0E, 0x3F, 0xE1, 0xFC, 0x0F, 0xF0, 0x61, 0xC3, 0x0E,
  0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x61, 0xC7, 0x1E, 0x3F, 0xE1, 0xFC, 0x00,
  0x03, 0xF0, 0xFF, 0x0E, 0x21, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x10, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x83, 0x3C, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E,
  0x60, 0xE3, 0x07, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x61, 0xC7, 0x3C, 0x3F,
  0xC1, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xFC,
  0x3F, 0x83, 0xF8, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xF1, 0x87, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x87, 0xCE, 0x1F, 0x38, 0x7C,
  0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE1, 0xC3, 0x07, 0xFC,
  0x0F, 0xF0, 0x0E, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0xE0, 0xE1, 0xC1, 0xC3,
  0x83, 0x07, 0x06, 0x0C, 0x1C, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0x83,
  0x83, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x60, 0xE1, 0xC1, 0xC3,
  0x83, 0x87, 0x07, 0x00, 0x0F, 0xE1, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x07, 0xC0, 0xF8, 0x0C, 0x00, 0x0E, 0x1C, 0x38, 0xE0,
  0xC3, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x01, 0x9C, 0x06, 0xE0, 0x3B, 0x00,
  0xFC, 0x03, 0xF0, 0x0E, 0xC0, 0x33, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0,
  0x61, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x60,
  0xE0, 0xFF, 0xFF, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x8F, 0x81,
  0xE1, 0xF0, 0x7C, 0x36, 0x0D, 0x86, 0xC3, 0xF0, 0xD8, 0x6E, 0x3B, 0x0D,
  0x87, 0x63, 0x30, 0xCC, 0x6E, 0x19, 0x9D, 0xC3, 0x33, 0x38, 0xE6, 0xE6,
  0x1C, 0xD8, 0xC3, 0x1F, 0x38, 0x63, 0xC7, 0x1C, 0x78, 0xC3, 0x8E, 0x18,
  0x71, 0xC7, 0x00, 0x0E, 0x06, 0x1C, 0x0C, 0x3C, 0x38, 0xF8, 0x71, 0xF0,
  0xE3, 0x61, 0x86, 0xC3, 0x0D, 0x8E, 0x3B, 0x9C, 0x73, 0x30, 0xC6, 0x61,
  0x8C, 0xC3, 0x1B, 0x8E, 0x37, 0x1C, 0x7C, 0x30, 0x78, 0x60, 0xF1, 0xC1,
  0xE3, 0x83, 0xC7, 0x07, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0x9C, 0x38, 0x73,
  0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x0D, 0xC0,
  0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0x9E, 0x1F, 0xE0,
  0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0x0C, 0xF1, 0xC7, 0x1C, 0x31, 0xC3, 0x1C,
  0x71, 0x87, 0x38, 0x73, 0x8E, 0x3F, 0xC3, 0xF8, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xE0, 0x7F, 0x87,
  0x9C, 0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x01,
  0xF8, 0x0D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7,
  0x9E, 0x1F, 0xE0, 0x7C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xC0, 0xFE, 0x0C, 0xF1, 0xC7, 0x1C, 0x31, 0xC7, 0x18, 0x71,
  0x87, 0x38, 0xE3, 0xBE, 0x3F, 0xC3, 0xF0, 0x33, 0x07, 0x38, 0x73, 0x87,
  0x38, 0x61, 0x8E, 0x1C, 0xE1, 0xCE, 0x1C, 0x03, 0xF0, 0x3F, 0xC3, 0xCC,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xC3, 0x1E,
  0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0x1C, 0x18, 0xC1, 0xC6, 0x0E, 0x70, 0x73,
  0x83, 0x1C, 0x18, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x1C, 0x38, 0xC1,
  0xCE, 0x0E, 0x70, 0x63, 0x83, 0x1C, 0x38, 0xE1, 0xC7, 0x1C, 0x1F, 0xC0,
  0xFC, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1,
  0x86, 0x38, 0x63, 0x86, 0x70, 0x67, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0xE0, 0xFC, 0x1C,
  0x1B, 0x83, 0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x19, 0xC7, 0xC7, 0x38, 0xD8,
  0xC7, 0x1F, 0x38, 0xE6, 0xE7, 0x1C, 0xDC, 0xC3, 0xBB, 0xB8, 0x76, 0x66,
  0x0E, 0xCD, 0xC1, 0xF9, 0xB8, 0x3E, 0x36, 0x06, 0xC7, 0xC0, 0xF0, 0xF0,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x70, 0x00, 0x07, 0x0E, 0x0E, 0x38,
  0x1C, 0x70, 0x19, 0xC0, 0x33, 0x00, 0x6E, 0x00, 0xD8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0x30,
  0x0E, 0x60, 0x38, 0xC0, 0x71, 0xC1, 0xC3, 0x87, 0x07, 0x00, 0xE0, 0xEC,
  0x39, 0x87, 0x31, 0xC6, 0x38, 0xEE, 0x1D, 0xC3, 0xF0, 0x7C, 0x0F, 0x80,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x70, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xE0, 0xFC, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x1F, 0x07, 0xE0, 0xC6, 0x31, 0xCE, 0x31,
  0x8C, 0x63, 0x18, 0xE7, 0x18, 0xC6, 0x31, 0x8E, 0x70, 0x07, 0xE0, 0xF8,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x3F, 0x07, 0xE0, 0x01, 0x80, 0x70, 0x1E, 0x03, 0xC0,
  0xFC, 0x19, 0x86, 0x31, 0xC6, 0x30, 0xEE, 0x0F, 0x81, 0x80, 0xFF, 0xFF,
  0x80, 0xE7, 0x33, 0x1F, 0x67, 0xFC, 0xE7, 0xB8, 0xE7, 0x1D, 0xC3, 0xB8,
  0x77, 0x0E, 0xC1, 0x98, 0x73, 0x0E, 0x61, 0xCE, 0x79, 0xFE, 0x1E, 0xC0,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0xFF, 0x1C,
  0x67, 0x0C, 0xE1, 0x98, 0x33, 0x06, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xCE,
  0x3B, 0xCE, 0x7F, 0xCD, 0xF0, 0x0F, 0x9F, 0xCE, 0x0E, 0x06, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x27, 0xE1, 0xF0, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x1F, 0xE3, 0xFE, 0x39, 0xE7,
  0x1C, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xC1, 0x8C, 0x18, 0xC3, 0x8C,
  0x38, 0xE7, 0x0F, 0xF0, 0x7B, 0x00, 0x0F, 0x87, 0xE3, 0x9D, 0xC7, 0x61,
  0xB8, 0xEF, 0xF3, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE1, 0x3F, 0x87,
  0xE0, 0x00, 0xF8, 0x07, 0x80, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1F,
  0x81, 0xFC, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x07, 0x80, 0x3C, 0x01, 0x80, 0x00, 0x07,
  0xD8, 0x7F, 0xC3, 0x9E, 0x38, 0xE1, 0xC7, 0x1C, 0x38, 0xE1, 0xC7, 0x0E,
  0x30, 0x61, 0x87, 0x0C, 0x38, 0x61, 0xC3, 0x9E, 0x1F, 0xE0, 0x7B, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x20, 0xE1, 0xFE, 0x0F, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0xFF, 0x1C, 0xE7,
  0x1C, 0xE3, 0x9C, 0x73, 0x0E, 0x61, 0x9C, 0x33, 0x8E, 0x61, 0xCC, 0x33,
  0x86, 0x71, 0xCE, 0x38, 0x06, 0x1C, 0x38, 0x20, 0x00, 0x07, 0x0C, 0x18,
  0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x00, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x20, 0x00, 0x00, 0x00, 0x70, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x1F, 0x03, 0xE0,
  0x70, 0x00, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x71, 0x8E, 0x19, 0xC3, 0x98, 0x3B, 0x83, 0x70, 0x3E, 0x03, 0xF0, 0x7F,
  0x07, 0x70, 0x63, 0x06, 0x30, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x0E, 0x1C,
  0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x00, 0x1B, 0xCF, 0x0F, 0xFF, 0xC7, 0x3C, 0xE7,
  0x1C, 0x73, 0x8E, 0x39, 0xC7, 0x1C, 0xC3, 0x0C, 0x61, 0x86, 0x71, 0xC7,
  0x38, 0xE3, 0x98, 0x61, 0x8C, 0x30, 0xCE, 0x18, 0xE7, 0x1C, 0x73, 0x8E,
  0x38, 0x1B, 0xC3, 0xFC, 0x73, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x39, 0x86,
  0x70, 0xCE, 0x39, 0x87, 0x30, 0xCE, 0x19, 0xC3, 0x38, 0xE0, 0x0F, 0x8F,
  0xE3, 0x9D, 0xC7, 0x61, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x6C, 0x3B,
  0x0E, 0xE7, 0x3F, 0x87, 0xC0, 0x0D, 0xF0, 0xFF, 0x0E, 0x31, 0xC3, 0x1C,
  0x31, 0xC3, 0x18, 0x31, 0x87, 0x38, 0x73, 0x87, 0x38, 0x63, 0x8E, 0x79,
  0xC7, 0xFC, 0x77, 0x86, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0x1F, 0x67, 0xFC, 0xE7, 0xB8, 0xE6, 0x1D, 0xC3, 0xB8, 0x77,
  0x0E, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0xCE, 0x71, 0xFE, 0x1E, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x1B, 0x8F, 0xC7,
  0xA7, 0x83, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07,
  0x03, 0x80, 0x1F, 0xCF, 0xE3, 0x88, 0xC0, 0x30, 0x0E, 0x03, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x8E, 0x3F, 0x8F, 0xC0, 0x1C, 0x30, 0x63,
  0xFF, 0xE6, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xF1,
  0xE0, 0x38, 0xE6, 0x1C, 0xC3, 0x38, 0x67, 0x1C, 0xC3, 0x98, 0x67, 0x0C,
  0xE3, 0x9C, 0x73, 0x0E, 0x63, 0x8C, 0x71, 0xF6, 0x3E, 0xC0, 0xC3, 0xE1,
  0xF0, 0xD8, 0xEC, 0x66, 0x73, 0x31, 0x98, 0xDC, 0x6C, 0x3E, 0x1E, 0x0F,
  0x07, 0x03, 0x80, 0x61, 0xC7, 0x63, 0xC7, 0x63, 0xC6, 0x63, 0xCE, 0x66,
  0xCC, 0x66, 0xDC, 0x6E, 0xDC, 0x6D, 0xD8, 0x6D, 0xF8, 0x79, 0xF0, 0x79,
  0xB0, 0x79, 0xF0, 0x71, 0xE0, 0x71, 0xE0, 0xF1, 0xC0, 0x1C, 0x71, 0xC6,
  0x0C, 0xE0, 0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x3B, 0x03, 0x30, 0x73, 0x86, 0x38, 0xE3, 0x80, 0x0C, 0x1C, 0x30, 0xE0,
  0xC3, 0x03, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0D, 0xC0,
  0x36, 0x00, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x1F,
  0xC7, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0x70, 0x3F, 0xCF, 0xE0, 0x01, 0xC1, 0xF0, 0x70, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0x1C, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x1C, 0x07, 0x80, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xF0,
  0x1C, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x3E, 0x07, 0x80, 0x38, 0x3F, 0xCF, 0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 20, 7, 0, -20 },
  { 19, 8, 7, 10, 3, -20 },
  { 26, 13, 20, 12, 0, -20 },
  { 59, 12, 23, 11, 0, -21 },
  { 94, 16, 20, 18, 1, -20 },
  { 134, 12, 20, 13, 0, -20 },
  { 164, 4, 7, 6, 3, -20 },
  { 168, 9, 24, 7, 0, -20 },
  { 195, 9, 24, 7, -2, -20 },
  { 222, 9, 10, 11, 3, -21 },
  { 234, 11, 14, 12, 1, -17 },
  { 254, 5, 7, 6, -1, -3 },
  { 259, 7, 3, 8, 0, -9 },
  { 262, 4, 4, 6, 0, -4 },
  { 264, 13, 20, 10, -1, -20 },
  { 297, 10, 20, 11, 1, -20 },
  { 322, 7, 20, 11, 3, -20 },
  { 340, 12, 20, 11, -1, -20 },
  { 370, 11, 20, 11, 0, -20 },
  { 398, 12, 20, 11, 0, -20 },
  { 428, 12, 20, 11, 0, -20 },
  { 458, 11, 20, 11, 1, -20 },
  { 486, 12, 20, 11, 1, -20 },
  { 516, 12, 20, 11, 0, -20 },
  { 546, 11, 20, 11, 0, -20 },
  { 574, 6, 15, 6, 0, -15 },
  { 586, 7, 19, 6, -1, -15 },
  { 603, 11, 12, 12, 1, -16 },
  { 620, 11, 8, 12, 1, -14 },
  { 631, 11, 12, 12, 1, -16 },
  { 648, 10, 20, 8, 0, -20 },
  { 673, 16, 22, 17, 1, -20 },
  { 717, 12, 20, 12, -2, -20 },
  { 747, 13, 20, 12, 0, -20 },
  { 780, 12, 20, 11, 1, -20 },
  { 810, 13, 20, 13, 0, -20 },
  { 843, 12, 20, 11, 0, -20 },
  { 873, 12, 20, 10, 0, -20 },
  { 903, 14, 20, 14, 1, -20 },
  { 938, 15, 20, 14, 0, -20 },
  { 976, 11, 20, 8, -1, -20 },
  { 1004, 11, 26, 6, -4, -20 },
  { 1040, 14, 20, 12, 0, -20 },
  { 1075, 8, 20, 10, 0, -20 },
  { 1095, 19, 20, 19, 0, -20 },
  { 1143, 15, 20, 15, 0, -20 },
  { 1181, 13, 20, 14, 1, -20 },
  { 1214, 12, 20, 12, 0, -20 },
  { 1244, 13, 25, 14, 1, -20 },
  { 1285, 12, 20, 12, 0, -20 },
  { 1315, 13, 20, 11, -1, -20 },
  { 1348, 10, 20, 10, 2, -20 },
  { 1373, 13, 20, 14, 1, -20 },
  { 1406, 12, 20, 12, 2, -20 },
  { 1436, 19, 20, 19, 2, -20 },
  { 1484, 15, 20, 11, -2, -20 },
  { 1522, 11, 20, 11, 2, -20 },
  { 1550, 13, 20, 10, -1, -20 },
  { 1583, 11, 24, 8, -1, -20 },
  { 1616, 5, 20, 10, 3, -20 },
  { 1629, 11, 24, 8, -2, -20 },
  { 1662, 11, 11, 11, 0, -20 },
  { 1678, 9, 2, 9, -2, 2 },
  { 1681, 4, 4, 7, 4, -21 },
  { 1683, 11, 15, 12, 1, -15 },
  { 1704, 11, 21, 12, 0, -21 },
  { 1733, 9, 15, 9, 1, -15 },
  { 1750, 12, 21, 12, 1, -21 },
  { 1782, 10, 15, 11, 1, -15 },
  { 1801, 13, 28, 7, -3, -21 },
  { 1847, 13, 22, 12, -1, -15 },
  { 1883, 11, 21, 12, 0, -21 },
  { 1912, 7, 21, 6, 0, -21 },
  { 1931, 11, 28, 6, -4, -21 },
  { 1970, 12, 21, 11, 0, -21 },
  { 2002, 7, 21, 6, 0, -21 },
  { 2021, 17, 15, 18, 0, -15 },
  { 2053, 11, 15, 12, 0, -15 },
  { 2074, 10, 15, 12, 1, -15 },
  { 2093, 12, 22, 12, -1, -15 },
  { 2126, 11, 22, 12, 1, -15 },
  { 2157, 9, 15, 8, 0, -15 },
  { 2174, 10, 15, 9, 0, -15 },
  { 2193, 7, 18, 7, 1, -18 },
  { 2209, 11, 15, 12, 1, -15 },
  { 2230, 9, 15, 10, 2, -15 },
  { 2247, 16, 15, 16, 1, -15 },
  { 2277, 12, 15, 10, -1, -15 },
  { 2300, 14, 22, 10, -2, -15 },
  { 2339, 10, 15, 8, -1, -15 },
  { 2358, 10, 24, 9, 1, -20 },
  { 2388, 2, 28, 10, 4, -21 },
  { 2395, 11, 24, 9, -2, -20 },
  { 2428, 11, 4, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC28PT7B_H_
