#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x79, 0xEE,
  0x39, 0xC7, 0x79, 0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x00, 0x00,
  0xE3, 0x80, 0x61, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0C, 0x70,
  0x0E, 0x38, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xC6, 0x00, 0xC7,
  0x00, 0xE3, 0x80, 0x71, 0x80, 0x30, 0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFE, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0x8E, 0x01, 0xC7, 0x00,
  0xE3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x44, 0x1E, 0x40, 0x1C,
  0x40, 0x1C, 0xC0, 0x1E, 0xC0, 0x1E, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0x78, 0x03, 0x38, 0x03, 0x38, 0x02,
  0x38, 0x82, 0x78, 0xC2, 0x70, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x04,
  0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x1C,
  0x1F, 0x81, 0x83, 0x98, 0x38, 0x71, 0x83, 0x07, 0x18, 0x70, 0x61, 0x86,
  0x0E, 0x38, 0xE0, 0xE3, 0x9C, 0x0E, 0x39, 0xC0, 0xE3, 0xB8, 0x0C, 0x73,
  0x9E, 0xC7, 0x73, 0xFE, 0x67, 0x77, 0xFE, 0xE6, 0x37, 0xCE, 0xE3, 0x39,
  0xCE, 0x30, 0x18, 0xC3, 0x03, 0x9C, 0x70, 0x31, 0xC7, 0x07, 0x1C, 0x70,
  0x61, 0x86, 0x0E, 0x18, 0xE0, 0xC1, 0x8E, 0x1C, 0x1D, 0xC1, 0x81, 0xF8,
  0x38, 0x0F, 0x00, 0x00, 0x70, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x9C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC7, 0x3D, 0xC7, 0x39,
  0xEF, 0x71, 0xEE, 0xF0, 0xFE, 0xF0, 0xFC, 0xE0, 0xFC, 0xE0, 0x78, 0xE0,
  0xF8, 0xF1, 0xF8, 0xFF, 0xFC, 0x7F, 0xBC, 0x3F, 0x3E, 0x7B, 0x9C, 0xEF,
  0x73, 0x9C, 0xE0, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x47, 0x06, 0x70, 0x7F, 0x7F, 0xFF,
  0x0F, 0xF0, 0xF0, 0x1F, 0x83, 0x98, 0x79, 0xC3, 0x1E, 0x00, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x3C, 0x71,
  0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x23, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0x0E, 0x3C, 0x78,
  0x71, 0xC1, 0xCF, 0x0F, 0x38, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70,
  0x39, 0xC0, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0x81, 0xCE, 0x0F, 0x38,
  0x3C, 0xE0, 0xE3, 0x87, 0x8E, 0x1C, 0x3C, 0xF0, 0xFF, 0x81, 0xFC, 0x03,
  0xE0, 0x00, 0x03, 0xC1, 0xE1, 0xF8, 0xFE, 0x7F, 0xBD, 0xEE, 0x71, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x00, 0x00,
  0x78, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0x9F, 0x06, 0x0F, 0x02, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x78, 0x03, 0xFE, 0x07, 0xFE, 0x07,
  0x9F, 0x02, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0xC0, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x6E, 0x00, 0xFE, 0x01, 0xDE, 0x01, 0x9C, 0x03, 0x9C, 0x03, 0x1C, 0x07,
  0x3C, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x38, 0x78, 0x30, 0x78, 0x7F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x7F, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x20, 0x78,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF0,
  0x3E, 0x20, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE7, 0x03, 0xDF, 0x87, 0x7F, 0x0F, 0x9F, 0x1E, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x38,
  0x38, 0x78, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x78, 0xF0, 0xE0, 0xE1, 0xC1,
  0xC7, 0x83, 0x8F, 0x07, 0x1E, 0x1E, 0x1C, 0x38, 0x3C, 0xE0, 0x3F, 0xC0,
  0x7E, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0x78, 0x78, 0x70, 0xE0, 0xF3, 0xC1,
  0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1E, 0x78, 0x78, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7D, 0xE0,
  0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xE0,
  0x79, 0xC0, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xB8,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x00, 0x0E, 0x0F, 0x1F, 0x1E, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x70,
  0xF0, 0xF0, 0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x03, 0x81,
  0xFE, 0x3F, 0xE3, 0x9F, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x30, 0x04, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0x80, 0xE0, 0x78, 0x07, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xE3, 0x81, 0x07,
  0x18, 0x3F, 0x19, 0xC3, 0xF8, 0xCC, 0x39, 0xC6, 0x63, 0x8C, 0x77, 0x18,
  0x63, 0xB1, 0xC7, 0x1D, 0x8E, 0x38, 0xDC, 0x61, 0x86, 0xE3, 0x1C, 0x77,
  0x38, 0xE3, 0x31, 0xC7, 0x19, 0x8E, 0x79, 0x8C, 0x7E, 0xDC, 0x61, 0xF7,
  0xC3, 0x06, 0x18, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x70, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B, 0x80,
  0x77, 0x01, 0xEE, 0x03, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0xF1,
  0xC1, 0xC3, 0x87, 0x87, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xE0, 0x73,
  0xC0, 0xE7, 0x81, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0,
  0x38, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x8F,
  0x83, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xF0, 0xF0, 0x78, 0x38, 0x38,
  0x1E, 0x1C, 0x0F, 0x0E, 0x07, 0x0F, 0x03, 0x87, 0x83, 0xC3, 0x81, 0xE1,
  0xC3, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0xFC, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x40,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x07,
  0x0E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x78, 0xE0,
  0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x0E, 0x07, 0x8F,
  0x03, 0xC7, 0x83, 0xC3, 0x83, 0xC1, 0xC7, 0xC1, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x08, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xDF, 0x07, 0x80, 0x83, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x0F, 0xC7, 0x07, 0xF3, 0xC1, 0xFC, 0xF0,
  0x0F, 0x3C, 0x03, 0x8F, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x1C, 0x07,
  0x87, 0x81, 0xC1, 0xF0, 0x70, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x83, 0x80, 0xF0, 0xF0, 0x1C,
  0x1E, 0x03, 0x83, 0xC0, 0xF0, 0x70, 0x1E, 0x0E, 0x03, 0x83, 0xC0, 0x70,
  0x78, 0x1E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x01, 0xC1,
  0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x3C, 0x07, 0x07,
  0x81, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x7F,
  0xC1, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0x70, 0x1C, 0x1E,
  0x03, 0x87, 0x80, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x73, 0xC0,
  0x0E, 0x78, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x00,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x07, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x3B, 0x81, 0xDC, 0x1D, 0xC0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0F,
  0x70, 0x77, 0x07, 0xB8, 0x7B, 0x83, 0x9C, 0x3B, 0xC1, 0xCE, 0x1D, 0xE0,
  0xE7, 0x1C, 0xE0, 0xF3, 0x8E, 0x70, 0x71, 0xCE, 0x38, 0x38, 0xE7, 0x3C,
  0x1C, 0x77, 0x1E, 0x0E, 0x3B, 0x8E, 0x0F, 0x1F, 0x87, 0x07, 0x0F, 0xC3,
  0x83, 0x87, 0xE3, 0xC1, 0xC3, 0xE1, 0xE1, 0xE1, 0xF0, 0xE0, 0xF0, 0xF0,
  0x70, 0x70, 0x78, 0x78, 0x00, 0x07, 0xC0, 0x70, 0x7C, 0x07, 0x07, 0xC0,
  0xF0, 0x7C, 0x0F, 0x0F, 0xC0, 0xE0, 0xFE, 0x0E, 0x0E, 0xE0, 0xE0, 0xEE,
  0x1E, 0x0E, 0xE1, 0xE1, 0xEE, 0x1C, 0x1E, 0xE1, 0xC1, 0xC7, 0x1C, 0x1C,
  0x73, 0xC1, 0xC7, 0x3C, 0x3C, 0x73, 0x83, 0x87, 0x38, 0x38, 0x73, 0x83,
  0x83, 0xF8, 0x38, 0x3F, 0x07, 0x83, 0xF0, 0x70, 0x3F, 0x07, 0x03, 0xF0,
  0x70, 0x3F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0E, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF9, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78,
  0x0E, 0x38, 0x07, 0x3C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xEF, 0x00, 0xF7,
  0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x1E, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xC0, 0xF0, 0xF0,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x07, 0x0F, 0x0F, 0x07, 0x0F, 0x07, 0x0F, 0x07, 0x0E, 0x07,
  0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x7C, 0x1F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xC0, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF9, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x78, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xC0, 0x1E, 0xE0, 0x0E, 0xF0, 0x0F,
  0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE1, 0xC0,
  0xF0, 0xF0, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x0F,
  0x07, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x38,
  0xF0, 0x78, 0xF0, 0x78, 0x70, 0x70, 0x70, 0x70, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x78, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC2, 0x01, 0xE0, 0xC1, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x38, 0x38, 0x0E, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xC0, 0x78, 0x70, 0x1C, 0x1C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0xE0, 0x38, 0x38, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x70,
  0x1C, 0x1C, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x3C, 0x1E,
  0x0F, 0x8F, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78,
  0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xC0,
  0xF3, 0xC0, 0xF3, 0x80, 0xF7, 0x80, 0xF7, 0x00, 0xF7, 0x00, 0xFF, 0x00,
  0xEE, 0x00, 0xEE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x1C, 0x07, 0xF8, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xDE,
  0x0F, 0x81, 0xCE, 0x07, 0xC1, 0xE7, 0x03, 0xE0, 0xE3, 0x83, 0xF0, 0xF1,
  0xC1, 0xF8, 0x78, 0xE1, 0xDC, 0x38, 0x70, 0xEE, 0x3C, 0x38, 0x77, 0x1C,
  0x1C, 0x73, 0x9E, 0x0E, 0x39, 0xCF, 0x07, 0x38, 0xE7, 0x03, 0x9C, 0x67,
  0x81, 0xCE, 0x33, 0x80, 0xEE, 0x19, 0xC0, 0x77, 0x1D, 0xE0, 0x3B, 0x8E,
  0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0,
  0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x03, 0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x70,
  0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x01,
  0xE3, 0x80, 0x78, 0x70, 0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x70, 0x3C, 0x1E,
  0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xE7, 0x07, 0x9C, 0x3C, 0x70, 0xF1, 0xC7,
  0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x00, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xC7,
  0x1C, 0x71, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x80, 0x77, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x1C, 0x38, 0x38,
  0x70, 0x71, 0xC0, 0xE7, 0x80, 0xFE, 0x01, 0xC0, 0xFF, 0xFF, 0xFE, 0xF9,
  0xE3, 0x8E, 0x1C, 0x30, 0x07, 0xCE, 0x1F, 0xDC, 0x7F, 0xF8, 0xF1, 0xE3,
  0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0xC0,
  0xE7, 0x83, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x78, 0xF1, 0xF1,
  0xFF, 0xC1, 0xFB, 0x83, 0xE7, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x7C, 0x1D,
  0xF8, 0x3F, 0xF8, 0xF8, 0xF1, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07,
  0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x79, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x0E, 0x3C, 0x3C, 0x78, 0xF1, 0xFF, 0xE3, 0xBF, 0x87, 0x3E, 0x00, 0x03,
  0xF0, 0xFF, 0x1F, 0xE1, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x8F, 0xF8, 0x7F, 0x83, 0xF0, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x07, 0xCE,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0xC7, 0x83, 0xC3, 0xC1, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x70, 0x70, 0x38, 0x78, 0x1C, 0x3C, 0x0E, 0x1E, 0x0F, 0x0E,
  0x07, 0x07, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xF1, 0xF0, 0x7F, 0xF0,
  0x1F, 0xB8, 0x0F, 0x9C, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x73,
  0xC3, 0x9C, 0x1D, 0xE1, 0xEE, 0x1E, 0x73, 0xE7, 0xFE, 0x3F, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x47, 0xEE, 0x1F, 0xF0,
  0x7F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF3, 0x81,
  0xFD, 0xC1, 0xFF, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x1C, 0x0E, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0x81,
  0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x7C, 0x1F, 0xFC, 0x07,
  0xEE, 0x03, 0xE7, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x60, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x7C, 0x1D, 0xF8, 0x3F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC7, 0x07, 0x0E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xE0, 0xF1, 0xC1,
  0xC3, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0x70, 0x71, 0xE0, 0xE3,
  0xC3, 0xC7, 0x07, 0x80, 0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x00,
  0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x0F,
  0xC0, 0x3F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x0F, 0x0E,
  0x1E, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x70, 0x1C, 0xF0, 0x1D, 0xE0, 0x1D,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3D, 0xC0, 0x39, 0xC0, 0x79,
  0xE0, 0x71, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xE0,
  0xF0, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x00, 0x0E, 0xFC, 0xF8,
  0x3F, 0xF7, 0xF0, 0xFF, 0xFF, 0xC7, 0xC7, 0xC7, 0x1E, 0x1E, 0x1C, 0x78,
  0x78, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x0F, 0x3C, 0x3C, 0x3C, 0xE0, 0xF0,
  0xE3, 0x83, 0x83, 0x8E, 0x0E, 0x0E, 0x78, 0x38, 0x79, 0xE1, 0xE1, 0xE7,
  0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0x73, 0xC3, 0xC3, 0xCF, 0x0F,
  0x0E, 0x38, 0x38, 0x38, 0x0E, 0x7C, 0x1D, 0xF8, 0x37, 0xF8, 0xF8, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x0E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xE0,
  0xF1, 0xC1, 0xC7, 0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0x70, 0x71,
  0xE0, 0xE3, 0xC1, 0xC7, 0x07, 0x80, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x87,
  0x0E, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3B, 0xC0, 0xEF,
  0x03, 0xB8, 0x1E, 0xE0, 0x7B, 0x81, 0xCE, 0x0F, 0x38, 0x3C, 0xF1, 0xE3,
  0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0x9F, 0x01, 0xDF, 0x80, 0xFF, 0xE0,
  0xF8, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x0F, 0x07,
  0x87, 0x03, 0xC3, 0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0xF0, 0x78, 0x78,
  0x38, 0x3C, 0x3C, 0x1E, 0x3C, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0x3E, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xCE, 0x1F, 0xDC, 0x7F,
  0xF8, 0xF1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x38, 0x1C, 0x70, 0x39,
  0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70,
  0x78, 0xF1, 0xF1, 0xFF, 0xC1, 0xFB, 0x83, 0xE7, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x0E, 0x70, 0xEF, 0x0F, 0xF1, 0xF9, 0x1F, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0xFF, 0xC7,
  0xFC, 0x78, 0x23, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x83, 0xC7,
  0xFC, 0x3F, 0xE1, 0xFC, 0x00, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1F, 0xDF,
  0xE7, 0xF8, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x3F, 0x0F, 0xC1, 0xF0, 0x1C,
  0x1E, 0x38, 0x38, 0x70, 0x71, 0xE0, 0xE3, 0x83, 0xC7, 0x07, 0x8E, 0x0E,
  0x3C, 0x1C, 0x78, 0x38, 0xE0, 0xF1, 0xC1, 0xC3, 0x83, 0x8F, 0x07, 0x1E,
  0x1E, 0x38, 0x3C, 0x70, 0xF0, 0xF1, 0xE1, 0xFF, 0xC3, 0xFB, 0x83, 0xE7,
  0x00, 0xF0, 0x7F, 0x83, 0xBC, 0x1D, 0xE1, 0xEF, 0x0E, 0x70, 0xF3, 0x87,
  0x1C, 0x78, 0xE3, 0x87, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0x77, 0x03,
  0xB8, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0xF0,
  0x7F, 0x87, 0x83, 0xBC, 0x3C, 0x3D, 0xC3, 0xE1, 0xCE, 0x1F, 0x0E, 0x71,
  0xF8, 0xF3, 0x8F, 0xC7, 0x1C, 0x6E, 0x78, 0xE7, 0x73, 0x87, 0x3B, 0x9C,
  0x39, 0x9D, 0xE1, 0xDC, 0xEE, 0x0E, 0xE7, 0x70, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x07, 0x83, 0x87, 0x81, 0xE3, 0x80, 0xF3, 0xC0,
  0x39, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3B, 0xC0, 0x38,
  0xE0, 0x3C, 0x70, 0x1C, 0x38, 0x1E, 0x1E, 0x1E, 0x0F, 0x00, 0x07, 0x81,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0xC0,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0xFE, 0x3F, 0xF1, 0xFF,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x0F, 0xC0, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0x1C, 0x00, 0x08, 0x02, 0xFE, 0x07, 0xFF, 0xFF, 0x3F, 0xF8, 0x1F,
  0xD0, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 11, 9, 13, 4, -26 },
  { 47, 17, 26, 16, 0, -26 },
  { 103, 16, 30, 15, 0, -28 },
  { 163, 20, 27, 24, 2, -27 },
  { 231, 16, 27, 17, 0, -27 },
  { 285, 5, 9, 8, 4, -26 },
  { 291, 11, 33, 10, 1, -27 },
  { 337, 12, 33, 10, -3, -27 },
  { 387, 12, 13, 14, 3, -28 },
  { 407, 15, 18, 16, 1, -22 },
  { 441, 7, 9, 8, -2, -4 },
  { 449, 8, 4, 10, 1, -12 },
  { 453, 5, 5, 8, 0, -5 },
  { 457, 18, 27, 13, -2, -27 },
  { 518, 14, 27, 15, 1, -27 },
  { 566, 10, 26, 15, 4, -26 },
  { 599, 16, 27, 15, -1, -27 },
  { 653, 16, 27, 15, -1, -27 },
  { 707, 16, 27, 15, -1, -27 },
  { 761, 15, 26, 15, 0, -26 },
  { 810, 15, 27, 15, 1, -27 },
  { 861, 16, 26, 15, 1, -26 },
  { 913, 15, 27, 15, 0, -27 },
  { 964, 15, 27, 15, 0, -27 },
  { 1015, 8, 20, 8, 0, -20 },
  { 1035, 10, 25, 8, -2, -20 },
  { 1067, 15, 17, 16, 1, -22 },
  { 1099, 15, 10, 16, 1, -18 },
  { 1118, 15, 17, 16, 1, -22 },
  { 1150, 12, 27, 11, 1, -27 },
  { 1191, 21, 30, 22, 1, -27 },
  { 1270, 15, 27, 16, -2, -27 },
  { 1321, 17, 26, 16, 0, -26 },
  { 1377, 17, 27, 15, 1, -27 },
  { 1435, 17, 26, 18, 0, -26 },
  { 1491, 16, 26, 14, 0, -26 },
  { 1543, 16, 26, 13, 0, -26 },
  { 1595, 18, 27, 19, 1, -27 },
  { 1656, 19, 26, 18, 0, -26 },
  { 1718, 15, 26, 10, -2, -26 },
  { 1767, 15, 33, 8, -6, -26 },
  { 1829, 19, 26, 16, 0, -26 },
  { 1891, 11, 26, 13, 0, -26 },
  { 1927, 25, 26, 24, 0, -26 },
  { 2009, 20, 26, 20, 0, -26 },
  { 2074, 17, 27, 19, 1, -27 },
  { 2132, 16, 26, 16, 0, -26 },
  { 2184, 17, 33, 19, 1, -27 },
  { 2255, 16, 26, 16, 0, -26 },
  { 2307, 17, 27, 14, -1, -27 },
  { 2365, 14, 26, 13, 2, -26 },
  { 2411, 18, 26, 18, 1, -26 },
  { 2470, 16, 26, 16, 3, -26 },
  { 2522, 25, 26, 25, 3, -26 },
  { 2604, 19, 26, 14, -2, -26 },
  { 2666, 14, 26, 14, 3, -26 },
  { 2712, 17, 26, 13, -2, -26 },
  { 2768, 14, 33, 10, -1, -27 },
  { 2826, 6, 27, 13, 4, -27 },
  { 2847, 15, 33, 10, -3, -27 },
  { 2909, 15, 14, 15, 0, -26 },
  { 2936, 12, 2, 11, -3, 3 },
  { 2939, 6, 6, 10, 5, -28 },
  { 2944, 15, 20, 16, 1, -20 },
  { 2982, 15, 28, 16, 0, -28 },
  { 3035, 12, 20, 12, 1, -20 },
  { 3065, 17, 28, 16, 1, -28 },
  { 3125, 13, 20, 15, 1, -20 },
  { 3158, 17, 37, 9, -4, -28 },
  { 3237, 17, 29, 16, -1, -20 },
  { 3299, 15, 28, 16, 0, -28 },
  { 3352, 9, 28, 8, 0, -28 },
  { 3384, 14, 37, 8, -5, -28 },
  { 3449, 16, 28, 14, 0, -28 },
  { 3505, 9, 28, 7, 0, -28 },
  { 3537, 22, 20, 23, 0, -20 },
  { 3592, 15, 20, 16, 0, -20 },
  { 3630, 14, 20, 16, 1, -20 },
  { 3665, 17, 29, 16, -2, -20 },
  { 3727, 15, 29, 16, 1, -20 },
  { 3782, 12, 20, 11, 0, -20 },
  { 3812, 13, 20, 12, 0, -20 },
  { 3845, 10, 24, 9, 1, -24 },
  { 3875, 15, 20, 16, 1, -20 },
  { 3913, 13, 20, 13, 2, -20 },
  { 3946, 21, 20, 21, 2, -20 },
  { 3999, 17, 20, 13, -2, -20 },
  { 4042, 18, 29, 13, -3, -20 },
  { 4108, 13, 20, 11, -1, -20 },
  { 4141, 14, 32, 12, 1, -26 },
  { 4197, 3, 37, 14, 5, -28 },
  { 4211, 13, 32, 12, -2, -26 },
  { 4263, 15, 6, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC37PT7B_H_
