#ifndef _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0x01, 0xC1, 0xF0, 0xF0, 0x78, 0x00, 0x79, 0xDC, 0x77, 0x3F, 0xCE,
  0xE3, 0xB8, 0xEE, 0x3B, 0x8C, 0xC7, 0x31, 0xC0, 0x00, 0xE3, 0x00, 0x63,
  0x80, 0x31, 0xC0, 0x38, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x0E, 0x30, 0x3F,
  0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0x81, 0xC6, 0x00, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x06, 0x38,
  0x07, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x63,
  0x80, 0x71, 0x80, 0x00, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x83, 0x91, 0x0E, 0x60, 0x1C, 0xC0, 0x39, 0x00, 0x7A,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x06, 0xF0, 0x0D, 0xE0, 0x13, 0xC0, 0x27, 0x18, 0xCE, 0x3F, 0xFC, 0x7F,
  0xF0, 0x7F, 0x80, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F,
  0x01, 0xC1, 0xF8, 0x18, 0x3B, 0x83, 0x83, 0x18, 0x70, 0x71, 0x87, 0x06,
  0x38, 0xE0, 0x63, 0x8E, 0x0E, 0x39, 0xC0, 0xE3, 0x9C, 0x0C, 0x33, 0x80,
  0xC7, 0x31, 0xCC, 0x77, 0x3E, 0xC6, 0x67, 0xFE, 0xEE, 0xE7, 0xFC, 0xCE,
  0x77, 0x9C, 0xC7, 0x01, 0x9C, 0x70, 0x39, 0xC7, 0x03, 0x18, 0x60, 0x71,
  0x8E, 0x06, 0x18, 0xE0, 0xE3, 0x8C, 0x1C, 0x39, 0xC1, 0xC1, 0x9C, 0x38,
  0x1F, 0x83, 0x81, 0xF0, 0x00, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x38, 0x0F, 0x38, 0x07, 0x78, 0x07, 0x70,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x1F, 0x87, 0x3F, 0xCF, 0x39, 0xCE,
  0x71, 0xCE, 0x71, 0xFC, 0xE0, 0xFC, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF0,
  0xE1, 0xF8, 0xFF, 0xF8, 0x7F, 0xBC, 0x3E, 0x3C, 0x7B, 0x9C, 0xEF, 0x73,
  0x9C, 0xE6, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x04,
  0x80, 0x70, 0x07, 0x04, 0x70, 0x77, 0x0F, 0xFF, 0x3F, 0xF0, 0xFF, 0x1F,
  0x03, 0xF8, 0x7B, 0x83, 0x1C, 0x11, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x3C, 0x71, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0x7F, 0xBF, 0xFF,
  0xC0, 0x23, 0xFF, 0xEF, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x1E, 0x71, 0xE3, 0x8E, 0x1C, 0xF0,
  0xE7, 0x07, 0x38, 0x3B, 0xC1, 0xDE, 0x0E, 0xE0, 0x77, 0x07, 0xF8, 0x3F,
  0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC1, 0xCE, 0x1E, 0x70,
  0xE3, 0x8F, 0x1F, 0xF0, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0x83, 0xC3, 0xE3,
  0xF3, 0xFB, 0xFB, 0x9C, 0x8E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0x1E, 0x02, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xFE, 0x07, 0xFE,
  0x07, 0x0F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x80, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x6E, 0x00, 0xFC,
  0x00, 0xDC, 0x01, 0x9C, 0x03, 0x9C, 0x03, 0x3C, 0x07, 0x38, 0x0E, 0x38,
  0x0C, 0x38, 0x1C, 0x38, 0x38, 0x78, 0x30, 0x70, 0x70, 0x70, 0x7F, 0xFC,
  0x7F, 0xFC, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0x00, 0xFF,
  0x03, 0xFF, 0x02, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x20, 0x78, 0x7F, 0xE0, 0xFF,
  0x81, 0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xBE, 0x1D, 0xFC,
  0x7F, 0xF1, 0xE1, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x07,
  0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x8F, 0x1E, 0x1F, 0xF0, 0x7F, 0x80, 0xFC,
  0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF9, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x78, 0xF0, 0xE0, 0xE3,
  0xC1, 0xC7, 0x03, 0x8F, 0x0F, 0x1E, 0x1C, 0x1C, 0x70, 0x3D, 0xE0, 0x3F,
  0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x1E, 0x78, 0x70, 0x71, 0xE0, 0xF3,
  0x81, 0xE7, 0x03, 0xCE, 0x07, 0x9C, 0x0E, 0x3C, 0x3C, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7F, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xCF, 0x1E, 0x1C,
  0x70, 0x71, 0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0F,
  0x3C, 0x7C, 0xF3, 0xF1, 0xFF, 0x87, 0xEE, 0x06, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x3F, 0xE0, 0xFF, 0x03, 0xF8,
  0x00, 0x06, 0x0E, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x70, 0xF0, 0xF0, 0xF0, 0x01, 0x80, 0xF0,
  0x3C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x0F, 0x87, 0xFC,
  0xFF, 0x98, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x1E,
  0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xFC, 0x01, 0xE1, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x03,
  0x0C, 0x00, 0x31, 0xC3, 0xE3, 0x38, 0x7F, 0x33, 0x0E, 0x63, 0x31, 0xC6,
  0x37, 0x18, 0xE3, 0x63, 0x8E, 0x36, 0x30, 0xC7, 0xE3, 0x1C, 0x7E, 0x71,
  0xC6, 0xE7, 0x1C, 0x6C, 0x71, 0x8C, 0xC7, 0x38, 0xCC, 0x77, 0xD8, 0xC3,
  0xCF, 0x8C, 0x38, 0xE0, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xE1,
  0xC3, 0xC3, 0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0xFC, 0x70, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x03, 0xDE, 0x07, 0xB8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x1F, 0x07, 0x0F, 0x0F, 0x07, 0x0E,
  0x07, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1F, 0xFC, 0x1F,
  0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x78, 0x70, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xC6, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x20, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xFE, 0x01,
  0xFF, 0x80, 0xE7, 0xE0, 0x70, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1C, 0x0F,
  0x0E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xC0, 0x70, 0xE0,
  0x38, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0E, 0x1C, 0x0F, 0x0E, 0x07, 0x8F,
  0x07, 0x87, 0x83, 0xC3, 0x83, 0xC1, 0xC7, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0x06, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x7F, 0x1C, 0x1F,
  0xCF, 0x07, 0xE3, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3,
  0xC0, 0x70, 0xF0, 0x1C, 0x1E, 0x07, 0x07, 0x83, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x1C, 0x0E,
  0x03, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xE0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x0F,
  0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x1C, 0x3C, 0x07, 0x0E, 0x03, 0xC7, 0x80, 0xE3, 0xC0, 0x38, 0xE0, 0x0E,
  0x78, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x77, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0xF7, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x1C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xF0,
  0x78, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0xEE, 0x0F, 0xE0, 0x7F, 0x07, 0x70, 0x77, 0x83,
  0x98, 0x3B, 0x81, 0xCC, 0x39, 0xC0, 0xE6, 0x1C, 0xE0, 0xF3, 0x9C, 0xF0,
  0x71, 0xCE, 0x70, 0x38, 0xE7, 0x38, 0x1C, 0x77, 0x1C, 0x0E, 0x3B, 0x8E,
  0x0F, 0x1F, 0x8F, 0x07, 0x0F, 0xC7, 0x03, 0x87, 0xC3, 0x81, 0xC3, 0xE1,
  0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x00, 0x07,
  0x80, 0x70, 0x7C, 0x0F, 0x07, 0xC0, 0xE0, 0x7C, 0x0E, 0x07, 0xC0, 0xE0,
  0xFC, 0x0E, 0x0F, 0xC1, 0xE0, 0xEE, 0x1C, 0x0E, 0xE1, 0xC1, 0xEE, 0x1C,
  0x1C, 0xE3, 0xC1, 0xCE, 0x3C, 0x1C, 0xE3, 0x81, 0xC7, 0x38, 0x3C, 0x73,
  0x83, 0x87, 0x78, 0x38, 0x77, 0x03, 0x87, 0x70, 0x38, 0x77, 0x07, 0x83,
  0xF0, 0x70, 0x3F, 0x07, 0x03, 0xE0, 0x70, 0x3E, 0x0F, 0x03, 0xE0, 0xF0,
  0x3E, 0x0E, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF1,
  0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x03,
  0xC7, 0x81, 0xC1, 0xE1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x3F, 0x07, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E,
  0x1C, 0x3C, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF1,
  0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9C,
  0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0x8F, 0x03,
  0xC7, 0x81, 0xC1, 0xE1, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x1E, 0x07, 0x0F, 0x0F, 0x0F,
  0x0E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x1C, 0x7C, 0x1F, 0xF8, 0x3F, 0xE0, 0x3D, 0xE0, 0x38, 0xE0, 0x38, 0xE0,
  0x38, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0x70, 0xF0, 0x70,
  0xF0, 0x78, 0xE0, 0x78, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xC6,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x60, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFD, 0xFF, 0xE7,
  0xFF, 0x81, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC3, 0x80, 0xE0, 0xE0,
  0x38, 0x38, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x1C,
  0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xE0, 0xE0, 0x38, 0x38, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0F, 0x0F, 0x03,
  0xC3, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81,
  0xEF, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xC3,
  0x87, 0x87, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x38, 0xE0, 0x73, 0xC0, 0xE7,
  0x01, 0xCE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x07, 0xB8, 0x0F, 0x03,
  0x9C, 0x07, 0x01, 0xCE, 0x07, 0x81, 0xE7, 0x03, 0xC0, 0xE3, 0x81, 0xE0,
  0xF1, 0xC1, 0xF0, 0x70, 0xE0, 0xD8, 0x38, 0x70, 0xEC, 0x3C, 0x38, 0x7E,
  0x1C, 0x1C, 0x37, 0x0E, 0x0E, 0x3B, 0x8F, 0x07, 0x1D, 0xC7, 0x03, 0x9C,
  0xE7, 0x81, 0xCE, 0x73, 0x80, 0xE6, 0x39, 0xC0, 0x77, 0x1D, 0xE0, 0x3B,
  0x8E, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x70, 0x78, 0x0F, 0x0E, 0x01,
  0xE3, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01,
  0xDC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x3D,
  0xC0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0E, 0x0E, 0x03, 0xC1,
  0xC0, 0x70, 0x38, 0x1E, 0x07, 0x80, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC,
  0x3C, 0x70, 0xE1, 0xC7, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07,
  0x70, 0x1D, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x70,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x38, 0x70, 0x70,
  0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xB8, 0x03, 0x80, 0xFF, 0xFF, 0xFC,
  0xF1, 0xC7, 0x8E, 0x38, 0x70, 0x03, 0x82, 0x1F, 0xB8, 0x7F, 0xF0, 0xF3,
  0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0xF3,
  0xC1, 0xE7, 0x83, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0x70, 0x78, 0xF1,
  0xE1, 0xFF, 0xC1, 0xFB, 0x83, 0xE7, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x18, 0x0E, 0xFC,
  0x1F, 0xF8, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x9E,
  0x0F, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0x8F, 0x07,
  0x1E, 0x1E, 0x3C, 0x78, 0xFF, 0xF1, 0xDF, 0xC3, 0x9F, 0x00, 0x01, 0xE0,
  0x7F, 0x0F, 0xE1, 0xE2, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x8F,
  0xF8, 0x7F, 0x83, 0xF0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0x9E, 0x0F, 0xDC, 0x1F, 0xFC,
  0x1E, 0x7C, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x38, 0x70, 0x38, 0x70, 0x38,
  0xF0, 0x38, 0xF0, 0x78, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0,
  0xE0, 0xE0, 0xE1, 0xE0, 0xFF, 0xE0, 0x7E, 0xE0, 0x7C, 0xE0, 0x01, 0xC0,
  0x3F, 0x83, 0xFC, 0x3C, 0xF3, 0xC3, 0x9C, 0x1D, 0xE1, 0xCE, 0x0E, 0x71,
  0xE7, 0xFE, 0x3F, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0xCE, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xA0, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x5E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x81, 0xFB, 0x80, 0xFF, 0xC0, 0xF3, 0xE0, 0xF0,
  0xF0, 0x70, 0x78, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0x83, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0xF8,
  0x3C, 0x78, 0x1F, 0xFC, 0x0F, 0xEE, 0x03, 0xEF, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x81, 0xE0, 0x71, 0xF0, 0x3F, 0xF0, 0x1F,
  0xF0, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x9C, 0x0E, 0xFC, 0x3F, 0xF1, 0xF3, 0xC7,
  0x87, 0x1E, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0xE3,
  0x83, 0x9E, 0x0E, 0x78, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0xF3,
  0xC3, 0xCE, 0x0E, 0x00, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x20, 0x00, 0x00,
  0x00, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x00, 0x00,
  0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0xBE, 0x03, 0xF0, 0x0F, 0xC0,
  0x18, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x1E, 0x1C, 0x78, 0x78, 0xE0, 0xE3,
  0x81, 0xCF, 0x03, 0xBC, 0x07, 0x70, 0x1D, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0xF7, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x78, 0x38, 0x70, 0xF0,
  0xE1, 0xC1, 0xC3, 0x83, 0xC0, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x00,
  0x00, 0x70, 0x70, 0x3B, 0xF7, 0xE0, 0xDF, 0xFF, 0xC7, 0xCF, 0xCF, 0x1E,
  0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xC1, 0xC3, 0x87, 0x0F, 0x0E, 0x3C, 0x38,
  0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x87, 0x8E, 0x0E, 0x1C, 0x78, 0x78, 0x71,
  0xE1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x3C, 0x70, 0xF0, 0xE3, 0xC3,
  0x83, 0x8F, 0x0E, 0x0E, 0x38, 0x38, 0x78, 0x00, 0x30, 0x3B, 0xF0, 0xDF,
  0xC7, 0xCF, 0x1E, 0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x07, 0x3C, 0x3C, 0xE0,
  0xE3, 0x83, 0x8E, 0x0E, 0x78, 0x39, 0xE1, 0xE7, 0x07, 0x1C, 0x1C, 0x70,
  0x73, 0xC3, 0xCF, 0x0F, 0x38, 0x38, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x3C,
  0xF3, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0x70, 0x3B, 0x83, 0xDC, 0x1C, 0xF1, 0xE7, 0xFE, 0x1F,
  0xE0, 0x7E, 0x00, 0x00, 0x0C, 0x01, 0xDF, 0x80, 0xFF, 0xC0, 0xF8, 0xF0,
  0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x87, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3C,
  0x3C, 0x1E, 0x3C, 0x1F, 0xFE, 0x0E, 0xFE, 0x07, 0x3E, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x82, 0x0F, 0x98, 0x3F, 0xF0, 0xF3, 0xE3, 0xC3,
  0xC7, 0x07, 0x9E, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0xC1, 0xE7,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xE1, 0xFF,
  0xC3, 0xFB, 0x83, 0xEF, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x70,
  0xEF, 0x0D, 0xF1, 0xFE, 0x1F, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xF3, 0xC2, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x83, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x06, 0x03,
  0x03, 0x81, 0xC1, 0xC3, 0xFD, 0xFE, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0xE3, 0xF0,
  0xF8, 0x1C, 0x1C, 0x70, 0x73, 0xC3, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE3,
  0x83, 0x9E, 0x1E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x3C, 0x3C, 0xF0, 0xF3,
  0x83, 0x8E, 0x1E, 0x38, 0x78, 0xFF, 0xE3, 0xFB, 0x07, 0xCC, 0x00, 0xE0,
  0x7F, 0x07, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xE3, 0x8F, 0x1C, 0x70,
  0xE7, 0x87, 0x38, 0x39, 0xC1, 0xDC, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0xF0, 0xFE, 0x0F, 0x0E, 0xE1,
  0xF0, 0xEE, 0x1F, 0x1E, 0xE3, 0xF1, 0xCE, 0x3F, 0x1C, 0xE3, 0x73, 0x8E,
  0x77, 0x38, 0xE7, 0x77, 0x8E, 0xE7, 0x70, 0xEE, 0x77, 0x0E, 0xC7, 0xE0,
  0xFC, 0x6E, 0x0F, 0xC6, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x78,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x00, 0x07, 0x0F, 0x07, 0x0E, 0x07, 0x9E,
  0x07, 0x9C, 0x03, 0xB8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0,
  0x3C, 0x70, 0x38, 0x70, 0x78, 0x70, 0xF0, 0x78, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x78, 0xE0,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x9E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xC7, 0xFC, 0x3F, 0xE0, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x7E,
  0x03, 0xE0, 0x18, 0x00, 0x3E, 0x05, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0x80,
  0x70,
};

const GFXglyph NotoSans_ExtraCondensed_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 26, 9, 0, -26 },
  { 31, 10, 10, 13, 4, -26 },
  { 44, 17, 26, 16, 0, -26 },
  { 100, 15, 29, 14, 0, -27 },
  { 155, 20, 26, 23, 2, -26 },
  { 220, 16, 26, 16, 0, -26 },
  { 272, 5, 10, 7, 4, -26 },
  { 279, 11, 32, 9, 1, -26 },
  { 323, 12, 32, 9, -3, -26 },
  { 371, 12, 13, 14, 3, -28 },
  { 391, 14, 17, 16, 1, -21 },
  { 421, 7, 9, 8, -2, -4 },
  { 429, 9, 3, 10, 0, -11 },
  { 433, 5, 5, 8, 0, -5 },
  { 437, 17, 26, 12, -2, -26 },
  { 493, 13, 26, 14, 1, -26 },
  { 536, 9, 26, 15, 4, -26 },
  { 566, 16, 26, 14, -1, -26 },
  { 618, 16, 26, 14, -1, -26 },
  { 670, 16, 26, 15, -1, -26 },
  { 722, 15, 26, 14, 0, -26 },
  { 771, 14, 26, 14, 1, -26 },
  { 817, 15, 26, 14, 1, -26 },
  { 866, 15, 26, 14, 0, -26 },
  { 915, 14, 26, 14, 0, -26 },
  { 961, 8, 20, 8, 0, -20 },
  { 981, 10, 25, 8, -2, -20 },
  { 1013, 14, 16, 16, 1, -21 },
  { 1041, 14, 11, 16, 1, -18 },
  { 1061, 14, 16, 16, 1, -21 },
  { 1089, 11, 26, 11, 1, -26 },
  { 1125, 20, 29, 22, 1, -26 },
  { 1198, 15, 26, 15, -2, -26 },
  { 1247, 16, 26, 16, 0, -26 },
  { 1299, 16, 26, 14, 1, -26 },
  { 1351, 17, 26, 17, 0, -26 },
  { 1407, 15, 26, 14, 0, -26 },
  { 1456, 15, 26, 13, 0, -26 },
  { 1505, 18, 26, 18, 1, -26 },
  { 1564, 19, 26, 18, 0, -26 },
  { 1626, 15, 26, 10, -2, -26 },
  { 1675, 14, 33, 8, -5, -26 },
  { 1733, 18, 26, 15, 0, -26 },
  { 1792, 10, 26, 13, 0, -26 },
  { 1825, 25, 26, 24, 0, -26 },
  { 1907, 20, 26, 19, 0, -26 },
  { 1972, 17, 26, 18, 1, -26 },
  { 2028, 16, 26, 15, 0, -26 },
  { 2080, 17, 32, 18, 1, -26 },
  { 2148, 16, 26, 16, 0, -26 },
  { 2200, 16, 26, 14, -1, -26 },
  { 2252, 14, 26, 13, 2, -26 },
  { 2298, 18, 26, 17, 1, -26 },
  { 2357, 15, 26, 15, 3, -26 },
  { 2406, 25, 26, 24, 2, -26 },
  { 2488, 19, 26, 14, -2, -26 },
  { 2550, 14, 26, 14, 3, -26 },
  { 2596, 16, 26, 13, -1, -26 },
  { 2648, 14, 32, 10, -1, -26 },
  { 2704, 6, 26, 13, 4, -26 },
  { 2724, 13, 32, 10, -2, -26 },
  { 2776, 15, 15, 15, 0, -26 },
  { 2805, 11, 2, 11, -3, 3 },
  { 2808, 6, 6, 10, 5, -28 },
  { 2813, 15, 20, 16, 1, -20 },
  { 2851, 15, 27, 15, 0, -27 },
  { 2902, 12, 20, 12, 1, -20 },
  { 2932, 16, 27, 16, 1, -27 },
  { 2986, 13, 20, 14, 1, -20 },
  { 3019, 17, 37, 9, -4, -28 },
  { 3098, 17, 29, 16, -1, -20 },
  { 3160, 14, 27, 15, 0, -27 },
  { 3208, 9, 27, 7, 0, -27 },
  { 3239, 14, 36, 7, -5, -27 },
  { 3302, 15, 27, 14, 0, -27 },
  { 3353, 9, 27, 7, 0, -27 },
  { 3384, 22, 20, 23, 0, -20 },
  { 3439, 14, 20, 15, 0, -20 },
  { 3474, 13, 20, 15, 1, -20 },
  { 3507, 17, 28, 15, -2, -20 },
  { 3567, 15, 29, 16, 1, -20 },
  { 3622, 12, 20, 10, 0, -20 },
  { 3652, 12, 20, 12, 0, -20 },
  { 3682, 9, 24, 9, 1, -24 },
  { 3709, 14, 19, 15, 1, -19 },
  { 3743, 13, 19, 13, 2, -19 },
  { 3774, 20, 19, 20, 2, -19 },
  { 3822, 16, 19, 13, -2, -19 },
  { 3860, 18, 28, 13, -3, -19 },
  { 3923, 13, 19, 11, -1, -19 },
  { 3954, 13, 32, 12, 1, -26 },
  { 4006, 3, 36, 13, 5, -28 },
  { 4020, 13, 32, 12, -2, -26 },
  { 4072, 14, 5, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_MediumItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_MEDIUMITALIC36PT7B_H_
